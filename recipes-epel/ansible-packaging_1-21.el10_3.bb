# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-packaging"
PV = "1"
PR = "21.el10_3"
PACKAGES = " \
 ansible-packaging \
 ansible-packaging-tests \
 ansible-srpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-packaging-1-21.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73debb44994ea61636b548763669787d132b845bcb41a414ce81890d973ed5f4"

URI_x86_64_v2_ansible-packaging = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-packaging-1-21.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-packaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-packaging}"
SRC_URI[x86_64_v2_ansible-packaging.sha256sum] = "c50d04f4233b1102bcda87f5a56ca9228660ff24ad4cfecb2d277165fd0ea596"

URI_x86_64_v2_ansible-packaging-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-packaging-tests-1-21.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-packaging-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-packaging-tests}"
SRC_URI[x86_64_v2_ansible-packaging-tests.sha256sum] = "31de719e676d4b0b15700aabf346a47dbeb8dc93a45744d6d6fb4186926351cb"

URI_x86_64_v2_ansible-srpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-srpm-macros-1-21.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-srpm-macros}"
SRC_URI[x86_64_v2_ansible-srpm-macros.sha256sum] = "f078d9acb6f9e766e1e84b57ff8bf9a851830ddb418ca4f8c486426821fc8dd4"

URI_aarch64_ansible-packaging = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-packaging-1-21.el10_3.noarch.rpm;name=aarch64_ansible-packaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-packaging}"
SRC_URI[aarch64_ansible-packaging.sha256sum] = "ff8a654f73929e762e989b5041a35d56885f76dd4f66d379cfd4fd3c5d888296"

URI_aarch64_ansible-packaging-tests = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-packaging-tests-1-21.el10_3.noarch.rpm;name=aarch64_ansible-packaging-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-packaging-tests}"
SRC_URI[aarch64_ansible-packaging-tests.sha256sum] = "21884b84799e3f5ba8f353282a73fdfbc02784177831e93a82365f6f174e71b7"

URI_aarch64_ansible-srpm-macros = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-srpm-macros-1-21.el10_3.noarch.rpm;name=aarch64_ansible-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-srpm-macros}"
SRC_URI[aarch64_ansible-srpm-macros.sha256sum] = "4ac2f3ecb3368fcaef797c7c4482b757d1b5777d579b4697876398ee30943dc0"

RDEPENDS:ansible-packaging = " \
 ansible-core \
 ansible-srpm-macros \
 python3 \
 python3-pyyaml \
 "
RDEPENDS:ansible-packaging-tests = " \
 ansible-packaging \
 ansible-test \
 python3-pytest \
 python3-pytest-forked \
 python3-pytest-mock \
 python3-pytest-xdist \
 python3-pyyaml \
 "
RDEPENDS:ansible-srpm-macros = " \
 "
