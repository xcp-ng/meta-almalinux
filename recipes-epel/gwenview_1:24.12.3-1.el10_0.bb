# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gwenview"
PE = "1"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 gwenview \
 gwenview-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gwenview-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "471d3373b070e87b9a6b7232ca3b9bf22f5a40de0490794e1a75c2e6a612daa9"

URI_x86_64_v2_gwenview = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gwenview-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gwenview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gwenview}"
SRC_URI[x86_64_v2_gwenview.sha256sum] = "c368b6513cbb303fcd21dba2b3ea258e74d1bb6bab9d558b807554d483e5727f"

URI_x86_64_v2_gwenview-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gwenview-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gwenview-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gwenview-libs}"
SRC_URI[x86_64_v2_gwenview-libs.sha256sum] = "c6386d3b72b528808e36ac47cb905602ae5274ae7e22c0508f6e7b79b774dc1f"

URI_aarch64_gwenview = "${EPEL_MIRROR}/aarch64/Packages/g/gwenview-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_gwenview;unpack=0"
SRC_URI:append = " ${URI_aarch64_gwenview}"
SRC_URI[aarch64_gwenview.sha256sum] = "9280ed69aad2546bfbfe507b392237592ff813e50fafd81d436da973b475837e"

URI_aarch64_gwenview-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gwenview-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_gwenview-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gwenview-libs}"
SRC_URI[aarch64_gwenview-libs.sha256sum] = "f6ed25b0f05dafe875a49fd18e194af01856bb7abfc94a61243fe425d9d999ef"

RDEPENDS:gwenview = " \
 exiv2-libs \
 glibc \
 gwenview-libs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 kf6-solid \
 kimageannotator-qt6 \
 libgcc \
 libstdc++ \
 libtiff \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:gwenview-libs = " \
 cfitsio \
 exiv2-libs \
 glibc \
 gwenview \
 kf6-baloo-libs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kimageannotator-qt6 \
 lcms2 \
 libX11 \
 libgcc \
 libjpeg-turbo \
 libkdcraw \
 libpng \
 libstdc++ \
 libwayland-client \
 phonon-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 qt6-qtwayland \
 "
