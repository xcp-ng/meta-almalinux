# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opentmux"
PV = "0.1"
PR = "2.el10_3"
PACKAGES = " \
 opentmux \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/opentmux-0.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b75edff86e4f99bbb416ddcdee984257afe4aaaf424e862465d3874649c1c9da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opentmux-0.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opentmux;unpack=0"
SRC_URI[x86_64_v2_opentmux.sha256sum] = "08aa75bac40465f922a7c1f19c04a169d1600fed3c57f5fe0ffd408ddcf4671d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/opentmux-0.1-2.el10_3.aarch64.rpm;name=aarch64_opentmux;unpack=0"
SRC_URI[aarch64_opentmux.sha256sum] = "0cb35e61f7a489429ced95d7ec264fc8940a17b82c66fe2a23cd5abb8fb89bd4"

RDEPENDS:opentmux = " \
 bash \
 glibc \
 grep \
 libevent \
 libutempter \
 ncurses-libs \
 sed \
 systemd-libs \
 virtual/coreutils \
 "
