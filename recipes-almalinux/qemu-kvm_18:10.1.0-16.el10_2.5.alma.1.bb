# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qemu-kvm"
PE = "18"
PV = "10.1.0"
PR = "16.el10_2.5.alma.1"
PACKAGES:x86_64_v2 = " \
 qemu-guest-agent \
 qemu-img \
 qemu-kvm \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-curl \
 qemu-kvm-block-rbd \
 qemu-kvm-common \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-display-virtio-vga \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-egl-headless \
 qemu-kvm-ui-opengl \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
"
PACKAGES:aarch64 = " \
 qemu-guest-agent \
 qemu-img \
 qemu-kvm \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-curl \
 qemu-kvm-block-rbd \
 qemu-kvm-common \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qemu-kvm-10.1.0-16.el10_2.5.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e68d41b4bf09703fcbf2ab9976743ad74c8b7d1df21dbfdaa9c1cdb1c263aab8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-guest-agent-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-guest-agent;unpack=0"
SRC_URI[x86_64_v2_qemu-guest-agent.sha256sum] = "ca84f5cc894eab8693a1b63d65d1054121d67bd9264240b73b954c3cabe796f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-img-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-img;unpack=0"
SRC_URI[x86_64_v2_qemu-img.sha256sum] = "58d70e843bbffd14671567743a73d04b4b96afcc5ad55eec83d5f310b0cae926"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm.sha256sum] = "77f8ebbc515fc36abc2ddc8c06c58d8e996dbaf265d0527510cff2ff1ab930fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-audio-pa-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-audio-pa;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-audio-pa.sha256sum] = "4a5ad50bc08faa4a5d5b3e1d83591c146444d0b16eaf6e0e08375a70a3b33eaa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-blkio-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-blkio;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-block-blkio.sha256sum] = "66738b4f15d47688c1bb4ba4e2f94cf1bca90f538c32b8d6f7f3985f384df651"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-curl-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-curl;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-block-curl.sha256sum] = "f2fce4d938f69f67a89d8d1b96b701ce6f3d3936f9a14f8a1f8e2bc9f2dfb3b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-rbd-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-rbd;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-block-rbd.sha256sum] = "801d7391417e9c09e22a685fdfad1ee1583a48c9f823939bc079d48c4a0f2675"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-common-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-common;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-common.sha256sum] = "9e9099d769801982b3cedb66b12dc6b30a595dffe10d009b98f5c50ed98ee90d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-core-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-core;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-core.sha256sum] = "724580aa3518c9acb7b2707307f4b4155d066ae58ef21eba73fc71c8e9b38876"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-gpu-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-gpu;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-gpu.sha256sum] = "d1b1724ea87c69963471fe528e5a2184dce07894e5cdc55b87353447f3bbd45a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-gpu-pci-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci.sha256sum] = "c0fca3ff76ea125f29a13df7fbe6a8a8b71c1953ed8ebecd5318b742f575135f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-vga-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-vga;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-vga.sha256sum] = "33b98c158f16d5aff520b681c960078dacc7fec567e28a58d6d623d75f349a67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-usb-host-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-usb-host;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-device-usb-host.sha256sum] = "06d49d8acde578a4969329110b4a68d6d64f42be192a5388ca4a95d35d185afc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-usb-redirect-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-usb-redirect;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-device-usb-redirect.sha256sum] = "c22249471790a4d4ba3a03d5cbcd95234652a940b033e2bdc08e879f55bf9462"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-docs-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-docs;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-docs.sha256sum] = "195a1dc949dd772688adb16a8eb7bdf7e3cde26f365d31f285b34f122922d59b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-tools-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-tools;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-tools.sha256sum] = "40f8e5ccde2017bc726cbf72a724d824298a0550bdc561ef7d73fcaf02d75c4e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-egl-headless-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-egl-headless;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-ui-egl-headless.sha256sum] = "c37ce813738a683272aeb5467835c870b13595b5de3bad50d61d98a51f258ae5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-opengl-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-opengl;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-ui-opengl.sha256sum] = "50aa6f75501007306213b0c592b4cb51d181ab9f465ef6750e6d252fdaa92174"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-spice-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-spice;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-ui-spice.sha256sum] = "c9cf62228a6778f66248e1a7ed507a1867ce56938a00542fe21df6d6ffb52695"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-pr-helper-10.1.0-16.el10_2.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-pr-helper;unpack=0"
SRC_URI[x86_64_v2_qemu-pr-helper.sha256sum] = "46cbfddf5a7dc5b69fda5338fee8b51c563998581a131cd47531b8dc029b4290"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-guest-agent-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-guest-agent;unpack=0"
SRC_URI[aarch64_qemu-guest-agent.sha256sum] = "d9d617e01c383aca4a4a46fa990bc485e6984526fcc82cf9a4dd7e3da4fc0f56"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-img-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-img;unpack=0"
SRC_URI[aarch64_qemu-img.sha256sum] = "a198f47d0703a1a332eee3d19c055ca1f3c313e678a340fb8b719deac8d3e907"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm;unpack=0"
SRC_URI[aarch64_qemu-kvm.sha256sum] = "c4fe484966c42816046affe812950549f47cf334963057c6bfbb90b79f6a581d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-audio-pa-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-audio-pa;unpack=0"
SRC_URI[aarch64_qemu-kvm-audio-pa.sha256sum] = "d692852fe8609ddd0b42b8c69e511206de8a52084d46b533a10adb5ea276757c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-blkio-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-blkio;unpack=0"
SRC_URI[aarch64_qemu-kvm-block-blkio.sha256sum] = "b31d985a0c8e4696a34e19f9a6300fdb882032de2cbdbc3953f4826624d3b55e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-curl-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-curl;unpack=0"
SRC_URI[aarch64_qemu-kvm-block-curl.sha256sum] = "f6a6171d77fb6b000c207f48f536c5a0d451825b25a516631652cba5540cf3b6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-rbd-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-rbd;unpack=0"
SRC_URI[aarch64_qemu-kvm-block-rbd.sha256sum] = "1ddfdad21bf3723eb5314b2fc337f4308876bb55198af475d526c3b1f4229ecb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-common-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-common;unpack=0"
SRC_URI[aarch64_qemu-kvm-common.sha256sum] = "52f87452baf392eb992f2ab33df35f47f559df22e7e60eb258c48090f504a4f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-core-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-core;unpack=0"
SRC_URI[aarch64_qemu-kvm-core.sha256sum] = "2f376fb151aeeecba5a9b225d0e644d07569536fce9267d8bf206196316fd0c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-display-virtio-gpu-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-display-virtio-gpu;unpack=0"
SRC_URI[aarch64_qemu-kvm-device-display-virtio-gpu.sha256sum] = "c59dc8dc5b6594335555d125b222deab46adbafd17e58a27f20163c6228e658b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-display-virtio-gpu-pci-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-display-virtio-gpu-pci;unpack=0"
SRC_URI[aarch64_qemu-kvm-device-display-virtio-gpu-pci.sha256sum] = "df455ad05e7a4350bdbac1b044ac5ac4ece275b63737464ae2766d57c657a8a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-usb-host-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-usb-host;unpack=0"
SRC_URI[aarch64_qemu-kvm-device-usb-host.sha256sum] = "62b3c352364f1818d235bbdd4e42890e6ebbdca44506da32c894e33cd343d64a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-usb-redirect-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-usb-redirect;unpack=0"
SRC_URI[aarch64_qemu-kvm-device-usb-redirect.sha256sum] = "7e10bacf591a57cc250bee4dfc55d7d14ef860c4c4a9f7340cdd00d2ec2129dd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-docs-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-docs;unpack=0"
SRC_URI[aarch64_qemu-kvm-docs.sha256sum] = "c49a4cce767e29fed4bab5dad378a0a1f0204298f46550ab746912d5ab73b7b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-tools-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-tools;unpack=0"
SRC_URI[aarch64_qemu-kvm-tools.sha256sum] = "a7fef5a210b58753aea0025ae4e81d3d33158e17efd6389e8e2f5eee9e508ea7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-ui-spice-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-ui-spice;unpack=0"
SRC_URI[aarch64_qemu-kvm-ui-spice.sha256sum] = "8ce2a550158075e4330d324a4f416114da69d857bc8a4ed22c5a00382b28080b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-pr-helper-10.1.0-16.el10_2.5.alma.1.aarch64.rpm;name=aarch64_qemu-pr-helper;unpack=0"
SRC_URI[aarch64_qemu-pr-helper.sha256sum] = "0bc5531f143385791971179cd54c6a1c77eca85072af320dbde7c8c54ef47fb4"

RDEPENDS:qemu-guest-agent = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 liburing \
 numactl-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:qemu-img = " \
 glib2 \
 glibc \
 gnutls \
 libaio \
 libgcc \
 libselinux \
 liburing \
 libzstd \
 numactl-libs \
 zlib-ng-compat \
 "
RDEPENDS:qemu-kvm:x86_64_v2 = " \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-rbd \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-display-virtio-vga \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-egl-headless \
 qemu-kvm-ui-opengl \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
 virtiofsd \
"
RDEPENDS:qemu-kvm:aarch64 = " \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-rbd \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
 virtiofsd \
"
RDEPENDS:qemu-kvm-audio-pa = " \
 glibc \
 pulseaudio-libs \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-block-blkio = " \
 glibc \
 libblkio \
 libgcc \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-block-curl = " \
 glibc \
 libgcc \
 qemu-kvm-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:qemu-kvm-block-rbd = " \
 glibc \
 libgcc \
 librados2 \
 librbd1 \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-common:x86_64_v2 = " \
 bash \
 glib2 \
 glibc \
 glibc-common \
 gnutls \
 ipxe-roms-qemu \
 libcap-ng \
 libgcc \
 seabios-bin \
 seavgabios-bin \
 shadow-utils \
 systemd \
"
RDEPENDS:qemu-kvm-common:aarch64 = " \
 bash \
 glib2 \
 glibc \
 glibc-common \
 gnutls \
 libcap-ng \
 libgcc \
 shadow-utils \
 systemd \
"
RDEPENDS:qemu-kvm-core:x86_64_v2 = " \
 capstone \
 cyrus-sasl-lib \
 edk2-ovmf \
 glib2 \
 glibc \
 gnutls \
 keyutils-libs \
 libaio \
 libfdt \
 libgcc \
 libpng \
 libseccomp \
 libslirp \
 liburing \
 libusb1 \
 libzstd \
 lzo \
 numactl-libs \
 pixman \
 qemu-img \
 qemu-kvm-common \
 snappy \
 zlib-ng-compat \
"
RDEPENDS:qemu-kvm-core:aarch64 = " \
 capstone \
 cyrus-sasl-lib \
 edk2-aarch64 \
 glib2 \
 glibc \
 gnutls \
 keyutils-libs \
 libaio \
 libfdt \
 libgcc \
 libpng \
 libseccomp \
 libslirp \
 liburing \
 libusb1 \
 libzstd \
 lzo \
 numactl-libs \
 pixman \
 qemu-img \
 qemu-kvm-common \
 snappy \
 zlib-ng-compat \
"
RDEPENDS:qemu-kvm-device-display-virtio-gpu = " \
 glibc \
 pixman \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-display-virtio-gpu-pci = " \
 glibc \
 qemu-kvm-common \
 qemu-kvm-device-display-virtio-gpu \
 "
RDEPENDS:qemu-kvm-device-display-virtio-vga = " \
 glibc \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-usb-host = " \
 glibc \
 libusb1 \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-usb-redirect = " \
 glibc \
 libgcc \
 qemu-kvm-common \
 usbredir \
 "
RDEPENDS:qemu-kvm-docs = " \
 "
RDEPENDS:qemu-kvm-tools = " \
 glib2 \
 glibc \
 libgcc \
 libxkbcommon \
 python3 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:qemu-kvm-ui-egl-headless = " \
 glibc \
 libepoxy \
 pixman \
 qemu-kvm-common \
 qemu-kvm-ui-opengl \
 "
RDEPENDS:qemu-kvm-ui-opengl = " \
 glibc \
 libepoxy \
 libgcc \
 mesa-dri-drivers \
 mesa-libEGL \
 mesa-libGL \
 mesa-libgbm \
 pixman \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-ui-spice:x86_64_v2 = " \
 glibc \
 libgcc \
 pixman \
 qemu-kvm-common \
 qemu-kvm-ui-opengl \
 spice-server \
"
RDEPENDS:qemu-kvm-ui-spice:aarch64 = " \
 glibc \
 libgcc \
 pixman \
 qemu-kvm-common \
 spice-server \
"
RDEPENDS:qemu-pr-helper = " \
 device-mapper-multipath-libs \
 glib2 \
 glibc \
 gnutls \
 libcap-ng \
 libgcc \
 liburing \
 numactl-libs \
 systemd-libs \
 "
