# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-h2"
PV = "0.4.19"
PR = "1.el10_3"
PACKAGES = " \
 rust-h2+default-devel \
 rust-h2+stream-devel \
 rust-h2+unstable-devel \
 rust-h2-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-h2-0.4.19-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a7a4883f065669734f7604eb6792c4fdfbea306fc8fe141725d577808a3b4575"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+default-devel-0.4.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-h2+default-devel.sha256sum] = "91ba73d77b5c120e6c3b9d39b509fd238965da2613d821c360c9407ed1c13ad5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+stream-devel-0.4.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+stream-devel;unpack=0"
SRC_URI[x86_64_v2_rust-h2+stream-devel.sha256sum] = "dc5046d556bd2106b9618400561f94a77bf17c1c4ec7f8f102c4c83d36deff1e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+unstable-devel-0.4.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+unstable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-h2+unstable-devel.sha256sum] = "ca21690b1f112116d1759109fa1c906056337ad51ef7951cbcea3f711a2a9a41"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2-devel-0.4.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-h2-devel.sha256sum] = "69d4126c950cfd933cc9da25d55de461cec4663edff6899fd35b4ef02b4d12fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+default-devel-0.4.19-1.el10_3.noarch.rpm;name=aarch64_rust-h2+default-devel;unpack=0"
SRC_URI[aarch64_rust-h2+default-devel.sha256sum] = "f4cd645ea0ce56009644b2fa29b4bfdb73036b3cc7fcbbe631462af0d1a23928"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+stream-devel-0.4.19-1.el10_3.noarch.rpm;name=aarch64_rust-h2+stream-devel;unpack=0"
SRC_URI[aarch64_rust-h2+stream-devel.sha256sum] = "ae47b14a144553acaebf39bb8f9fc4518003207652590860c031c7725f556b28"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+unstable-devel-0.4.19-1.el10_3.noarch.rpm;name=aarch64_rust-h2+unstable-devel;unpack=0"
SRC_URI[aarch64_rust-h2+unstable-devel.sha256sum] = "345a7980a786e7f9356a5cd72f0f3ab8dbe9f0f73e2978742344f1dbe403f3b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-h2-devel-0.4.19-1.el10_3.noarch.rpm;name=aarch64_rust-h2-devel;unpack=0"
SRC_URI[aarch64_rust-h2-devel.sha256sum] = "35aad15128866f0f3d40fb7b5b98bc1c35b105e09d7ff2421a52f2b3c8fa5611"

RDEPENDS:rust-h2+default-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2+stream-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2+unstable-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2-devel = " \
 cargo \
 rust \
 rust-atomic-waker+default-devel \
 rust-bytes+default-devel \
 rust-fnv+default-devel \
 rust-futures-core-devel \
 rust-futures-sink-devel \
 rust-http+default-devel \
 rust-indexmap+default-devel \
 rust-indexmap+std-devel \
 rust-slab+default-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio-util+codec-devel \
 rust-tokio-util+default-devel \
 rust-tokio-util+io-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
