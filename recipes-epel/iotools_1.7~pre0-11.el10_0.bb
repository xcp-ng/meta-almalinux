# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iotools"
PV = "1.7~pre0"
PR = "11.el10_0"
PACKAGES = " \
 iotools \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/i/iotools-1.7~pre0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "74096511193e83736e73d23cd4ccd4449c0a4b62b48e8b12c11855ad993d3716"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/iotools-1.7~pre0-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_iotools;unpack=0"
SRC_URI[x86_64_v2_iotools.sha256sum] = "69ace0d30e80c7f3b613ac3decbb4c05041a6e3cc5a88c90dd1d37c64bee2ef2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/iotools-1.7~pre0-11.el10_0.aarch64.rpm;name=aarch64_iotools;unpack=0"
SRC_URI[aarch64_iotools.sha256sum] = "7c9dfbd0e162c0866fb7836ac235a6d8c7c5aa8aeebea188f6cdee1fd7f660b0"

RDEPENDS:iotools = " \
 glibc \
 "
