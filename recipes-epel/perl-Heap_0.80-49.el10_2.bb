# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Heap"
PV = "0.80"
PR = "49.el10_2"
PACKAGES = " \
 perl-Heap \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Heap-0.80-49.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e0415003b6f10bcdcd6933461eba8188b4bf3fcdfe25427e10eb2b8f5c950972"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Heap-0.80-49.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Heap;unpack=0"
SRC_URI[x86_64_v2_perl-Heap.sha256sum] = "bf8160b3cf48ff12e5b7d0c37dae6ea1f3e1e52bb91d0da9fbf6a65f43e376a6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Heap-0.80-49.el10_2.noarch.rpm;name=aarch64_perl-Heap;unpack=0"
SRC_URI[aarch64_perl-Heap.sha256sum] = "8ea0c0e2038fc9ee084b29540fba060b1855f227a1a64dbd2f4eb66ba2e39eef"

RDEPENDS:perl-Heap = " \
 perl-Exporter \
 perl-Heap \
 perl-libs \
 perl-vars \
 "
