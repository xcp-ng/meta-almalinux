# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yarnpkg"
PV = "1.22.22"
PR = "11.el10_1"
PACKAGES = " \
 yarnpkg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yarnpkg-1.22.22-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef0a8313bde5610f68fc95c1840401b3ab1c250b76653422917015959643fb14"

URI_x86_64_v2_yarnpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yarnpkg-1.22.22-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yarnpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yarnpkg}"
SRC_URI[x86_64_v2_yarnpkg.sha256sum] = "c1ea37d328ca11adf1d8d72f97b221d5dca6d2fdf483cac8c74f3524bda2d99e"

URI_aarch64_yarnpkg = "${EPEL_MIRROR}/aarch64/Packages/y/yarnpkg-1.22.22-11.el10_1.aarch64.rpm;name=aarch64_yarnpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_yarnpkg}"
SRC_URI[aarch64_yarnpkg.sha256sum] = "b1ac5180117febd85b2b093562743f2279feb6f3ff7870ef89b38657c18f06fa"

RDEPENDS:yarnpkg = " \
 bash \
 nodejs \
 "
