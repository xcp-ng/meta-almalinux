# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsepol"
PV = "3.11"
PR = "1.el10"
PACKAGES = " \
 libsepol \
 libsepol-devel \
 libsepol-static \
 libsepol-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libsepol-3.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac8d720871ab1e577451384aa8b12f286072da4384fcda3af86303ad759844ed"

URI_x86_64_v2_libsepol = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsepol-3.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol}"
SRC_URI[x86_64_v2_libsepol.sha256sum] = "88316a7e40fbafa035a8f7d7927a190bbcf0bcc2371490150eef8b198f7989ea"

URI_x86_64_v2_libsepol-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsepol-devel-3.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol-devel}"
SRC_URI[x86_64_v2_libsepol-devel.sha256sum] = "0afb8e7317036d1f63de01b8429f697d2386e944265fb2b3bd64e5de8e7b8788"

URI_x86_64_v2_libsepol-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsepol-static-3.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol-static}"
SRC_URI[x86_64_v2_libsepol-static.sha256sum] = "e981b6889ab5e65a23429bc77f12e57447451b6b46630c1cfcb0778ee7457f31"

URI_x86_64_v2_libsepol-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsepol-utils-3.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol-utils}"
SRC_URI[x86_64_v2_libsepol-utils.sha256sum] = "6492fd1d1c923f309d82f8802ecb44b7ae26a78eeeeb0c4ce239acdf3af5ced7"

URI_aarch64_libsepol = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsepol-3.11-1.el10.aarch64.rpm;name=aarch64_libsepol;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol}"
SRC_URI[aarch64_libsepol.sha256sum] = "e41a8875677dfbd24b8b50569a451a5673f86c4877e1ec3de9f9d5e594113562"

URI_aarch64_libsepol-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsepol-devel-3.11-1.el10.aarch64.rpm;name=aarch64_libsepol-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol-devel}"
SRC_URI[aarch64_libsepol-devel.sha256sum] = "70f0d35df19d6f2a18cfcc2724278faacf9040049065bfb6f47bdbc68ddc6d87"

URI_aarch64_libsepol-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsepol-static-3.11-1.el10.aarch64.rpm;name=aarch64_libsepol-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol-static}"
SRC_URI[aarch64_libsepol-static.sha256sum] = "62d4d55b569d327c7e4ab758d5987d06d63b8a6e208bbad1ef320ffc067ace8a"

URI_aarch64_libsepol-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsepol-utils-3.11-1.el10.aarch64.rpm;name=aarch64_libsepol-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol-utils}"
SRC_URI[aarch64_libsepol-utils.sha256sum] = "8a9c909103e2ce1a1a68ac6c19042ac8367e5452ba273f62506cb669dbb6e672"

RDEPENDS:libsepol = " \
 glibc \
 "
RDEPENDS:libsepol-devel = " \
 libsepol \
 pkgconf-pkg-config \
 "
RDEPENDS:libsepol-static = " \
 libsepol-devel \
 "
RDEPENDS:libsepol-utils = " \
 glibc \
 libsepol \
 "
