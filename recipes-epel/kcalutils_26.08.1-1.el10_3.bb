# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcalutils"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kcalutils \
 kcalutils-devel \
 kcalutils-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kcalutils-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "775eea90ec8dbd1ea8ede577f05a2986d304cdc86bc79119fc95487fd14655a9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalutils-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcalutils;unpack=0"
SRC_URI[x86_64_v2_kcalutils.sha256sum] = "bc2600b2cfce7e5708219582366af51424fb5cfd7c4d4cf0f1c67fed958d60c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalutils-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcalutils-devel;unpack=0"
SRC_URI[x86_64_v2_kcalutils-devel.sha256sum] = "0c8d7cef9b34bc37afaa76a3e473cb8f89f223b5c8e1dbc861fba93696240375"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalutils-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kcalutils-doc;unpack=0"
SRC_URI[x86_64_v2_kcalutils-doc.sha256sum] = "a5bddd9c597baa9f1b040ff5e0f8edb416b4793c8ce55053ba8d494aa7e652e0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kcalutils-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kcalutils;unpack=0"
SRC_URI[aarch64_kcalutils.sha256sum] = "f46665700c35798d2708bb8e1261a89ffc229cced0be10b4d3fe882df849ffd9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kcalutils-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kcalutils-devel;unpack=0"
SRC_URI[aarch64_kcalutils-devel.sha256sum] = "13fd9471513f1b26946af3ebde5fe3e0c55f079e884f8571e07b09c2fa59901e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kcalutils-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kcalutils-doc;unpack=0"
SRC_URI[aarch64_kcalutils-doc.sha256sum] = "fc08c7b4f2f493f916189542409efd60c8ecb86260182312912976ae6f76c775"

RDEPENDS:kcalutils = " \
 glibc \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kcalutils-devel = " \
 cmake-filesystem \
 kcalutils \
 kf6-kcalendarcore-devel \
 kf6-kcoreaddons-devel \
 "
RDEPENDS:kcalutils-doc = " \
 "
