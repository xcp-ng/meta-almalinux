# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glow"
PV = "2.0.0"
PR = "1.el10_0"
PACKAGES = " \
 glow \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/glow-2.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5fc31ee7b3cf43beef62730380509e78d53dbfa19b7b7d26f03a853935d26c6"

URI_x86_64_v2_glow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glow-2.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glow}"
SRC_URI[x86_64_v2_glow.sha256sum] = "0975cbf0294d1ff0d841ca91c16b6f8cfe7b6ed84861c8bdea175ca22a398942"

URI_aarch64_glow = "${EPEL_MIRROR}/aarch64/Packages/g/glow-2.0.0-1.el10_0.aarch64.rpm;name=aarch64_glow;unpack=0"
SRC_URI:append = " ${URI_aarch64_glow}"
SRC_URI[aarch64_glow.sha256sum] = "c0c2ffd9f6ebf2e67224c7520df36cc657cbaabc92f58e4cc561bf0b7f83dc95"

RDEPENDS:glow = " \
 glibc \
 "
