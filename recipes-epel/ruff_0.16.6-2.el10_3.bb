# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruff"
PV = "0.16.6"
PR = "2.el10_3"
PACKAGES = " \
 python3-ruff \
 ruff \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/ruff-0.16.6-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bafb4edbbe747d0f3ead9cb732a7d725a89c4249bbdd7e863035d70c6ef366c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ruff-0.16.6-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ruff;unpack=0"
SRC_URI[x86_64_v2_python3-ruff.sha256sum] = "fb53d622c7812320c5e5f5aff83bc01ac06d0488d80e0145d0b9a58f47e69147"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruff-0.16.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ruff;unpack=0"
SRC_URI[x86_64_v2_ruff.sha256sum] = "3c1127bc5a2cf34e8dcc77aa2d63247bdd34c64b2252e92ddfca61697a892a56"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-ruff-0.16.6-2.el10_3.noarch.rpm;name=aarch64_python3-ruff;unpack=0"
SRC_URI[aarch64_python3-ruff.sha256sum] = "9c3e728488cd13e3aaea0305ab69ad3fd0c5973659903ec7ff24087cd7a90c45"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruff-0.16.6-2.el10_3.aarch64.rpm;name=aarch64_ruff;unpack=0"
SRC_URI[aarch64_ruff.sha256sum] = "700d19b530c2bd8a96fccbb67e9349c7e40dd75e758b60e66d23f11bb36695ec"

RDEPENDS:python3-ruff = " \
 python3 \
 ruff \
 "
RDEPENDS:ruff = " \
 glibc \
 jemalloc \
 libgcc \
 "
