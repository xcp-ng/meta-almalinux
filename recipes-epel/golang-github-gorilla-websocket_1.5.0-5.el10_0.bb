# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-gorilla-websocket"
PV = "1.5.0"
PR = "5.el10_0"
PACKAGES = " \
 golang-github-gorilla-websocket-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-gorilla-websocket-1.5.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ccebe6f9fd4a997c84c979a9e080fabb44efb7432b49ab1f2d4963bfb183d79b"

URI_x86_64_v2_golang-github-gorilla-websocket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-gorilla-websocket-devel-1.5.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-gorilla-websocket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-gorilla-websocket-devel}"
SRC_URI[x86_64_v2_golang-github-gorilla-websocket-devel.sha256sum] = "f9c5be5606c0779d524fb637cbc4dc969aee94aea5380ec54a7aecfc822c337b"

URI_aarch64_golang-github-gorilla-websocket-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-gorilla-websocket-devel-1.5.0-5.el10_0.noarch.rpm;name=aarch64_golang-github-gorilla-websocket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-gorilla-websocket-devel}"
SRC_URI[aarch64_golang-github-gorilla-websocket-devel.sha256sum] = "82ac2e4f22cefd0e40004c1cf50d874738228ee4ca9ce8dfae47955b18b861c9"

RDEPENDS:golang-github-gorilla-websocket-devel = " \
 go-filesystem \
 "
