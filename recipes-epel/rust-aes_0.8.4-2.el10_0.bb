# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aes"
PV = "0.8.4"
PR = "2.el10_0"
PACKAGES = " \
 rust-aes+default-devel \
 rust-aes+hazmat-devel \
 rust-aes+zeroize-devel \
 rust-aes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aes-0.8.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b78899712988dfd6d96805c783f6d4b986cc112375bded028dede468e9c93f04"

URI_x86_64_v2_rust-aes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes+default-devel-0.8.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes+default-devel}"
SRC_URI[x86_64_v2_rust-aes+default-devel.sha256sum] = "30ec3f64eda806b6a4f651e1dc9b7be0c65845ee1d95ff304a191f39e43a8f03"

URI_x86_64_v2_rust-aes+hazmat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes+hazmat-devel-0.8.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes+hazmat-devel}"
SRC_URI[x86_64_v2_rust-aes+hazmat-devel.sha256sum] = "28dc14d665d05d4ddec4ddbc9357debdca7c66b5d082e22de5cef3ce29f6b297"

URI_x86_64_v2_rust-aes+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes+zeroize-devel-0.8.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes+zeroize-devel}"
SRC_URI[x86_64_v2_rust-aes+zeroize-devel.sha256sum] = "f561b68504498e4ef44b15f6425fb0267badf859ba0e37d8a5602db0e6b09f24"

URI_x86_64_v2_rust-aes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-devel-0.8.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-devel}"
SRC_URI[x86_64_v2_rust-aes-devel.sha256sum] = "aa61572e458988167b94cf972a56fd5982d3cbc9acac140dd11bddd657f352cb"

URI_aarch64_rust-aes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes+default-devel-0.8.4-2.el10_0.noarch.rpm;name=aarch64_rust-aes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes+default-devel}"
SRC_URI[aarch64_rust-aes+default-devel.sha256sum] = "e5e7de24f184248f45bd87154ae05a4e4d0d30c54d7871fb3d2d0770757808f1"

URI_aarch64_rust-aes+hazmat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes+hazmat-devel-0.8.4-2.el10_0.noarch.rpm;name=aarch64_rust-aes+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes+hazmat-devel}"
SRC_URI[aarch64_rust-aes+hazmat-devel.sha256sum] = "690e21871f6cc808932db1486fc432f5243cc1231d1a88dfccb485c77d78165b"

URI_aarch64_rust-aes+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes+zeroize-devel-0.8.4-2.el10_0.noarch.rpm;name=aarch64_rust-aes+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes+zeroize-devel}"
SRC_URI[aarch64_rust-aes+zeroize-devel.sha256sum] = "8b1b274106f136f6fa8525af14449683a404e6c6a88f28278bdc1d8cb9dcccc9"

URI_aarch64_rust-aes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-devel-0.8.4-2.el10_0.noarch.rpm;name=aarch64_rust-aes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-devel}"
SRC_URI[aarch64_rust-aes-devel.sha256sum] = "1703ed3a7f042c290b3865c9ace30d3e4d332a1187479c7f34fd068e1f285f61"

RDEPENDS:rust-aes+default-devel = " \
 cargo \
 rust-aes-devel \
 "
RDEPENDS:rust-aes+hazmat-devel = " \
 cargo \
 rust-aes-devel \
 "
RDEPENDS:rust-aes+zeroize-devel = " \
 cargo \
 rust-aes-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-aes-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-cipher0.4+default-devel \
 rust-cpufeatures0.2+default-devel \
 "
