# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lvm2"
PE = "10"
PV = "2.03.28"
PR = "6.el10"
PACKAGES = " \
 device-mapper \
 device-mapper-devel \
 device-mapper-event \
 device-mapper-event-devel \
 device-mapper-event-libs \
 device-mapper-libs \
 lvm2 \
 lvm2-dbusd \
 lvm2-devel \
 lvm2-libs \
 lvm2-lockd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lvm2-2.03.28-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af26655d0201f2458b565bf9f3c330ff91decd1d09454fb2f1da71fce00656e8"

URI_x86_64_v2_device-mapper = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-1.02.202-6.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper}"
SRC_URI[x86_64_v2_device-mapper.sha256sum] = "94c7a1d3a48b1a586ce680427c63f9293e0fd9314866b9b28f2485a0aeb4dfb2"

URI_x86_64_v2_device-mapper-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/device-mapper-devel-1.02.202-6.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-devel}"
SRC_URI[x86_64_v2_device-mapper-devel.sha256sum] = "80efde797f603bcab8dadba0813c0bf279b1df3645a9728fc3a2b40a3f235ae2"

URI_x86_64_v2_device-mapper-event = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-event-1.02.202-6.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-event;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-event}"
SRC_URI[x86_64_v2_device-mapper-event.sha256sum] = "f3e312206077397de321f85f75ed8afa33e5067170cac2624a6b4de55b918fe7"

URI_x86_64_v2_device-mapper-event-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/device-mapper-event-devel-1.02.202-6.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-event-devel}"
SRC_URI[x86_64_v2_device-mapper-event-devel.sha256sum] = "b6bc019d7dbce55d9da520b12ecf6d5ba8362f8c29c7460a983d108743d96bbe"

URI_x86_64_v2_device-mapper-event-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-event-libs-1.02.202-6.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-event-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-event-libs}"
SRC_URI[x86_64_v2_device-mapper-event-libs.sha256sum] = "20a0c49156e9431c0fefe03d82bc9839d299680391f910829febf671f468b539"

URI_x86_64_v2_device-mapper-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-libs-1.02.202-6.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-libs}"
SRC_URI[x86_64_v2_device-mapper-libs.sha256sum] = "891770d113c9615e8dbb2d2cbf4939eea242c49be32108f4949e73745a0a1f50"

URI_x86_64_v2_lvm2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lvm2-2.03.28-6.el10.x86_64_v2.rpm;name=x86_64_v2_lvm2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lvm2}"
SRC_URI[x86_64_v2_lvm2.sha256sum] = "ffbc422ee9591183c00f24f61dfb09041d4ef831eb6df97b2b8d460d421e1d42"

URI_x86_64_v2_lvm2-dbusd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lvm2-dbusd-2.03.28-6.el10.noarch.rpm;name=x86_64_v2_lvm2-dbusd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lvm2-dbusd}"
SRC_URI[x86_64_v2_lvm2-dbusd.sha256sum] = "5661ba27c120fefb31b7e350b99861cb51b1bb9e1512c5507f92f35a87c298b7"

URI_x86_64_v2_lvm2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/lvm2-devel-2.03.28-6.el10.x86_64_v2.rpm;name=x86_64_v2_lvm2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lvm2-devel}"
SRC_URI[x86_64_v2_lvm2-devel.sha256sum] = "8edf8fabffbcb7b979c665704a0dae499b0b4a465c2cd113683d9b1f51cd93aa"

URI_x86_64_v2_lvm2-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lvm2-libs-2.03.28-6.el10.x86_64_v2.rpm;name=x86_64_v2_lvm2-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lvm2-libs}"
SRC_URI[x86_64_v2_lvm2-libs.sha256sum] = "69b39d88992b93bf8ef2ede24a58d7b9bf10cf18506b1b525e6262610190a527"

URI_x86_64_v2_lvm2-lockd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lvm2-lockd-2.03.28-6.el10.x86_64_v2.rpm;name=x86_64_v2_lvm2-lockd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lvm2-lockd}"
SRC_URI[x86_64_v2_lvm2-lockd.sha256sum] = "46e5067accaf07c7d817999c45e7d6514c95417cd127a22d783538631f920d03"

URI_aarch64_device-mapper = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-1.02.202-6.el10.aarch64.rpm;name=aarch64_device-mapper;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper}"
SRC_URI[aarch64_device-mapper.sha256sum] = "7d22345efeff20c06da2e4152f3e167e443b6e12f5e4fea2a3c79adc6239ba7e"

URI_aarch64_device-mapper-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/device-mapper-devel-1.02.202-6.el10.aarch64.rpm;name=aarch64_device-mapper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-devel}"
SRC_URI[aarch64_device-mapper-devel.sha256sum] = "f178c10bce86a8f46548518c815d84c4cc15803f90287fdaff00bb89800fcf31"

URI_aarch64_device-mapper-event = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-event-1.02.202-6.el10.aarch64.rpm;name=aarch64_device-mapper-event;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-event}"
SRC_URI[aarch64_device-mapper-event.sha256sum] = "a54c25a6b55b152c392939bda1471bbf19b53e5575ea4e3324f5d479262bef6e"

URI_aarch64_device-mapper-event-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/device-mapper-event-devel-1.02.202-6.el10.aarch64.rpm;name=aarch64_device-mapper-event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-event-devel}"
SRC_URI[aarch64_device-mapper-event-devel.sha256sum] = "551b6c91e1b8518fe65cc6703b3523e79639524c6689dcec5b8d339204500c8d"

URI_aarch64_device-mapper-event-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-event-libs-1.02.202-6.el10.aarch64.rpm;name=aarch64_device-mapper-event-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-event-libs}"
SRC_URI[aarch64_device-mapper-event-libs.sha256sum] = "eff287b380ec738cc0393ece7dc334c0724a34140519c446c0b0d09b7c6ca930"

URI_aarch64_device-mapper-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-libs-1.02.202-6.el10.aarch64.rpm;name=aarch64_device-mapper-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-libs}"
SRC_URI[aarch64_device-mapper-libs.sha256sum] = "e8bce3cb0b16ae2c35dbe82dfd832936483423b3b56a2485df3f2e54cd87a874"

URI_aarch64_lvm2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lvm2-2.03.28-6.el10.aarch64.rpm;name=aarch64_lvm2;unpack=0"
SRC_URI:append = " ${URI_aarch64_lvm2}"
SRC_URI[aarch64_lvm2.sha256sum] = "16bb9d999cf8d0c71e78964630d48281d3acb5606db800cee30fa4c47d1ffa5f"

URI_aarch64_lvm2-dbusd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lvm2-dbusd-2.03.28-6.el10.noarch.rpm;name=aarch64_lvm2-dbusd;unpack=0"
SRC_URI:append = " ${URI_aarch64_lvm2-dbusd}"
SRC_URI[aarch64_lvm2-dbusd.sha256sum] = "5661ba27c120fefb31b7e350b99861cb51b1bb9e1512c5507f92f35a87c298b7"

URI_aarch64_lvm2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/lvm2-devel-2.03.28-6.el10.aarch64.rpm;name=aarch64_lvm2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lvm2-devel}"
SRC_URI[aarch64_lvm2-devel.sha256sum] = "e1ee04bddf8bd525d6a3388533c1b06241334c12f35d7b80eb6822838b71a77b"

URI_aarch64_lvm2-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lvm2-libs-2.03.28-6.el10.aarch64.rpm;name=aarch64_lvm2-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lvm2-libs}"
SRC_URI[aarch64_lvm2-libs.sha256sum] = "f4dfefdca961cad52bdd8bfa1f8d34c7838497280586444b1e0dabe702d25972"

URI_aarch64_lvm2-lockd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lvm2-lockd-2.03.28-6.el10.aarch64.rpm;name=aarch64_lvm2-lockd;unpack=0"
SRC_URI:append = " ${URI_aarch64_lvm2-lockd}"
SRC_URI[aarch64_lvm2-lockd.sha256sum] = "5927ee3b6f03ffea485d81ae3a0b36fe875fea8e21f135d48e28009665f80c49"

RDEPENDS:device-mapper = " \
 bash \
 device-mapper-libs \
 glibc \
 systemd \
 util-linux-core \
 "
RDEPENDS:device-mapper-devel = " \
 device-mapper \
 device-mapper-libs \
 libselinux-devel \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:device-mapper-event = " \
 bash \
 device-mapper \
 device-mapper-event-libs \
 device-mapper-libs \
 glibc \
 libgcc \
 systemd \
 "
RDEPENDS:device-mapper-event-devel = " \
 device-mapper-event \
 device-mapper-event-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:device-mapper-event-libs = " \
 device-mapper-libs \
 glibc \
 "
RDEPENDS:device-mapper-libs = " \
 device-mapper \
 glibc \
 libselinux \
 systemd-libs \
 "
RDEPENDS:lvm2 = " \
 bash \
 device-mapper-event-libs \
 device-mapper-persistent-data \
 glibc \
 kmod \
 libaio \
 libblkid \
 libedit \
 libnvme \
 libselinux \
 lvm2-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:lvm2-dbusd = " \
 bash \
 dbus \
 lvm2 \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-pyudev \
 systemd \
 "
RDEPENDS:lvm2-devel = " \
 device-mapper-devel \
 device-mapper-event-devel \
 lvm2 \
 lvm2-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:lvm2-libs = " \
 device-mapper-event \
 device-mapper-event-libs \
 device-mapper-libs \
 glibc \
 libaio \
 libblkid \
 libnvme \
 libselinux \
 systemd-libs \
 "
RDEPENDS:lvm2-lockd = " \
 bash \
 glibc \
 libselinux \
 lvm2 \
 sanlock-lib \
 systemd \
 systemd-libs \
 "
