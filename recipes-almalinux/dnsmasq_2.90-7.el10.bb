# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnsmasq"
PV = "2.90"
PR = "7.el10"
PACKAGES = " \
 dnsmasq \
 dnsmasq-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dnsmasq-2.90-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc31199cfe5c24e614a50408b970708a3b2517067e6d0db61813a5189315b735"

URI_x86_64_v2_dnsmasq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsmasq-2.90-7.el10.x86_64_v2.rpm;name=x86_64_v2_dnsmasq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsmasq}"
SRC_URI[x86_64_v2_dnsmasq.sha256sum] = "2d2c571122f03da92e59689663bd23bbb7b5e43e9e3f3cc495ff028d983f8c6a"

URI_x86_64_v2_dnsmasq-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsmasq-utils-2.90-7.el10.x86_64_v2.rpm;name=x86_64_v2_dnsmasq-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsmasq-utils}"
SRC_URI[x86_64_v2_dnsmasq-utils.sha256sum] = "e6b5beb6354ce597eaeae8df523cfb2160ac659ca5cb9524987ea7da20f9ad78"

URI_aarch64_dnsmasq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsmasq-2.90-7.el10.aarch64.rpm;name=aarch64_dnsmasq;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsmasq}"
SRC_URI[aarch64_dnsmasq.sha256sum] = "db9ceb4f61001e92fbe60570ea00fc91231a6bb660b96fb2c2e16c6a8799cb82"

URI_aarch64_dnsmasq-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsmasq-utils-2.90-7.el10.aarch64.rpm;name=aarch64_dnsmasq-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsmasq-utils}"
SRC_URI[aarch64_dnsmasq-utils.sha256sum] = "714754bf54afd4f5492b27c8babfc683cd2a4a469aebb16e4404646b374041fa"

RDEPENDS:dnsmasq = " \
 bash \
 dbus-libs \
 glibc \
 gmp \
 libidn2 \
 libnetfilter_conntrack \
 nettle \
 "
RDEPENDS:dnsmasq-utils = " \
 glibc \
 "
