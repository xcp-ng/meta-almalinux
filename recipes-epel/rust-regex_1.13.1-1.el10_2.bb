# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex"
PV = "1.13.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-regex+default-devel \
 rust-regex+logging-devel \
 rust-regex+pattern-devel \
 rust-regex+perf-backtrack-devel \
 rust-regex+perf-cache-devel \
 rust-regex+perf-devel \
 rust-regex+perf-dfa-devel \
 rust-regex+perf-dfa-full-devel \
 rust-regex+perf-inline-devel \
 rust-regex+perf-literal-devel \
 rust-regex+perf-onepass-devel \
 rust-regex+std-devel \
 rust-regex+unicode-age-devel \
 rust-regex+unicode-bool-devel \
 rust-regex+unicode-case-devel \
 rust-regex+unicode-devel \
 rust-regex+unicode-gencat-devel \
 rust-regex+unicode-perl-devel \
 rust-regex+unicode-script-devel \
 rust-regex+unicode-segment-devel \
 rust-regex+unstable-devel \
 rust-regex+use_std-devel \
 rust-regex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-1.13.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbdc5e5c69cbc766f7d1846fdfad15cdc6c69b97072781bd8f087e5beb4ea3ed"

URI_x86_64_v2_rust-regex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+default-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+default-devel}"
SRC_URI[x86_64_v2_rust-regex+default-devel.sha256sum] = "9774979d8e97999e9735c02696a5ae7c9f72861cde70579438fd10900de961b8"

URI_x86_64_v2_rust-regex+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+logging-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+logging-devel}"
SRC_URI[x86_64_v2_rust-regex+logging-devel.sha256sum] = "0fba1504c213f8c07702c50a00f970203e5b7fa042debbbcef468afefd6a3070"

URI_x86_64_v2_rust-regex+pattern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+pattern-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+pattern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+pattern-devel}"
SRC_URI[x86_64_v2_rust-regex+pattern-devel.sha256sum] = "a767fc72ae892f90a3b11529496377185a91d4f9ae4bd5351e773e6931a6c4d1"

URI_x86_64_v2_rust-regex+perf-backtrack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-backtrack-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-backtrack-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-backtrack-devel.sha256sum] = "05082b2069372831b95d6f6f6ccddece547810ed490f38b3e42acf232b0ccf44"

URI_x86_64_v2_rust-regex+perf-cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-cache-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-cache-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-cache-devel.sha256sum] = "6a9e488f8159b984214dbe9654324ca9dc7a7d34b6a0c9b9571ce0345d4fe3c6"

URI_x86_64_v2_rust-regex+perf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-devel.sha256sum] = "ff80fee2a8e11afda54f62ce08aa8b06145cb4fc429ac5cb0f4f8494885f1bf8"

URI_x86_64_v2_rust-regex+perf-dfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-dfa-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-dfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-dfa-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-dfa-devel.sha256sum] = "d291b80f6ea91e746af1fc0cf36438cdc871d94061134bfc39f50fac4c2f55e2"

URI_x86_64_v2_rust-regex+perf-dfa-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-dfa-full-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-dfa-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-dfa-full-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-dfa-full-devel.sha256sum] = "ce4f3b807b7f18517fc82b8fa2c5906e9167695ae8c4e2bc4dba70b8d9b2b9b8"

URI_x86_64_v2_rust-regex+perf-inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-inline-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-inline-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-inline-devel.sha256sum] = "513639a90ccf787d769b27a88ea34186fca3dcd088505e8ccf1dbe25bae107e6"

URI_x86_64_v2_rust-regex+perf-literal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-literal-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-literal-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-literal-devel.sha256sum] = "1ccc527e110849b5ca9d330c1b4a34541336493adeddd9e1f4dfeb206a59019c"

URI_x86_64_v2_rust-regex+perf-onepass-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-onepass-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-onepass-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-onepass-devel.sha256sum] = "1216c84a5519c7379763b043a9dd067edf0e96eaef9a0421fc4be1ad19cd90a2"

URI_x86_64_v2_rust-regex+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+std-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+std-devel}"
SRC_URI[x86_64_v2_rust-regex+std-devel.sha256sum] = "850309a728ff51a1ffc74ec60d5d7594baeb73c80c438721b6a3ac00ebba2af6"

URI_x86_64_v2_rust-regex+unicode-age-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-age-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-age-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-age-devel.sha256sum] = "aeef068fbd729a1ca47b9ca463021f04683352399173e05fa4f6c3b97d01380d"

URI_x86_64_v2_rust-regex+unicode-bool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-bool-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-bool-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-bool-devel.sha256sum] = "f34f8131a020addc8e36bc0b89e77d3d267241459bcfb157f7324a2a0c3c8192"

URI_x86_64_v2_rust-regex+unicode-case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-case-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-case-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-case-devel.sha256sum] = "86ea76d85da2b5df3db900643666f69158da9218f70e92e398f4e15025101780"

URI_x86_64_v2_rust-regex+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-devel.sha256sum] = "9a8d8006ff251d58ea6e43875d7809d89e50f66023d406d2a148a146691691c0"

URI_x86_64_v2_rust-regex+unicode-gencat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-gencat-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-gencat-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-gencat-devel.sha256sum] = "76161252c6cf6cd60fa90923fd97716fd2c8c6ce46eeb6b0f5a95363fbf5ecfb"

URI_x86_64_v2_rust-regex+unicode-perl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-perl-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-perl-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-perl-devel.sha256sum] = "2fa159b920f38f9b08dce7320c5d19dee93df700910a2fa4b62ccde920063e87"

URI_x86_64_v2_rust-regex+unicode-script-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-script-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-script-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-script-devel.sha256sum] = "1ac13076bb07d3a3a66037d2a40afa938b138a9fae4b47549e176c7bbecdb7dd"

URI_x86_64_v2_rust-regex+unicode-segment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-segment-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-segment-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-segment-devel.sha256sum] = "f083407260fbdd260ac99fd71be23f9adbf0585804410cf1c59031431b59e510"

URI_x86_64_v2_rust-regex+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unstable-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unstable-devel}"
SRC_URI[x86_64_v2_rust-regex+unstable-devel.sha256sum] = "140e3f789c2b54a716e817c4eecba951623afcbb4c53dc997fbd521b576d33f9"

URI_x86_64_v2_rust-regex+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+use_std-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+use_std-devel}"
SRC_URI[x86_64_v2_rust-regex+use_std-devel.sha256sum] = "f4100ab7c3e2a91ce08ae43a0f4aadeadebbdffaa37a23e244a77f4ce37683c3"

URI_x86_64_v2_rust-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-devel}"
SRC_URI[x86_64_v2_rust-regex-devel.sha256sum] = "3ef2159dead46b69a338b15d370f9750d6971045d3a868366b12c8563cad21a0"

URI_aarch64_rust-regex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+default-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+default-devel}"
SRC_URI[aarch64_rust-regex+default-devel.sha256sum] = "4a81e6c94ce8ee5ca34747e6010b354567c96a4d9ed981fd7d2d9ee882004ed1"

URI_aarch64_rust-regex+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+logging-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+logging-devel}"
SRC_URI[aarch64_rust-regex+logging-devel.sha256sum] = "623d884a4e24ce401f0ed7aaf7cb39b6f8f4ddeacfd2c8eb86853f14877719a3"

URI_aarch64_rust-regex+pattern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+pattern-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+pattern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+pattern-devel}"
SRC_URI[aarch64_rust-regex+pattern-devel.sha256sum] = "17ed8a9db8e6da81d248a4c5504fe6220ea4310242fe5e3e81f0ccbab362efb6"

URI_aarch64_rust-regex+perf-backtrack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-backtrack-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+perf-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-backtrack-devel}"
SRC_URI[aarch64_rust-regex+perf-backtrack-devel.sha256sum] = "b017beaa708a4119ccb01006ec7b30fae27f3c0ec74b1919a73224762b3740f4"

URI_aarch64_rust-regex+perf-cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-cache-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+perf-cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-cache-devel}"
SRC_URI[aarch64_rust-regex+perf-cache-devel.sha256sum] = "9cc808852b633642deb50bdc7b1f2b0b793378d61ea125887706d456d91fb44f"

URI_aarch64_rust-regex+perf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+perf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-devel}"
SRC_URI[aarch64_rust-regex+perf-devel.sha256sum] = "5cbabe9285269f4992f7dcd7d0b031a6461b3e3cbf15accd02444f8bca147778"

URI_aarch64_rust-regex+perf-dfa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-dfa-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+perf-dfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-dfa-devel}"
SRC_URI[aarch64_rust-regex+perf-dfa-devel.sha256sum] = "2489f42745353b928658bfb119a7b8472ae1d97e8697a04be933b58484b2e2c3"

URI_aarch64_rust-regex+perf-dfa-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-dfa-full-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+perf-dfa-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-dfa-full-devel}"
SRC_URI[aarch64_rust-regex+perf-dfa-full-devel.sha256sum] = "37c4b9707ccdc596ba3f7af49b2787db079a3942f46bc4ba6cd038848af29b3a"

URI_aarch64_rust-regex+perf-inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-inline-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-inline-devel}"
SRC_URI[aarch64_rust-regex+perf-inline-devel.sha256sum] = "412604bb8105158b6b7f7e3da604838d7b83ec09b3c6dacfdeae73a42ca1d895"

URI_aarch64_rust-regex+perf-literal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-literal-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-literal-devel}"
SRC_URI[aarch64_rust-regex+perf-literal-devel.sha256sum] = "91d273dd7ea5649d3d5e86ea371fcb8baf7176299f17b524f7d904daa2906f8b"

URI_aarch64_rust-regex+perf-onepass-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-onepass-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+perf-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-onepass-devel}"
SRC_URI[aarch64_rust-regex+perf-onepass-devel.sha256sum] = "837ba5f41c0201a1890172cb08e4e038eadce96d468bc3703da52fd107fc6dd4"

URI_aarch64_rust-regex+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+std-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+std-devel}"
SRC_URI[aarch64_rust-regex+std-devel.sha256sum] = "5fd6b4e2b0522429fe4f000ef9f264e2fa7656ea94e4b5102cf72c7c17a2df47"

URI_aarch64_rust-regex+unicode-age-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-age-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-age-devel}"
SRC_URI[aarch64_rust-regex+unicode-age-devel.sha256sum] = "a3f11c6811d13213bd6fc03cf2b6f189e5960d650cadb0e5b928f56a80bd505f"

URI_aarch64_rust-regex+unicode-bool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-bool-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-bool-devel}"
SRC_URI[aarch64_rust-regex+unicode-bool-devel.sha256sum] = "22032058b807916dce4b92169bfe980f44d5017fefb6711e84f19e9854cbf4ff"

URI_aarch64_rust-regex+unicode-case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-case-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-case-devel}"
SRC_URI[aarch64_rust-regex+unicode-case-devel.sha256sum] = "8640ba7d1f58e72b0d6aa0c13e8cb2b6eafabc592a2f7e106ff71c8c3f6e5db8"

URI_aarch64_rust-regex+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-devel}"
SRC_URI[aarch64_rust-regex+unicode-devel.sha256sum] = "ca61272c32cb0c86acc7d657c5c9ce60a728ef3cce6bf14dcd5176ed9e820c87"

URI_aarch64_rust-regex+unicode-gencat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-gencat-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-gencat-devel}"
SRC_URI[aarch64_rust-regex+unicode-gencat-devel.sha256sum] = "3194e952f7b8690358e6a93366ad8e9c2e9c451aa7156d1f9f5bb79234955bef"

URI_aarch64_rust-regex+unicode-perl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-perl-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-perl-devel}"
SRC_URI[aarch64_rust-regex+unicode-perl-devel.sha256sum] = "524936dab67a14b2c1025989a48d5e2ac519519f92fd4dd81784c2c5bd328abe"

URI_aarch64_rust-regex+unicode-script-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-script-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-script-devel}"
SRC_URI[aarch64_rust-regex+unicode-script-devel.sha256sum] = "aa6f0d7e37a20645f660ec805d32abe3c4f4b5bfa3f412f91b180aeed0433c01"

URI_aarch64_rust-regex+unicode-segment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-segment-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-segment-devel}"
SRC_URI[aarch64_rust-regex+unicode-segment-devel.sha256sum] = "60a762990f2bdb3796217dc7afc5e796c28a5e410dc840936a969b34f51ecfe0"

URI_aarch64_rust-regex+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unstable-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unstable-devel}"
SRC_URI[aarch64_rust-regex+unstable-devel.sha256sum] = "993ea2525bd75f0b572f808cd56fb2f303956870927c25cfae0dd3f8625b6a79"

URI_aarch64_rust-regex+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+use_std-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+use_std-devel}"
SRC_URI[aarch64_rust-regex+use_std-devel.sha256sum] = "3e6e806752df66de17d7310d2f4bff15586f84c59c91a10b4a179509640c4a85"

URI_aarch64_rust-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-devel}"
SRC_URI[aarch64_rust-regex-devel.sha256sum] = "377990b7ddfd58e8dd1b5003fc1175380911954ebb80043df57f6463497a3fed"

RDEPENDS:rust-regex+default-devel = " \
 cargo \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 rust-regex-syntax+default-devel \
 "
RDEPENDS:rust-regex+logging-devel = " \
 cargo \
 rust-aho-corasick+logging-devel \
 rust-aho-corasick-devel \
 rust-memchr+logging-devel \
 rust-memchr-devel \
 rust-regex-automata+logging-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+pattern-devel = " \
 cargo \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-backtrack-devel = " \
 cargo \
 rust-regex-automata+nfa-backtrack-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-cache-devel = " \
 cargo \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-devel = " \
 cargo \
 rust-regex+perf-backtrack-devel \
 rust-regex+perf-cache-devel \
 rust-regex+perf-dfa-devel \
 rust-regex+perf-inline-devel \
 rust-regex+perf-literal-devel \
 rust-regex+perf-onepass-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-dfa-devel = " \
 cargo \
 rust-regex-automata+hybrid-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-dfa-full-devel = " \
 cargo \
 rust-regex-automata+dfa-build-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-inline-devel = " \
 cargo \
 rust-regex-automata+perf-inline-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-literal-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-memchr-devel \
 rust-regex-automata+perf-literal-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-onepass-devel = " \
 cargo \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+std-devel = " \
 cargo \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-regex-automata+std-devel \
 rust-regex-devel \
 rust-regex-syntax+std-devel \
 "
RDEPENDS:rust-regex+unicode-age-devel = " \
 cargo \
 rust-regex-automata+unicode-age-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-age-devel \
 "
RDEPENDS:rust-regex+unicode-bool-devel = " \
 cargo \
 rust-regex-automata+unicode-bool-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-bool-devel \
 "
RDEPENDS:rust-regex+unicode-case-devel = " \
 cargo \
 rust-regex-automata+unicode-case-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-case-devel \
 "
RDEPENDS:rust-regex+unicode-devel = " \
 cargo \
 rust-regex+unicode-age-devel \
 rust-regex+unicode-bool-devel \
 rust-regex+unicode-case-devel \
 rust-regex+unicode-gencat-devel \
 rust-regex+unicode-perl-devel \
 rust-regex+unicode-script-devel \
 rust-regex+unicode-segment-devel \
 rust-regex-automata+unicode-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-devel \
 "
RDEPENDS:rust-regex+unicode-gencat-devel = " \
 cargo \
 rust-regex-automata+unicode-gencat-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-gencat-devel \
 "
RDEPENDS:rust-regex+unicode-perl-devel = " \
 cargo \
 rust-regex-automata+unicode-perl-devel \
 rust-regex-automata+unicode-word-boundary-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-perl-devel \
 "
RDEPENDS:rust-regex+unicode-script-devel = " \
 cargo \
 rust-regex-automata+unicode-script-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-script-devel \
 "
RDEPENDS:rust-regex+unicode-segment-devel = " \
 cargo \
 rust-regex-automata+unicode-segment-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-segment-devel \
 "
RDEPENDS:rust-regex+unstable-devel = " \
 cargo \
 rust-regex+pattern-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+use_std-devel = " \
 cargo \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex-devel = " \
 cargo \
 rust \
 rust-regex-automata+alloc-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 rust-regex-syntax-devel \
 "
