# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-elixir"
PV = "0.3.5"
PR = "3.el10_1"
PACKAGES = " \
 rust-tree-sitter-elixir+default-devel \
 rust-tree-sitter-elixir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-elixir-0.3.5-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f656d2ed8a7c197ba9ba7e90414f375ffcecf58d9fab978ec3c062e596fdf34d"

URI_x86_64_v2_rust-tree-sitter-elixir+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-elixir+default-devel-0.3.5-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-elixir+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-elixir+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-elixir+default-devel.sha256sum] = "c5327a6ba5bd09386c9cf4cfd01083f20ae1f0ec22eb3542e5033bdf991d71a8"

URI_x86_64_v2_rust-tree-sitter-elixir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-elixir-devel-0.3.5-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-elixir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-elixir-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-elixir-devel.sha256sum] = "01d0adce04bf203c994eb50edc88e19a989c69d8cd77dcbe72241fb445ca1bc1"

URI_aarch64_rust-tree-sitter-elixir+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-elixir+default-devel-0.3.5-3.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-elixir+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-elixir+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-elixir+default-devel.sha256sum] = "18cc1717be48caca727700d309d14467ff81205c92c57824da32894b29b0d3fd"

URI_aarch64_rust-tree-sitter-elixir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-elixir-devel-0.3.5-3.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-elixir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-elixir-devel}"
SRC_URI[aarch64_rust-tree-sitter-elixir-devel.sha256sum] = "5f808f3a8c658ed213c334f381769fa7d107f32ba1d1b3a2d15003db69df4255"

RDEPENDS:rust-tree-sitter-elixir+default-devel = " \
 cargo \
 rust-tree-sitter-elixir-devel \
 "
RDEPENDS:rust-tree-sitter-elixir-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
