# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "beust-jcommander"
PV = "1.82"
PR = "10.el10"
PACKAGES = " \
 beust-jcommander \
 beust-jcommander-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/beust-jcommander-1.82-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcc05ecd90be5493a8b8280c3fd3f5d125f3d80a249549d7c0ff245be5ab0385"

URI_x86_64_v2_beust-jcommander = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/beust-jcommander-1.82-10.el10.noarch.rpm;name=x86_64_v2_beust-jcommander;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_beust-jcommander}"
SRC_URI[x86_64_v2_beust-jcommander.sha256sum] = "9f74fb8cfa175a3f3068a090f8c883c4e5da413458efc8c1aceb5a48bcfdbb31"

URI_x86_64_v2_beust-jcommander-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/beust-jcommander-javadoc-1.82-10.el10.noarch.rpm;name=x86_64_v2_beust-jcommander-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_beust-jcommander-javadoc}"
SRC_URI[x86_64_v2_beust-jcommander-javadoc.sha256sum] = "5fcce60109a39f7892a293163854f078a16bd69a6f65f7b81737f216dddc81d8"

URI_aarch64_beust-jcommander = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/beust-jcommander-1.82-10.el10.noarch.rpm;name=aarch64_beust-jcommander;unpack=0"
SRC_URI:append = " ${URI_aarch64_beust-jcommander}"
SRC_URI[aarch64_beust-jcommander.sha256sum] = "9f74fb8cfa175a3f3068a090f8c883c4e5da413458efc8c1aceb5a48bcfdbb31"

URI_aarch64_beust-jcommander-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/beust-jcommander-javadoc-1.82-10.el10.noarch.rpm;name=aarch64_beust-jcommander-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_beust-jcommander-javadoc}"
SRC_URI[aarch64_beust-jcommander-javadoc.sha256sum] = "5fcce60109a39f7892a293163854f078a16bd69a6f65f7b81737f216dddc81d8"

RDEPENDS:beust-jcommander = " \
 javapackages-filesystem \
 "
RDEPENDS:beust-jcommander-javadoc = " \
 javapackages-filesystem \
 "
