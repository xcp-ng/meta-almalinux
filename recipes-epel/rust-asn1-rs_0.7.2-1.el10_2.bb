# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-asn1-rs"
PV = "0.7.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-asn1-rs+bigint-devel \
 rust-asn1-rs+bits-devel \
 rust-asn1-rs+bitvec-devel \
 rust-asn1-rs+colored-devel \
 rust-asn1-rs+cookie-factory-devel \
 rust-asn1-rs+datetime-devel \
 rust-asn1-rs+debug-devel \
 rust-asn1-rs+default-devel \
 rust-asn1-rs+num-bigint-devel \
 rust-asn1-rs+serialize-devel \
 rust-asn1-rs+std-devel \
 rust-asn1-rs+time-devel \
 rust-asn1-rs+trace-devel \
 rust-asn1-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-asn1-rs-0.7.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b7dfa9cb91471d244107efb14c38168bb1c8419d5b0453b47854a64abfb9553"

URI_x86_64_v2_rust-asn1-rs+bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+bigint-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+bigint-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+bigint-devel.sha256sum] = "a6ada0cb19b92ada74a16f60629a4c71d8e42668e947295e24655f8712354102"

URI_x86_64_v2_rust-asn1-rs+bits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+bits-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+bits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+bits-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+bits-devel.sha256sum] = "3c3e0764ad66b7c8961319e4aa61b722192557f88c3382402f71a7399f299d72"

URI_x86_64_v2_rust-asn1-rs+bitvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+bitvec-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+bitvec-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+bitvec-devel.sha256sum] = "b2bdc72bdfcec18a4d8ca1b3a3881b7c292dde2dba251db5304104a2fa795248"

URI_x86_64_v2_rust-asn1-rs+colored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+colored-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+colored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+colored-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+colored-devel.sha256sum] = "ec2e326d50e7daea55edbf6a5b9dd39550bc5e221de37028386552fedca9c8ad"

URI_x86_64_v2_rust-asn1-rs+cookie-factory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+cookie-factory-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+cookie-factory-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+cookie-factory-devel.sha256sum] = "358bf3bd9a1e8547e212d64b35ad25a57c80168c58150e18eb8dc75dc36a4322"

URI_x86_64_v2_rust-asn1-rs+datetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+datetime-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+datetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+datetime-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+datetime-devel.sha256sum] = "81ffc007335f8e10b426663a360f39e5f926777974d621b9178fb37410e4a40c"

URI_x86_64_v2_rust-asn1-rs+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+debug-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+debug-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+debug-devel.sha256sum] = "f1029271a4c3d8d4d7f2d3302d9713b331a94cbee74f097ff0fa2591c42b242e"

URI_x86_64_v2_rust-asn1-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+default-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+default-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+default-devel.sha256sum] = "ec63cf3151feeac1530d4754955ae41b781b4b88a4af7c0dd87313fd50e4f9c6"

URI_x86_64_v2_rust-asn1-rs+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+num-bigint-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+num-bigint-devel.sha256sum] = "d1743d53bfffa4cfdcaf4e1f9bcfb37cf27de87e921cf23ce977282fd7548b50"

URI_x86_64_v2_rust-asn1-rs+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+serialize-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+serialize-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+serialize-devel.sha256sum] = "18d086252c6e06c60ec4407ac44969d1ad5c15d0d0c99950882a06d87801732c"

URI_x86_64_v2_rust-asn1-rs+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+std-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+std-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+std-devel.sha256sum] = "52508a5ab017303c15125d25c9d2d8b86629e89bdb72010c02839b43481dd0b7"

URI_x86_64_v2_rust-asn1-rs+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+time-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+time-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+time-devel.sha256sum] = "63c2464e70ee36374d7856044486a033519d61b600c9cc10e23cb58c12e87842"

URI_x86_64_v2_rust-asn1-rs+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+trace-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+trace-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+trace-devel.sha256sum] = "1f92a51d033b73aec1293c73b92ecbfbff98b0769b983ab5e02a8472e9a654fc"

URI_x86_64_v2_rust-asn1-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs-devel.sha256sum] = "34cc43e01d493a2b7e0e3fe75f4b62cbfdfa6e33e80a4907cf875a5f7cea99c0"

URI_aarch64_rust-asn1-rs+bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+bigint-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs+bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+bigint-devel}"
SRC_URI[aarch64_rust-asn1-rs+bigint-devel.sha256sum] = "d31c296c6f0598a6204becb4212eedbe1b9d7c620a5d55f2b3c975f3feef360f"

URI_aarch64_rust-asn1-rs+bits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+bits-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs+bits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+bits-devel}"
SRC_URI[aarch64_rust-asn1-rs+bits-devel.sha256sum] = "a1cfbce018730b377b4ae44caae7af7224624260965d7f51bf3000906049442b"

URI_aarch64_rust-asn1-rs+bitvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+bitvec-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+bitvec-devel}"
SRC_URI[aarch64_rust-asn1-rs+bitvec-devel.sha256sum] = "24fb09016dd13889c4c71ee2d303a13bc1cb2e1bc9fb3c2bc9f5988c0c5125fd"

URI_aarch64_rust-asn1-rs+colored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+colored-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs+colored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+colored-devel}"
SRC_URI[aarch64_rust-asn1-rs+colored-devel.sha256sum] = "2fdfda056dc4a8f7aabd69268440396d318f354851ec7404894cced913671b9b"

URI_aarch64_rust-asn1-rs+cookie-factory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+cookie-factory-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs+cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+cookie-factory-devel}"
SRC_URI[aarch64_rust-asn1-rs+cookie-factory-devel.sha256sum] = "1c532a694ea9f20ead6a83b280aaf872da0ab9828c5887ae26b2c95b395ae98d"

URI_aarch64_rust-asn1-rs+datetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+datetime-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs+datetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+datetime-devel}"
SRC_URI[aarch64_rust-asn1-rs+datetime-devel.sha256sum] = "4ae774de58ac4f539c6cafca365c28ce54d65462ffb2bc8c01ac176aebe3db0b"

URI_aarch64_rust-asn1-rs+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+debug-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+debug-devel}"
SRC_URI[aarch64_rust-asn1-rs+debug-devel.sha256sum] = "50ce3485bde7d28231be29702dbc13f57e4db87d65bdbe3bf05571c8efa5c43d"

URI_aarch64_rust-asn1-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+default-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+default-devel}"
SRC_URI[aarch64_rust-asn1-rs+default-devel.sha256sum] = "6241b04065b91a12c11a8af220ffc9d598b78fdb5e0f87bb815a8aca1b280749"

URI_aarch64_rust-asn1-rs+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+num-bigint-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+num-bigint-devel}"
SRC_URI[aarch64_rust-asn1-rs+num-bigint-devel.sha256sum] = "2279b199d8c10664c7989c6439ee356fd3af878282390dd36410a38e4a0986f3"

URI_aarch64_rust-asn1-rs+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+serialize-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+serialize-devel}"
SRC_URI[aarch64_rust-asn1-rs+serialize-devel.sha256sum] = "585c46d092a593d7ddf502823be48b0c4c1fd40fdd80a5cf7f5c7acec0374cfd"

URI_aarch64_rust-asn1-rs+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+std-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+std-devel}"
SRC_URI[aarch64_rust-asn1-rs+std-devel.sha256sum] = "9c048b06cc297b0bdb35980057da35677904932a8c85c52d7f303d8dffd9d1db"

URI_aarch64_rust-asn1-rs+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+time-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+time-devel}"
SRC_URI[aarch64_rust-asn1-rs+time-devel.sha256sum] = "b9368e6c9f5de3434e60929f3635679668cd50b5744d3047f59987ee67340e37"

URI_aarch64_rust-asn1-rs+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+trace-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+trace-devel}"
SRC_URI[aarch64_rust-asn1-rs+trace-devel.sha256sum] = "6d3eab52be2c82b725053cd8ac7936e585595f7a1a29490de944fd1d1c670681"

URI_aarch64_rust-asn1-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs-devel}"
SRC_URI[aarch64_rust-asn1-rs-devel.sha256sum] = "e80077f2217a9799fe33b82454ec7a03df794eb1922523399cb7d183f2967a7d"

RDEPENDS:rust-asn1-rs+bigint-devel = " \
 cargo \
 rust-asn1-rs+num-bigint-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+bits-devel = " \
 cargo \
 rust-asn1-rs+bitvec-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+bitvec-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-bitvec+default-devel \
 "
RDEPENDS:rust-asn1-rs+colored-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-colored+default-devel \
 "
RDEPENDS:rust-asn1-rs+cookie-factory-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-cookie-factory+default-devel \
 "
RDEPENDS:rust-asn1-rs+datetime-devel = " \
 cargo \
 rust-asn1-rs+time-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+debug-devel = " \
 cargo \
 rust-asn1-rs+colored-devel \
 rust-asn1-rs+std-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+default-devel = " \
 cargo \
 rust-asn1-rs+std-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+num-bigint-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-num-bigint+default-devel \
 "
RDEPENDS:rust-asn1-rs+serialize-devel = " \
 cargo \
 rust-asn1-rs+cookie-factory-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+std-devel = " \
 cargo \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+time-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-asn1-rs+trace-devel = " \
 cargo \
 rust-asn1-rs+debug-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs-devel = " \
 cargo \
 rust \
 rust-asn1-rs-derive+default-devel \
 rust-asn1-rs-impl+default-devel \
 rust-displaydoc+default-devel \
 rust-nom7+std-devel \
 rust-nom7-devel \
 rust-num-traits+default-devel \
 rust-rusticata-macros+default-devel \
 rust-thiserror+default-devel \
 "
