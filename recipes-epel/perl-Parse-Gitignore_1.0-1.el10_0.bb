# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Parse-Gitignore"
PV = "1.0"
PR = "1.el10_0"
PACKAGES = " \
 perl-Parse-Gitignore \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Parse-Gitignore-1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3dd2302760445ca62ab50b933ffab2dc7883ec70587cd3dbeffbf7dc13ad897"

URI_x86_64_v2_perl-Parse-Gitignore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Parse-Gitignore-1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Parse-Gitignore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Parse-Gitignore}"
SRC_URI[x86_64_v2_perl-Parse-Gitignore.sha256sum] = "aed9711c3d602ee436c7ee4c033a4611f3d23b6c6a66183a6043507cff4a1f5d"

URI_aarch64_perl-Parse-Gitignore = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Parse-Gitignore-1.0-1.el10_0.noarch.rpm;name=aarch64_perl-Parse-Gitignore;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Parse-Gitignore}"
SRC_URI[aarch64_perl-Parse-Gitignore.sha256sum] = "90c836d5834e833161c4e106217a5317495c110f250332300bbfd27a5234aec5"

RDEPENDS:perl-Parse-Gitignore = " \
 perl-Carp \
 perl-File-Slurper \
 perl-PathTools \
 perl-libs \
 "
