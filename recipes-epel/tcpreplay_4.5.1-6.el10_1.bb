# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tcpreplay"
PV = "4.5.1"
PR = "6.el10_1"
PACKAGES = " \
 tcpreplay \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tcpreplay-4.5.1-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b140906301460e4421e7b27c8c31eecc5d94c6a98566d817e784555feb2484a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcpreplay-4.5.1-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcpreplay;unpack=0"
SRC_URI[x86_64_v2_tcpreplay.sha256sum] = "2beb72b18b7f7a0478310a755b27f57be18cddb788896617d6e5d604441918c4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tcpreplay-4.5.1-6.el10_1.aarch64.rpm;name=aarch64_tcpreplay;unpack=0"
SRC_URI[aarch64_tcpreplay.sha256sum] = "edd78cdb944e8f8a0d52f00717780dad81319f185319ecbf3a1f970d602c5043"

RDEPENDS:tcpreplay = " \
 glibc \
 libpcap \
 tcpdump \
 "
