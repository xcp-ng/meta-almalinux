# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spacer"
PV = "0.5.0"
PR = "1.el10_3"
PACKAGES = " \
 spacer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spacer-0.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f9b414f3f75c3254994fa2493a7bde4f73dc924ffa0528a1fc97b25dc6961f8"

URI_x86_64_v2_spacer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spacer-0.5.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spacer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spacer}"
SRC_URI[x86_64_v2_spacer.sha256sum] = "c8570fcd3902d6789d4d9b56cd26570a7445aa2aeded44693b67c2445b60e1f0"

URI_aarch64_spacer = "${EPEL_MIRROR}/aarch64/Packages/s/spacer-0.5.0-1.el10_3.aarch64.rpm;name=aarch64_spacer;unpack=0"
SRC_URI:append = " ${URI_aarch64_spacer}"
SRC_URI[aarch64_spacer.sha256sum] = "72fbc7377eb7ce5ee6955bb1bd4fddd8d1bed391166e2f17f001e929329e4cea"

RDEPENDS:spacer = " \
 glibc \
 libgcc \
 "
