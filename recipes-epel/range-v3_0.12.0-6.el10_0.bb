# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "range-v3"
PV = "0.12.0"
PR = "6.el10_0"
PACKAGES = " \
 range-v3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/range-v3-0.12.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fa1e66260a7671ee2e95c7184e20cbc4940baddfa1ccb68d564955ee6216310"

URI_x86_64_v2_range-v3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/range-v3-devel-0.12.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_range-v3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_range-v3-devel}"
SRC_URI[x86_64_v2_range-v3-devel.sha256sum] = "d8a0450dcd1bfc78abe835e9395dba2c38dd10015e3e7b63463ecba1fc2f98e2"

URI_aarch64_range-v3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/range-v3-devel-0.12.0-6.el10_0.aarch64.rpm;name=aarch64_range-v3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_range-v3-devel}"
SRC_URI[aarch64_range-v3-devel.sha256sum] = "887e46d8edb7a5dc3652df7dc888b270999571b862e8a00056b84c706e4117c8"

RDEPENDS:range-v3-devel = " \
 cmake-filesystem \
 "
