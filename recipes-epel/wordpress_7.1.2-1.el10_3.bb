# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wordpress"
PV = "7.1.2"
PR = "1.el10_3"
PACKAGES = " \
 wordpress \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/wordpress-7.1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ab3b4145af327992accc1f550813959e65e488d33733b7c2f9d022e8d86fe2e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wordpress-7.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_wordpress;unpack=0"
SRC_URI[x86_64_v2_wordpress.sha256sum] = "0a460d7e355b1d466611fb81b9f1eb74979c4adcbf5debbe13e197b429640b6c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wordpress-7.1.2-1.el10_3.noarch.rpm;name=aarch64_wordpress;unpack=0"
SRC_URI[aarch64_wordpress.sha256sum] = "00896275af84c7001426d018095277aa9e87b36b033f70a7b732cc837cb37241"

RDEPENDS:wordpress = " \
 ca-certificates \
 httpd \
 httpd-filesystem \
 nginx-filesystem \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-gettext \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-libxml \
 virtual/php-mbstring \
 virtual/php-mysqli \
 virtual/php-openssl \
 virtual/php-simplexml \
 virtual/php-sodium \
 virtual/php-xml \
 virtual/php-xmlreader \
 virtual/php-zip \
 virtual/php-zlib \
 virtual/php_httpd_ \
 virtual/php_language__ge_7.2 \
 virtual/webserver \
 "
