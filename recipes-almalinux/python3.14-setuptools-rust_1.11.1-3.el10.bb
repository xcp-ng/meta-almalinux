# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-setuptools-rust"
PV = "1.11.1"
PR = "3.el10"
PACKAGES = " \
 python3.14-setuptools-rust \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python3.14-setuptools-rust-1.11.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "300e64357d56d004824a0c8d6ddb154ce5f8783d272d22a79247b0bdfd938c89"

URI_x86_64_v2_python3.14-setuptools-rust = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-setuptools-rust-1.11.1-3.el10.noarch.rpm;name=x86_64_v2_python3.14-setuptools-rust;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-setuptools-rust}"
SRC_URI[x86_64_v2_python3.14-setuptools-rust.sha256sum] = "c3945b44d446d30f706b793cc9417e0cc0c83fb4165ca4a3a7bd9c386b9b870a"

URI_aarch64_python3.14-setuptools-rust = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-setuptools-rust-1.11.1-3.el10.noarch.rpm;name=aarch64_python3.14-setuptools-rust;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-setuptools-rust}"
SRC_URI[aarch64_python3.14-setuptools-rust.sha256sum] = "c3945b44d446d30f706b793cc9417e0cc0c83fb4165ca4a3a7bd9c386b9b870a"

RDEPENDS:python3.14-setuptools-rust = " \
 python3.14 \
 python3.14-semantic_version \
 python3.14-setuptools \
 "
