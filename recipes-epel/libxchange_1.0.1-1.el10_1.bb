# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxchange"
PV = "1.0.1"
PR = "1.el10_1"
PACKAGES = " \
 libxchange \
 libxchange-devel \
 libxchange-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libxchange-1.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ba274206daa49fb26182fe82d1c014522965a95a29d236c089a79ff0e2ab6649"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxchange-1.0.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxchange;unpack=0"
SRC_URI[x86_64_v2_libxchange.sha256sum] = "c7bb765203e5db403237c07fbaff654e2b8f1551e623acfb8c6c8ade9ac34962"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxchange-devel-1.0.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxchange-devel;unpack=0"
SRC_URI[x86_64_v2_libxchange-devel.sha256sum] = "c2cb9063315273604cce7b4b9d522404de9af642bca8fd70310fa04878d0cc5c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxchange-doc-1.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libxchange-doc;unpack=0"
SRC_URI[x86_64_v2_libxchange-doc.sha256sum] = "8ac19b4573c846daa0694de87e46c2669af75af7670079407f750607a1e14dfa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libxchange-1.0.1-1.el10_1.aarch64.rpm;name=aarch64_libxchange;unpack=0"
SRC_URI[aarch64_libxchange.sha256sum] = "e36c8060d626f42290efbde6c75989444bc4e776b2ef6cff6a4b7f62e7ab4bce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libxchange-devel-1.0.1-1.el10_1.aarch64.rpm;name=aarch64_libxchange-devel;unpack=0"
SRC_URI[aarch64_libxchange-devel.sha256sum] = "d9aa08864ee5d4d35ac92c74dbe572be44ff36b5de2dda7a49385f06bb2467c4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libxchange-doc-1.0.1-1.el10_1.noarch.rpm;name=aarch64_libxchange-doc;unpack=0"
SRC_URI[aarch64_libxchange-doc.sha256sum] = "9bc0819ab12199321df572df1ea0973d02d7f518819df27d1f0b3cbd7a300472"

RDEPENDS:libxchange = " \
 glibc \
 "
RDEPENDS:libxchange-devel = " \
 libxchange \
 "
RDEPENDS:libxchange-doc = " \
 "
