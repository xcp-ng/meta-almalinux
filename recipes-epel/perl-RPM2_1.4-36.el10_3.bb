# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-RPM2"
PV = "1.4"
PR = "36.el10_3"
PACKAGES = " \
 perl-RPM2 \
 perl-RPM2-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-RPM2-1.4-36.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d24d1ee8f2eec929051c2457f8cf4426ac6c9120070aeac782cbe7141607670"

URI_x86_64_v2_perl-RPM2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-RPM2-1.4-36.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-RPM2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-RPM2}"
SRC_URI[x86_64_v2_perl-RPM2.sha256sum] = "79d24d9a5a7bffdf34c44c9adc196af265a6ab1a69e743f11690e5e209f8cb3e"

URI_x86_64_v2_perl-RPM2-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-RPM2-tests-1.4-36.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-RPM2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-RPM2-tests}"
SRC_URI[x86_64_v2_perl-RPM2-tests.sha256sum] = "3a9a3d9fdfcdd80a6fa71627c05034c8799d96f750079bae8c3392438bf42ab8"

URI_aarch64_perl-RPM2 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-RPM2-1.4-36.el10_3.aarch64.rpm;name=aarch64_perl-RPM2;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-RPM2}"
SRC_URI[aarch64_perl-RPM2.sha256sum] = "eab44c58694f33ee259f175d8f92aadf5a7904275210a0ab6e8095c479eb7a9b"

URI_aarch64_perl-RPM2-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-RPM2-tests-1.4-36.el10_3.noarch.rpm;name=aarch64_perl-RPM2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-RPM2-tests}"
SRC_URI[aarch64_perl-RPM2-tests.sha256sum] = "5dbb4c55f70596924b618da9857da3e504e65f0e75edf7a981bb34e7e56bcb8c"

RDEPENDS:perl-RPM2 = " \
 glibc \
 perl-DynaLoader \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 perl-overload \
 rpm-libs \
 "
RDEPENDS:perl-RPM2-tests = " \
 bash \
 perl-File-Temp \
 perl-POSIX \
 perl-RPM2 \
 perl-Test \
 perl-Test-Harness \
 perl-interpreter \
 perl-libs \
 rpm \
 "
