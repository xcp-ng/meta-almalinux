# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deranged"
PV = "0.4.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-deranged+alloc-devel \
 rust-deranged+default-devel \
 rust-deranged+num-devel \
 rust-deranged+powerfmt-devel \
 rust-deranged+quickcheck-devel \
 rust-deranged+rand-devel \
 rust-deranged+rand08-devel \
 rust-deranged+rand09-devel \
 rust-deranged+serde-devel \
 rust-deranged+std-devel \
 rust-deranged-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deranged-0.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7b97a1ba66ffbbbb7a9c8ea39823ec2e167d6a4d4810177273231c8ff2b83e5"

URI_x86_64_v2_rust-deranged+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+alloc-devel-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+alloc-devel}"
SRC_URI[x86_64_v2_rust-deranged+alloc-devel.sha256sum] = "15e28628f2ab9127be04a5ae2200c41095a2241d55a8c857e6292b427dccd21c"

URI_x86_64_v2_rust-deranged+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+default-devel-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+default-devel}"
SRC_URI[x86_64_v2_rust-deranged+default-devel.sha256sum] = "586c41eb40ba5d09651ffe1800e1b8582f23edb762932b5750d215a7705a7ab4"

URI_x86_64_v2_rust-deranged+num-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+num-devel-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+num-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+num-devel}"
SRC_URI[x86_64_v2_rust-deranged+num-devel.sha256sum] = "ec185e1e3a2084fdbf53f34c8332270f253d13c4079053d0771fb75dbd74f893"

URI_x86_64_v2_rust-deranged+powerfmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+powerfmt-devel-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+powerfmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+powerfmt-devel}"
SRC_URI[x86_64_v2_rust-deranged+powerfmt-devel.sha256sum] = "c008a9c65c3c90454a6cd5aed8942e9eeab8e9da6a68ac73d2eca5c3f9cf047d"

URI_x86_64_v2_rust-deranged+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+quickcheck-devel-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-deranged+quickcheck-devel.sha256sum] = "2a18511d759032cb882fc26e7167be759df3518155bd0499e560d27f948c4267"

URI_x86_64_v2_rust-deranged+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+rand-devel-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+rand-devel}"
SRC_URI[x86_64_v2_rust-deranged+rand-devel.sha256sum] = "60fd95a65321d6718577db95aaaf30178b466e74da9e080eaef40c84519948d5"

URI_x86_64_v2_rust-deranged+rand08-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+rand08-devel-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+rand08-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+rand08-devel}"
SRC_URI[x86_64_v2_rust-deranged+rand08-devel.sha256sum] = "5abb798d4fbe40adb501793b88db6a4d2728770b62fa8020ecb4116eb639cab2"

URI_x86_64_v2_rust-deranged+rand09-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+rand09-devel-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+rand09-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+rand09-devel}"
SRC_URI[x86_64_v2_rust-deranged+rand09-devel.sha256sum] = "3ba0a949ddc448fb4c37bed86c8bd1342dcf03249b576ba221ab4b424b4397d6"

URI_x86_64_v2_rust-deranged+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+serde-devel-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+serde-devel}"
SRC_URI[x86_64_v2_rust-deranged+serde-devel.sha256sum] = "c66b84c4d55f79311b3dc3edba1fe730a29b3aa88ce4605978872650e8f6523c"

URI_x86_64_v2_rust-deranged+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+std-devel-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+std-devel}"
SRC_URI[x86_64_v2_rust-deranged+std-devel.sha256sum] = "18cbb648ac232ce28163193e49c8e6d0c21f8ba007ce44a7915444a170a6cb4e"

URI_x86_64_v2_rust-deranged-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged-devel-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged-devel}"
SRC_URI[x86_64_v2_rust-deranged-devel.sha256sum] = "3967d9fa80e8c1101e6d8f76a11d4cf1586c9137b73613c3bf84f709a6e5d21e"

URI_aarch64_rust-deranged+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+alloc-devel-0.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-deranged+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+alloc-devel}"
SRC_URI[aarch64_rust-deranged+alloc-devel.sha256sum] = "a1882656c5569f09090082f1713fff2b710b88a619737e9f9e600249ba30d83a"

URI_aarch64_rust-deranged+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+default-devel-0.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-deranged+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+default-devel}"
SRC_URI[aarch64_rust-deranged+default-devel.sha256sum] = "b195ceeebe678dbafdd2f666de7827bb82279177c8d757602645563dc560ad2f"

URI_aarch64_rust-deranged+num-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+num-devel-0.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-deranged+num-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+num-devel}"
SRC_URI[aarch64_rust-deranged+num-devel.sha256sum] = "cb1c95b077125d57a8eed4e1516f62a8efde23821bd514d60e42f953ced331ee"

URI_aarch64_rust-deranged+powerfmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+powerfmt-devel-0.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-deranged+powerfmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+powerfmt-devel}"
SRC_URI[aarch64_rust-deranged+powerfmt-devel.sha256sum] = "bcb712929edf2369bb2c8162613e4b0ebbb65ec4f3337f17b665f2c2eab0ff40"

URI_aarch64_rust-deranged+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+quickcheck-devel-0.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-deranged+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+quickcheck-devel}"
SRC_URI[aarch64_rust-deranged+quickcheck-devel.sha256sum] = "0a7e317d20f3e6eee7c6519152188b0e98739e44f8e04b5b581d2b8812d3e59b"

URI_aarch64_rust-deranged+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+rand-devel-0.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-deranged+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+rand-devel}"
SRC_URI[aarch64_rust-deranged+rand-devel.sha256sum] = "150a92053826aac0623ff4ca5583c19435e273940a8745ddce6822fb7e5b426d"

URI_aarch64_rust-deranged+rand08-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+rand08-devel-0.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-deranged+rand08-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+rand08-devel}"
SRC_URI[aarch64_rust-deranged+rand08-devel.sha256sum] = "568cc30c613d3978d44c8cf97a6351073624e6fe1d640907939735199ebbc8eb"

URI_aarch64_rust-deranged+rand09-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+rand09-devel-0.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-deranged+rand09-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+rand09-devel}"
SRC_URI[aarch64_rust-deranged+rand09-devel.sha256sum] = "6f8db3c1cabb663c6f12655409ad7bae244b74d69a00c45210f0546757572f03"

URI_aarch64_rust-deranged+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+serde-devel-0.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-deranged+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+serde-devel}"
SRC_URI[aarch64_rust-deranged+serde-devel.sha256sum] = "e1c818eabeb0402bd27a9757d3707eb364a5100172106cb10c250af7090bf137"

URI_aarch64_rust-deranged+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+std-devel-0.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-deranged+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+std-devel}"
SRC_URI[aarch64_rust-deranged+std-devel.sha256sum] = "59e19db215d981d7443f2a2ac7e1601d188ab97215561367874bd9735178fbf6"

URI_aarch64_rust-deranged-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged-devel-0.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-deranged-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged-devel}"
SRC_URI[aarch64_rust-deranged-devel.sha256sum] = "4046e36971098293122dfbf24f66462c072a99ea05ec3dde484094ab3cfb5cee"

RDEPENDS:rust-deranged+alloc-devel = " \
 cargo \
 rust-deranged-devel \
 "
RDEPENDS:rust-deranged+default-devel = " \
 cargo \
 rust-deranged+std-devel \
 rust-deranged-devel \
 "
RDEPENDS:rust-deranged+num-devel = " \
 cargo \
 rust-deranged-devel \
 rust-num-traits-devel \
 "
RDEPENDS:rust-deranged+powerfmt-devel = " \
 cargo \
 rust-deranged-devel \
 rust-powerfmt-devel \
 "
RDEPENDS:rust-deranged+quickcheck-devel = " \
 cargo \
 rust-deranged+alloc-devel \
 rust-deranged-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-deranged+rand-devel = " \
 cargo \
 rust-deranged+rand08-devel \
 rust-deranged+rand09-devel \
 rust-deranged-devel \
 "
RDEPENDS:rust-deranged+rand08-devel = " \
 cargo \
 rust-deranged-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-deranged+rand09-devel = " \
 cargo \
 rust-deranged-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-deranged+serde-devel = " \
 cargo \
 rust-deranged-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-deranged+std-devel = " \
 cargo \
 rust-deranged+alloc-devel \
 rust-deranged-devel \
 "
RDEPENDS:rust-deranged-devel = " \
 cargo \
 rust \
 "
