# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derive_arbitrary"
PV = "1.4.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-derive_arbitrary+default-devel \
 rust-derive_arbitrary-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-derive_arbitrary-1.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "345cc7641a817633bbf35533431a9df41dedd691b79c154cc9c652777789d085"

URI_x86_64_v2_rust-derive_arbitrary+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_arbitrary+default-devel-1.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_arbitrary+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_arbitrary+default-devel}"
SRC_URI[x86_64_v2_rust-derive_arbitrary+default-devel.sha256sum] = "004940dd421f357c49134523ca952fe69007db202d21060979a070439547d939"

URI_x86_64_v2_rust-derive_arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_arbitrary-devel-1.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_arbitrary-devel}"
SRC_URI[x86_64_v2_rust-derive_arbitrary-devel.sha256sum] = "1815226d13845715322236cac0087ca2033f62daa6045c95cb92ae31cf4b3f45"

URI_aarch64_rust-derive_arbitrary+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_arbitrary+default-devel-1.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-derive_arbitrary+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_arbitrary+default-devel}"
SRC_URI[aarch64_rust-derive_arbitrary+default-devel.sha256sum] = "0815ff4abd7d385f06a36fbbad2be674840a9447afd5c25989a6726580284c32"

URI_aarch64_rust-derive_arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_arbitrary-devel-1.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-derive_arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_arbitrary-devel}"
SRC_URI[aarch64_rust-derive_arbitrary-devel.sha256sum] = "dc62db7f5d0b4506d1acb042a9b683d857d7884f94002cc404df539e20ad88de"

RDEPENDS:rust-derive_arbitrary+default-devel = " \
 cargo \
 rust-derive_arbitrary-devel \
 "
RDEPENDS:rust-derive_arbitrary-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+parsing-devel \
 "
