# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oniguruma"
PV = "6.9.9"
PR = "7.el10"
PACKAGES = " \
 oniguruma \
 oniguruma-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/oniguruma-6.9.9-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "479bb902b2324247d5238611cf078979e4beccc3872c3d3803ecb6266e0ba740"

URI_x86_64_v2_oniguruma = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/oniguruma-6.9.9-7.el10.x86_64_v2.rpm;name=x86_64_v2_oniguruma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oniguruma}"
SRC_URI[x86_64_v2_oniguruma.sha256sum] = "3631cdbd84800c12de026ec836470f2b3a91de380333e3e52165b6c9572b007a"

URI_x86_64_v2_oniguruma-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/oniguruma-devel-6.9.9-7.el10.x86_64_v2.rpm;name=x86_64_v2_oniguruma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oniguruma-devel}"
SRC_URI[x86_64_v2_oniguruma-devel.sha256sum] = "c15522d80a9a44f07a98dafb381d1743d69f8209b11840272755607f02383c9d"

URI_aarch64_oniguruma = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/oniguruma-6.9.9-7.el10.aarch64.rpm;name=aarch64_oniguruma;unpack=0"
SRC_URI:append = " ${URI_aarch64_oniguruma}"
SRC_URI[aarch64_oniguruma.sha256sum] = "60b9eb3a6b0a39b67abbfb3cdb4278550a3c51be0cbd7ba2588c3dc3d5eb7f39"

URI_aarch64_oniguruma-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/oniguruma-devel-6.9.9-7.el10.aarch64.rpm;name=aarch64_oniguruma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_oniguruma-devel}"
SRC_URI[aarch64_oniguruma-devel.sha256sum] = "59b9522edb176242e3d474831b65bccaf322bb8abc0745ffc42ad197135db3cd"

RDEPENDS:oniguruma = " \
 glibc \
 "
RDEPENDS:oniguruma-devel = " \
 bash \
 oniguruma \
 pkgconf-pkg-config \
 "
