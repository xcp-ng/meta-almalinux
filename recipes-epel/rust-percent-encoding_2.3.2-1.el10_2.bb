# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-percent-encoding"
PV = "2.3.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-percent-encoding+alloc-devel \
 rust-percent-encoding+default-devel \
 rust-percent-encoding+std-devel \
 rust-percent-encoding-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-percent-encoding-2.3.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6ae41a8222a3f758d2906982f1b1c5913e28310886e27d4ba94b76e7f017ab05"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-percent-encoding+alloc-devel-2.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-percent-encoding+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-percent-encoding+alloc-devel.sha256sum] = "150311418aa5a687664af4636316a92e201d039b94e986b9b95ed0fd4ea8993f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-percent-encoding+default-devel-2.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-percent-encoding+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-percent-encoding+default-devel.sha256sum] = "16d70cdcf0de6f4ca076de2df02b608cad6d83f9bd5ef0de4e873bca4ab703b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-percent-encoding+std-devel-2.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-percent-encoding+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-percent-encoding+std-devel.sha256sum] = "46889590f80aa4152a1dceb68bfb44975871712d927190a939d441c3cc75073e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-percent-encoding-devel-2.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-percent-encoding-devel;unpack=0"
SRC_URI[x86_64_v2_rust-percent-encoding-devel.sha256sum] = "6d6140cb996a2b238bfd7af0cb6cd9dde0c1afb00f5fba886d1c2abb5a13d6a9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-percent-encoding+alloc-devel-2.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-percent-encoding+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-percent-encoding+alloc-devel.sha256sum] = "72bb8c84ffa2d0431582e0557549124c2495776632cb2f8225fdb35944f48164"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-percent-encoding+default-devel-2.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-percent-encoding+default-devel;unpack=0"
SRC_URI[aarch64_rust-percent-encoding+default-devel.sha256sum] = "4bb763a214c223741a5ade620b50259350001f4e893a952fa744fcc086a5abd6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-percent-encoding+std-devel-2.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-percent-encoding+std-devel;unpack=0"
SRC_URI[aarch64_rust-percent-encoding+std-devel.sha256sum] = "6a9942fa8a647a13663d2ab762fc66d36e7b43ca8c136ceb13dbdcd7b9823a73"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-percent-encoding-devel-2.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-percent-encoding-devel;unpack=0"
SRC_URI[aarch64_rust-percent-encoding-devel.sha256sum] = "ad5b98d26962e2aeee6145416e3da0c1dc9a39fea16ee62a858802693361d209"

RDEPENDS:rust-percent-encoding+alloc-devel = " \
 cargo \
 rust-percent-encoding-devel \
 "
RDEPENDS:rust-percent-encoding+default-devel = " \
 cargo \
 rust-percent-encoding+std-devel \
 rust-percent-encoding-devel \
 "
RDEPENDS:rust-percent-encoding+std-devel = " \
 cargo \
 rust-percent-encoding+alloc-devel \
 rust-percent-encoding-devel \
 "
RDEPENDS:rust-percent-encoding-devel = " \
 cargo \
 rust \
 "
