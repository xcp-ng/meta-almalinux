# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-simba"
PV = "0.9.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-simba+cordic-devel \
 rust-simba+default-devel \
 rust-simba+fixed-devel \
 rust-simba+libm-devel \
 rust-simba+libm_force-devel \
 rust-simba+partial_fixed_point_support-devel \
 rust-simba+portable_simd-devel \
 rust-simba+rand-devel \
 rust-simba+rkyv-devel \
 rust-simba+rkyv-serialize-devel \
 rust-simba+serde-devel \
 rust-simba+serde_serialize-devel \
 rust-simba+std-devel \
 rust-simba+wide-devel \
 rust-simba-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-simba-0.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06f8042aba0a4b4f2949ed7a9c3bf78ea6419d36ec5593745f8b8c3437683681"

URI_x86_64_v2_rust-simba+cordic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+cordic-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+cordic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+cordic-devel}"
SRC_URI[x86_64_v2_rust-simba+cordic-devel.sha256sum] = "d928f20b10a2b6c915864183eec33ce2aed3d3162b36d7bcf53ccb7afba441e8"

URI_x86_64_v2_rust-simba+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+default-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+default-devel}"
SRC_URI[x86_64_v2_rust-simba+default-devel.sha256sum] = "a7bac9d2110f25a1253d35665dec88f4cd4e6aea65cc61c8e78a09a42561aa3e"

URI_x86_64_v2_rust-simba+fixed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+fixed-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+fixed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+fixed-devel}"
SRC_URI[x86_64_v2_rust-simba+fixed-devel.sha256sum] = "59ecb7b1e1a6839afcc90277eba818d3696468a993a856a0ab140f8d3282a6ed"

URI_x86_64_v2_rust-simba+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+libm-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+libm-devel}"
SRC_URI[x86_64_v2_rust-simba+libm-devel.sha256sum] = "155eade96853ece43f8e3061fbe73ce812d58b529b6bf0775d6f60b08ccbd34c"

URI_x86_64_v2_rust-simba+libm_force-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+libm_force-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+libm_force-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+libm_force-devel}"
SRC_URI[x86_64_v2_rust-simba+libm_force-devel.sha256sum] = "8fab5e059b46f809a712d1b6be41d9bd78b08a99bc0949f76d20ff2bad72b4b3"

URI_x86_64_v2_rust-simba+partial_fixed_point_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+partial_fixed_point_support-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+partial_fixed_point_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+partial_fixed_point_support-devel}"
SRC_URI[x86_64_v2_rust-simba+partial_fixed_point_support-devel.sha256sum] = "83cbe6339578e7cf171e44d345b18e8d924d95812a8c9ff32e5f7d1a02859335"

URI_x86_64_v2_rust-simba+portable_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+portable_simd-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+portable_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+portable_simd-devel}"
SRC_URI[x86_64_v2_rust-simba+portable_simd-devel.sha256sum] = "6bbd0d5b970c34d79be8368c43d406add82f0d0be71a560a13e6f32d7a1efc53"

URI_x86_64_v2_rust-simba+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+rand-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+rand-devel}"
SRC_URI[x86_64_v2_rust-simba+rand-devel.sha256sum] = "55af6b886931020187b99302d4c94460915d89af51d06635e06bf970b65c4efe"

URI_x86_64_v2_rust-simba+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+rkyv-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+rkyv-devel}"
SRC_URI[x86_64_v2_rust-simba+rkyv-devel.sha256sum] = "c30b5bd5376fc8733471c585f661200250269eb937bf3c04681add85b8e28e95"

URI_x86_64_v2_rust-simba+rkyv-serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+rkyv-serialize-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+rkyv-serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+rkyv-serialize-devel}"
SRC_URI[x86_64_v2_rust-simba+rkyv-serialize-devel.sha256sum] = "f31d1fde4c7d747428b91a7c79c13eb1a8876026c89a7482b737262c6aa688e0"

URI_x86_64_v2_rust-simba+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+serde-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+serde-devel}"
SRC_URI[x86_64_v2_rust-simba+serde-devel.sha256sum] = "e87da6548e6fd8d8f88431ad16bf5ba9346b6d3d7403aecaa452cbbbc7a33930"

URI_x86_64_v2_rust-simba+serde_serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+serde_serialize-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+serde_serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+serde_serialize-devel}"
SRC_URI[x86_64_v2_rust-simba+serde_serialize-devel.sha256sum] = "c8502e2dd5fb8a7a67cc9127a998e91f4cecf5102b5a0f5ca57b4d8dd71b6bfc"

URI_x86_64_v2_rust-simba+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+std-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+std-devel}"
SRC_URI[x86_64_v2_rust-simba+std-devel.sha256sum] = "069edbdcc43126ff88cbe18c4ed143277a36b8ae97371f247165da982918ed52"

URI_x86_64_v2_rust-simba+wide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+wide-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+wide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+wide-devel}"
SRC_URI[x86_64_v2_rust-simba+wide-devel.sha256sum] = "962460945b22dbfa6e05d51485e70e19379c02a3f06246b3c1bd487db411650b"

URI_x86_64_v2_rust-simba-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba-devel}"
SRC_URI[x86_64_v2_rust-simba-devel.sha256sum] = "32798167ae3ca1cdfdf28818b69c3bf892a3feb68fd54730b115c0cbf50623ec"

URI_aarch64_rust-simba+cordic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+cordic-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-simba+cordic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+cordic-devel}"
SRC_URI[aarch64_rust-simba+cordic-devel.sha256sum] = "41588b3d6c75fd00eba1bde9653de205448c3fc87afafed600739bc0e6b06c1c"

URI_aarch64_rust-simba+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+default-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-simba+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+default-devel}"
SRC_URI[aarch64_rust-simba+default-devel.sha256sum] = "850eef343dd7cdf85d2aa36f0e21ee1353148c12c8080c251398c3c5beff8a40"

URI_aarch64_rust-simba+fixed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+fixed-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-simba+fixed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+fixed-devel}"
SRC_URI[aarch64_rust-simba+fixed-devel.sha256sum] = "31060e2f57a284ffe54a85bef7aa71b9e10ce6a19ce04439e2061abfb60c6830"

URI_aarch64_rust-simba+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+libm-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-simba+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+libm-devel}"
SRC_URI[aarch64_rust-simba+libm-devel.sha256sum] = "52f19c24cab64436b0aafc486efe29b3f9b17db228b675d0513f25fe12fbfcaa"

URI_aarch64_rust-simba+libm_force-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+libm_force-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-simba+libm_force-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+libm_force-devel}"
SRC_URI[aarch64_rust-simba+libm_force-devel.sha256sum] = "e63306007987b451af994dc1fcd6296f30d7534fc448c77e6dccddcde4e3bbac"

URI_aarch64_rust-simba+partial_fixed_point_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+partial_fixed_point_support-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-simba+partial_fixed_point_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+partial_fixed_point_support-devel}"
SRC_URI[aarch64_rust-simba+partial_fixed_point_support-devel.sha256sum] = "1f97a6e597708947c838ef2861be3ac4dd0cd651f28ef6bc2a42c12174af1471"

URI_aarch64_rust-simba+portable_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+portable_simd-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-simba+portable_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+portable_simd-devel}"
SRC_URI[aarch64_rust-simba+portable_simd-devel.sha256sum] = "0ad0564039641f83bee72e4de7da6d5cf4253c1ac2856533db0c7c901d6104ce"

URI_aarch64_rust-simba+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+rand-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-simba+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+rand-devel}"
SRC_URI[aarch64_rust-simba+rand-devel.sha256sum] = "830dace334520fe285b0c2afc40c7602eea47c4f266f4e01d6a8ea32373ba666"

URI_aarch64_rust-simba+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+rkyv-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-simba+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+rkyv-devel}"
SRC_URI[aarch64_rust-simba+rkyv-devel.sha256sum] = "d512bb025533215b055ede47c5f12788decfc1b21e51f16fcc5748248dba3cac"

URI_aarch64_rust-simba+rkyv-serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+rkyv-serialize-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-simba+rkyv-serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+rkyv-serialize-devel}"
SRC_URI[aarch64_rust-simba+rkyv-serialize-devel.sha256sum] = "e9c22aa335fcc026d3498f4b2ef18c95ed7e15d2ff7464a67b26fb0db8a55dcc"

URI_aarch64_rust-simba+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+serde-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-simba+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+serde-devel}"
SRC_URI[aarch64_rust-simba+serde-devel.sha256sum] = "2fc7713db5edcba2b99b6af1f62667cd57f9c7e7702fb5f4347b9a8c40549a00"

URI_aarch64_rust-simba+serde_serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+serde_serialize-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-simba+serde_serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+serde_serialize-devel}"
SRC_URI[aarch64_rust-simba+serde_serialize-devel.sha256sum] = "fbe36efa407af6fd86d8e78dbd24475df2a6df091b0361ea65d50100e91fb739"

URI_aarch64_rust-simba+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+std-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-simba+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+std-devel}"
SRC_URI[aarch64_rust-simba+std-devel.sha256sum] = "c21c47e7ca1a7cd28bbb952fee91123022a1ea889e40ce25078099cdd86af446"

URI_aarch64_rust-simba+wide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+wide-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-simba+wide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+wide-devel}"
SRC_URI[aarch64_rust-simba+wide-devel.sha256sum] = "f4650f074bd188c06977695a982208217114dc3d1bbdb1ed7f55577eab31b0a9"

URI_aarch64_rust-simba-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-simba-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba-devel}"
SRC_URI[aarch64_rust-simba-devel.sha256sum] = "dcfde844039117dc3906195d70d786593b9d9db9469cbf445edb1da953810daf"

RDEPENDS:rust-simba+cordic-devel = " \
 cargo \
 rust-cordic+default-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+default-devel = " \
 cargo \
 rust-simba+std-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+fixed-devel = " \
 cargo \
 rust-fixed+default-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+libm-devel = " \
 cargo \
 rust-num-traits+libm-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+libm_force-devel = " \
 cargo \
 rust-libm+default-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+partial_fixed_point_support-devel = " \
 cargo \
 rust-simba+cordic-devel \
 rust-simba+fixed-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+portable_simd-devel = " \
 cargo \
 rust-simba+std-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+rand-devel = " \
 cargo \
 rust-rand0.8+default-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+rkyv-devel = " \
 cargo \
 rust-rkyv0.7+default-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+rkyv-serialize-devel = " \
 cargo \
 rust-simba+rkyv-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+serde_serialize-devel = " \
 cargo \
 rust-fixed+default-devel \
 rust-fixed+serde-devel \
 rust-simba+serde-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+std-devel = " \
 cargo \
 rust-simba-devel \
 rust-wide+std-devel \
 rust-wide-devel \
 "
RDEPENDS:rust-simba+wide-devel = " \
 cargo \
 rust-simba-devel \
 rust-wide-devel \
 "
RDEPENDS:rust-simba-devel = " \
 cargo \
 rust-approx-devel \
 rust-num-complex-devel \
 rust-num-traits-devel \
 rust-paste+default-devel \
 "
