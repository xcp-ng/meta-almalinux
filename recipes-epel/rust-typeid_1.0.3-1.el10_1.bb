# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typeid"
PV = "1.0.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-typeid+default-devel \
 rust-typeid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typeid-1.0.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0daaa152be4eafac2e5974d257f3256e2223212661a5aa3f194483db00c7e39a"

URI_x86_64_v2_rust-typeid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typeid+default-devel-1.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typeid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typeid+default-devel}"
SRC_URI[x86_64_v2_rust-typeid+default-devel.sha256sum] = "32fb2cc7969031937038e74644fba634eeb783b4d2b133e362ac0ed18d4ab686"

URI_x86_64_v2_rust-typeid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typeid-devel-1.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typeid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typeid-devel}"
SRC_URI[x86_64_v2_rust-typeid-devel.sha256sum] = "dff68c804dadb7b325a3b77e614e70a7100357ff7f05844967c5b7ba8cc6315e"

URI_aarch64_rust-typeid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typeid+default-devel-1.0.3-1.el10_1.noarch.rpm;name=aarch64_rust-typeid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typeid+default-devel}"
SRC_URI[aarch64_rust-typeid+default-devel.sha256sum] = "6f095e5d4fa642fff3f4a048d8f5dc4d5957a226d2acd7d407efc85fd462ac66"

URI_aarch64_rust-typeid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typeid-devel-1.0.3-1.el10_1.noarch.rpm;name=aarch64_rust-typeid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typeid-devel}"
SRC_URI[aarch64_rust-typeid-devel.sha256sum] = "2dce2afffbb964ef757b89383822f83dff457208b33a818a23d8fc8eff4481a8"

RDEPENDS:rust-typeid+default-devel = " \
 cargo \
 rust-typeid-devel \
 "
RDEPENDS:rust-typeid-devel = " \
 cargo \
 rust \
 "
