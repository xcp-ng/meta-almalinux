# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_complete"
PV = "4.5.64"
PR = "1.el10_1"
PACKAGES = " \
 rust-clap_complete+debug-devel \
 rust-clap_complete+default-devel \
 rust-clap_complete+unstable-doc-devel \
 rust-clap_complete+unstable-dynamic-devel \
 rust-clap_complete-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_complete-4.5.64-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abb51a88d0d1933745edac01f935922c5ac10d386095bcc7ada71f4293fd0404"

URI_x86_64_v2_rust-clap_complete+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+debug-devel-4.5.64-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+debug-devel.sha256sum] = "f3f981ab19acb592999507401ce4010d78a05560e73711f7e017db1881ae5ab8"

URI_x86_64_v2_rust-clap_complete+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+default-devel-4.5.64-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+default-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+default-devel.sha256sum] = "51ae7cb36f4413061d502c13cf6ebe9b88629cbd32fc341a125fcb04ade653cc"

URI_x86_64_v2_rust-clap_complete+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+unstable-doc-devel-4.5.64-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+unstable-doc-devel.sha256sum] = "a891e940560ba73c212d29230179d9f5fa502e492224cd973527f7fd4d83befd"

URI_x86_64_v2_rust-clap_complete+unstable-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+unstable-dynamic-devel-4.5.64-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+unstable-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+unstable-dynamic-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+unstable-dynamic-devel.sha256sum] = "c8de7447854cb2856774a3d824fb2482166ee53e55334e44332df4af9c79526a"

URI_x86_64_v2_rust-clap_complete-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete-devel-4.5.64-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete-devel}"
SRC_URI[x86_64_v2_rust-clap_complete-devel.sha256sum] = "d4abd72a88134431fc355db18e409a91ba792021b60e65a3a16c26851d1ff12b"

URI_aarch64_rust-clap_complete+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+debug-devel-4.5.64-1.el10_1.noarch.rpm;name=aarch64_rust-clap_complete+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+debug-devel}"
SRC_URI[aarch64_rust-clap_complete+debug-devel.sha256sum] = "923da84eb80c84dc66bf7434ba8cbbee9f777dc86bd127ce3ff1b40cb01b4e8d"

URI_aarch64_rust-clap_complete+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+default-devel-4.5.64-1.el10_1.noarch.rpm;name=aarch64_rust-clap_complete+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+default-devel}"
SRC_URI[aarch64_rust-clap_complete+default-devel.sha256sum] = "e1a8535205aee906f9281f1228146f9247db8f8a30fe44edc333011f79826477"

URI_aarch64_rust-clap_complete+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+unstable-doc-devel-4.5.64-1.el10_1.noarch.rpm;name=aarch64_rust-clap_complete+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+unstable-doc-devel}"
SRC_URI[aarch64_rust-clap_complete+unstable-doc-devel.sha256sum] = "b62a74923f88ed3378d0b0b5ee1eb5e75c77db4bf36dbfcffcc9b458710c4a26"

URI_aarch64_rust-clap_complete+unstable-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+unstable-dynamic-devel-4.5.64-1.el10_1.noarch.rpm;name=aarch64_rust-clap_complete+unstable-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+unstable-dynamic-devel}"
SRC_URI[aarch64_rust-clap_complete+unstable-dynamic-devel.sha256sum] = "42dfee24df0715f458d6a1099ea62f6b0b522f5d3f7b3674261c817f6593a663"

URI_aarch64_rust-clap_complete-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete-devel-4.5.64-1.el10_1.noarch.rpm;name=aarch64_rust-clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete-devel}"
SRC_URI[aarch64_rust-clap_complete-devel.sha256sum] = "d75d7335c252e6f89caf7bd952de9fcd6f0dcde5d25c0e0372b9229ce8b4c128"

RDEPENDS:rust-clap_complete+debug-devel = " \
 cargo \
 rust-clap+debug-devel \
 rust-clap_complete-devel \
 "
RDEPENDS:rust-clap_complete+default-devel = " \
 cargo \
 rust-clap_complete-devel \
 "
RDEPENDS:rust-clap_complete+unstable-doc-devel = " \
 cargo \
 rust-clap_complete+unstable-dynamic-devel \
 rust-clap_complete-devel \
 "
RDEPENDS:rust-clap_complete+unstable-dynamic-devel = " \
 cargo \
 rust-clap+unstable-ext-devel \
 rust-clap_complete-devel \
 rust-clap_lex+default-devel \
 rust-is_executable+default-devel \
 rust-shlex+default-devel \
 "
RDEPENDS:rust-clap_complete-devel = " \
 cargo \
 rust \
 rust-clap+std-devel \
 rust-clap-devel \
 "
