# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-base64ct"
PV = "1.8.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-base64ct+alloc-devel \
 rust-base64ct+default-devel \
 rust-base64ct+std-devel \
 rust-base64ct-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-base64ct-1.8.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48d13b52584fb30bd8adeb7798e4e6989a12fec4a6fd644393970434d100bff4"

URI_x86_64_v2_rust-base64ct+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct+alloc-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64ct+alloc-devel}"
SRC_URI[x86_64_v2_rust-base64ct+alloc-devel.sha256sum] = "f737d8e72bccc48f92f7411a1cd66685fe37d4a400cfef71142a49aaccae8417"

URI_x86_64_v2_rust-base64ct+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct+default-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64ct+default-devel}"
SRC_URI[x86_64_v2_rust-base64ct+default-devel.sha256sum] = "f160e0bb1f0973efd4317324a36dd61c4b43d674f237d28c358c92ea6f4bcb2f"

URI_x86_64_v2_rust-base64ct+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct+std-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64ct+std-devel}"
SRC_URI[x86_64_v2_rust-base64ct+std-devel.sha256sum] = "0c9b71f6b60fdd48d0e1371d9839f7657874851d8057f6fdf2fa3128a1d5447d"

URI_x86_64_v2_rust-base64ct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64ct-devel}"
SRC_URI[x86_64_v2_rust-base64ct-devel.sha256sum] = "57a00816d107200481159868aa0b99cd376b23192f951e90c0ef8d6a5c7220a8"

URI_aarch64_rust-base64ct+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct+alloc-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-base64ct+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64ct+alloc-devel}"
SRC_URI[aarch64_rust-base64ct+alloc-devel.sha256sum] = "03e1f0439a21d5cc06f7cbf1d8c2f16707bb6e38bac3bed62f9ca087b95c013c"

URI_aarch64_rust-base64ct+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct+default-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-base64ct+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64ct+default-devel}"
SRC_URI[aarch64_rust-base64ct+default-devel.sha256sum] = "251418b7067a436b63709e36524d6a8278471a4b3e635209a1248c700bc556cc"

URI_aarch64_rust-base64ct+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct+std-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-base64ct+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64ct+std-devel}"
SRC_URI[aarch64_rust-base64ct+std-devel.sha256sum] = "85356b4c21513a20a2a648387b6896f74ab915ab3008931709858409954c3cdb"

URI_aarch64_rust-base64ct-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-base64ct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64ct-devel}"
SRC_URI[aarch64_rust-base64ct-devel.sha256sum] = "efd4bc19fc7b16585ded23be2fffa05329c7b35a431c8cbf0b5062a8ed9b26c9"

RDEPENDS:rust-base64ct+alloc-devel = " \
 cargo \
 rust-base64ct-devel \
 "
RDEPENDS:rust-base64ct+default-devel = " \
 cargo \
 rust-base64ct-devel \
 "
RDEPENDS:rust-base64ct+std-devel = " \
 cargo \
 rust-base64ct+alloc-devel \
 rust-base64ct-devel \
 "
RDEPENDS:rust-base64ct-devel = " \
 cargo \
 rust \
 "
