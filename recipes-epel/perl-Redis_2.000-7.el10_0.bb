# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Redis"
PV = "2.000"
PR = "7.el10_0"
PACKAGES = " \
 perl-Redis \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Redis-2.000-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6cd885aba4522ac9ff2d8b5e2e1921708097ab0460a3ebd2871529fe810a4118"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Redis-2.000-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Redis;unpack=0"
SRC_URI[x86_64_v2_perl-Redis.sha256sum] = "c8c776e5e3e2cb491d3407eca938fddb3cffa7093c1956651b7dacd1fe505c47"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Redis-2.000-7.el10_0.noarch.rpm;name=aarch64_perl-Redis;unpack=0"
SRC_URI[aarch64_perl-Redis.sha256sum] = "cf7806231c69b4f0d848de7a8f10d9e4d0fe3b174b4137eb92c4f0989fec327b"

RDEPENDS:perl-Redis = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Errno \
 perl-Fcntl \
 perl-IO \
 perl-IO-Socket-SSL \
 perl-IO-Socket-Timeout \
 perl-Redis \
 perl-Scalar-List-Utils \
 perl-Tie \
 perl-Time-HiRes \
 perl-Try-Tiny \
 perl-base \
 perl-constant \
 perl-libs \
 "
