# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgeography"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kgeography \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgeography-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28ceb9107d691bd1fa970bde1dcf99cd0fe7b01c919d15d0183d7af1cf5f7588"

URI_x86_64_v2_kgeography = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgeography-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgeography;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgeography}"
SRC_URI[x86_64_v2_kgeography.sha256sum] = "10d6d8189c986a28fa8bd2d9a15c9a41913d47ae9df7f4aef14a1c517505f03d"

URI_aarch64_kgeography = "${EPEL_MIRROR}/aarch64/Packages/k/kgeography-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kgeography;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgeography}"
SRC_URI[aarch64_kgeography.sha256sum] = "ecd2982cf73b0c7c4b8318edb4c0be0119fa31b5c66150e6881e85be024bf284"

RDEPENDS:kgeography = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
