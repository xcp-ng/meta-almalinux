# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spice-html5"
PV = "0.3.0"
PR = "8.el10"
PACKAGES = " \
 spice-html5 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/spice-html5-0.3.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f1c27ef18e11f18bcade5c9642aed3c5355bd8924201c33df56aa905769506e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/spice-html5-0.3.0-8.el10.noarch.rpm;name=x86_64_v2_spice-html5;unpack=0"
SRC_URI[x86_64_v2_spice-html5.sha256sum] = "21af7dc0e7d73c7b09cb33f4571a8bd9ebcd0f5aa613102c74fa7331a1dd2f6e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/spice-html5-0.3.0-8.el10.noarch.rpm;name=aarch64_spice-html5;unpack=0"
SRC_URI[aarch64_spice-html5.sha256sum] = "21af7dc0e7d73c7b09cb33f4571a8bd9ebcd0f5aa613102c74fa7331a1dd2f6e"

RDEPENDS:spice-html5 = " \
 "
