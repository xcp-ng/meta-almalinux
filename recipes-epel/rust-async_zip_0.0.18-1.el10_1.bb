# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async_zip"
PV = "0.0.18"
PR = "1.el10_1"
PACKAGES = " \
 rust-async_zip+async-compression-devel \
 rust-async_zip+bzip2-devel \
 rust-async_zip+chrono-devel \
 rust-async_zip+default-devel \
 rust-async_zip+deflate-devel \
 rust-async_zip+deflate64-devel \
 rust-async_zip+full-devel \
 rust-async_zip+lzma-devel \
 rust-async_zip+tokio-devel \
 rust-async_zip+tokio-fs-devel \
 rust-async_zip+tokio-util-devel \
 rust-async_zip+xz-devel \
 rust-async_zip+zstd-devel \
 rust-async_zip-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async_zip-0.0.18-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4def1c680dbc888e2a671b10501b63820a50834b6bf4c0bb255fc6529b58d01c"

URI_x86_64_v2_rust-async_zip+async-compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_zip+async-compression-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_zip+async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_zip+async-compression-devel}"
SRC_URI[x86_64_v2_rust-async_zip+async-compression-devel.sha256sum] = "597d55917aec6b29e0610d17253411ee660e0eb82b15c0744780a7e10d957370"

URI_x86_64_v2_rust-async_zip+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_zip+bzip2-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_zip+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_zip+bzip2-devel}"
SRC_URI[x86_64_v2_rust-async_zip+bzip2-devel.sha256sum] = "6939c039119ee4749a8e56e77a373b1d30648bc6f74a122c0ed2d9412a48cb6c"

URI_x86_64_v2_rust-async_zip+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_zip+chrono-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_zip+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_zip+chrono-devel}"
SRC_URI[x86_64_v2_rust-async_zip+chrono-devel.sha256sum] = "111025e4c72d9d102c9a8bac1be5b176da352096f0775787c96c690a0f63b7eb"

URI_x86_64_v2_rust-async_zip+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_zip+default-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_zip+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_zip+default-devel}"
SRC_URI[x86_64_v2_rust-async_zip+default-devel.sha256sum] = "d5ed5bdf62efb56e3e09718f6a0f53f04faabd8edaa32fee4622d042846e409c"

URI_x86_64_v2_rust-async_zip+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_zip+deflate-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_zip+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_zip+deflate-devel}"
SRC_URI[x86_64_v2_rust-async_zip+deflate-devel.sha256sum] = "5748196104a2ef39deee4a4ebaa3383288551a18942fb176c92700e4696c2087"

URI_x86_64_v2_rust-async_zip+deflate64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_zip+deflate64-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_zip+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_zip+deflate64-devel}"
SRC_URI[x86_64_v2_rust-async_zip+deflate64-devel.sha256sum] = "c91c57fe939cbb6e22db84f8bba4c8988d10ca2e8b9527e026c770ca37b25e1d"

URI_x86_64_v2_rust-async_zip+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_zip+full-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_zip+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_zip+full-devel}"
SRC_URI[x86_64_v2_rust-async_zip+full-devel.sha256sum] = "963c04e5caac2197f78ffe93c1c7f495dae14474ad46714b44e8d1f4a4300e74"

URI_x86_64_v2_rust-async_zip+lzma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_zip+lzma-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_zip+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_zip+lzma-devel}"
SRC_URI[x86_64_v2_rust-async_zip+lzma-devel.sha256sum] = "32f39cd2c5ab5bec5d36e567cb4058087a3cbd25074a7ecf58e94cf806e49cf1"

URI_x86_64_v2_rust-async_zip+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_zip+tokio-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_zip+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_zip+tokio-devel}"
SRC_URI[x86_64_v2_rust-async_zip+tokio-devel.sha256sum] = "73e41d42273bada086c8c82e2be28107eb761441403c218f77804d57590b2c62"

URI_x86_64_v2_rust-async_zip+tokio-fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_zip+tokio-fs-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_zip+tokio-fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_zip+tokio-fs-devel}"
SRC_URI[x86_64_v2_rust-async_zip+tokio-fs-devel.sha256sum] = "daa71caec2a3627e3a0024333bf72a874abcbd630d24f70e3386fb89b8f5b523"

URI_x86_64_v2_rust-async_zip+tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_zip+tokio-util-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_zip+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_zip+tokio-util-devel}"
SRC_URI[x86_64_v2_rust-async_zip+tokio-util-devel.sha256sum] = "984f5ffc2fcf230507c900c29ff098db7b07cda0381e674df40e5cefbd860a92"

URI_x86_64_v2_rust-async_zip+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_zip+xz-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_zip+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_zip+xz-devel}"
SRC_URI[x86_64_v2_rust-async_zip+xz-devel.sha256sum] = "d9c9f0a98223eb15232771e6380c0db2e3151ba11eed75a575e1f8c9e1aa8717"

URI_x86_64_v2_rust-async_zip+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_zip+zstd-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_zip+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_zip+zstd-devel}"
SRC_URI[x86_64_v2_rust-async_zip+zstd-devel.sha256sum] = "6589ebbb70f5be624d327cd23386bf2bbd23a69082dc092ad9de5b153694c79a"

URI_x86_64_v2_rust-async_zip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_zip-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_zip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_zip-devel}"
SRC_URI[x86_64_v2_rust-async_zip-devel.sha256sum] = "d800d7d588913fae7ff18dc45697044334e96efd22ce24920e137850ef6164eb"

URI_aarch64_rust-async_zip+async-compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_zip+async-compression-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-async_zip+async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_zip+async-compression-devel}"
SRC_URI[aarch64_rust-async_zip+async-compression-devel.sha256sum] = "c6cef66a905abf6b51a58469ba927d7d7ab73c863b658ee430b7855c71b6b1d7"

URI_aarch64_rust-async_zip+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_zip+bzip2-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-async_zip+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_zip+bzip2-devel}"
SRC_URI[aarch64_rust-async_zip+bzip2-devel.sha256sum] = "1417715dae4e99b886cef3fbb27167a52a4acedb07e19cefd53f3aaa07149a65"

URI_aarch64_rust-async_zip+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_zip+chrono-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-async_zip+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_zip+chrono-devel}"
SRC_URI[aarch64_rust-async_zip+chrono-devel.sha256sum] = "94f80aa0a517e142e7c6aeee6cd88dedc8df5cd073652dccab87807ff5e804d2"

URI_aarch64_rust-async_zip+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_zip+default-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-async_zip+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_zip+default-devel}"
SRC_URI[aarch64_rust-async_zip+default-devel.sha256sum] = "aed3c949164d6db8e3c20810fccebfc6c96a9c4b0eea0abc5837ada5e18c37b7"

URI_aarch64_rust-async_zip+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_zip+deflate-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-async_zip+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_zip+deflate-devel}"
SRC_URI[aarch64_rust-async_zip+deflate-devel.sha256sum] = "405c541108be34c8df9a3f01214dd8c0cf3899baf0463bdf0fc7069aa00dd6e9"

URI_aarch64_rust-async_zip+deflate64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_zip+deflate64-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-async_zip+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_zip+deflate64-devel}"
SRC_URI[aarch64_rust-async_zip+deflate64-devel.sha256sum] = "67ef9af3b18e192e5454a3d69bd35ed51abcf0c5033f956f78dccea71ebff591"

URI_aarch64_rust-async_zip+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_zip+full-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-async_zip+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_zip+full-devel}"
SRC_URI[aarch64_rust-async_zip+full-devel.sha256sum] = "c1399b40b0f54ebc4c685f5b9cb61d5b0ce71e8ef393647cc4bacefd204aa984"

URI_aarch64_rust-async_zip+lzma-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_zip+lzma-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-async_zip+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_zip+lzma-devel}"
SRC_URI[aarch64_rust-async_zip+lzma-devel.sha256sum] = "92df9acd428a5261e353ab28290f1b9bb50cb970a80befd5f63518fc82783ed8"

URI_aarch64_rust-async_zip+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_zip+tokio-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-async_zip+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_zip+tokio-devel}"
SRC_URI[aarch64_rust-async_zip+tokio-devel.sha256sum] = "547795b37c090bf97697535ecb4d76462a3b3322490fd9adccc9fe1b0c51ba88"

URI_aarch64_rust-async_zip+tokio-fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_zip+tokio-fs-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-async_zip+tokio-fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_zip+tokio-fs-devel}"
SRC_URI[aarch64_rust-async_zip+tokio-fs-devel.sha256sum] = "a223074520684c81c97863311eaf3bf0c6aecb5d729da99f0ef4aa00c4305ab4"

URI_aarch64_rust-async_zip+tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_zip+tokio-util-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-async_zip+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_zip+tokio-util-devel}"
SRC_URI[aarch64_rust-async_zip+tokio-util-devel.sha256sum] = "2a8a3ebc758d450ef57bdd311129452b4e95c1152cd5b7df0e634f02e5c6185a"

URI_aarch64_rust-async_zip+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_zip+xz-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-async_zip+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_zip+xz-devel}"
SRC_URI[aarch64_rust-async_zip+xz-devel.sha256sum] = "e0836d1918572919ac0fc1cad93c9d364e039541d7381fd07094ad07b4c245e9"

URI_aarch64_rust-async_zip+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_zip+zstd-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-async_zip+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_zip+zstd-devel}"
SRC_URI[aarch64_rust-async_zip+zstd-devel.sha256sum] = "dee84de49c5a61ccea0b786b4b4e8af74c246347a3100890ee946ee4f5029a34"

URI_aarch64_rust-async_zip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_zip-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-async_zip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_zip-devel}"
SRC_URI[aarch64_rust-async_zip-devel.sha256sum] = "805b828ae933170421b3ff255f406a2f81a97b2f73df1740836cc5b2b34e7149"

RDEPENDS:rust-async_zip+async-compression-devel = " \
 cargo \
 rust-async-compression+futures-io-devel \
 rust-async-compression-devel \
 rust-async_zip-devel \
 "
RDEPENDS:rust-async_zip+bzip2-devel = " \
 cargo \
 rust-async-compression+bzip2-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression-devel \
 rust-async_zip-devel \
 "
RDEPENDS:rust-async_zip+chrono-devel = " \
 cargo \
 rust-async_zip-devel \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-async_zip+default-devel = " \
 cargo \
 rust-async_zip-devel \
 "
RDEPENDS:rust-async_zip+deflate-devel = " \
 cargo \
 rust-async-compression+deflate-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression-devel \
 rust-async_zip-devel \
 "
RDEPENDS:rust-async_zip+deflate64-devel = " \
 cargo \
 rust-async-compression+deflate64-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression-devel \
 rust-async_zip-devel \
 "
RDEPENDS:rust-async_zip+full-devel = " \
 cargo \
 rust-async_zip+bzip2-devel \
 rust-async_zip+chrono-devel \
 rust-async_zip+deflate-devel \
 rust-async_zip+deflate64-devel \
 rust-async_zip+lzma-devel \
 rust-async_zip+tokio-fs-devel \
 rust-async_zip+xz-devel \
 rust-async_zip+zstd-devel \
 rust-async_zip-devel \
 "
RDEPENDS:rust-async_zip+lzma-devel = " \
 cargo \
 rust-async-compression+futures-io-devel \
 rust-async-compression+lzma-devel \
 rust-async-compression-devel \
 rust-async_zip-devel \
 "
RDEPENDS:rust-async_zip+tokio-devel = " \
 cargo \
 rust-async_zip+tokio-util-devel \
 rust-async_zip-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-async_zip+tokio-fs-devel = " \
 cargo \
 rust-async_zip-devel \
 rust-tokio+fs-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-async_zip+tokio-util-devel = " \
 cargo \
 rust-async_zip-devel \
 rust-tokio-util+compat-devel \
 rust-tokio-util+default-devel \
 "
RDEPENDS:rust-async_zip+xz-devel = " \
 cargo \
 rust-async-compression+futures-io-devel \
 rust-async-compression+xz-devel \
 rust-async-compression-devel \
 rust-async_zip-devel \
 "
RDEPENDS:rust-async_zip+zstd-devel = " \
 cargo \
 rust-async-compression+futures-io-devel \
 rust-async-compression+zstd-devel \
 rust-async-compression-devel \
 rust-async_zip-devel \
 "
RDEPENDS:rust-async_zip-devel = " \
 cargo \
 rust-crc32fast+default-devel \
 rust-futures-lite+std-devel \
 rust-futures-lite-devel \
 rust-pin-project+default-devel \
 rust-thiserror+default-devel \
 "
