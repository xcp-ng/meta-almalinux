# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-openapi-jsonpointer"
PV = "0.19.5"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-openapi-jsonpointer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-openapi-jsonpointer-0.19.5-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b291ae76b29944a249093ab349f2369bc5a2835f214a9f3086b3223238fc6614"

URI_x86_64_v2_golang-github-openapi-jsonpointer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-openapi-jsonpointer-devel-0.19.5-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-openapi-jsonpointer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-openapi-jsonpointer-devel}"
SRC_URI[x86_64_v2_golang-github-openapi-jsonpointer-devel.sha256sum] = "bbef8d177e3f77bd72a27f1bc663c0a7c53e1ccab1f99cd435ff1b5b7e091dfb"

URI_aarch64_golang-github-openapi-jsonpointer-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-openapi-jsonpointer-devel-0.19.5-13.el10_0.noarch.rpm;name=aarch64_golang-github-openapi-jsonpointer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-openapi-jsonpointer-devel}"
SRC_URI[aarch64_golang-github-openapi-jsonpointer-devel.sha256sum] = "7722c368d02147e6612736548a5b591b1e3119af4bc817cddcc76c348b931333"

RDEPENDS:golang-github-openapi-jsonpointer-devel = " \
 go-filesystem \
 golang-github-openapi-swag-devel \
 "
