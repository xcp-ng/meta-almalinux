# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-credential"
PV = "0.4.9"
PR = "1.el10_2"
PACKAGES = " \
 rust-cargo-credential+default-devel \
 rust-cargo-credential-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-credential-0.4.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c54b1bd7271816ed501524067419f380cb11fbc7d3b213e94719f2e9df005f5c"

URI_x86_64_v2_rust-cargo-credential+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-credential+default-devel-0.4.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-credential+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-credential+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-credential+default-devel.sha256sum] = "c10285cda0e0a6ab2c158bb7b5490d0693d62efaaee26e8c420a1a24c8cdbbcf"

URI_x86_64_v2_rust-cargo-credential-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-credential-devel-0.4.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-credential-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-credential-devel}"
SRC_URI[x86_64_v2_rust-cargo-credential-devel.sha256sum] = "a6e9093dc2c284091389b75888565f974d6d88d57b969df1d00c58ec70f0a32b"

URI_aarch64_rust-cargo-credential+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-credential+default-devel-0.4.9-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-credential+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-credential+default-devel}"
SRC_URI[aarch64_rust-cargo-credential+default-devel.sha256sum] = "8e99cb7519a1bbd9d009a2fb9a746c5ca14a1a0d7aca4475f8aea2c583cd39e0"

URI_aarch64_rust-cargo-credential-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-credential-devel-0.4.9-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-credential-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-credential-devel}"
SRC_URI[aarch64_rust-cargo-credential-devel.sha256sum] = "7e82432434f5e865a1d13d4a82e360bad829cd927aff17ff8e2cbdd465d67eba"

RDEPENDS:rust-cargo-credential+default-devel = " \
 cargo \
 rust-cargo-credential-devel \
 "
RDEPENDS:rust-cargo-credential-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-libc+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-time+serde-devel \
 "
