# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsolv"
PV = "0.7.33"
PR = "5.el10_2.alma.1"
PACKAGES = " \
 libsolv \
 libsolv-devel \
 libsolv-tools \
 libsolv-tools-base \
 python3-solv \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libsolv-0.7.33-5.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa24b23d2bf71d76c9259352393bf56fb47d3fe25e8516a5926cd5cb97c23b2d"

URI_x86_64_v2_libsolv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsolv-0.7.33-5.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libsolv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsolv}"
SRC_URI[x86_64_v2_libsolv.sha256sum] = "e895ffa0c46f76581d290afd40baae1bc23e918e5216f18a707d4f2d3148afb2"

URI_x86_64_v2_libsolv-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsolv-devel-0.7.33-5.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libsolv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsolv-devel}"
SRC_URI[x86_64_v2_libsolv-devel.sha256sum] = "fdad5cf124d8941754bcd44b2e2f37a268c04e97e0c7c1cbcc2852e8d82d1660"

URI_x86_64_v2_libsolv-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsolv-tools-0.7.33-5.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libsolv-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsolv-tools}"
SRC_URI[x86_64_v2_libsolv-tools.sha256sum] = "93fd68f51d2d4b13aee60a8f5ef5901e25375c05a3467d257a52c75c6100c6b9"

URI_x86_64_v2_libsolv-tools-base = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsolv-tools-base-0.7.33-5.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libsolv-tools-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsolv-tools-base}"
SRC_URI[x86_64_v2_libsolv-tools-base.sha256sum] = "5585a7ebd15413234d6efc0338c8021a17c3f5ea6d59d55a91293ce01877bbdc"

URI_x86_64_v2_python3-solv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-solv-0.7.33-5.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-solv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-solv}"
SRC_URI[x86_64_v2_python3-solv.sha256sum] = "d56e1078d09d8f30d9b0b2f04a74af4c9db55c5f74db6aca4e8520c09127fa33"

URI_aarch64_libsolv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsolv-0.7.33-5.el10_2.alma.1.aarch64.rpm;name=aarch64_libsolv;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsolv}"
SRC_URI[aarch64_libsolv.sha256sum] = "d3b79b35f5b427c724ff7f0eebbbd2f1ed0f440c2bb70151756d1a7fda38ba28"

URI_aarch64_libsolv-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsolv-devel-0.7.33-5.el10_2.alma.1.aarch64.rpm;name=aarch64_libsolv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsolv-devel}"
SRC_URI[aarch64_libsolv-devel.sha256sum] = "8ff2397e769b9e3de980ab9954961c0517850e9001f16726d79fce607b37abb1"

URI_aarch64_libsolv-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsolv-tools-0.7.33-5.el10_2.alma.1.aarch64.rpm;name=aarch64_libsolv-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsolv-tools}"
SRC_URI[aarch64_libsolv-tools.sha256sum] = "bed5b20e656a2c333e8d49c5093219d6670ca91fcbe5257084dd844d02c330b6"

URI_aarch64_libsolv-tools-base = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsolv-tools-base-0.7.33-5.el10_2.alma.1.aarch64.rpm;name=aarch64_libsolv-tools-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsolv-tools-base}"
SRC_URI[aarch64_libsolv-tools-base.sha256sum] = "ca1817ad4ede9df6af5cbedef645dd888f657463e50f0223b748d0c7160af42e"

URI_aarch64_python3-solv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-solv-0.7.33-5.el10_2.alma.1.aarch64.rpm;name=aarch64_python3-solv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-solv}"
SRC_URI[aarch64_python3-solv.sha256sum] = "9ae4a8f37c17788d1df05dd85efca3749fe4bff98393853733bd443d7b9f992e"

RDEPENDS:libsolv = " \
 bzip2-libs \
 glibc \
 libxml2 \
 libzstd \
 openssl-libs \
 rpm-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libsolv-devel = " \
 libsolv \
 libsolv-devel \
 pkgconf-pkg-config \
 rpm-devel \
 "
RDEPENDS:libsolv-tools = " \
 glibc \
 libsolv \
 libsolv-tools-base \
 "
RDEPENDS:libsolv-tools-base = " \
 glibc \
 libsolv \
 rpm-libs \
 "
RDEPENDS:python3-solv = " \
 glibc \
 libsolv \
 python3 \
 "
