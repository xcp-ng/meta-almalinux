# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ron"
PV = "0.10.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-ron+default-devel \
 rust-ron+indexmap-devel \
 rust-ron+integer128-devel \
 rust-ron-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ron-0.10.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e191aafb25c67fdd852593cf0c847eea0dd956bacec6e9e5898deb00d88b2fb2"

URI_x86_64_v2_rust-ron+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+default-devel-0.10.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+default-devel}"
SRC_URI[x86_64_v2_rust-ron+default-devel.sha256sum] = "5f0130267ca7d7d2c0a144a679d0b81f416ff6ebd6e201b987a676a9baeeda34"

URI_x86_64_v2_rust-ron+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+indexmap-devel-0.10.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+indexmap-devel}"
SRC_URI[x86_64_v2_rust-ron+indexmap-devel.sha256sum] = "b6ce31d51ab44a19d88d7b0264a34f6a4738b267799fa95bd3c5bc8d8c565b12"

URI_x86_64_v2_rust-ron+integer128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+integer128-devel-0.10.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+integer128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+integer128-devel}"
SRC_URI[x86_64_v2_rust-ron+integer128-devel.sha256sum] = "49429323d7b4d487ef7f8541e3011ff1391f3b795d1aa3f373bd9ced56216a3e"

URI_x86_64_v2_rust-ron-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron-devel-0.10.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron-devel}"
SRC_URI[x86_64_v2_rust-ron-devel.sha256sum] = "83736f52a6be4aa9cde9e7be4ef9e6b1269d76031eebcf789fd921f8246fc88c"

URI_aarch64_rust-ron+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+default-devel-0.10.1-1.el10_1.noarch.rpm;name=aarch64_rust-ron+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+default-devel}"
SRC_URI[aarch64_rust-ron+default-devel.sha256sum] = "29435836e118ec3462d8a5deaf0df40f9bba0bf1bf8a00b27680e7c82b35f6da"

URI_aarch64_rust-ron+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+indexmap-devel-0.10.1-1.el10_1.noarch.rpm;name=aarch64_rust-ron+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+indexmap-devel}"
SRC_URI[aarch64_rust-ron+indexmap-devel.sha256sum] = "3fcd4f5f648d5fc77ef31b9f9476df3e1b0becf9715e23b7f9bf924cfa324cac"

URI_aarch64_rust-ron+integer128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+integer128-devel-0.10.1-1.el10_1.noarch.rpm;name=aarch64_rust-ron+integer128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+integer128-devel}"
SRC_URI[aarch64_rust-ron+integer128-devel.sha256sum] = "231140506788b7ffceb88b1fa1e5563b5f3c519e71575de48f3657e15d331518"

URI_aarch64_rust-ron-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron-devel-0.10.1-1.el10_1.noarch.rpm;name=aarch64_rust-ron-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron-devel}"
SRC_URI[aarch64_rust-ron-devel.sha256sum] = "f0edada2feaa3c5b7efddccdc25145bce305ef04afff0a1d5e449a272db16905"

RDEPENDS:rust-ron+default-devel = " \
 cargo \
 rust-ron-devel \
 "
RDEPENDS:rust-ron+indexmap-devel = " \
 cargo \
 rust-indexmap+serde-devel \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-ron-devel \
 "
RDEPENDS:rust-ron+integer128-devel = " \
 cargo \
 rust-ron-devel \
 "
RDEPENDS:rust-ron-devel = " \
 cargo \
 rust \
 rust-base64+std-devel \
 rust-base64-devel \
 rust-bitflags+serde-devel \
 rust-bitflags-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-serde_derive-devel \
 rust-unicode-ident-devel \
 "
