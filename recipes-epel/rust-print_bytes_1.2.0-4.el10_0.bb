# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-print_bytes"
PV = "1.2.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-print_bytes+default-devel \
 rust-print_bytes+specialization-devel \
 rust-print_bytes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-print_bytes-1.2.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "282e8650a6f6b18cee44995d9a6ee79f852ae8d5838da420de130d074b75626a"

URI_x86_64_v2_rust-print_bytes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-print_bytes+default-devel-1.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-print_bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-print_bytes+default-devel}"
SRC_URI[x86_64_v2_rust-print_bytes+default-devel.sha256sum] = "cd63245e677099d026f7ee9bd8f3dd2c989f0b6c23addbc451297a7e05d72521"

URI_x86_64_v2_rust-print_bytes+specialization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-print_bytes+specialization-devel-1.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-print_bytes+specialization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-print_bytes+specialization-devel}"
SRC_URI[x86_64_v2_rust-print_bytes+specialization-devel.sha256sum] = "9bf30c2c30d8fe7a3281bbeead28a299cdbd62e83eb3d2045c1bca7ef939dce0"

URI_x86_64_v2_rust-print_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-print_bytes-devel-1.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-print_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-print_bytes-devel}"
SRC_URI[x86_64_v2_rust-print_bytes-devel.sha256sum] = "14452f58805053327880797b6221500786aee9063d28b25654e5ac68b57ee2de"

URI_aarch64_rust-print_bytes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-print_bytes+default-devel-1.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-print_bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-print_bytes+default-devel}"
SRC_URI[aarch64_rust-print_bytes+default-devel.sha256sum] = "594dea6c38aa9b2a866182979c6b6764192ba97c25091f34bdfb8c0124e750ac"

URI_aarch64_rust-print_bytes+specialization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-print_bytes+specialization-devel-1.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-print_bytes+specialization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-print_bytes+specialization-devel}"
SRC_URI[aarch64_rust-print_bytes+specialization-devel.sha256sum] = "2faf5a86b59976c6e9a80ccf62f6aa807828530d42389089af0358db049f1687"

URI_aarch64_rust-print_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-print_bytes-devel-1.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-print_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-print_bytes-devel}"
SRC_URI[aarch64_rust-print_bytes-devel.sha256sum] = "dff999668670be3331a087f16869e3c7751b3ea5eaae51f74c002fa6ca0ef45e"

RDEPENDS:rust-print_bytes+default-devel = " \
 cargo \
 rust-print_bytes-devel \
 "
RDEPENDS:rust-print_bytes+specialization-devel = " \
 cargo \
 rust-print_bytes-devel \
 "
RDEPENDS:rust-print_bytes-devel = " \
 cargo \
 rust \
 "
