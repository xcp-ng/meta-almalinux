# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-google-auth-oauthlib"
PV = "1.2.1"
PR = "3.el10_1"
PACKAGES = " \
 python3-google-auth-oauthlib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-google-auth-oauthlib-1.2.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01c3928ca8fc572c0b8815372a8458cf565053dab9173a8666de6bd6cca28309"

URI_x86_64_v2_python3-google-auth-oauthlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth-oauthlib-1.2.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth-oauthlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth-oauthlib}"
SRC_URI[x86_64_v2_python3-google-auth-oauthlib.sha256sum] = "d17ac24ea1172f0132dfd6555f83c14ebb0c64a57e94dcf4e5704431f794df65"

URI_aarch64_python3-google-auth-oauthlib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth-oauthlib-1.2.1-3.el10_1.noarch.rpm;name=aarch64_python3-google-auth-oauthlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth-oauthlib}"
SRC_URI[aarch64_python3-google-auth-oauthlib.sha256sum] = "66f1d59b0bd3be5f21d0fd1fa4d77f72da34d7946649ab9b1929ee0811b4d157"

RDEPENDS:python3-google-auth-oauthlib = " \
 python3 \
 python3-google-auth \
 python3-requests-oauthlib \
 "
