# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "srcpd"
PV = "2.1.7"
PR = "3.el10_0"
PACKAGES = " \
 srcpd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/srcpd-2.1.7-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e1a684071f23d461cfa18ef3f9ef82a42dc6cfdd44917d0e041dff77f183fbb3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/srcpd-2.1.7-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_srcpd;unpack=0"
SRC_URI[x86_64_v2_srcpd.sha256sum] = "ed14f54661ae1dcb1a5ed1001a12afc6b73dce951a4a5f7a5e2120c6cb14661b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/srcpd-2.1.7-3.el10_0.aarch64.rpm;name=aarch64_srcpd;unpack=0"
SRC_URI[aarch64_srcpd.sha256sum] = "7e6bddb2220612fc9a6961980336a06fa12d8edb218873672859c599ccf6d90d"

RDEPENDS:srcpd = " \
 bash \
 glibc \
 libgcc \
 libxml2 \
 systemd \
 "
