# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiten"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kiten \
 kiten-devel \
 kiten-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kiten-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ce395350d8c716f26e7b2f731f134c159dc992fc495feafd28f115adc6dd89ea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiten-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiten;unpack=0"
SRC_URI[x86_64_v2_kiten.sha256sum] = "fb1eb28559af78a4b5e855fc10fae1d4edbd659a047bd896bd341c49e9b3c509"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiten-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiten-devel;unpack=0"
SRC_URI[x86_64_v2_kiten-devel.sha256sum] = "fd4fc0a6c51dab7d7d89db145e08b45c7352bb153cbf9e413662e7e123c264c7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiten-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiten-libs;unpack=0"
SRC_URI[x86_64_v2_kiten-libs.sha256sum] = "611951dd643fdf42737dbbcff4008e1bc616a870f69d5790c1fdff9634ca4211"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiten-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kiten;unpack=0"
SRC_URI[aarch64_kiten.sha256sum] = "4594ddfacca030e48fe2ddfd23257ac3c910937897add0b6ed85d1164f910fec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiten-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kiten-devel;unpack=0"
SRC_URI[aarch64_kiten-devel.sha256sum] = "9f0c2b0f93ea0fcacca9410c20dcec69ff7a8ce9d14fad521507c44512fc9f2b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiten-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kiten-libs;unpack=0"
SRC_URI[aarch64_kiten-libs.sha256sum] = "615bd183a6033f306b3da8b7f8e9e1f8370e0f9ead6da0d029dec42a3815d705"

RDEPENDS:kiten = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kiten-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kiten-devel = " \
 kiten-libs \
 "
RDEPENDS:kiten-libs = " \
 glibc \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kiten \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
