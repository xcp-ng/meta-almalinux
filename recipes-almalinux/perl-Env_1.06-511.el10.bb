# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Env"
PV = "1.06"
PR = "511.el10"
PACKAGES = " \
 perl-Env \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Env-1.06-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bba9ee97c41ac49279f267eb72a58691be748ada2ebeb3c5ecdad80ff05d5ce3"

URI_x86_64_v2_perl-Env = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Env-1.06-511.el10.noarch.rpm;name=x86_64_v2_perl-Env;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Env}"
SRC_URI[x86_64_v2_perl-Env.sha256sum] = "453a4f4fa555ba7b5c99d836e4f38fa5ebd22157066a159dfcd7052ff7fd8d96"

URI_aarch64_perl-Env = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Env-1.06-511.el10.noarch.rpm;name=aarch64_perl-Env;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Env}"
SRC_URI[aarch64_perl-Env.sha256sum] = "453a4f4fa555ba7b5c99d836e4f38fa5ebd22157066a159dfcd7052ff7fd8d96"

RDEPENDS:perl-Env = " \
 perl-Tie \
 perl-libs \
 "
