# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdnf"
PV = "0.73.1"
PR = "15.el10_2.alma.1"
PACKAGES = " \
 libdnf \
 libdnf-devel \
 python3-hawkey \
 python3-libdnf \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libdnf-0.73.1-15.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5442169b7d4ab2ff19834952829dab96c72a5916e105e16cba331d092c9988a1"

URI_x86_64_v2_libdnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libdnf-0.73.1-15.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libdnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdnf}"
SRC_URI[x86_64_v2_libdnf.sha256sum] = "d10836bd54c06f0a350ee4a3e368c28c2b0cb5a8e94192a7ed36eead8dd1cd57"

URI_x86_64_v2_libdnf-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdnf-devel-0.73.1-15.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libdnf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdnf-devel}"
SRC_URI[x86_64_v2_libdnf-devel.sha256sum] = "028a91117e0a97de4197ab99c06562b84d52eed5c17a8c8f2cc62ce501fdebc1"

URI_x86_64_v2_python3-hawkey = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-hawkey-0.73.1-15.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-hawkey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hawkey}"
SRC_URI[x86_64_v2_python3-hawkey.sha256sum] = "e9c91eb5300aada43d0af620ea663ebb8358d5d8736c5f00e4c04c4f0b83799c"
RPROVIDES:python3-hawkey:x86_64_v2 = "virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_"

URI_x86_64_v2_python3-libdnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libdnf-0.73.1-15.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-libdnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libdnf}"
SRC_URI[x86_64_v2_python3-libdnf.sha256sum] = "2ee4dfcb30c2ca15e43a72608c1dae35892c4d15b7ae10e767b322186b2be409"

URI_aarch64_libdnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libdnf-0.73.1-15.el10_2.alma.1.aarch64.rpm;name=aarch64_libdnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdnf}"
SRC_URI[aarch64_libdnf.sha256sum] = "2d60c321a2d94cc7eb542b6083cc7bfe0dbfae2c9f03568e1c6faa484cf5c290"

URI_aarch64_libdnf-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdnf-devel-0.73.1-15.el10_2.alma.1.aarch64.rpm;name=aarch64_libdnf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdnf-devel}"
SRC_URI[aarch64_libdnf-devel.sha256sum] = "9f2ee5e791061f7fbe23cea1b3b9e346b2a477ceddcf90f916009030b692f778"

URI_aarch64_python3-hawkey = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-hawkey-0.73.1-15.el10_2.alma.1.aarch64.rpm;name=aarch64_python3-hawkey;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hawkey}"
SRC_URI[aarch64_python3-hawkey.sha256sum] = "a4677356198a8f7d42e6ad9dac7212658f3f91d713859c3b4affceffb468c839"
RPROVIDES:python3-hawkey:aarch64 = "virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_"

URI_aarch64_python3-libdnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libdnf-0.73.1-15.el10_2.alma.1.aarch64.rpm;name=aarch64_python3-libdnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libdnf}"
SRC_URI[aarch64_python3-libdnf.sha256sum] = "eb9e8bb68a6f3f02729c82ffffced0fe3c308ba8684ac65d62deed2700946670"

RDEPENDS:libdnf = " \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libmodulemd \
 librepo \
 libsmartcols \
 libsolv \
 libstdc++ \
 rpm-libs \
 sqlite-libs \
 "
RDEPENDS:libdnf-devel = " \
 glib2-devel \
 libdnf \
 librepo-devel \
 libsolv-devel \
 pkgconf-pkg-config \
 rpm-devel \
 sqlite-devel \
 "
RDEPENDS:python3-hawkey = " \
 glib2 \
 glibc \
 libdnf \
 libgcc \
 libsolv \
 libstdc++ \
 python3 \
 python3-libdnf \
 python3-libs \
 "
RDEPENDS:python3-libdnf = " \
 glibc \
 libdnf \
 libgcc \
 libsmartcols \
 libstdc++ \
 python3 \
 python3-libs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_"

PROVIDES:append:aarch64 = " rpm/virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_"
