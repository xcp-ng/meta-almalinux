# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wl-clipboard-rs"
PV = "0.9.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-wl-clipboard-rs+default-devel \
 rust-wl-clipboard-rs+dlopen-devel \
 rust-wl-clipboard-rs+native_lib-devel \
 rust-wl-clipboard-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wl-clipboard-rs-0.9.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17c1be81b6cd17b40a5042001dde049f74cf1cc5774f330a3cc24a22e960f8ab"

URI_x86_64_v2_rust-wl-clipboard-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wl-clipboard-rs+default-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wl-clipboard-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wl-clipboard-rs+default-devel}"
SRC_URI[x86_64_v2_rust-wl-clipboard-rs+default-devel.sha256sum] = "b2adfe6592d3f442787a87ef6fcf7b2e17c1dcc7195ce7cd547afb704af253a8"

URI_x86_64_v2_rust-wl-clipboard-rs+dlopen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wl-clipboard-rs+dlopen-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wl-clipboard-rs+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wl-clipboard-rs+dlopen-devel}"
SRC_URI[x86_64_v2_rust-wl-clipboard-rs+dlopen-devel.sha256sum] = "452dd70d180eb21026c80881a62584d3cef995293a7d3b3a043abee5580ffe1c"

URI_x86_64_v2_rust-wl-clipboard-rs+native_lib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wl-clipboard-rs+native_lib-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wl-clipboard-rs+native_lib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wl-clipboard-rs+native_lib-devel}"
SRC_URI[x86_64_v2_rust-wl-clipboard-rs+native_lib-devel.sha256sum] = "b0a1f442425e8c20f86da449547468730b1245b0cec9668acb3a857fb2ac3978"

URI_x86_64_v2_rust-wl-clipboard-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wl-clipboard-rs-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wl-clipboard-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wl-clipboard-rs-devel}"
SRC_URI[x86_64_v2_rust-wl-clipboard-rs-devel.sha256sum] = "c1d6bfcb3379e74ee9f52c84e1c48d9897f765d737d8064c872e1d10f47f8932"

URI_aarch64_rust-wl-clipboard-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wl-clipboard-rs+default-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-wl-clipboard-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wl-clipboard-rs+default-devel}"
SRC_URI[aarch64_rust-wl-clipboard-rs+default-devel.sha256sum] = "ade6e741421e0cc49bcf819ee38429d690693b1d07f1ec9e239ec93d2b19cd3d"

URI_aarch64_rust-wl-clipboard-rs+dlopen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wl-clipboard-rs+dlopen-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-wl-clipboard-rs+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wl-clipboard-rs+dlopen-devel}"
SRC_URI[aarch64_rust-wl-clipboard-rs+dlopen-devel.sha256sum] = "a8d74f2bc873f797ce60f18f623fed91431766fdfd096f3d3a88e5cf6d6f679f"

URI_aarch64_rust-wl-clipboard-rs+native_lib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wl-clipboard-rs+native_lib-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-wl-clipboard-rs+native_lib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wl-clipboard-rs+native_lib-devel}"
SRC_URI[aarch64_rust-wl-clipboard-rs+native_lib-devel.sha256sum] = "eea89ce4ca5415a8dea7ba3a7186452a45cf413754678a37fc1bc72f6087c5f1"

URI_aarch64_rust-wl-clipboard-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wl-clipboard-rs-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-wl-clipboard-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wl-clipboard-rs-devel}"
SRC_URI[aarch64_rust-wl-clipboard-rs-devel.sha256sum] = "827e189e405102cbeb9cc761b6608380d437a9622b0e9c392a4ef8b535b588c3"

RDEPENDS:rust-wl-clipboard-rs+default-devel = " \
 cargo \
 rust-wl-clipboard-rs-devel \
 "
RDEPENDS:rust-wl-clipboard-rs+dlopen-devel = " \
 cargo \
 rust-wayland-backend+dlopen-devel \
 rust-wl-clipboard-rs+native_lib-devel \
 rust-wl-clipboard-rs-devel \
 "
RDEPENDS:rust-wl-clipboard-rs+native_lib-devel = " \
 cargo \
 rust-wayland-backend+client_system-devel \
 rust-wayland-backend+server_system-devel \
 rust-wl-clipboard-rs-devel \
 "
RDEPENDS:rust-wl-clipboard-rs-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-os_pipe+default-devel \
 rust-os_pipe+io_safety-devel \
 rust-rustix0.38+default-devel \
 rust-rustix0.38+event-devel \
 rust-rustix0.38+fs-devel \
 rust-tempfile+default-devel \
 rust-thiserror+default-devel \
 rust-tree_magic_mini+default-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-client+default-devel \
 rust-wayland-protocols+client-devel \
 rust-wayland-protocols+default-devel \
 rust-wayland-protocols+staging-devel \
 rust-wayland-protocols-wlr+client-devel \
 rust-wayland-protocols-wlr+default-devel \
 "
