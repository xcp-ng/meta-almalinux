# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "v4l-utils"
PV = "1.26.1"
PR = "5.el10"
PACKAGES = " \
 libdvbv5 \
 libv4l \
 libv4l-devel \
 v4l-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/v4l-utils-1.26.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62676c4e1b8058b228d17bfad21cb90c19027dce13b05d7a3665c13670cae95b"

URI_x86_64_v2_libdvbv5 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdvbv5-1.26.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_libdvbv5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdvbv5}"
SRC_URI[x86_64_v2_libdvbv5.sha256sum] = "bc3e2f9ffa37a1fede0f8571fd570e2fa622bb450f0124576dd71e11398d7337"

URI_x86_64_v2_libv4l = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libv4l-1.26.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_libv4l;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libv4l}"
SRC_URI[x86_64_v2_libv4l.sha256sum] = "6ace3ef303c11921b8409f603229fb761956f5bbe332e4ae2d1c030ba6e4e609"

URI_x86_64_v2_libv4l-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libv4l-devel-1.26.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_libv4l-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libv4l-devel}"
SRC_URI[x86_64_v2_libv4l-devel.sha256sum] = "542ca7dcba502783855cce9181aa5d408c64bba1b622603884662bf8f02ff1da"

URI_x86_64_v2_v4l-utils = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/v4l-utils-1.26.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_v4l-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_v4l-utils}"
SRC_URI[x86_64_v2_v4l-utils.sha256sum] = "dcdf82af8bca288217aec99a3de3698809640034eb5de5bc8ec093a3a246338f"

URI_aarch64_libdvbv5 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdvbv5-1.26.1-5.el10.aarch64.rpm;name=aarch64_libdvbv5;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdvbv5}"
SRC_URI[aarch64_libdvbv5.sha256sum] = "5af6b8c071c29cf88c0dde9ff465bd1f49f2a397d337b7b160189b8111ccf93e"

URI_aarch64_libv4l = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libv4l-1.26.1-5.el10.aarch64.rpm;name=aarch64_libv4l;unpack=0"
SRC_URI:append = " ${URI_aarch64_libv4l}"
SRC_URI[aarch64_libv4l.sha256sum] = "0bf97c64a4d9e7bc5ff7121803282f07b778951ab8e8f31d58cac379ddefbb2b"

URI_aarch64_libv4l-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libv4l-devel-1.26.1-5.el10.aarch64.rpm;name=aarch64_libv4l-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libv4l-devel}"
SRC_URI[aarch64_libv4l-devel.sha256sum] = "469f884460ae107b4d1f78f95bcb33c228735d88904c3ec63ef409251f757e22"

URI_aarch64_v4l-utils = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/v4l-utils-1.26.1-5.el10.aarch64.rpm;name=aarch64_v4l-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_v4l-utils}"
SRC_URI[aarch64_v4l-utils.sha256sum] = "1810685fddd585ff621c69c1d4fc0862f6a8a92e1f7d30d87877e3a8d3499e6f"

RDEPENDS:libdvbv5 = " \
 glibc \
 systemd-libs \
 "
RDEPENDS:libv4l = " \
 glibc \
 libjpeg-turbo \
 "
RDEPENDS:libv4l-devel = " \
 libjpeg-turbo-devel \
 libv4l \
 libv4l-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:v4l-utils = " \
 glibc \
 libdvbv5 \
 libgcc \
 libstdc++ \
 libv4l \
 systemd-libs \
 systemd-udev \
 "
