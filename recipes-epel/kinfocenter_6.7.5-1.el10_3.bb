# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kinfocenter"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kinfocenter \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kinfocenter-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "16e50d5094a5fdb0da6d1d22522a036c305ce3ae02028d5b548063515716fe9c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kinfocenter-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kinfocenter;unpack=0"
SRC_URI[x86_64_v2_kinfocenter.sha256sum] = "6facfd543317afc4e035d97e3ecd0efac7e4d8caa3a49800269eac388e82979b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kinfocenter-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kinfocenter;unpack=0"
SRC_URI[aarch64_kinfocenter.sha256sum] = "ba55a2bc59b0ce3a3dadd922ec746b16604bda1b29f0d246fe05be47be60ea57"

RDEPENDS:kinfocenter = " \
 aha \
 clinfo \
 dmidecode \
 egl-utils \
 fwupd \
 glibc \
 hwdata \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kservice \
 kf6-solid \
 libdisplay-info-tools \
 libdrm \
 libstdc++ \
 libusb1 \
 plasma-systemsettings \
 pulseaudio-utils \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 systemd-libs \
 vulkan-tools \
 wayland-utils \
 xdpyinfo \
 "
