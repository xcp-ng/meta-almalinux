# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cassowary"
PV = "0.3.0"
PR = "17.el10_1"
PACKAGES = " \
 rust-cassowary+default-devel \
 rust-cassowary-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cassowary-0.3.0-17.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99e47e4ac52e4ced6397f923e89ffd70609dc3dab53c7581dc7206ee940949c2"

URI_x86_64_v2_rust-cassowary+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cassowary+default-devel-0.3.0-17.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cassowary+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cassowary+default-devel}"
SRC_URI[x86_64_v2_rust-cassowary+default-devel.sha256sum] = "38de0fc71c1f7aa4810e2e75a996d11a924ff067d1bbc9fedd226f759fd0a321"

URI_x86_64_v2_rust-cassowary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cassowary-devel-0.3.0-17.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cassowary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cassowary-devel}"
SRC_URI[x86_64_v2_rust-cassowary-devel.sha256sum] = "32a6dd24a35c09ac6faf33e23ecc51a3d376c8caaad809696947eea5fe751732"

URI_aarch64_rust-cassowary+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cassowary+default-devel-0.3.0-17.el10_1.noarch.rpm;name=aarch64_rust-cassowary+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cassowary+default-devel}"
SRC_URI[aarch64_rust-cassowary+default-devel.sha256sum] = "4924f69e438c4d29efaf894b53f60b21884f4720b1548e65a2225c760361f08c"

URI_aarch64_rust-cassowary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cassowary-devel-0.3.0-17.el10_1.noarch.rpm;name=aarch64_rust-cassowary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cassowary-devel}"
SRC_URI[aarch64_rust-cassowary-devel.sha256sum] = "029c502a4c92a292ef041c40afa6564e92153ebb4e6c716ad9aa56f57ae2911b"

RDEPENDS:rust-cassowary+default-devel = " \
 cargo \
 rust-cassowary-devel \
 "
RDEPENDS:rust-cassowary-devel = " \
 cargo \
 "
