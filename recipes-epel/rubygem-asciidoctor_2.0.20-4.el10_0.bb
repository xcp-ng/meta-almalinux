# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-asciidoctor"
PV = "2.0.20"
PR = "4.el10_0"
PACKAGES = " \
 rubygem-asciidoctor \
 rubygem-asciidoctor-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-asciidoctor-2.0.20-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9affa337ab9e12d24597bae5fa64fce5669624ed5f8db6f1768b73e226e9e14a"

URI_x86_64_v2_rubygem-asciidoctor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-asciidoctor-2.0.20-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-asciidoctor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-asciidoctor}"
SRC_URI[x86_64_v2_rubygem-asciidoctor.sha256sum] = "9cf41cbe9ecd2dcaaac2b8b2f66c1a1e9d5e6c4f889cec90a0457a1e5b7b0429"

URI_x86_64_v2_rubygem-asciidoctor-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-asciidoctor-doc-2.0.20-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-asciidoctor-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-asciidoctor-doc}"
SRC_URI[x86_64_v2_rubygem-asciidoctor-doc.sha256sum] = "d260419603483bc8c1954f26e511beaac4f7124c77a6244b7c50070a94aafe59"

URI_aarch64_rubygem-asciidoctor = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-asciidoctor-2.0.20-4.el10_0.noarch.rpm;name=aarch64_rubygem-asciidoctor;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-asciidoctor}"
SRC_URI[aarch64_rubygem-asciidoctor.sha256sum] = "8ca642380a485abb28e6563483b8f6630d7dc8a09e972dad9038bb719aa2e4c0"

URI_aarch64_rubygem-asciidoctor-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-asciidoctor-doc-2.0.20-4.el10_0.noarch.rpm;name=aarch64_rubygem-asciidoctor-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-asciidoctor-doc}"
SRC_URI[aarch64_rubygem-asciidoctor-doc.sha256sum] = "b7754e53dd522ec58701cdf99f566c0a6d7a843e4f697b8195159bb8f64ee5b8"

RDEPENDS:rubygem-asciidoctor = " \
 ruby \
 rubygems \
 "
RDEPENDS:rubygem-asciidoctor-doc = " \
 rubygem-asciidoctor \
 "
