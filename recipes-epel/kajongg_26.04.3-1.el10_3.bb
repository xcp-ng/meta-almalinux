# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kajongg"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kajongg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kajongg-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc2d393caf04eb28ed1db1e11d0b9be1ab157813c480792bb15737db9717fd75"

URI_x86_64_v2_kajongg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kajongg-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kajongg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kajongg}"
SRC_URI[x86_64_v2_kajongg.sha256sum] = "3f1e2714de9b950d29f978df841036ccb1593010db9875f3e95d30020bbb4987"

URI_aarch64_kajongg = "${EPEL_MIRROR}/aarch64/Packages/k/kajongg-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kajongg;unpack=0"
SRC_URI:append = " ${URI_aarch64_kajongg}"
SRC_URI[aarch64_kajongg.sha256sum] = "dc1c8c9ea73a5147b66b449bc574a47ec96192cb38d13284c78c62004179075f"

RDEPENDS:kajongg = " \
 libkmahjongg-data \
 python3 \
 python3-QtPy \
 python3-pyqt6 \
 python3-twisted \
 vorbis-tools \
 "
