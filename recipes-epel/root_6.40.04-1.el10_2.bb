# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "root"
PV = "6.40.04"
PR = "1.el10_2"
PACKAGES = " \
 python3-root \
 python3-root+distrdf \
 python3-root+jupyroot \
 root \
 root-cli \
 root-cling \
 root-core \
 root-fftw \
 root-foam \
 root-font-files \
 root-fumili \
 root-gdml \
 root-genetic \
 root-genvector \
 root-geom \
 root-geom-builder \
 root-geom-checker \
 root-geom-painter \
 root-geom-webviewer \
 root-graf \
 root-graf-asimage \
 root-graf-fitsio \
 root-graf-gpad \
 root-graf-gpadv7 \
 root-graf-gviz \
 root-graf-postscript \
 root-graf-primitives \
 root-graf-x11 \
 root-graf3d \
 root-graf3d-csg \
 root-graf3d-eve \
 root-graf3d-eve7 \
 root-graf3d-gl \
 root-graf3d-glad \
 root-graf3d-gviz3d \
 root-graf3d-x3d \
 root-gui \
 root-gui-browsable \
 root-gui-browsable-v7 \
 root-gui-browserv7 \
 root-gui-browserv7-v7 \
 root-gui-builder \
 root-gui-canvaspainter \
 root-gui-fitpanel \
 root-gui-fitpanelv7 \
 root-gui-ged \
 root-gui-html \
 root-gui-qt6webdisplay \
 root-gui-recorder \
 root-gui-treemap \
 root-gui-webdisplay \
 root-gui-webgui6 \
 root-hbook \
 root-hist \
 root-hist-factory \
 root-hist-painter \
 root-histv7 \
 root-histv7util \
 root-icons \
 root-io \
 root-io-dcache \
 root-io-sql \
 root-io-xml \
 root-io-xmlparser \
 root-mathcore \
 root-mathmore \
 root-matrix \
 root-minuit \
 root-minuit2 \
 root-mlp \
 root-montecarlo-eg \
 root-montecarlo-pythia8 \
 root-multiproc \
 root-net \
 root-net-auth \
 root-net-curl \
 root-net-davix \
 root-net-http \
 root-net-httpsniff \
 root-net-rpdutils \
 root-netx \
 root-physics \
 root-quadp \
 root-r \
 root-r-tools \
 root-roofit \
 root-roofit-batchcompute \
 root-roofit-codegen \
 root-roofit-core \
 root-roofit-hs3 \
 root-roofit-more \
 root-roofit-multiprocess \
 root-roofit-zmq \
 root-roostats \
 root-smatrix \
 root-spectrum \
 root-spectrum-painter \
 root-splot \
 root-sql-sqlite \
 root-testsupport \
 root-tmva \
 root-tmva-gui \
 root-tmva-python \
 root-tmva-r \
 root-tmva-sofie \
 root-tmva-sofie-parser \
 root-tmva-sofie-parser-python \
 root-tmva-utils \
 root-tpython \
 root-tree \
 root-tree-dataframe \
 root-tree-ml \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 root-tree-ntuple-utils \
 root-tree-player \
 root-tree-viewer \
 root-tree-webviewer \
 root-tutorial \
 root-unfold \
 root-unuran \
 root-vecops \
 root-xroofit \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/root-6.40.04-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "85e745b432dca9d90370b6620eba5c6f78f1cf70d5a2196e7d55a0e9a1ffda62"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-root-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-root;unpack=0"
SRC_URI[x86_64_v2_python3-root.sha256sum] = "77842bd3ce48a524122bf27978e3c9eb1da85262b11c3b8f3e5bd8e250edae53"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-root+distrdf-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-root+distrdf;unpack=0"
SRC_URI[x86_64_v2_python3-root+distrdf.sha256sum] = "d61d7e38fd61684664f005571742e0b0ddeb5f6c87521e8edbf0cffbe6afeeb5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-root+jupyroot-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-root+jupyroot;unpack=0"
SRC_URI[x86_64_v2_python3-root+jupyroot.sha256sum] = "7494033d2a242c9e9267550ea144c771c3971c1346e4ec7a1290663219953948"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root;unpack=0"
SRC_URI[x86_64_v2_root.sha256sum] = "5dfbaadd4a6ae6cb5a1964555e425aa19a0b8ca87b27d866612a3e4b06a5d1b1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-cli-6.40.04-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_root-cli;unpack=0"
SRC_URI[x86_64_v2_root-cli.sha256sum] = "fbd153f4411a7d76d477ff04323e58bde3534946f1ab380e0fe0bd8aa4c06970"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-cling-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-cling;unpack=0"
SRC_URI[x86_64_v2_root-cling.sha256sum] = "53828ce47f8837416c1ebae9966e447cb0485a5b7227f52b836b9e9c1ab9eb55"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-core-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-core;unpack=0"
SRC_URI[x86_64_v2_root-core.sha256sum] = "e0da3050bfc6dc746f445e49001a84f8d7ab8a91e863e1702f28b9d1c79e94de"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-fftw-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-fftw;unpack=0"
SRC_URI[x86_64_v2_root-fftw.sha256sum] = "20d1795fdfaee30dd234ef6d0ee90b7b57784348f13a35c506ca850310792750"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-foam-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-foam;unpack=0"
SRC_URI[x86_64_v2_root-foam.sha256sum] = "a333221b28d7e8b1ddca30a2b628530b8a5904168c8c643aab81d38c1019a51d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-font-files-6.40.04-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_root-font-files;unpack=0"
SRC_URI[x86_64_v2_root-font-files.sha256sum] = "eb029fd76688d6b2ad703bca5d95f0f7a0dcca8aef69b1cfdf47097b4403fc2a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-fumili-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-fumili;unpack=0"
SRC_URI[x86_64_v2_root-fumili.sha256sum] = "61a61af706a9fbba5be26b1e6a8f1196c7aabfbc15cafe8ef84b2bea223e7355"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gdml-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gdml;unpack=0"
SRC_URI[x86_64_v2_root-gdml.sha256sum] = "797d043966b54eedb9ee117ac95972b85b07cebeb65d4e386b96631afdec07f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-genetic-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-genetic;unpack=0"
SRC_URI[x86_64_v2_root-genetic.sha256sum] = "7211a20fa898c7cc6178fef871fadeb87b82cc753f4f0cb5d60b9f3a87891395"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-genvector-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-genvector;unpack=0"
SRC_URI[x86_64_v2_root-genvector.sha256sum] = "a6483ed1e0f61687084e08ce6f49bec800d3469367c0ae129cefb2597f1a226f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom;unpack=0"
SRC_URI[x86_64_v2_root-geom.sha256sum] = "570e94d26609b98cf930f9f107f1a9d7f4efba38e7dbee5c5e257b425022ab44"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-builder-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-builder;unpack=0"
SRC_URI[x86_64_v2_root-geom-builder.sha256sum] = "3bf5c26c38ab883c2755caee146ea2df055637629d525292b6345a304c6bea47"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-checker-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-checker;unpack=0"
SRC_URI[x86_64_v2_root-geom-checker.sha256sum] = "af55c190282464b1f6efbe0119483aa37dafafb7ec37036225685645d1889acd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-painter-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-painter;unpack=0"
SRC_URI[x86_64_v2_root-geom-painter.sha256sum] = "aee611a260691b14563c350ebc0513cac7a82eaf11e22ba26272551292bda710"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-webviewer-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-webviewer;unpack=0"
SRC_URI[x86_64_v2_root-geom-webviewer.sha256sum] = "4fa3d209c7f33b1d232329f1b799870cbd117c29185f089635ab843143f6e17a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf;unpack=0"
SRC_URI[x86_64_v2_root-graf.sha256sum] = "d6ecd157c5c9581df69850916360181965c1bb79013621b83d6e87869e3604e8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-asimage-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-asimage;unpack=0"
SRC_URI[x86_64_v2_root-graf-asimage.sha256sum] = "786cf3fa32ed11c28c6fe516017576ee9ecc9ad6bea181c26a3b398d6e233e1f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-fitsio-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-fitsio;unpack=0"
SRC_URI[x86_64_v2_root-graf-fitsio.sha256sum] = "3b1977f3e8c9ec07844c418cd443f00cb5373e4e48d334dd6ccca005aa1444a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-gpad-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-gpad;unpack=0"
SRC_URI[x86_64_v2_root-graf-gpad.sha256sum] = "f39def822eee0e72b24d548694e570c8566f39cde20195a67e3ac3307b859ab5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-gpadv7-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-gpadv7;unpack=0"
SRC_URI[x86_64_v2_root-graf-gpadv7.sha256sum] = "149a00a25aa7ee535eb7b0238a63f65d22f984cd2a1576a70bbbec2440af7413"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-gviz-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-gviz;unpack=0"
SRC_URI[x86_64_v2_root-graf-gviz.sha256sum] = "a795a73ae1cf700f15dd23fee1fe31d393931eebb3d91645be81ac2d8f3a7a93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-postscript-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-postscript;unpack=0"
SRC_URI[x86_64_v2_root-graf-postscript.sha256sum] = "1bc7f55726ebdb4dfe42b4151882feb7f7fe8bb971e07847ea0b7f3bfc7f64c6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-primitives-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-primitives;unpack=0"
SRC_URI[x86_64_v2_root-graf-primitives.sha256sum] = "b25877e9ed32f5ab65a8e44c6f64919a7b08a99b54b6640df2824ddf70a54ccb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-x11-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-x11;unpack=0"
SRC_URI[x86_64_v2_root-graf-x11.sha256sum] = "3e9d86dd8dd073c029736b6003544033ac520833359afe7c4e0e40a07b04e4fc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d;unpack=0"
SRC_URI[x86_64_v2_root-graf3d.sha256sum] = "fceffb53e862093f6e13b1d408d524380f3829fb5ad9e5646bb663407dacd79d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-csg-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-csg;unpack=0"
SRC_URI[x86_64_v2_root-graf3d-csg.sha256sum] = "b88dec571b2cdab5f627c29b93b8742c415a495820f8e10b339a41af4ca3676b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-eve-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-eve;unpack=0"
SRC_URI[x86_64_v2_root-graf3d-eve.sha256sum] = "091bdcc5bf5c9dfa5a3d5d7e63fa2d1452ac03c350babd5cc2bb510d0ea98a8a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-eve7-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-eve7;unpack=0"
SRC_URI[x86_64_v2_root-graf3d-eve7.sha256sum] = "d99113f9924bc42a121d9aeeda441a9b2d6c63fe760e4098ab2d68db35af42c5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-gl-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-gl;unpack=0"
SRC_URI[x86_64_v2_root-graf3d-gl.sha256sum] = "86cce7e1308168e04b983f900263bcdb5b4ece34f29cad8ec05ebc495091255a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-glad-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-glad;unpack=0"
SRC_URI[x86_64_v2_root-graf3d-glad.sha256sum] = "3f2ac6e7a243bb2047c423b776512bdc438bfcbc54616baf7c70f0f314579952"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-gviz3d-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-gviz3d;unpack=0"
SRC_URI[x86_64_v2_root-graf3d-gviz3d.sha256sum] = "b52b2897d9171f1da9a27b47556d80f62ddcfc0f86ca333884f64839e618f0da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-x3d-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-x3d;unpack=0"
SRC_URI[x86_64_v2_root-graf3d-x3d.sha256sum] = "d3eebff75e612901e69f89337f9e338aafed795179661d42af30ddcb5688e2ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui;unpack=0"
SRC_URI[x86_64_v2_root-gui.sha256sum] = "3e2fd93c6826a04a957f8d96cbd9ff39381c4e1437183830665152b15a0919cc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browsable-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browsable;unpack=0"
SRC_URI[x86_64_v2_root-gui-browsable.sha256sum] = "46e7809cfbd34de3294cc70b8d909290707c0dc35c2d5c8c1e997dc1d799d3bf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browsable-v7-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browsable-v7;unpack=0"
SRC_URI[x86_64_v2_root-gui-browsable-v7.sha256sum] = "da332dc4963267dca2c3c2be371d727339b6ad415244602ddb99ec126a295605"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browserv7-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browserv7;unpack=0"
SRC_URI[x86_64_v2_root-gui-browserv7.sha256sum] = "993528ac41e9c1dd63b776df1b625f4e33fb69f257ccc4a97d221404c876e329"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browserv7-v7-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browserv7-v7;unpack=0"
SRC_URI[x86_64_v2_root-gui-browserv7-v7.sha256sum] = "27d70b5826bbfeb91bdb24af1ab0894c17e29c4e711603cd404a66e3261c9638"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-builder-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-builder;unpack=0"
SRC_URI[x86_64_v2_root-gui-builder.sha256sum] = "79d083dadb10b20aa577bb1c3464c0e170003505fbb4684308dcbdee674fcaf1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-canvaspainter-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-canvaspainter;unpack=0"
SRC_URI[x86_64_v2_root-gui-canvaspainter.sha256sum] = "f113e71f9651288af839ce41523cf940d89cfc5e0b35e61ba6a7c8d152dc2f43"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-fitpanel-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-fitpanel;unpack=0"
SRC_URI[x86_64_v2_root-gui-fitpanel.sha256sum] = "f9dbe566631f0881a248a5f4ddda6b85e7eec6aa3ac2d1cde7169771ba176478"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-fitpanelv7-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-fitpanelv7;unpack=0"
SRC_URI[x86_64_v2_root-gui-fitpanelv7.sha256sum] = "f31fd377dce0c5e1db171b91807c782c7e245d1f110261bbb540fdd82446d587"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-ged-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-ged;unpack=0"
SRC_URI[x86_64_v2_root-gui-ged.sha256sum] = "d11efda4ae9519ae473de7d9dfc672828977360ccf7765878da7b06b338c9b4e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-html-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-html;unpack=0"
SRC_URI[x86_64_v2_root-gui-html.sha256sum] = "37c479541a5daa502f5fc468cfb562f85b37075e3fb80f37012035f61a2d2458"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-qt6webdisplay-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-qt6webdisplay;unpack=0"
SRC_URI[x86_64_v2_root-gui-qt6webdisplay.sha256sum] = "5488311c605a3bc3278ce4d056dea20192d6c7c255539fc97ccddcca385ea67f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-recorder-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-recorder;unpack=0"
SRC_URI[x86_64_v2_root-gui-recorder.sha256sum] = "9704d25e06dea6434d617540a836d432d994726dc8a7293fffa1027a201a249a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-treemap-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-treemap;unpack=0"
SRC_URI[x86_64_v2_root-gui-treemap.sha256sum] = "7a842764c9fa191232763dc4577125bb25d389ec2ef1de3b508b56b72487fd18"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-webdisplay-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-webdisplay;unpack=0"
SRC_URI[x86_64_v2_root-gui-webdisplay.sha256sum] = "fcd2033492ad38d07d61bb0d14db1e06b07207b4779a02ab6d8e54fff3da44a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-webgui6-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-webgui6;unpack=0"
SRC_URI[x86_64_v2_root-gui-webgui6.sha256sum] = "360482bc853be64a7abc4cf3c07c4f0241055d05e4670340ad1fe0b09a205a65"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hbook-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hbook;unpack=0"
SRC_URI[x86_64_v2_root-hbook.sha256sum] = "95a5cfee861bf705dd933da1688dc676f1053feb59cd4a0db4939c850c1bf43b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hist-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hist;unpack=0"
SRC_URI[x86_64_v2_root-hist.sha256sum] = "e776555f5d8821596aaf70ada9ffb6810155e8dfa581f18139247af3e402c80f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hist-factory-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hist-factory;unpack=0"
SRC_URI[x86_64_v2_root-hist-factory.sha256sum] = "0d764435b888c7e22e29d9bd78d3af2f7fa3f5682b1e243fe06957ce948a1c16"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hist-painter-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hist-painter;unpack=0"
SRC_URI[x86_64_v2_root-hist-painter.sha256sum] = "d34b98b7fec30a0900a2dab69e211a35424117418db512292c3d1c66f338a834"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-histv7-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-histv7;unpack=0"
SRC_URI[x86_64_v2_root-histv7.sha256sum] = "9ec24f0111ce4d35ef0871c214b347b5f835f0a1d4f21e035068ffb07980acee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-histv7util-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-histv7util;unpack=0"
SRC_URI[x86_64_v2_root-histv7util.sha256sum] = "5afa7c5c2e2b10e3bd6e890587ea6f75286f97233bcddb532fae950b75f29bbf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-icons-6.40.04-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_root-icons;unpack=0"
SRC_URI[x86_64_v2_root-icons.sha256sum] = "6f035ae58f5ca768dc05cc9fcc205080204fdacc4a87a1489ed1c58737e30815"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io;unpack=0"
SRC_URI[x86_64_v2_root-io.sha256sum] = "ab6f12acfa3d29f0f774743a7a48d82e8fd2945bda8d85f22a7bcc9d1f686ca0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-dcache-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-dcache;unpack=0"
SRC_URI[x86_64_v2_root-io-dcache.sha256sum] = "8a346ac26d6cf89feeaec0020b8352d5893d7b7ea9f2adea950503185bb84464"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-sql-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-sql;unpack=0"
SRC_URI[x86_64_v2_root-io-sql.sha256sum] = "1e770301e9a662f72187eb3329fb2fdd3c1d857d4defda28660a811daadb589f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-xml-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-xml;unpack=0"
SRC_URI[x86_64_v2_root-io-xml.sha256sum] = "fa7b8b4bcfba268c473d53e0dcd7d86d6ff1bc591e21b2dbd4dd4a8d52addf57"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-xmlparser-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-xmlparser;unpack=0"
SRC_URI[x86_64_v2_root-io-xmlparser.sha256sum] = "9fbaeaed4e2169a21df645650a2a52ddb86187a97cf55065a323b220b26611a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-mathcore-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-mathcore;unpack=0"
SRC_URI[x86_64_v2_root-mathcore.sha256sum] = "3174bf7dd52602cc332ec81864c74e6e4f348bb3ade29360d0612d400d436d04"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-mathmore-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-mathmore;unpack=0"
SRC_URI[x86_64_v2_root-mathmore.sha256sum] = "22d097639159ac2cb26ae87937d3df84718632a084db1818ddeff3fc7e549ddc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-matrix-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-matrix;unpack=0"
SRC_URI[x86_64_v2_root-matrix.sha256sum] = "003e1f562e16a3c16b2d92a12b6e894cf93efb2bc1a9c93f597965effd275039"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-minuit-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-minuit;unpack=0"
SRC_URI[x86_64_v2_root-minuit.sha256sum] = "e07df041718f936bda63d4728c030496c2dbe8cca9da64345f703ef5b0ab6048"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-minuit2-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-minuit2;unpack=0"
SRC_URI[x86_64_v2_root-minuit2.sha256sum] = "962d596da2c312e4063b9f89a33c8f64cc686e9efd21cfcf9e32c7174aec7b4d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-mlp-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-mlp;unpack=0"
SRC_URI[x86_64_v2_root-mlp.sha256sum] = "3fa2da45fc8e39dce8f5c67fd79ffe7157ab488f0b57405e1dcf6f8eaa8b131e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-montecarlo-eg-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-montecarlo-eg;unpack=0"
SRC_URI[x86_64_v2_root-montecarlo-eg.sha256sum] = "7e145ddce63964e25dcfd930641a8475f75f9c4975edbf25aa048ecba5fe432a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-montecarlo-pythia8-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-montecarlo-pythia8;unpack=0"
SRC_URI[x86_64_v2_root-montecarlo-pythia8.sha256sum] = "80a98752e28eae5b10ecf8a9e1b69365ecbbb2bcc848dd51f93c269ed9c5d142"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-multiproc-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-multiproc;unpack=0"
SRC_URI[x86_64_v2_root-multiproc.sha256sum] = "661927215a7014d152f191697f950e13dceabb6cbaca524d15c00590a4586638"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net;unpack=0"
SRC_URI[x86_64_v2_root-net.sha256sum] = "1ffd1e432e2c1db29b6ca68d483554ec48b18b5d3e9b12535dd2890c07593b38"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-auth-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-auth;unpack=0"
SRC_URI[x86_64_v2_root-net-auth.sha256sum] = "be6139eff96a8b68393c0e0184caa346396ce4cb193c36da8e8532775ed5dc87"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-curl-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-curl;unpack=0"
SRC_URI[x86_64_v2_root-net-curl.sha256sum] = "ca9ee89ead80d162eb3ed3fa85644119f8c5d40c083bc35d80e147586a45f4ff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-davix-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-davix;unpack=0"
SRC_URI[x86_64_v2_root-net-davix.sha256sum] = "bb2b395b63cf46a6afa7034f7909d456e9b7c8628bfecaa11bfc7a0f4082911d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-http-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-http;unpack=0"
SRC_URI[x86_64_v2_root-net-http.sha256sum] = "2752951154d53dc74fbf1545777c4094fbf2c5de84e4405732ed9654323e6494"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-httpsniff-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-httpsniff;unpack=0"
SRC_URI[x86_64_v2_root-net-httpsniff.sha256sum] = "8515001b7ddd567068712f453e9333891eea1f2c95c2f09705980ac8ab06388d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-rpdutils-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-rpdutils;unpack=0"
SRC_URI[x86_64_v2_root-net-rpdutils.sha256sum] = "f9e8c996ee2e57eb5004b3088b8a2b88d2aac30184c72a8371d2926648434d1f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-netx-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-netx;unpack=0"
SRC_URI[x86_64_v2_root-netx.sha256sum] = "8b76cd3d55447299a1e492760dbe3cda4f41b0e8d9bf98632376b13adb3a03ab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-physics-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-physics;unpack=0"
SRC_URI[x86_64_v2_root-physics.sha256sum] = "654729235f951c3547b306fb78e5af02d4be8c8bcdf2029b1515e943e803e988"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-quadp-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-quadp;unpack=0"
SRC_URI[x86_64_v2_root-quadp.sha256sum] = "8399953a62e8585ea62ddf837f2e85c107873d85194754924cfe8d7d8e56656f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-r-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-r;unpack=0"
SRC_URI[x86_64_v2_root-r.sha256sum] = "4b2d887da8936d09ca614995e5f3060ec1e1d28ea381e546f79b262944de3be2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-r-tools-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-r-tools;unpack=0"
SRC_URI[x86_64_v2_root-r-tools.sha256sum] = "45ca30ee504fe6d3a39ed92ef7f27e53bc6b9d3588046c6fc08a3bc267f491ae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit;unpack=0"
SRC_URI[x86_64_v2_root-roofit.sha256sum] = "e3d5ad2056d0746b175b55b8255ba5ef0477ef74e35b22aa8086cdfe9d8c5486"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-batchcompute-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-batchcompute;unpack=0"
SRC_URI[x86_64_v2_root-roofit-batchcompute.sha256sum] = "e5fef132f229be5e681bde7ea4a2371985494c557d761b8dcd1f943ce6b8a877"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-codegen-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-codegen;unpack=0"
SRC_URI[x86_64_v2_root-roofit-codegen.sha256sum] = "fd940cd53ba2615f7b6938aec2eab5111c086c9117e6d49a0ae25e7c8a28f39c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-core-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-core;unpack=0"
SRC_URI[x86_64_v2_root-roofit-core.sha256sum] = "e66fa2ef322737811f7a373da96c867eca59e00f0f79f9525c3fa79fdec9e20c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-hs3-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-hs3;unpack=0"
SRC_URI[x86_64_v2_root-roofit-hs3.sha256sum] = "d157e7826f74c09441d076f2dade8a1c51c51a8e774a62f0b921a4fd06f75e9b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-more-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-more;unpack=0"
SRC_URI[x86_64_v2_root-roofit-more.sha256sum] = "1d704f6ab9221e2fb0aa18f1a175f5c048f18eacbc7418540f3f9067d3e9121e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-multiprocess-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-multiprocess;unpack=0"
SRC_URI[x86_64_v2_root-roofit-multiprocess.sha256sum] = "01b57dc89973052337a498df0f53e208b804836e484cedfa843433fde016f3c8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-zmq-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-zmq;unpack=0"
SRC_URI[x86_64_v2_root-roofit-zmq.sha256sum] = "eaa697caa39c22629f88388df53325dec82e9d93304aac138e14d9295001c7dd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roostats-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roostats;unpack=0"
SRC_URI[x86_64_v2_root-roostats.sha256sum] = "107aa976c7c83983e923b5eecc2e62421d61e8cd2a1c6ad672f2f1016ec8a344"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-smatrix-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-smatrix;unpack=0"
SRC_URI[x86_64_v2_root-smatrix.sha256sum] = "75f48b3f8d06b0c2e2e6ac93fdeab2b37e18b1df18f7d38c3ac4a24453c527ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-spectrum-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-spectrum;unpack=0"
SRC_URI[x86_64_v2_root-spectrum.sha256sum] = "7885b7d2d0565c5c321ea20dafebcfaf797a4916ede631a6b6a8b152b69cfb7d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-spectrum-painter-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-spectrum-painter;unpack=0"
SRC_URI[x86_64_v2_root-spectrum-painter.sha256sum] = "95db95c99dda1fe9b81ef6a1019d7ef9dceecf0fcde38c0f3ead1f8dc44ddfed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-splot-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-splot;unpack=0"
SRC_URI[x86_64_v2_root-splot.sha256sum] = "0e51d9b076f708dea5eb65ebe27e46e37a93f3f451b4a704cf34e1462d18270f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-sql-sqlite-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-sql-sqlite;unpack=0"
SRC_URI[x86_64_v2_root-sql-sqlite.sha256sum] = "c545f002b4f6c19b3ef37a36c06aaa393a477ffbed4b76bb6ac34e59d36f05ef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-testsupport-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-testsupport;unpack=0"
SRC_URI[x86_64_v2_root-testsupport.sha256sum] = "01755bcd1e890a13051583fc4f4eb946906cb2e0e16fe346769ca56864dbc779"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva;unpack=0"
SRC_URI[x86_64_v2_root-tmva.sha256sum] = "f162879a22ce42a6056e8824a411b8e06ece1bef501603a6538be0cb3990e2ac"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-gui-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-gui;unpack=0"
SRC_URI[x86_64_v2_root-tmva-gui.sha256sum] = "7840ab6a4270a8b9c844a33d68ab108ca3f4923002cf1b4eef18e5a6e6126545"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-python-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-python;unpack=0"
SRC_URI[x86_64_v2_root-tmva-python.sha256sum] = "2a24c0bc4fabcdd00dcbdc578d3ff41e0dc52e029662b3189d97d034aa2ee786"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-r-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-r;unpack=0"
SRC_URI[x86_64_v2_root-tmva-r.sha256sum] = "d9aabe4511f65ef3ec5be50cca68449c5b39f7288f73706417ef9f77dac7f23e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-sofie-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-sofie;unpack=0"
SRC_URI[x86_64_v2_root-tmva-sofie.sha256sum] = "168758824bbc6accbdfe80d71c4a6bf39f0838036e9fbad4b5e7692e586c608a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-sofie-parser-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-sofie-parser;unpack=0"
SRC_URI[x86_64_v2_root-tmva-sofie-parser.sha256sum] = "e4a0c3da8e2f5c36470676f67ba12bdebc383d126d40a051908a4e799e10abdc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-sofie-parser-python-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-sofie-parser-python;unpack=0"
SRC_URI[x86_64_v2_root-tmva-sofie-parser-python.sha256sum] = "82ba11438a130c0ef1ae6bd1f70f623ae3780db2ff333c50fafcf7e32247e7f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-utils-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-utils;unpack=0"
SRC_URI[x86_64_v2_root-tmva-utils.sha256sum] = "c085c1f1a805b576d1a0383d2134d887f46051ef757847addfc4e5eadd2305ea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tpython-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tpython;unpack=0"
SRC_URI[x86_64_v2_root-tpython.sha256sum] = "669a4d21692c557d38362cb6bca32788130e4ba61e4c3d70f8c097d34699a430"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree;unpack=0"
SRC_URI[x86_64_v2_root-tree.sha256sum] = "6ca15316324c96a029f6a521169a84f0bcad96f8cfe1977f0778932d855ee911"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-dataframe-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-dataframe;unpack=0"
SRC_URI[x86_64_v2_root-tree-dataframe.sha256sum] = "b7cb63d8f37de15eb9f4c2b0dd3593cead4e17297babf21c7ecdff48d7527ac8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ml-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ml;unpack=0"
SRC_URI[x86_64_v2_root-tree-ml.sha256sum] = "96aca3104c8a58979fb9d1bed3097c7b0f82cb642b5e8505b156d62365dd356a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ntuple-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ntuple;unpack=0"
SRC_URI[x86_64_v2_root-tree-ntuple.sha256sum] = "e32aabc3c0ee1b1902ee041cdabfbb300a183b8b4d8c363515848291880405dd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ntuple-browse-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ntuple-browse;unpack=0"
SRC_URI[x86_64_v2_root-tree-ntuple-browse.sha256sum] = "19816306bf35a116c66b4fa90490f71723568655306340291778e91a5689644c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ntuple-utils-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ntuple-utils;unpack=0"
SRC_URI[x86_64_v2_root-tree-ntuple-utils.sha256sum] = "4113c9f6a781d115178c5e19dc4ae34e3b067434f48a89a54470b5d6577ccc5f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-player-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-player;unpack=0"
SRC_URI[x86_64_v2_root-tree-player.sha256sum] = "d488a8ea4b9c8f50d79e5f8ad437b006bffb6f2c3d2cb2bd181b09f2c7980a81"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-viewer-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-viewer;unpack=0"
SRC_URI[x86_64_v2_root-tree-viewer.sha256sum] = "02d433702a84cfe8d8c9a601c51b13750577ccb8cf804dc761b473e8d53d3ea1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-webviewer-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-webviewer;unpack=0"
SRC_URI[x86_64_v2_root-tree-webviewer.sha256sum] = "b68a6c1b4af55143eab90bcb2797558669b19d768da9fc487568c9ec26e2acc6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tutorial-6.40.04-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_root-tutorial;unpack=0"
SRC_URI[x86_64_v2_root-tutorial.sha256sum] = "753f7f3ec790a448e82fb77e3fcc9fd7cd4c0d59845bbedc91cda5c94b08e756"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-unfold-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-unfold;unpack=0"
SRC_URI[x86_64_v2_root-unfold.sha256sum] = "f38d2e879449374b30ab0465b9982950dfa10943746fc8593effd5cd558977c5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-unuran-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-unuran;unpack=0"
SRC_URI[x86_64_v2_root-unuran.sha256sum] = "f0b6326d76bcf4fe9013b02661a7cc6500cadc691e90b4b37c90e36858076f76"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-vecops-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-vecops;unpack=0"
SRC_URI[x86_64_v2_root-vecops.sha256sum] = "3eca8282823e8e31c0089d928cae55748c06ffc41151e1fec9ae936e64caa74b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-xroofit-6.40.04-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-xroofit;unpack=0"
SRC_URI[x86_64_v2_root-xroofit.sha256sum] = "4a594ebbc4694181071783b8552f774027d30b9f3351da89c5d7972ce7f332d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-root-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_python3-root;unpack=0"
SRC_URI[aarch64_python3-root.sha256sum] = "a79e40f2a0e275abcb7068ece20e5cfc0b851227ea4a8382ba1d8ca7d0b7fb65"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-root+distrdf-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_python3-root+distrdf;unpack=0"
SRC_URI[aarch64_python3-root+distrdf.sha256sum] = "dddecd44320e084b72c52158f83c8e93794757dbad96bcf7aea21faad2f74028"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-root+jupyroot-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_python3-root+jupyroot;unpack=0"
SRC_URI[aarch64_python3-root+jupyroot.sha256sum] = "bde47b3d427479f535d4e50e9bdbbae8ed8f6ff2dbdb2ee9675bab5d26f08694"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root;unpack=0"
SRC_URI[aarch64_root.sha256sum] = "11d98f97fc0d7ddfac4e9b8bac80ce46c5a9e8de8bcbce5615be4084e5ba7b1e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-cli-6.40.04-1.el10_2.noarch.rpm;name=aarch64_root-cli;unpack=0"
SRC_URI[aarch64_root-cli.sha256sum] = "0711b4948db946273003b63341b28c3bd17a74c58bccfeb350467d65c56f4bcd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-cling-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-cling;unpack=0"
SRC_URI[aarch64_root-cling.sha256sum] = "1680a887751e3ef0b3bb1c8a20fa12204155126056d80762c63d98d65f70609f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-core-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-core;unpack=0"
SRC_URI[aarch64_root-core.sha256sum] = "614ccba39810dc26ea55db41f14dc89771da86959b5efc9a64da7c92dd58dbd8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-fftw-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-fftw;unpack=0"
SRC_URI[aarch64_root-fftw.sha256sum] = "e9a3acd1e6e1fe3a865f26d69f20752a7b7b7d9a25c515332689abc1f325d030"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-foam-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-foam;unpack=0"
SRC_URI[aarch64_root-foam.sha256sum] = "507421d09335ff1006afe2664828bdbb2008e9b921966d22d2681413bd23a264"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-font-files-6.40.04-1.el10_2.noarch.rpm;name=aarch64_root-font-files;unpack=0"
SRC_URI[aarch64_root-font-files.sha256sum] = "0c0b659924b9bb18a714a99d855f05811eb24b339b3bf7dcaf3b42f3795d5330"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-fumili-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-fumili;unpack=0"
SRC_URI[aarch64_root-fumili.sha256sum] = "16bb76644cab44ab1c82e2f736782ef673b8c2b413bef681ccce1923767e574d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gdml-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gdml;unpack=0"
SRC_URI[aarch64_root-gdml.sha256sum] = "4e1ea7bda73405a60d92d1bd90d293ff0a7e5e90c7165cab23242c25f5053fd4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-genetic-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-genetic;unpack=0"
SRC_URI[aarch64_root-genetic.sha256sum] = "e624452987d945c72407ccea9284798f168b2784e19c564218fb8c9ee435f9f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-genvector-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-genvector;unpack=0"
SRC_URI[aarch64_root-genvector.sha256sum] = "f4e50eb1bb32afd55adb3e625d3466c5da0dd6af658748c0d6831dec1acd1a47"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-geom-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-geom;unpack=0"
SRC_URI[aarch64_root-geom.sha256sum] = "aed4dd08141fed483389e56ff377016300ee832505c99738c5147bf2bc8ead69"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-geom-builder-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-geom-builder;unpack=0"
SRC_URI[aarch64_root-geom-builder.sha256sum] = "919398c21cffc3099696d009dc43a4ac2978bc34dc7ca19955e297be462740a6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-geom-checker-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-geom-checker;unpack=0"
SRC_URI[aarch64_root-geom-checker.sha256sum] = "d1fd55073a4851ebf629cefe18dfb0dbc0b200ad6d088dd826202820d50a94dc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-geom-painter-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-geom-painter;unpack=0"
SRC_URI[aarch64_root-geom-painter.sha256sum] = "176b42e37663aaf433671adf78b7b42e925cf20c5d3c1aadb4ed59f0688af2d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-geom-webviewer-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-geom-webviewer;unpack=0"
SRC_URI[aarch64_root-geom-webviewer.sha256sum] = "979b67f11d79cbf51351659489a06dd4ee54a82a2ac63682932f689130299882"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf;unpack=0"
SRC_URI[aarch64_root-graf.sha256sum] = "6e0034c0c2fcdede16a62a65c554d6b357bb2a31b4c6add826c18aaab8861faf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-asimage-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf-asimage;unpack=0"
SRC_URI[aarch64_root-graf-asimage.sha256sum] = "492c4eeb685aa8a81c2aed30e0329aaecb4ac4ea8c55f3895278938105443ba1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-fitsio-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf-fitsio;unpack=0"
SRC_URI[aarch64_root-graf-fitsio.sha256sum] = "d6f89af058f69f142d5a90ff31d1a63c6c1b4e2d01d37eb0fd0682cfb08ea5b5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-gpad-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf-gpad;unpack=0"
SRC_URI[aarch64_root-graf-gpad.sha256sum] = "a9d3b027b657b716db4d5be87b63cf1fa56f4fe83ed84ff86dd0cc3e7cdd6e00"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-gpadv7-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf-gpadv7;unpack=0"
SRC_URI[aarch64_root-graf-gpadv7.sha256sum] = "b6dee61c9ec6064881f68afebc7ded825ee10f5bb5c47b3cdb15415a19636742"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-gviz-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf-gviz;unpack=0"
SRC_URI[aarch64_root-graf-gviz.sha256sum] = "d278dd49b377bce0bfd40b0a7c000d58250ccace14803459f80f08442d744060"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-postscript-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf-postscript;unpack=0"
SRC_URI[aarch64_root-graf-postscript.sha256sum] = "fc4ecc60e7245e46adcd02821e0697118bc55e61e0fa71eadfebc74dc3a31073"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-primitives-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf-primitives;unpack=0"
SRC_URI[aarch64_root-graf-primitives.sha256sum] = "07b09243a40f9fd0e991e85248de411c0fe6268c9921a546e1787b17dcf3b2cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf-x11-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf-x11;unpack=0"
SRC_URI[aarch64_root-graf-x11.sha256sum] = "999ece36cbbf320af42b91ee306f6bf0524b54b1135a4144fc8c1a5dcfd03b9b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d;unpack=0"
SRC_URI[aarch64_root-graf3d.sha256sum] = "e9d386790629bc529e9bb62980554bd03af45ef2068f28ac746166a935159b34"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-csg-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d-csg;unpack=0"
SRC_URI[aarch64_root-graf3d-csg.sha256sum] = "16f10faa74a653d8871f48ed4b1b63e077c9dc34a5a859dfffcaa43dc6feffc1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-eve-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d-eve;unpack=0"
SRC_URI[aarch64_root-graf3d-eve.sha256sum] = "144ee77633841e58aa086cdfe74ca6813f92a937d8df7a08d5e5c84f7a3ff454"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-eve7-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d-eve7;unpack=0"
SRC_URI[aarch64_root-graf3d-eve7.sha256sum] = "ab5c27566b31553e28f646ce44084605e13f5a6ff236d026e470eedfdf960abe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-gl-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d-gl;unpack=0"
SRC_URI[aarch64_root-graf3d-gl.sha256sum] = "af52bda73ed524baf66b91012cf36d253a8bcd26ae233c564628f284c7e13ce9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-glad-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d-glad;unpack=0"
SRC_URI[aarch64_root-graf3d-glad.sha256sum] = "8815d9863508e66d546164e41b456005890a37303aa491fb01790de5ef32a55e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-gviz3d-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d-gviz3d;unpack=0"
SRC_URI[aarch64_root-graf3d-gviz3d.sha256sum] = "82c007c18dd9981cd0e6719c161b7678fda6b2eda35b667db24bba0542a5baaf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-x3d-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d-x3d;unpack=0"
SRC_URI[aarch64_root-graf3d-x3d.sha256sum] = "dd22c639a53462ed8771519a79e017bb9002b9c6ab2e33000edbb3a78f2afeb1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui;unpack=0"
SRC_URI[aarch64_root-gui.sha256sum] = "4ea93b3dbe076651c7c2fa30090c6aa775d97bd35ef2ed085d01b23fb202c759"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browsable-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui-browsable;unpack=0"
SRC_URI[aarch64_root-gui-browsable.sha256sum] = "6b811cc4406c26efa05709e114e334c36d85f6220d782c43872faeb905c3c936"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browsable-v7-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui-browsable-v7;unpack=0"
SRC_URI[aarch64_root-gui-browsable-v7.sha256sum] = "ae03f281b1a8e6c291b49571b43a06ef65e974f3bc7098d7ec8538e72c4531c4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browserv7-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui-browserv7;unpack=0"
SRC_URI[aarch64_root-gui-browserv7.sha256sum] = "0bec018d4dd67ad81f641aae72d334602392ab67aabfe32741aa80e8f99ef47a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browserv7-v7-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui-browserv7-v7;unpack=0"
SRC_URI[aarch64_root-gui-browserv7-v7.sha256sum] = "f4c6beb2d03678ef8296d7394e7abf0bf41c0633a8c0b18c0636e1562440a5cd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-builder-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui-builder;unpack=0"
SRC_URI[aarch64_root-gui-builder.sha256sum] = "5756d3adb6a34d27d815eec74c856e276964190c67dd3e6c7225e37c59e456a6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-canvaspainter-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui-canvaspainter;unpack=0"
SRC_URI[aarch64_root-gui-canvaspainter.sha256sum] = "edf4ffb2756b20d6045f12bfa09d4c3d47426b50bba87e3eb8d9da1d0c92f835"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-fitpanel-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui-fitpanel;unpack=0"
SRC_URI[aarch64_root-gui-fitpanel.sha256sum] = "4c84b35fa37e7145aecbd5510575fea5aaeb15604de7bed98dc274dba3c84c81"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-fitpanelv7-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui-fitpanelv7;unpack=0"
SRC_URI[aarch64_root-gui-fitpanelv7.sha256sum] = "d0c3aed1279cda245cc7c734dfe35e9889950864c26a459fb992611869046a25"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-ged-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui-ged;unpack=0"
SRC_URI[aarch64_root-gui-ged.sha256sum] = "3ed983d9a03c7ecb495980fc95465194f2987ce2516bb5cf44d99bd5a0ff3435"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-html-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui-html;unpack=0"
SRC_URI[aarch64_root-gui-html.sha256sum] = "a770c146308f5db5b2f75f70a37fbf63325c2f8b8cffe10bd1772aaa48d20fa1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-qt6webdisplay-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui-qt6webdisplay;unpack=0"
SRC_URI[aarch64_root-gui-qt6webdisplay.sha256sum] = "24d77b3781b6e93e7eda6ea8a3dddaa8816309e8fc051cf5d8dea11db7c0e176"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-recorder-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui-recorder;unpack=0"
SRC_URI[aarch64_root-gui-recorder.sha256sum] = "14eace01636ab8b7643e15f7c06fee1c8ece409dd92914937b93f4cee6389c11"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-treemap-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui-treemap;unpack=0"
SRC_URI[aarch64_root-gui-treemap.sha256sum] = "2c53c7feb066db04e2cebe6023e67d2ba18431c0907d938c6785a89d254618d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-webdisplay-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui-webdisplay;unpack=0"
SRC_URI[aarch64_root-gui-webdisplay.sha256sum] = "4ac054e5614919eb330e7d8dea14f532b987f64dd3e53cdc1fcd39630591b445"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-gui-webgui6-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-gui-webgui6;unpack=0"
SRC_URI[aarch64_root-gui-webgui6.sha256sum] = "b0667df0ea7821eaeabdad1724096a45c753969c63ceb6a11efaabfc477c7611"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-hbook-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-hbook;unpack=0"
SRC_URI[aarch64_root-hbook.sha256sum] = "eae626f292283b2cd5331b7cefb7f0ff0276c7b23a766c6fd5dc675ece62663e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-hist-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-hist;unpack=0"
SRC_URI[aarch64_root-hist.sha256sum] = "7c2aaeb11d869deef1fe825d68baa8653566c9c5a615ceb646ef2f710383ebb2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-hist-factory-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-hist-factory;unpack=0"
SRC_URI[aarch64_root-hist-factory.sha256sum] = "7946ae0d8437f59ab2a11d97b8d0899f9808f63251641d864ecdeb0fdb3be818"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-hist-painter-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-hist-painter;unpack=0"
SRC_URI[aarch64_root-hist-painter.sha256sum] = "181e1da02fb94a303930ed3e77cafd31c3d6dab0625a12bc0539af33d8d2ac79"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-histv7-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-histv7;unpack=0"
SRC_URI[aarch64_root-histv7.sha256sum] = "3dc3b904c524d2a25ae60c31c9ed5c76ba1f0eca672831aa773577243f05cd3d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-histv7util-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-histv7util;unpack=0"
SRC_URI[aarch64_root-histv7util.sha256sum] = "62d37bf2180cdf07b723f9030f39c5715dbc8e762543efee264df406f5648729"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-icons-6.40.04-1.el10_2.noarch.rpm;name=aarch64_root-icons;unpack=0"
SRC_URI[aarch64_root-icons.sha256sum] = "5151e3cf4cc735e43f22c6c5d1575f34ad2b50df6a115fbd255c2c063b27857b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-io-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-io;unpack=0"
SRC_URI[aarch64_root-io.sha256sum] = "84d23f4d24b8e62196650d40bbced9a34f1ce0f1b0e1ca5b4b9cd7a45e8b4b50"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-io-dcache-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-io-dcache;unpack=0"
SRC_URI[aarch64_root-io-dcache.sha256sum] = "2d6fa1818da89dc238fea53c8dff87d0607023e69b9e24a50b97c75ac2bea071"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-io-sql-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-io-sql;unpack=0"
SRC_URI[aarch64_root-io-sql.sha256sum] = "b13a070e70ccacad5d0f3d6ba145b5f4ee1e4d3cc0265e65d4922913c17e9742"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-io-xml-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-io-xml;unpack=0"
SRC_URI[aarch64_root-io-xml.sha256sum] = "5f1b515b7c559620d68cde7df5c6c39bbcb329f9b0a46e8955908f72ebe2c9f7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-io-xmlparser-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-io-xmlparser;unpack=0"
SRC_URI[aarch64_root-io-xmlparser.sha256sum] = "a476888c6aefbfc094a209777763f305ebdeed80cfda82ddf2164a4a13a6c08d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-mathcore-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-mathcore;unpack=0"
SRC_URI[aarch64_root-mathcore.sha256sum] = "389123ed40cdb7c6def1d90848401a5d739a1ffed8f31ba8bc14ca89e016f3b9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-mathmore-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-mathmore;unpack=0"
SRC_URI[aarch64_root-mathmore.sha256sum] = "2829f3531cf233e119d12c1af1ab25145c274cf4363f876c7718cd92784e5fda"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-matrix-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-matrix;unpack=0"
SRC_URI[aarch64_root-matrix.sha256sum] = "96144a8cbc1d54a76d263eebfa7fcbdd599a53b507adf7f194f0243721266eb7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-minuit-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-minuit;unpack=0"
SRC_URI[aarch64_root-minuit.sha256sum] = "c49baf74273c1e45a35021dfa79fdb3ba699e88a469fc4f98c3a80d0130a820f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-minuit2-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-minuit2;unpack=0"
SRC_URI[aarch64_root-minuit2.sha256sum] = "7fa7e73b6f00664d3db592f979608547517f5a430e541488b257e368033d5307"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-mlp-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-mlp;unpack=0"
SRC_URI[aarch64_root-mlp.sha256sum] = "be9ca937e9036e97fb5ce81b6cfcb92ffff7206d88848c34f9bde5bcd0e85b76"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-montecarlo-eg-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-montecarlo-eg;unpack=0"
SRC_URI[aarch64_root-montecarlo-eg.sha256sum] = "6a59f7cc47e20b13f81e5ac587ed0ca48a2f3f5e50f7ce006c939269b223d4fb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-montecarlo-pythia8-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-montecarlo-pythia8;unpack=0"
SRC_URI[aarch64_root-montecarlo-pythia8.sha256sum] = "003d2725513bfcccb274988093b4b6f5f51224e04b9e21475eb7175992ec81cb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-multiproc-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-multiproc;unpack=0"
SRC_URI[aarch64_root-multiproc.sha256sum] = "dd624e91b840209fcb4daa21eee2547fec9636b8b10ada0c68c9beb21db7185b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-net-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-net;unpack=0"
SRC_URI[aarch64_root-net.sha256sum] = "d7c808d0f369200e9628fce560f428cab2c037e15c7654171124a22a567f16a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-net-auth-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-net-auth;unpack=0"
SRC_URI[aarch64_root-net-auth.sha256sum] = "5564918d9a78686d717b1cce5eeecffe31d8881f4b6e9fc19748780959d5de4e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-net-curl-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-net-curl;unpack=0"
SRC_URI[aarch64_root-net-curl.sha256sum] = "09d3f145927889fef3ac831c7bc3b563e155f1e898a4785a741a4b057e1f2763"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-net-davix-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-net-davix;unpack=0"
SRC_URI[aarch64_root-net-davix.sha256sum] = "1fa9f4830d16ab38f5a6a64d683ac042409e176056288f14983ce914724ae2c6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-net-http-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-net-http;unpack=0"
SRC_URI[aarch64_root-net-http.sha256sum] = "54ebd56c6aea7259e2770a158b34566fa211fda641aca84524bf467e0d49b545"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-net-httpsniff-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-net-httpsniff;unpack=0"
SRC_URI[aarch64_root-net-httpsniff.sha256sum] = "718ee3087c22b66d19e107b2df74ebaaa2cc976286ec46f4c2193185843b1b8a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-net-rpdutils-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-net-rpdutils;unpack=0"
SRC_URI[aarch64_root-net-rpdutils.sha256sum] = "fd4a514af0d38fc768bc8e03a47c7bf3a50289e37c69912452b2b0d85c72d0fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-netx-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-netx;unpack=0"
SRC_URI[aarch64_root-netx.sha256sum] = "ec6037c8bbe5903ae9a7d6c403acce2bacc0a205913d68c7ca294c8882dda2ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-physics-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-physics;unpack=0"
SRC_URI[aarch64_root-physics.sha256sum] = "611c2ce3bc1f9cfb5ccd211bedf74fa3c6d15e70f9228d5661907229e5d339ea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-quadp-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-quadp;unpack=0"
SRC_URI[aarch64_root-quadp.sha256sum] = "65fe9a710f605f585a6bf23b58d0a78cdabb1b5e9f6fe086f109beed0a3d1a9b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-r-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-r;unpack=0"
SRC_URI[aarch64_root-r.sha256sum] = "a3821e9bba39d1303fb2f335814c6be1f5fa8c92749f966830852f303e791f7f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-r-tools-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-r-tools;unpack=0"
SRC_URI[aarch64_root-r-tools.sha256sum] = "79c627ad32a8276786f418f5af206ebf598c868145eb39acc765f3647b3ed0e0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-roofit;unpack=0"
SRC_URI[aarch64_root-roofit.sha256sum] = "23e4798c96efd1e33027615a6f369e632b22e91b598221f171ef8d18a9a7aca1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-batchcompute-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-roofit-batchcompute;unpack=0"
SRC_URI[aarch64_root-roofit-batchcompute.sha256sum] = "53de4482a54e8315b7ae7075c51f67f50ec941f22a435396f9fced200133b823"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-codegen-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-roofit-codegen;unpack=0"
SRC_URI[aarch64_root-roofit-codegen.sha256sum] = "5da4609bb1c8ba401bd66ffd0af8b26243f235e394b25b456b47e12a9ff411e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-core-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-roofit-core;unpack=0"
SRC_URI[aarch64_root-roofit-core.sha256sum] = "65a508638f5f8f0c4620549ba061c96713347a5296c474557263eb5ca4eaf118"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-hs3-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-roofit-hs3;unpack=0"
SRC_URI[aarch64_root-roofit-hs3.sha256sum] = "3a5930cb7c65b144fc1bc07f553d536658e95de42c3d8bed697de5875b185e21"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-more-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-roofit-more;unpack=0"
SRC_URI[aarch64_root-roofit-more.sha256sum] = "fef8626623de655d8cab04a680e1fd6beb2b481e44461c2d53f5b322395aacfa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-multiprocess-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-roofit-multiprocess;unpack=0"
SRC_URI[aarch64_root-roofit-multiprocess.sha256sum] = "33fce3414f83a82ffb8097f45cbad0145d87c229ed3639f0ac4b4332e9611809"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-zmq-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-roofit-zmq;unpack=0"
SRC_URI[aarch64_root-roofit-zmq.sha256sum] = "7787d583bc153642dfa9367b5bbe810b2bccc7eb43c1a1aa8b7ee0ccf17b39f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-roostats-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-roostats;unpack=0"
SRC_URI[aarch64_root-roostats.sha256sum] = "4f2044f061b03df8ac14a2e34ed0edd10f09b59d19b8d4b132c1a4d4e4d83974"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-smatrix-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-smatrix;unpack=0"
SRC_URI[aarch64_root-smatrix.sha256sum] = "c5621adac67b2cdd233cbf3950f1cc88850b58244fb650e8f5d17f60bd6249e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-spectrum-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-spectrum;unpack=0"
SRC_URI[aarch64_root-spectrum.sha256sum] = "55046cd491d77ea1eb4dca6215df20c1de5769f613aeb17bfeb8b11600f20f52"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-spectrum-painter-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-spectrum-painter;unpack=0"
SRC_URI[aarch64_root-spectrum-painter.sha256sum] = "91ec592755f4a13992fb9b511f38768f30edb727515d84748d3593ea0d80cb0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-splot-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-splot;unpack=0"
SRC_URI[aarch64_root-splot.sha256sum] = "cb8f62eb1ac455d7c03f4b9e6f6e9ea74e9fd471ea95088efdf6fa355b6dc4b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-sql-sqlite-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-sql-sqlite;unpack=0"
SRC_URI[aarch64_root-sql-sqlite.sha256sum] = "cd7755289e2be338bb427d79093d13d7a5bbd6870a7712f5018dc166d768a46f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-testsupport-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-testsupport;unpack=0"
SRC_URI[aarch64_root-testsupport.sha256sum] = "941c45ff6ae9099c70a86f26d1c08f7184d84f017995dbf8c45cfab517414a5f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tmva;unpack=0"
SRC_URI[aarch64_root-tmva.sha256sum] = "17581df202fb04c6e032d953cbc2e756dc61380f30038bc962306c163f767cdb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-gui-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tmva-gui;unpack=0"
SRC_URI[aarch64_root-tmva-gui.sha256sum] = "bea37c93f7b2de02c0cd8b5c3e9f2308eced7c9bef015354163185ad0165bd98"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-python-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tmva-python;unpack=0"
SRC_URI[aarch64_root-tmva-python.sha256sum] = "b48660ed3211f1ce5b444ab9d02b8ca013fd17c8df2dacdc07ae97bb04f4ee9d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-r-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tmva-r;unpack=0"
SRC_URI[aarch64_root-tmva-r.sha256sum] = "44a6fa8678bbf609d8d124604cd11b03c548e366320a60b19dbfa7d618190b72"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-sofie-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tmva-sofie;unpack=0"
SRC_URI[aarch64_root-tmva-sofie.sha256sum] = "215758c32c79eb681995f4e2306470846cefd57c7aa483cc848713d494bc4cc6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-sofie-parser-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tmva-sofie-parser;unpack=0"
SRC_URI[aarch64_root-tmva-sofie-parser.sha256sum] = "efb54c8c3089ea56ea6f94ab36327412f6eabc93f2873495ba2d2b5525122c5f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-sofie-parser-python-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tmva-sofie-parser-python;unpack=0"
SRC_URI[aarch64_root-tmva-sofie-parser-python.sha256sum] = "9ad04fe6b1784e442d427f4aff4eb9adc36e2e34191613b7c0a3d0627a755e80"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-utils-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tmva-utils;unpack=0"
SRC_URI[aarch64_root-tmva-utils.sha256sum] = "99c036a2a38e4908ae70626abc5eca9521c4b0e3ad658560b73b7db916ec175e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tpython-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tpython;unpack=0"
SRC_URI[aarch64_root-tpython.sha256sum] = "a04a4f3bf19df37e644af796d3e07c55344fae2f01b1566c3e9a040e63c9ea9d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tree;unpack=0"
SRC_URI[aarch64_root-tree.sha256sum] = "15ee0ed1e43eee91ee7b756f97282a2cf5faf45937989a026a10ee94d3bd5ac3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-dataframe-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tree-dataframe;unpack=0"
SRC_URI[aarch64_root-tree-dataframe.sha256sum] = "9c271d0771fbebb0d89bc9fff3b28f7ad4b37979709ec220c372cc4811500c79"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ml-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tree-ml;unpack=0"
SRC_URI[aarch64_root-tree-ml.sha256sum] = "a7fbe27bbef1e8efdeadd0cb82bc7fabc0d603fd22808b8391d1bbf4b968cd07"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ntuple-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tree-ntuple;unpack=0"
SRC_URI[aarch64_root-tree-ntuple.sha256sum] = "2874542c167ee07df0b7b0a2b728922e01771289ec0761ddb703f2a95a04fe6a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ntuple-browse-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tree-ntuple-browse;unpack=0"
SRC_URI[aarch64_root-tree-ntuple-browse.sha256sum] = "4295e382bf1313b47e44a413cda3ae20682f478e1f0ffd8e8997a40e492eef29"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ntuple-utils-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tree-ntuple-utils;unpack=0"
SRC_URI[aarch64_root-tree-ntuple-utils.sha256sum] = "43a70ad90a88de01dfcea7ab100b24211cd32bb192c7291329a1bd6400e32133"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-player-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tree-player;unpack=0"
SRC_URI[aarch64_root-tree-player.sha256sum] = "de3a78ddd44556fc0ba6204117b339fca23f38c395b88783c90c06854ac621b0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-viewer-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tree-viewer;unpack=0"
SRC_URI[aarch64_root-tree-viewer.sha256sum] = "d52db5332682486fce929f72b9513ce76b3c0c61767d22de4fb32ceb5469c8bb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tree-webviewer-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-tree-webviewer;unpack=0"
SRC_URI[aarch64_root-tree-webviewer.sha256sum] = "89293286b1b5bfbe6e67087822493610cee1dc1a3fc5c2ba7bf624db0f21ac71"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-tutorial-6.40.04-1.el10_2.noarch.rpm;name=aarch64_root-tutorial;unpack=0"
SRC_URI[aarch64_root-tutorial.sha256sum] = "fa4d4fd53d9c5354868c083a700198f3ff6a0f0252cd03b384c4349fbfb0d1b2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-unfold-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-unfold;unpack=0"
SRC_URI[aarch64_root-unfold.sha256sum] = "9ff50f72debc8300260d6fedfaa76d79f7fe96e8bc5a78598d8e7c724353320c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-unuran-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-unuran;unpack=0"
SRC_URI[aarch64_root-unuran.sha256sum] = "39cbb92377d3909259cc521a0a8b4aa71c7760f2e008211620008d36e68c378d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-vecops-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-vecops;unpack=0"
SRC_URI[aarch64_root-vecops.sha256sum] = "a99a6505c39920951129dfedcab1c6d5f47e92427214a8bdb715cba74fe8c33f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/root-xroofit-6.40.04-1.el10_2.aarch64.rpm;name=aarch64_root-xroofit;unpack=0"
SRC_URI[aarch64_root-xroofit.sha256sum] = "122e955128c9d6218b28e452f2cb8ff343ec9577edb0b10c8022b496161d1c4a"

RDEPENDS:python3-root = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 root-core \
 root-io \
 root-tree \
 "
RDEPENDS:python3-root+distrdf = " \
 python3 \
 python3-root \
 root-tree-dataframe \
 "
RDEPENDS:python3-root+jupyroot = " \
 bash \
 js-jsroot \
 python-jupyter-filesystem \
 python3 \
 python3-ipython \
 python3-metakernel \
 python3-notebook \
 python3-root \
 root-core \
 "
RDEPENDS:root = " \
 bash \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-mathcore \
 root-multiproc \
 root-net \
 root-tree \
 root-tree-ntuple \
 root-tree-player \
 "
RDEPENDS:root-cli = " \
 python3 \
 python3-root \
 "
RDEPENDS:root-cling = " \
 gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 python3 \
 redhat-rpm-config \
 root-core \
 root-io \
 zlib-ng-compat \
 "
RDEPENDS:root-core = " \
 bash \
 glibc \
 gnu-free-mono-fonts \
 gnu-free-sans-fonts \
 gnu-free-serif-fonts \
 google-droid-sans-fonts \
 json-devel \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 pcre2 \
 root-cling \
 root-font-files \
 root-graf \
 root-graf-asimage \
 root-graf-gpad \
 root-graf-postscript \
 root-graf3d \
 root-hist \
 root-icons \
 root-io \
 root-mathcore \
 root-matrix \
 root-multiproc \
 root-net \
 root-physics \
 root-tree \
 root-tree-dataframe \
 root-tree-ntuple \
 root-tree-ntuple-utils \
 root-tree-player \
 root-vecops \
 tbb \
 urw-base35-d050000l-fonts \
 urw-base35-standard-symbols-ps-fonts \
 urw-base35-z003-fonts \
 xorg-x11-fonts-ISO8859-1-75dpi \
 xxhash-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:root-fftw = " \
 fftw-libs-double \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-foam = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-font-files = " \
 root-core \
 "
RDEPENDS:root-fumili = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-gdml = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-hist \
 root-io-xml \
 "
RDEPENDS:root-genetic = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-tmva \
 "
RDEPENDS:root-genvector = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-geom = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-geom-builder = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-gui \
 root-gui-ged \
 "
RDEPENDS:root-geom-checker = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-graf3d \
 root-hist \
 root-io \
 root-mathcore \
 root-tree \
 "
RDEPENDS:root-geom-painter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-graf3d \
 root-hist \
 "
RDEPENDS:root-geom-webviewer = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-geom-painter \
 root-graf3d-csg \
 root-gui-webdisplay \
 root-io \
 "
RDEPENDS:root-graf = " \
 fontconfig \
 freetype \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-graf-asimage = " \
 fontconfig \
 freetype \
 giflib \
 glibc \
 libX11 \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf-postscript \
 root-gui \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-graf-fitsio = " \
 cfitsio \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-matrix \
 "
RDEPENDS:root-graf-gpad = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-postscript \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-graf-gpadv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-graf-gviz = " \
 glibc \
 graphviz \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-hist \
 "
RDEPENDS:root-graf-postscript = " \
 fontconfig \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 zlib-ng-compat \
 "
RDEPENDS:root-graf-primitives = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 "
RDEPENDS:root-graf-x11 = " \
 freetype \
 glibc \
 libX11 \
 libXext \
 libXft \
 libXpm \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 "
RDEPENDS:root-graf3d = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-graf3d-csg = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-graf3d-eve = " \
 glibc \
 libgcc \
 libstdc++ \
 mesa-libGLU \
 root-core \
 root-geom \
 root-graf \
 root-graf-gpad \
 root-graf3d \
 root-graf3d-gl \
 root-graf3d-glad \
 root-gui \
 root-gui-ged \
 root-hist \
 root-io \
 root-mathcore \
 root-montecarlo-eg \
 root-physics \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-graf3d-eve7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-geom-webviewer \
 root-graf \
 root-graf3d \
 root-graf3d-csg \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-mathcore \
 root-montecarlo-eg \
 root-net-http \
 root-physics \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-graf3d-gl = " \
 fontconfig \
 ftgl \
 gl2ps \
 glibc \
 libX11 \
 libgcc \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 mesa-libGLU \
 root-core \
 root-graf \
 root-graf-asimage \
 root-graf-gpad \
 root-graf3d \
 root-graf3d-csg \
 root-graf3d-glad \
 root-gui \
 root-gui-ged \
 root-hist \
 root-mathcore \
 root-tree \
 "
RDEPENDS:root-graf3d-glad = " \
 glibc \
 libX11 \
 root-core \
 "
RDEPENDS:root-graf3d-gviz3d = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-graf3d \
 root-graf3d-gl \
 root-gui \
 root-gui-ged \
 "
RDEPENDS:root-graf3d-x3d = " \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 root-core \
 root-graf3d \
 root-gui \
 "
RDEPENDS:root-gui = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf-x11 \
 root-gui-ged \
 root-io \
 root-mathcore \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 "
RDEPENDS:root-gui-browsable = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-gui-treemap \
 root-hist \
 root-io \
 root-tree \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 "
RDEPENDS:root-gui-browsable-v7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 root-gui-browsable \
 root-gui-treemap \
 root-hist \
 root-tree \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 "
RDEPENDS:root-gui-browserv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-geom-webviewer \
 root-graf-gpad \
 root-gui-browsable \
 root-gui-webdisplay \
 root-gui-webgui6 \
 root-io \
 root-tree \
 root-tree-webviewer \
 "
RDEPENDS:root-gui-browserv7-v7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 root-gui-browsable \
 root-gui-browserv7 \
 "
RDEPENDS:root-gui-builder = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-gui \
 root-mathcore \
 "
RDEPENDS:root-gui-canvaspainter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 root-gui-webdisplay \
 root-io \
 "
RDEPENDS:root-gui-fitpanel = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpad \
 root-gui \
 root-hist \
 root-mathcore \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-gui-fitpanelv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpad \
 root-graf-gpadv7 \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-gui-ged = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-hist \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-gui-html = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-gui \
 root-net \
 "
RDEPENDS:root-gui-qt6webdisplay = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 root-core \
 root-gui-webdisplay \
 root-net-http \
 "
RDEPENDS:root-gui-recorder = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpad \
 root-gui \
 root-io \
 root-tree \
 "
RDEPENDS:root-gui-treemap = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 "
RDEPENDS:root-gui-webdisplay = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-mathcore \
 root-net \
 root-net-http \
 "
RDEPENDS:root-gui-webgui6 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-net-http \
 "
RDEPENDS:root-hbook = " \
 glibc \
 libgcc \
 libgfortran \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-tree \
 "
RDEPENDS:root-hist = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist-painter \
 root-io \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-hist-factory = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-io-xmlparser \
 root-roofit \
 root-roofit-core \
 root-roostats \
 "
RDEPENDS:root-hist-painter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-histv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-histv7util = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 "
RDEPENDS:root-icons = " \
 root-core \
 "
RDEPENDS:root-io = " \
 glibc \
 libgcc \
 libstdc++ \
 liburing \
 liburing-devel \
 root-core \
 "
RDEPENDS:root-io-dcache = " \
 dcap-libs \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-io-sql = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 "
RDEPENDS:root-io-xml = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-io-xmlparser = " \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 root-core \
 "
RDEPENDS:root-mathcore = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathmore \
 root-minuit2 \
 "
RDEPENDS:root-mathmore = " \
 glibc \
 gsl \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 "
RDEPENDS:root-matrix = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 "
RDEPENDS:root-minuit = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-minuit2 = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-mlp = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-mathcore \
 root-matrix \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-montecarlo-eg = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf3d \
 root-mathcore \
 "
RDEPENDS:root-montecarlo-pythia8 = " \
 glibc \
 libgcc \
 libstdc++ \
 pythia8 \
 root-core \
 root-montecarlo-eg \
 "
RDEPENDS:root-multiproc = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 "
RDEPENDS:root-net = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 root-core \
 root-io \
 "
RDEPENDS:root-net-auth = " \
 glibc \
 libgcc \
 libstdc++ \
 libxcrypt \
 root-core \
 root-net \
 "
RDEPENDS:root-net-curl = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:root-net-davix = " \
 davix-libs \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-net-http = " \
 bash \
 civetweb \
 fcgi \
 glibc \
 js-jsroot \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-net-httpsniff = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-io \
 root-io-xml \
 root-net-http \
 root-tree \
 "
RDEPENDS:root-net-rpdutils = " \
 glibc \
 libgcc \
 libstdc++ \
 libxcrypt \
 root-core \
 root-net \
 "
RDEPENDS:root-netx = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:root-physics = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-quadp = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-matrix \
 "
RDEPENDS:root-r = " \
 R-RInside \
 R-Rcpp \
 R-core \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 readline \
 root-core \
 root-matrix \
 "
RDEPENDS:root-r-tools = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-matrix \
 root-r \
 "
RDEPENDS:root-roofit = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-mathcore \
 root-matrix \
 root-roofit-batchcompute \
 root-roofit-core \
 root-tree \
 "
RDEPENDS:root-roofit-batchcompute = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-roofit-codegen = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist-factory \
 root-roofit \
 root-roofit-core \
 "
RDEPENDS:root-roofit-core = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-foam \
 root-graf \
 root-hist \
 root-io \
 root-mathcore \
 root-matrix \
 root-minuit2 \
 root-roofit-batchcompute \
 root-roofit-multiprocess \
 root-roofit-zmq \
 root-tree \
 zeromq \
 "
RDEPENDS:root-roofit-hs3 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-hist-factory \
 root-matrix \
 root-roofit \
 root-roofit-core \
 "
RDEPENDS:root-roofit-more = " \
 glibc \
 gsl \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-mathmore \
 root-roofit-core \
 "
RDEPENDS:root-roofit-multiprocess = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-roofit-zmq \
 zeromq \
 "
RDEPENDS:root-roofit-zmq = " \
 glibc \
 libgcc \
 libstdc++ \
 zeromq \
 "
RDEPENDS:root-roostats = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-io \
 root-mathcore \
 root-matrix \
 root-minuit \
 root-roofit \
 root-roofit-core \
 root-tree \
 "
RDEPENDS:root-smatrix = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-spectrum = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 "
RDEPENDS:root-spectrum-painter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-hist \
 "
RDEPENDS:root-splot = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-matrix \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-sql-sqlite = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-net \
 sqlite-libs \
 "
RDEPENDS:root-testsupport = " \
 root-core \
 "
RDEPENDS:root-tmva = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-io \
 root-io-xml \
 root-mathcore \
 root-matrix \
 root-minuit \
 root-mlp \
 root-multiproc \
 root-net \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-tmva-gui = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-hist \
 root-io \
 root-io-xml \
 root-matrix \
 root-tmva \
 root-tree \
 root-tree-viewer \
 "
RDEPENDS:root-tmva-python = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 python3-numpy \
 root-core \
 root-tmva \
 root-tree \
 "
RDEPENDS:root-tmva-r = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-matrix \
 root-r \
 root-tmva \
 "
RDEPENDS:root-tmva-sofie = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-tmva-sofie-parser = " \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 root-core \
 root-tmva-sofie \
 "
RDEPENDS:root-tmva-sofie-parser-python = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 python3-numpy \
 root-core \
 root-tmva-sofie \
 "
RDEPENDS:root-tmva-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-tpython = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 python3-root \
 root-core \
 "
RDEPENDS:root-tree = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 "
RDEPENDS:root-tree-dataframe = " \
 glibc \
 libarrow \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-mathcore \
 root-tree \
 root-tree-ntuple \
 root-tree-player \
 root-vecops \
 sqlite-libs \
 "
RDEPENDS:root-tree-ml = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-vecops \
 "
RDEPENDS:root-tree-ntuple = " \
 glibc \
 libgcc \
 libstdc++ \
 libuuid \
 root-core \
 root-io \
 xxhash-libs \
 "
RDEPENDS:root-tree-ntuple-browse = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui-treemap \
 root-hist \
 root-io \
 root-tree-ntuple \
 root-tree-ntuple-utils \
 "
RDEPENDS:root-tree-ntuple-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-tree \
 root-tree-ntuple \
 "
RDEPENDS:root-tree-player = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf3d \
 root-hist \
 root-io \
 root-mathcore \
 root-multiproc \
 root-net \
 root-tree \
 "
RDEPENDS:root-tree-viewer = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-gui-ged \
 root-hist \
 root-io \
 root-mathcore \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-tree-webviewer = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-tree \
 "
RDEPENDS:root-tutorial = " \
 root \
 "
RDEPENDS:root-unfold = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io-xmlparser \
 root-matrix \
 "
RDEPENDS:root-unuran = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 unuran \
 "
RDEPENDS:root-vecops = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-xroofit = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-gui-fitpanel \
 root-gui-ged \
 root-hist \
 root-hist-factory \
 root-io \
 root-mathcore \
 root-matrix \
 root-roofit \
 root-roofit-core \
 root-roofit-hs3 \
 root-roostats \
 root-tree \
 "
