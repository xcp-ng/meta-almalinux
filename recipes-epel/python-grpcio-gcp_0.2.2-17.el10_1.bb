# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-grpcio-gcp"
PV = "0.2.2"
PR = "17.el10_1"
PACKAGES = " \
 python3-grpcio-gcp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-grpcio-gcp-0.2.2-17.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77f5f26b6e781c2576d7e03c3b84c8ee5d7a97f7ebc0cb3ebddc2abe0e511cd4"

URI_x86_64_v2_python3-grpcio-gcp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-grpcio-gcp-0.2.2-17.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-grpcio-gcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-grpcio-gcp}"
SRC_URI[x86_64_v2_python3-grpcio-gcp.sha256sum] = "071a28163c683f617330a9d98fb84528561697d43679d328f929568a1f148bf8"

URI_aarch64_python3-grpcio-gcp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-grpcio-gcp-0.2.2-17.el10_1.noarch.rpm;name=aarch64_python3-grpcio-gcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-grpcio-gcp}"
SRC_URI[aarch64_python3-grpcio-gcp.sha256sum] = "21b6757dddbcd29ddaf90e1c58d80b837d9d1695c06138439d5efb156c38914b"

RDEPENDS:python3-grpcio-gcp = " \
 python3 \
 python3-grpcio \
 "
