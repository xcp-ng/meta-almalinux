# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-platform-verifier"
PV = "0.6.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustls-platform-verifier+base64-devel \
 rust-rustls-platform-verifier+cert-logging-devel \
 rust-rustls-platform-verifier+dbg-devel \
 rust-rustls-platform-verifier+default-devel \
 rust-rustls-platform-verifier+ffi-testing-devel \
 rust-rustls-platform-verifier-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-platform-verifier-0.6.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b9c16b7be784c6c3bcba8c5cbd26dd19cbf46b9d525fdea079ffd67eca33c68"

URI_x86_64_v2_rust-rustls-platform-verifier+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier+base64-devel-0.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier+base64-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier+base64-devel.sha256sum] = "a09db7ae932d50e218738c453b0fd3b98475ca7de47641b2b6fbc3d577013ece"

URI_x86_64_v2_rust-rustls-platform-verifier+cert-logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier+cert-logging-devel-0.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier+cert-logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier+cert-logging-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier+cert-logging-devel.sha256sum] = "d0a46fc4c0f3f40bf3b775d020f246fe99bb834e7568f640f1aa2bd944839aee"

URI_x86_64_v2_rust-rustls-platform-verifier+dbg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier+dbg-devel-0.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier+dbg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier+dbg-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier+dbg-devel.sha256sum] = "6f78aebd30fee9033c2af850c42b366b61bf7bb9ac956413c40af40ff245aec1"

URI_x86_64_v2_rust-rustls-platform-verifier+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier+default-devel-0.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier+default-devel.sha256sum] = "f80aa906cdd5f3070ea0965dbbe5b2b2214fcff6dfd34ab987dcaf2f5b73a0a6"

URI_x86_64_v2_rust-rustls-platform-verifier+ffi-testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier+ffi-testing-devel-0.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier+ffi-testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier+ffi-testing-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier+ffi-testing-devel.sha256sum] = "38562ab207de469100aa0622576d4ada1181adc9483dbbe573ad404d7e9de856"

URI_x86_64_v2_rust-rustls-platform-verifier-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier-devel-0.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier-devel.sha256sum] = "58860317feafcde1bd19f0366ed9c6c268f0c3db6da99410ccfc96f96c585c93"

URI_aarch64_rust-rustls-platform-verifier+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier+base64-devel-0.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-platform-verifier+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier+base64-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier+base64-devel.sha256sum] = "a0e4515b511eb8ae6fc449c2eb5bd759a1b3f2292ed0bdb05ecd7835839e94ff"

URI_aarch64_rust-rustls-platform-verifier+cert-logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier+cert-logging-devel-0.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-platform-verifier+cert-logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier+cert-logging-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier+cert-logging-devel.sha256sum] = "b75a0f89cf43d4ee46c68e6203843085f647959f90387f0c6e3a96c4bc138484"

URI_aarch64_rust-rustls-platform-verifier+dbg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier+dbg-devel-0.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-platform-verifier+dbg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier+dbg-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier+dbg-devel.sha256sum] = "2cdbad2e72d5c57658a3d7043776f062d9d18fd649b46cd33e652e242b3fbc8e"

URI_aarch64_rust-rustls-platform-verifier+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier+default-devel-0.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-platform-verifier+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier+default-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier+default-devel.sha256sum] = "6dbaf6f44a00de2a6096f4d0217c90a3c181388df7c0009cda392dfa2244c361"

URI_aarch64_rust-rustls-platform-verifier+ffi-testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier+ffi-testing-devel-0.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-platform-verifier+ffi-testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier+ffi-testing-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier+ffi-testing-devel.sha256sum] = "cb3e5c85ff61dc63a298c9aa74446df981f6a58cb816702c89a9edce2944c8c2"

URI_aarch64_rust-rustls-platform-verifier-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier-devel-0.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-platform-verifier-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier-devel.sha256sum] = "f6ad390989434a0524ca5a1ade8dc0a0aa9c9f72a39a16b066f9b02473fb44f3"

RDEPENDS:rust-rustls-platform-verifier+base64-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-rustls-platform-verifier-devel \
 "
RDEPENDS:rust-rustls-platform-verifier+cert-logging-devel = " \
 cargo \
 rust-rustls-platform-verifier+base64-devel \
 rust-rustls-platform-verifier-devel \
 "
RDEPENDS:rust-rustls-platform-verifier+dbg-devel = " \
 cargo \
 rust-rustls-platform-verifier-devel \
 "
RDEPENDS:rust-rustls-platform-verifier+default-devel = " \
 cargo \
 rust-rustls-platform-verifier-devel \
 "
RDEPENDS:rust-rustls-platform-verifier+ffi-testing-devel = " \
 cargo \
 rust-rustls+ring-devel \
 rust-rustls-platform-verifier-devel \
 "
RDEPENDS:rust-rustls-platform-verifier-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-rustls-native-certs+default-devel \
 rust-rustls-webpki-devel \
 "
