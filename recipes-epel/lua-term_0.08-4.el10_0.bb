# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-term"
PV = "0.08"
PR = "4.el10_0"
PACKAGES = " \
 lua-term \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-term-0.08-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed7886ff09078bab4ef203ffbc6870d5df816d239945471c79db7e30519bf29c"

URI_x86_64_v2_lua-term = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-term-0.08-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-term;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-term}"
SRC_URI[x86_64_v2_lua-term.sha256sum] = "4ea179606c9a83f4e0fc705abd9e1c41e7c5f2d6b3857186826d753e4b1eee5b"

URI_aarch64_lua-term = "${EPEL_MIRROR}/aarch64/Packages/l/lua-term-0.08-4.el10_0.aarch64.rpm;name=aarch64_lua-term;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-term}"
SRC_URI[aarch64_lua-term.sha256sum] = "5de1681cc4189af0cbe0b4f70ea10afc1cde4307c96ef1aed0b767dd5bfb74f0"

RDEPENDS:lua-term = " \
 glibc \
 lua \
 lua-libs \
 "
