# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-remote-desktop"
PV = "49.3"
PR = "3.el10"
PACKAGES = " \
 gnome-remote-desktop \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-remote-desktop-49.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02eb5d7f2557806ef5aa4dda8e60b2da49a5e8f1dfafdc36b760c47184bce74e"

URI_x86_64_v2_gnome-remote-desktop = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-remote-desktop-49.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-remote-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-remote-desktop}"
SRC_URI[x86_64_v2_gnome-remote-desktop.sha256sum] = "d70a793685aca544397598f93cfeae69cfda4f899cf33c5905e73696b8ba31ea"

URI_aarch64_gnome-remote-desktop = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-remote-desktop-49.3-3.el10.aarch64.rpm;name=aarch64_gnome-remote-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-remote-desktop}"
SRC_URI[aarch64_gnome-remote-desktop.sha256sum] = "200118ad27150ce1752773f8ea88cea819a822e7ef84d78c72b006612c3d73d4"

RDEPENDS:gnome-remote-desktop = " \
 bash \
 cairo \
 fdk-aac-free \
 freerdp-libs \
 fuse3-libs \
 glib2 \
 glibc \
 libei \
 libepoxy \
 libgcc \
 libnotify \
 libsecret \
 libva \
 libwinpr \
 libxkbcommon \
 opus \
 pipewire \
 pipewire-libs \
 polkit-libs \
 systemd-libs \
 tpm2-tss \
 vulkan-loader \
 "
