# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hawtjni"
PV = "1.18"
PR = "19.el10_3"
PACKAGES = " \
 hawtjni \
 hawtjni-javadoc \
 hawtjni-runtime \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hawtjni-1.18-19.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a5e28c2bfcc4d7df217ed0ac500acd157833106db2dcd009002f8c357a9ee99"

URI_x86_64_v2_hawtjni = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hawtjni-1.18-19.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_hawtjni;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hawtjni}"
SRC_URI[x86_64_v2_hawtjni.sha256sum] = "74b6530b50b8767fbfaeef702c37e9da91b4b7d8b65fa7bcce7f69f253a56aba"

URI_x86_64_v2_hawtjni-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hawtjni-javadoc-1.18-19.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_hawtjni-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hawtjni-javadoc}"
SRC_URI[x86_64_v2_hawtjni-javadoc.sha256sum] = "5a4de0261856c4a23fc7035ce8faff70541f5e0decf2bb860d0e464a7196f194"

URI_x86_64_v2_hawtjni-runtime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hawtjni-runtime-1.18-19.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_hawtjni-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hawtjni-runtime}"
SRC_URI[x86_64_v2_hawtjni-runtime.sha256sum] = "44ed6823d8e15fb89e4ee64f5452b4e613463225b4f176c69114b0be7a6671f6"

URI_aarch64_hawtjni = "${EPEL_MIRROR}/aarch64/Packages/h/hawtjni-1.18-19.el10_3.noarch.rpm;name=aarch64_hawtjni;unpack=0"
SRC_URI:append = " ${URI_aarch64_hawtjni}"
SRC_URI[aarch64_hawtjni.sha256sum] = "274a11a4986f05815facc29839f44bb4a277f712d16064c38727837d2a9ff971"

URI_aarch64_hawtjni-javadoc = "${EPEL_MIRROR}/aarch64/Packages/h/hawtjni-javadoc-1.18-19.el10_3.noarch.rpm;name=aarch64_hawtjni-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_hawtjni-javadoc}"
SRC_URI[aarch64_hawtjni-javadoc.sha256sum] = "5423be559f5f348535b42bc9dab0d08a7189b8c5c32b25edb9ef48dd8848c275"

URI_aarch64_hawtjni-runtime = "${EPEL_MIRROR}/aarch64/Packages/h/hawtjni-runtime-1.18-19.el10_3.noarch.rpm;name=aarch64_hawtjni-runtime;unpack=0"
SRC_URI:append = " ${URI_aarch64_hawtjni-runtime}"
SRC_URI[aarch64_hawtjni-runtime.sha256sum] = "87a45653420bb28c297db3712b66ddcc854e0ebfa6437a94f4c639414b320efc"

RDEPENDS:hawtjni = " \
 apache-commons-cli \
 apache-commons-lang3 \
 autoconf \
 automake \
 hawtjni-runtime \
 javapackages-filesystem \
 libtool \
 make \
 objectweb-asm \
 xbean \
 "
RDEPENDS:hawtjni-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:hawtjni-runtime = " \
 javapackages-filesystem \
 "
