# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snapm"
PV = "0.4.3"
PR = "1.el10"
PACKAGES = " \
 python3-snapm \
 python3-snapm-doc \
 snapm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/snapm-0.4.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e3c625f82b615bf2238307b5a28ea9b9409177ab20dad545c677593036e4cc9"

URI_x86_64_v2_python3-snapm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-snapm-0.4.3-1.el10.noarch.rpm;name=x86_64_v2_python3-snapm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-snapm}"
SRC_URI[x86_64_v2_python3-snapm.sha256sum] = "a27e94742f1a960ca4ea78f6fb9cba10dd0bf89d13938d2f10158554dab14560"

URI_x86_64_v2_python3-snapm-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-snapm-doc-0.4.3-1.el10.noarch.rpm;name=x86_64_v2_python3-snapm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-snapm-doc}"
SRC_URI[x86_64_v2_python3-snapm-doc.sha256sum] = "af3df165b152f29cd313009798ea426c0501b2e1fe1297961db484803d6bc9e2"

URI_x86_64_v2_snapm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/snapm-0.4.3-1.el10.noarch.rpm;name=x86_64_v2_snapm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapm}"
SRC_URI[x86_64_v2_snapm.sha256sum] = "7c888607dce6e530a1d385a6e328d153974b3f2a9eba866c8603173e1f50ab42"

URI_aarch64_python3-snapm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-snapm-0.4.3-1.el10.noarch.rpm;name=aarch64_python3-snapm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-snapm}"
SRC_URI[aarch64_python3-snapm.sha256sum] = "a27e94742f1a960ca4ea78f6fb9cba10dd0bf89d13938d2f10158554dab14560"

URI_aarch64_python3-snapm-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-snapm-doc-0.4.3-1.el10.noarch.rpm;name=aarch64_python3-snapm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-snapm-doc}"
SRC_URI[aarch64_python3-snapm-doc.sha256sum] = "af3df165b152f29cd313009798ea426c0501b2e1fe1297961db484803d6bc9e2"

URI_aarch64_snapm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/snapm-0.4.3-1.el10.noarch.rpm;name=aarch64_snapm;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapm}"
SRC_URI[aarch64_snapm.sha256sum] = "7c888607dce6e530a1d385a6e328d153974b3f2a9eba866c8603173e1f50ab42"

RDEPENDS:python3-snapm = " \
 python3 \
 python3-boom \
 python3-dateutil \
 python3-dbus-client-gen \
 python3-dbus-python-client-gen \
 python3-justbytes \
 python3-packaging \
 python3-wcwidth \
 "
RDEPENDS:python3-snapm-doc = " \
 "
RDEPENDS:snapm = " \
 python3 \
 python3-snapm \
 "
