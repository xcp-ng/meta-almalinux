# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c-icap"
PV = "0.6.5"
PR = "1.el10_3"
PACKAGES = " \
 c-icap \
 c-icap-devel \
 c-icap-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/c-icap-0.6.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6239387e06e7351c3e156971a7860d8c7bd7f07bbfeba41ea19178874398aefd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c-icap-0.6.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c-icap;unpack=0"
SRC_URI[x86_64_v2_c-icap.sha256sum] = "19451225afb834f4a744444beaebff98d399f7669eb47e0bf6506dc2c22a7b30"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c-icap-devel-0.6.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c-icap-devel;unpack=0"
SRC_URI[x86_64_v2_c-icap-devel.sha256sum] = "92b1d1d6a2475d5ef981490f87b04a73a51f0500eab24ac5730a5128c06c5c72"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c-icap-libs-0.6.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c-icap-libs;unpack=0"
SRC_URI[x86_64_v2_c-icap-libs.sha256sum] = "46e98db07bd9c35d5fb6899a07ea46b8f5c640a8283d1e3ca5db32cc2ffa2f10"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/c-icap-0.6.5-1.el10_3.aarch64.rpm;name=aarch64_c-icap;unpack=0"
SRC_URI[aarch64_c-icap.sha256sum] = "0d14896ad6f556c9f23b3bd54b3ecc378c1c3e0eba7826e64e1f1466fa0c4a6e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/c-icap-devel-0.6.5-1.el10_3.aarch64.rpm;name=aarch64_c-icap-devel;unpack=0"
SRC_URI[aarch64_c-icap-devel.sha256sum] = "b8aa5315f150eefbacddef71fb1428bb57ed612645e5cf806acd278fab02ff2b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/c-icap-libs-0.6.5-1.el10_3.aarch64.rpm;name=aarch64_c-icap-libs;unpack=0"
SRC_URI[aarch64_c-icap-libs.sha256sum] = "caf838b8cc1fa87c7d4cb89d1bdc65e050b051848645fdacd084d18f7bfd1f8c"

RDEPENDS:c-icap = " \
 bash \
 c-icap-libs \
 glibc \
 libatomic \
 lmdb-libs \
 logrotate \
 openldap \
 shadow-utils \
 "
RDEPENDS:c-icap-devel = " \
 bash \
 c-icap-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:c-icap-libs = " \
 bzip2-libs \
 glibc \
 libatomic \
 libbrotli \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
