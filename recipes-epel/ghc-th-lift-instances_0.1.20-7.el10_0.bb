# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-th-lift-instances"
PV = "0.1.20"
PR = "7.el10_0"
PACKAGES = " \
 ghc-th-lift-instances \
 ghc-th-lift-instances-devel \
 ghc-th-lift-instances-doc \
 ghc-th-lift-instances-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-th-lift-instances-0.1.20-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5cbe149df7753ef9e976392a571dd51d6e4c01d2c19a14967ceee5a04232c148"

URI_x86_64_v2_ghc-th-lift-instances = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-lift-instances-0.1.20-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-th-lift-instances;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-lift-instances}"
SRC_URI[x86_64_v2_ghc-th-lift-instances.sha256sum] = "24f238494a441486538d5e40fe5af653068a1a23826d8b629efd924509cdef22"

URI_x86_64_v2_ghc-th-lift-instances-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-lift-instances-devel-0.1.20-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-th-lift-instances-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-lift-instances-devel}"
SRC_URI[x86_64_v2_ghc-th-lift-instances-devel.sha256sum] = "c9cce5a02493d2b306c57d841450b3349e799b63db0e41dbd82342227be48e73"

URI_x86_64_v2_ghc-th-lift-instances-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-lift-instances-doc-0.1.20-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-th-lift-instances-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-lift-instances-doc}"
SRC_URI[x86_64_v2_ghc-th-lift-instances-doc.sha256sum] = "147a8baad442977f8cba012132f5c7156d1a7b1c003f1bb446e34664e3da8fe5"

URI_x86_64_v2_ghc-th-lift-instances-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-lift-instances-prof-0.1.20-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-th-lift-instances-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-lift-instances-prof}"
SRC_URI[x86_64_v2_ghc-th-lift-instances-prof.sha256sum] = "41f5f4d23e0c19e37d1db353da91442c44ff353261ab19ab0ddc3794677fe1bf"

URI_aarch64_ghc-th-lift-instances = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-lift-instances-0.1.20-7.el10_0.aarch64.rpm;name=aarch64_ghc-th-lift-instances;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-lift-instances}"
SRC_URI[aarch64_ghc-th-lift-instances.sha256sum] = "eb6ffe81bc6354e8860ae05fddeae091acf33253979ec3237158ffae2d522fdf"

URI_aarch64_ghc-th-lift-instances-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-lift-instances-devel-0.1.20-7.el10_0.aarch64.rpm;name=aarch64_ghc-th-lift-instances-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-lift-instances-devel}"
SRC_URI[aarch64_ghc-th-lift-instances-devel.sha256sum] = "3853a03269dc5f78223097c83c867a732eee6345344d47be0aebe1d7a1e444ec"

URI_aarch64_ghc-th-lift-instances-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-lift-instances-doc-0.1.20-7.el10_0.noarch.rpm;name=aarch64_ghc-th-lift-instances-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-lift-instances-doc}"
SRC_URI[aarch64_ghc-th-lift-instances-doc.sha256sum] = "d7f766310dd22add1244582a97db8c78582ad008492b5d93cab38c413414fb56"

URI_aarch64_ghc-th-lift-instances-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-lift-instances-prof-0.1.20-7.el10_0.aarch64.rpm;name=aarch64_ghc-th-lift-instances-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-lift-instances-prof}"
SRC_URI[aarch64_ghc-th-lift-instances-prof.sha256sum] = "bd5c2c73e30f8e031155998b512f2698abac11081b63b4e29633240625ebb165"

RDEPENDS:ghc-th-lift-instances = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-primitive \
 ghc-template-haskell \
 ghc-text \
 ghc-th-abstraction \
 ghc-th-lift \
 ghc-transformers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-th-lift-instances-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-th-lift-devel \
 ghc-th-lift-instances \
 ghc-transformers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-th-lift-instances-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-th-lift-instances-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-th-lift-instances-devel \
 ghc-th-lift-prof \
 ghc-transformers-prof \
 ghc-vector-prof \
 "
