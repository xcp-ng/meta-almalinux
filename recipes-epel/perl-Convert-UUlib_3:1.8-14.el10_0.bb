# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Convert-UUlib"
PE = "3"
PV = "1.8"
PR = "14.el10_0"
PACKAGES = " \
 perl-Convert-UUlib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Convert-UUlib-1.8-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2199dc3bff1960d712567d1a1f3b7f585b1c80ea6f6e1a3abbf42862841f8206"

URI_x86_64_v2_perl-Convert-UUlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Convert-UUlib-1.8-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Convert-UUlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Convert-UUlib}"
SRC_URI[x86_64_v2_perl-Convert-UUlib.sha256sum] = "d140c90b918aaa7dfb29fadf3ba93a77862872a27ebeae6b4dbb5069b8c8bb9c"

URI_aarch64_perl-Convert-UUlib = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Convert-UUlib-1.8-14.el10_0.aarch64.rpm;name=aarch64_perl-Convert-UUlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Convert-UUlib}"
SRC_URI[aarch64_perl-Convert-UUlib.sha256sum] = "c5d29b045b87dc70e6d737fdf5fb6555f33dd773ea9c35109270054beec18324"

RDEPENDS:perl-Convert-UUlib = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-common-sense \
 perl-libs \
 "
