# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs22"
PE = "1"
PV = "22.23.1"
PR = "2.el10"
PACKAGES = " \
 nodejs \
 nodejs-devel \
 nodejs-docs \
 nodejs-full-i18n \
 nodejs-libs \
 nodejs-npm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs22-22.23.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31045771db07dbf88f6e372121b1a562aa9afc1cf4c234270a2fa26ce869011f"

URI_x86_64_v2_nodejs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-22.23.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs}"
SRC_URI[x86_64_v2_nodejs.sha256sum] = "44871ab818615de6bc38ae44a23c52d03e5ca71c5c0ed67553309f18adf5f799"
RPROVIDES:nodejs:x86_64_v2 = "virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

URI_x86_64_v2_nodejs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-devel-22.23.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-devel}"
SRC_URI[x86_64_v2_nodejs-devel.sha256sum] = "5a14954c723763990ea97b0526d65e5c84071a1ad4714c2b19b4912b01997616"

URI_x86_64_v2_nodejs-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-docs-22.23.1-2.el10.noarch.rpm;name=x86_64_v2_nodejs-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-docs}"
SRC_URI[x86_64_v2_nodejs-docs.sha256sum] = "e87c6e2426549a6370e724d731e459f17e175953b0ebe8455cf2b11ed983bbf4"

URI_x86_64_v2_nodejs-full-i18n = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-full-i18n-22.23.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs-full-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-full-i18n}"
SRC_URI[x86_64_v2_nodejs-full-i18n.sha256sum] = "368c799333f725f962a8276e28002c04cdaf5ed35a00702ac926184e52a07fbe"

URI_x86_64_v2_nodejs-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-libs-22.23.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-libs}"
SRC_URI[x86_64_v2_nodejs-libs.sha256sum] = "0450c4280ac822574ca5f292260a30c7dc32f71f364eaeb76390d0145d50ee0d"

URI_x86_64_v2_nodejs-npm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-npm-10.9.8-1.22.23.1.2.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs-npm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-npm}"
SRC_URI[x86_64_v2_nodejs-npm.sha256sum] = "60714c8cdcd4a04feb5f5ecf14c38b3851b511771f07da12846f42e11e1ba76d"

URI_aarch64_nodejs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-22.23.1-2.el10.aarch64.rpm;name=aarch64_nodejs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs}"
SRC_URI[aarch64_nodejs.sha256sum] = "faace524c0766133c552ad67d6087242e5e7591f600ea74305c79157cfac54ca"
RPROVIDES:nodejs:aarch64 = "virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

URI_aarch64_nodejs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-devel-22.23.1-2.el10.aarch64.rpm;name=aarch64_nodejs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-devel}"
SRC_URI[aarch64_nodejs-devel.sha256sum] = "b0b68afcaaf2422eeda6c2c0a58f7f5a20831f81a1ac799fe65c2329e5c13949"

URI_aarch64_nodejs-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-docs-22.23.1-2.el10.noarch.rpm;name=aarch64_nodejs-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-docs}"
SRC_URI[aarch64_nodejs-docs.sha256sum] = "e87c6e2426549a6370e724d731e459f17e175953b0ebe8455cf2b11ed983bbf4"

URI_aarch64_nodejs-full-i18n = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-full-i18n-22.23.1-2.el10.aarch64.rpm;name=aarch64_nodejs-full-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-full-i18n}"
SRC_URI[aarch64_nodejs-full-i18n.sha256sum] = "dc663e58deac33a27f55782806802704b5c9c0f8aebbd09bc152088be29778a9"

URI_aarch64_nodejs-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-libs-22.23.1-2.el10.aarch64.rpm;name=aarch64_nodejs-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-libs}"
SRC_URI[aarch64_nodejs-libs.sha256sum] = "f61fc373fa012f102ae83b1937aa9cd7697727dbf26618c9cbdada1d08790159"

URI_aarch64_nodejs-npm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-npm-10.9.8-1.22.23.1.2.el10.aarch64.rpm;name=aarch64_nodejs-npm;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-npm}"
SRC_URI[aarch64_nodejs-npm.sha256sum] = "34c02e70a0b0339cf2b2d9e9a323f6368a5fc7377da4bf960dc1928282791214"

RDEPENDS:nodejs = " \
 ca-certificates \
 glibc \
 libuv \
 nodejs-libs \
 openssl \
 "
RDEPENDS:nodejs-devel = " \
 bash \
 brotli-devel \
 libuv-devel \
 nodejs \
 nodejs-libs \
 nodejs-packaging \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:nodejs-docs = " \
 nodejs \
 "
RDEPENDS:nodejs-full-i18n = " \
 nodejs \
 "
RDEPENDS:nodejs-libs = " \
 c-ares \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 libuv \
 openssl-libs \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:nodejs-npm = " \
 bash \
 nodejs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/nodejs_engine_ rpm/virtual/nodejs_engine__ge_0.8.0"

PROVIDES:append:aarch64 = " rpm/virtual/nodejs_engine_ rpm/virtual/nodejs_engine__ge_0.8.0"
