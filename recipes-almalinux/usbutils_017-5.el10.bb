# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "usbutils"
PV = "017"
PR = "5.el10"
PACKAGES = " \
 usbutils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/usbutils-017-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "63b72221efdb27ae21a6252f36606a6a1136f0050c4cb8049a93b808f031d55d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/usbutils-017-5.el10.x86_64_v2.rpm;name=x86_64_v2_usbutils;unpack=0"
SRC_URI[x86_64_v2_usbutils.sha256sum] = "bf26700d9e9709a99c482a8b2d30d3a1a12e04cac849f529864f0cda49592f04"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/usbutils-017-5.el10.aarch64.rpm;name=aarch64_usbutils;unpack=0"
SRC_URI[aarch64_usbutils.sha256sum] = "0350bc195b58a79b018822eb5f05c8536c37d07147b3d9fa938a414c31ee246c"

RDEPENDS:usbutils = " \
 bash \
 glibc \
 hwdata \
 libusb1 \
 python3 \
 systemd-libs \
 "
