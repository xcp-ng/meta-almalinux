# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "junit5"
PV = "5.10.2"
PR = "5.el10"
PACKAGES = " \
 junit5 \
 junit5-guide \
 junit5-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/junit5-5.10.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcb0cd65c486c9a77bb6fb59fca226923a1db714e8793fb7aae15683f71e345c"

URI_x86_64_v2_junit5 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/junit5-5.10.2-5.el10.noarch.rpm;name=x86_64_v2_junit5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_junit5}"
SRC_URI[x86_64_v2_junit5.sha256sum] = "35d98c412c9266cbd4e95ced39260b86fc63cd64ecb1a07ba1572ce966ca6afd"

URI_x86_64_v2_junit5-guide = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/junit5-guide-5.10.2-5.el10.noarch.rpm;name=x86_64_v2_junit5-guide;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_junit5-guide}"
SRC_URI[x86_64_v2_junit5-guide.sha256sum] = "a5ba91e6a8e76bce329ce27c9347f6430acfefb14a04acacf07c92c7e4184b6e"

URI_x86_64_v2_junit5-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/junit5-javadoc-5.10.2-5.el10.noarch.rpm;name=x86_64_v2_junit5-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_junit5-javadoc}"
SRC_URI[x86_64_v2_junit5-javadoc.sha256sum] = "69842aa0b0d62c5b90951724dd7f24bc32ebe0ff89359ac8b3565e12bcb710e8"

URI_aarch64_junit5 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/junit5-5.10.2-5.el10.noarch.rpm;name=aarch64_junit5;unpack=0"
SRC_URI:append = " ${URI_aarch64_junit5}"
SRC_URI[aarch64_junit5.sha256sum] = "35d98c412c9266cbd4e95ced39260b86fc63cd64ecb1a07ba1572ce966ca6afd"

URI_aarch64_junit5-guide = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/junit5-guide-5.10.2-5.el10.noarch.rpm;name=aarch64_junit5-guide;unpack=0"
SRC_URI:append = " ${URI_aarch64_junit5-guide}"
SRC_URI[aarch64_junit5-guide.sha256sum] = "a5ba91e6a8e76bce329ce27c9347f6430acfefb14a04acacf07c92c7e4184b6e"

URI_aarch64_junit5-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/junit5-javadoc-5.10.2-5.el10.noarch.rpm;name=aarch64_junit5-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_junit5-javadoc}"
SRC_URI[aarch64_junit5-javadoc.sha256sum] = "69842aa0b0d62c5b90951724dd7f24bc32ebe0ff89359ac8b3565e12bcb710e8"

RDEPENDS:junit5 = " \
 assertj-core \
 javapackages-filesystem \
 junit \
 opentest4j \
 univocity-parsers \
 "
RDEPENDS:junit5-guide = " \
 junit5-javadoc \
 "
RDEPENDS:junit5-javadoc = " \
 javapackages-filesystem \
 "
