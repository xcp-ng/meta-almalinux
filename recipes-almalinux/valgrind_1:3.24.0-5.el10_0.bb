# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "valgrind"
PE = "1"
PV = "3.24.0"
PR = "5.el10_0"
PACKAGES = " \
 valgrind \
 valgrind-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/valgrind-3.24.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d608c309be64d7802d45a306de2b8869fc9adaa256fe3689e82bfd819cca919"

URI_x86_64_v2_valgrind = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-3.24.0-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_valgrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind}"
SRC_URI[x86_64_v2_valgrind.sha256sum] = "c86c9142ff29aafe7d2ee26932e00ae465b2e03266cfaebed15110cb4f31154b"

URI_x86_64_v2_valgrind-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-devel-3.24.0-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_valgrind-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind-devel}"
SRC_URI[x86_64_v2_valgrind-devel.sha256sum] = "1e6a820565967da01197f7da67f7e5cc93e8366a1907803e9a4fec093e3b22d2"

URI_aarch64_valgrind = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-3.24.0-5.el10_0.aarch64.rpm;name=aarch64_valgrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind}"
SRC_URI[aarch64_valgrind.sha256sum] = "3dd909639182e279d4ba1b564fc30071e39f0075ec24de57c9301128456d58be"

URI_aarch64_valgrind-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-devel-3.24.0-5.el10_0.aarch64.rpm;name=aarch64_valgrind-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind-devel}"
SRC_URI[aarch64_valgrind-devel.sha256sum] = "5bc95fdad9741d9d6a7a8245d4ecb7ceae9aac793f579809a50d9a8ff8068a38"

RDEPENDS:valgrind = " \
 glibc \
 libgcc \
 perl-interpreter \
 python3 \
 "
RDEPENDS:valgrind-devel = " \
 pkgconf-pkg-config \
 valgrind \
 "
