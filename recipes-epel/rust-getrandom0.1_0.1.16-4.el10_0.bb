# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-getrandom0.1"
PV = "0.1.16"
PR = "4.el10_0"
PACKAGES = " \
 rust-getrandom0.1+default-devel \
 rust-getrandom0.1+dummy-devel \
 rust-getrandom0.1+log-devel \
 rust-getrandom0.1+std-devel \
 rust-getrandom0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-getrandom0.1-0.1.16-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8f1cffc67b53f88fc590ef3cfb20f6fc1f4ef34d1b66e5a5f80364b541ba605"

URI_x86_64_v2_rust-getrandom0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.1+default-devel-0.1.16-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.1+default-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.1+default-devel.sha256sum] = "ecf7a788336f2a81a68fd148d56a307153590641e25f193f2c9492dc81947f8b"

URI_x86_64_v2_rust-getrandom0.1+dummy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.1+dummy-devel-0.1.16-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.1+dummy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.1+dummy-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.1+dummy-devel.sha256sum] = "9c102a219384c8bcb1cdcc138fca479a319132e7ed3da34bb0e722f9b302dd81"

URI_x86_64_v2_rust-getrandom0.1+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.1+log-devel-0.1.16-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.1+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.1+log-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.1+log-devel.sha256sum] = "5423dae732258aa1eae134b6bcb6d5357c2f8fcd80e1bf340f68a454d4b08076"

URI_x86_64_v2_rust-getrandom0.1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.1+std-devel-0.1.16-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.1+std-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.1+std-devel.sha256sum] = "d12ddc407682d129f58979bb288c1a8d368d07f2c6a9b660b673991f916b4596"

URI_x86_64_v2_rust-getrandom0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.1-devel-0.1.16-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.1-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.1-devel.sha256sum] = "e357d3101614647e12253f5c333c99db0ec1a5d6d7551ed9321f747957e6df31"

URI_aarch64_rust-getrandom0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.1+default-devel-0.1.16-4.el10_0.noarch.rpm;name=aarch64_rust-getrandom0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.1+default-devel}"
SRC_URI[aarch64_rust-getrandom0.1+default-devel.sha256sum] = "8862e29ba9c3eda55f442d24ca8fdc7a4b800781deba8263f85f7aaa13f6cc98"

URI_aarch64_rust-getrandom0.1+dummy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.1+dummy-devel-0.1.16-4.el10_0.noarch.rpm;name=aarch64_rust-getrandom0.1+dummy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.1+dummy-devel}"
SRC_URI[aarch64_rust-getrandom0.1+dummy-devel.sha256sum] = "aae162979a755ee753c67f909abcc83555086da30a3c7bc39b36145e77857704"

URI_aarch64_rust-getrandom0.1+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.1+log-devel-0.1.16-4.el10_0.noarch.rpm;name=aarch64_rust-getrandom0.1+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.1+log-devel}"
SRC_URI[aarch64_rust-getrandom0.1+log-devel.sha256sum] = "ff354bc4859a3f30bfa77a96b68d78f62c296a0a3aca05a0711f7c4237d0ad6a"

URI_aarch64_rust-getrandom0.1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.1+std-devel-0.1.16-4.el10_0.noarch.rpm;name=aarch64_rust-getrandom0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.1+std-devel}"
SRC_URI[aarch64_rust-getrandom0.1+std-devel.sha256sum] = "5d4061553896d67da77554a5c6edb281a4d40948880475bf711ae5c8bdc60b4c"

URI_aarch64_rust-getrandom0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.1-devel-0.1.16-4.el10_0.noarch.rpm;name=aarch64_rust-getrandom0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.1-devel}"
SRC_URI[aarch64_rust-getrandom0.1-devel.sha256sum] = "78f35724796e69a5cbbc60701b7f5ac1548d27af23be5cf488291b7ed65628f1"

RDEPENDS:rust-getrandom0.1+default-devel = " \
 cargo \
 rust-getrandom0.1-devel \
 "
RDEPENDS:rust-getrandom0.1+dummy-devel = " \
 cargo \
 rust-getrandom0.1-devel \
 "
RDEPENDS:rust-getrandom0.1+log-devel = " \
 cargo \
 rust-getrandom0.1-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-getrandom0.1+std-devel = " \
 cargo \
 rust-getrandom0.1-devel \
 "
RDEPENDS:rust-getrandom0.1-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-libc-devel \
 "
