# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_chroot"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_chroot+default-devel \
 rust-uu_chroot-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_chroot-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5756911b4484ee0bcd788f461d7fb76fa3d8748769d86c6f70d9c137e64590e1"

URI_x86_64_v2_rust-uu_chroot+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_chroot+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_chroot+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_chroot+default-devel}"
SRC_URI[x86_64_v2_rust-uu_chroot+default-devel.sha256sum] = "e24cc306868e7bb166397d3b92c2157f2661efb417888f6227ffd7761c87f9ec"

URI_x86_64_v2_rust-uu_chroot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_chroot-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_chroot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_chroot-devel}"
SRC_URI[x86_64_v2_rust-uu_chroot-devel.sha256sum] = "22585e419ce246353330b99dab9c3b9d2f24a390b17425ae25cbc6edff9c87a9"

URI_aarch64_rust-uu_chroot+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_chroot+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_chroot+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_chroot+default-devel}"
SRC_URI[aarch64_rust-uu_chroot+default-devel.sha256sum] = "3f0bc3c4df10e26ad489b29ab228c3b637b7e6eadde693cc72588bd76e11cb4d"

URI_aarch64_rust-uu_chroot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_chroot-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_chroot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_chroot-devel}"
SRC_URI[aarch64_rust-uu_chroot-devel.sha256sum] = "a869091ad417077a58d795533d7a64ea019c715cb8646f58ce66c11911e2b64d"

RDEPENDS:rust-uu_chroot+default-devel = " \
 cargo \
 rust-uu_chroot-devel \
 "
RDEPENDS:rust-uu_chroot-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+fs-devel \
 "
