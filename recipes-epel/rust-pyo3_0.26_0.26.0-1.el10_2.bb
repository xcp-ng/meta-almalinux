# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3_0.26"
PV = "0.26.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-pyo3_0.26+abi3-devel \
 rust-pyo3_0.26+abi3-py310-devel \
 rust-pyo3_0.26+abi3-py311-devel \
 rust-pyo3_0.26+abi3-py312-devel \
 rust-pyo3_0.26+abi3-py313-devel \
 rust-pyo3_0.26+abi3-py314-devel \
 rust-pyo3_0.26+abi3-py37-devel \
 rust-pyo3_0.26+abi3-py38-devel \
 rust-pyo3_0.26+abi3-py39-devel \
 rust-pyo3_0.26+anyhow-devel \
 rust-pyo3_0.26+arc_lock-devel \
 rust-pyo3_0.26+auto-initialize-devel \
 rust-pyo3_0.26+bigdecimal-devel \
 rust-pyo3_0.26+bytes-devel \
 rust-pyo3_0.26+chrono-devel \
 rust-pyo3_0.26+chrono-local-devel \
 rust-pyo3_0.26+chrono-tz-devel \
 rust-pyo3_0.26+default-devel \
 rust-pyo3_0.26+either-devel \
 rust-pyo3_0.26+experimental-async-devel \
 rust-pyo3_0.26+experimental-inspect-devel \
 rust-pyo3_0.26+extension-module-devel \
 rust-pyo3_0.26+eyre-devel \
 rust-pyo3_0.26+full-devel \
 rust-pyo3_0.26+hashbrown-devel \
 rust-pyo3_0.26+indexmap-devel \
 rust-pyo3_0.26+indoc-devel \
 rust-pyo3_0.26+inventory-devel \
 rust-pyo3_0.26+jiff-02-devel \
 rust-pyo3_0.26+lock_api-devel \
 rust-pyo3_0.26+macros-devel \
 rust-pyo3_0.26+multiple-pymethods-devel \
 rust-pyo3_0.26+nightly-devel \
 rust-pyo3_0.26+num-bigint-devel \
 rust-pyo3_0.26+num-complex-devel \
 rust-pyo3_0.26+num-rational-devel \
 rust-pyo3_0.26+ordered-float-devel \
 rust-pyo3_0.26+parking_lot-devel \
 rust-pyo3_0.26+py-clone-devel \
 rust-pyo3_0.26+pyo3-macros-devel \
 rust-pyo3_0.26+rust_decimal-devel \
 rust-pyo3_0.26+serde-devel \
 rust-pyo3_0.26+smallvec-devel \
 rust-pyo3_0.26+time-devel \
 rust-pyo3_0.26+unindent-devel \
 rust-pyo3_0.26+uuid-devel \
 rust-pyo3_0.26-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3_0.26-0.26.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cbfc0268d8960e7e4ea0aacd05153157d2d092366bca276072e50083754631e"

URI_x86_64_v2_rust-pyo3_0.26+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+abi3-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+abi3-devel.sha256sum] = "22fa7b609099f0c8a25b9ef0db5ce17d0156fea570955a1d3497b139fb46a979"

URI_x86_64_v2_rust-pyo3_0.26+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+abi3-py310-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+abi3-py310-devel.sha256sum] = "d4d18426199b0c6068883575891fd588e307e3b585ca01856ea2c28c72a5f7eb"

URI_x86_64_v2_rust-pyo3_0.26+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+abi3-py311-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+abi3-py311-devel.sha256sum] = "0c042dfb2fdf2dd1072a59b891e3f08379cc9d0db73494c6f2eab3159d023dd6"

URI_x86_64_v2_rust-pyo3_0.26+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+abi3-py312-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+abi3-py312-devel.sha256sum] = "2b5be05d2003f2619bd77eab8cf983a03784ac99a6b080292e920a193d187c93"

URI_x86_64_v2_rust-pyo3_0.26+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+abi3-py313-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+abi3-py313-devel.sha256sum] = "eaf6f875097afb5a5fa67146d06f3593eea54d9b5529c8f41716bc20a7f36a53"

URI_x86_64_v2_rust-pyo3_0.26+abi3-py314-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+abi3-py314-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+abi3-py314-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+abi3-py314-devel.sha256sum] = "e77408987017680c3a6fcacfc60b0a62855d8388d8adc844cb2f21a1b0cec54d"

URI_x86_64_v2_rust-pyo3_0.26+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+abi3-py37-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+abi3-py37-devel.sha256sum] = "49591951ed68859745fa074b7075a0b510367c4363a9cdb9330521723005ce85"

URI_x86_64_v2_rust-pyo3_0.26+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+abi3-py38-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+abi3-py38-devel.sha256sum] = "e020c82d505bc482f7d2d7ca5017cf1c3d5a7397a1e2c26a1e61b3f39d6d4d7c"

URI_x86_64_v2_rust-pyo3_0.26+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+abi3-py39-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+abi3-py39-devel.sha256sum] = "55d8446f1fd4f3812645adc8ad5795b1109b3ed417fe0b1c5ad78a5ebcf6ff41"

URI_x86_64_v2_rust-pyo3_0.26+anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+anyhow-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+anyhow-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+anyhow-devel.sha256sum] = "b170103fe07815f0566f4b62312eade51f7a0e572551a910871bfbd84f513bf7"

URI_x86_64_v2_rust-pyo3_0.26+arc_lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+arc_lock-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+arc_lock-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+arc_lock-devel.sha256sum] = "cc1aabacb93221640acaf06b96b69b68e2dffcba93ecd1d79990db516815e61a"

URI_x86_64_v2_rust-pyo3_0.26+auto-initialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+auto-initialize-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+auto-initialize-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+auto-initialize-devel.sha256sum] = "ab44309dbe1dbfe819bb25fc852137a634f6c712b19e9e887af1100aedd3328d"

URI_x86_64_v2_rust-pyo3_0.26+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+bigdecimal-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+bigdecimal-devel.sha256sum] = "8a495400c863037dbfa03137749e6f7321c04df426c74dadb476a77ad2269978"

URI_x86_64_v2_rust-pyo3_0.26+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+bytes-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+bytes-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+bytes-devel.sha256sum] = "e7fb48f82dfdb54653e3490340ec90f7c13f1ccf175030ae42cbeb13458f02b6"

URI_x86_64_v2_rust-pyo3_0.26+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+chrono-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+chrono-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+chrono-devel.sha256sum] = "a5e2c0f6a5a1a238c6075d708a23c28fb837cb40078d7a6ac7dbd8e4e5eabf44"

URI_x86_64_v2_rust-pyo3_0.26+chrono-local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+chrono-local-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+chrono-local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+chrono-local-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+chrono-local-devel.sha256sum] = "097d0ec42229d317de48bee28105487001cd8761ef18e06bf2c991d9e89bb3ef"

URI_x86_64_v2_rust-pyo3_0.26+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+chrono-tz-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+chrono-tz-devel.sha256sum] = "21b5357617cb6093718289cfeec099ba959ffb31073701128055eb9987486cf6"

URI_x86_64_v2_rust-pyo3_0.26+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+default-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+default-devel.sha256sum] = "717e704689822d6dcfd98224894b5fce0cf2d8e8f7a4c395f072a9b960e57bf1"

URI_x86_64_v2_rust-pyo3_0.26+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+either-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+either-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+either-devel.sha256sum] = "2542d7c3e240aef60c8c4b13b1594dafdfffccd3f6a8dc283e1937b37ff3ad90"

URI_x86_64_v2_rust-pyo3_0.26+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+experimental-async-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+experimental-async-devel.sha256sum] = "5da3fd6ba07139b924761d003408e980e577ce285c7411264db8efaa02941640"

URI_x86_64_v2_rust-pyo3_0.26+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+experimental-inspect-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+experimental-inspect-devel.sha256sum] = "f775aa57a03cd97e4919e8c6dba84aa39574824534b17507fafeb4b4644301a6"

URI_x86_64_v2_rust-pyo3_0.26+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+extension-module-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+extension-module-devel.sha256sum] = "19c107811719bbf33d7f9f2e408db25b8243e25251542326faa9e168f458b78d"

URI_x86_64_v2_rust-pyo3_0.26+eyre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+eyre-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+eyre-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+eyre-devel.sha256sum] = "53d959d41b7abcf44af87f43fe9ac6bf88f024b38a47380f6d43516c401e8625"

URI_x86_64_v2_rust-pyo3_0.26+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+full-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+full-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+full-devel.sha256sum] = "32782063cc1eb6ea72faacf67afd73c11c23cdb2e05da40e5d88851e74477f61"

URI_x86_64_v2_rust-pyo3_0.26+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+hashbrown-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+hashbrown-devel.sha256sum] = "c845fa148278b30342bacb745fa0f1f93caaf2f2fa2b6d7e31211836cfa287d2"

URI_x86_64_v2_rust-pyo3_0.26+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+indexmap-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+indexmap-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+indexmap-devel.sha256sum] = "40cc6593f88c48424772b71724a6f15aaf7f956e210619b42cf42e2a0e6c3829"

URI_x86_64_v2_rust-pyo3_0.26+indoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+indoc-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+indoc-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+indoc-devel.sha256sum] = "18c149f926982c965b2df6d360ee1946432a1b75c1cbbfcdc3628561da69f187"

URI_x86_64_v2_rust-pyo3_0.26+inventory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+inventory-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+inventory-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+inventory-devel.sha256sum] = "16dcd38f8761f1ed852531f4290ff90bc23fa660dcc5590ad94d27fed86aee1a"

URI_x86_64_v2_rust-pyo3_0.26+jiff-02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+jiff-02-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+jiff-02-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+jiff-02-devel.sha256sum] = "36f60977151db471759e81af1124a76b9c59cf88a94badcacd98946e315c8a83"

URI_x86_64_v2_rust-pyo3_0.26+lock_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+lock_api-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+lock_api-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+lock_api-devel.sha256sum] = "c66d4cb6eb72f79e8666fc3d9644fd672b029c93a1b3c853debcd5fab0141cd7"

URI_x86_64_v2_rust-pyo3_0.26+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+macros-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+macros-devel.sha256sum] = "f5ac16a78f0846b34e55faf6a9408a1c55394990d33b90fe7ce4afbf70b6ffe3"

URI_x86_64_v2_rust-pyo3_0.26+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+multiple-pymethods-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+multiple-pymethods-devel.sha256sum] = "6f7fccdce990fb0c13d674633766ef68acb25680fe4e0a897644d4ac4d53f0f8"

URI_x86_64_v2_rust-pyo3_0.26+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+nightly-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+nightly-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+nightly-devel.sha256sum] = "d3f07db4fb3fded9de8c1821f40b00d1fb240bfe384efea835cdbc55fab95fd7"

URI_x86_64_v2_rust-pyo3_0.26+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+num-bigint-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+num-bigint-devel.sha256sum] = "2407f81e0c8ea695e7de526761d5d4eed672694b0235f1cf5ccda8256e8aceff"

URI_x86_64_v2_rust-pyo3_0.26+num-complex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+num-complex-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+num-complex-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+num-complex-devel.sha256sum] = "ebc9ea27d8b16e2927d44ced89830b00b967992ab94f47568e507ddce44b61c5"

URI_x86_64_v2_rust-pyo3_0.26+num-rational-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+num-rational-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+num-rational-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+num-rational-devel.sha256sum] = "b10cf0f5235c91da0172235b63ddff6fcca5f3cebb1b990bccd3f11a3b4f7dd9"

URI_x86_64_v2_rust-pyo3_0.26+ordered-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+ordered-float-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+ordered-float-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+ordered-float-devel.sha256sum] = "b7dae21888caec1ad0f9ba819424318af44d97af05014861911392fe7e9b2c28"

URI_x86_64_v2_rust-pyo3_0.26+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+parking_lot-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+parking_lot-devel.sha256sum] = "8b812067f54ca5c3d08932a20ef9ba1f510966a393cc00ecd7ffa59c0893e602"

URI_x86_64_v2_rust-pyo3_0.26+py-clone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+py-clone-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+py-clone-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+py-clone-devel.sha256sum] = "c42c20f47ec1d254fa099ced8bb4bd7b202d389025ef3239a896eb0aaf6347eb"

URI_x86_64_v2_rust-pyo3_0.26+pyo3-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+pyo3-macros-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+pyo3-macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+pyo3-macros-devel.sha256sum] = "cc3d841257ce58a8f06add310391b125635f9b76cbe0814c14f84f0d3ce6f01e"

URI_x86_64_v2_rust-pyo3_0.26+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+rust_decimal-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+rust_decimal-devel.sha256sum] = "d6b052f277763c7769a0f5e26e4b9593cc2c4714ef8802f619c14952bdb94c5d"

URI_x86_64_v2_rust-pyo3_0.26+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+serde-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+serde-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+serde-devel.sha256sum] = "31b2ab8533a4c49ec520b14b4b8c2febef164997b93d0031ce13ea779fbf1eda"

URI_x86_64_v2_rust-pyo3_0.26+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+smallvec-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+smallvec-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+smallvec-devel.sha256sum] = "88d187ceebb7be6a70c049d0d4e296607bc2dd448a572a8004dac6b14c339246"

URI_x86_64_v2_rust-pyo3_0.26+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+time-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+time-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+time-devel.sha256sum] = "978cc8d44093be6bd8af1b411b2190748ef1aa6cf12c7ad580e8d97c143e2031"

URI_x86_64_v2_rust-pyo3_0.26+unindent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+unindent-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+unindent-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+unindent-devel.sha256sum] = "9c2197f40e76251d92886acb89c93da9ba223838928e74ccd32d3b513da07779"

URI_x86_64_v2_rust-pyo3_0.26+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26+uuid-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26+uuid-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26+uuid-devel.sha256sum] = "611fec7a80fed249272193c447e301dbe534f2f63f341e4984c68bd39f59badd"

URI_x86_64_v2_rust-pyo3_0.26-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.26-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.26-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.26-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.26-devel.sha256sum] = "7a0c679fb9336b2bd23890908151933ec37fb77e49b1fa267699aa0e54f837d4"

URI_aarch64_rust-pyo3_0.26+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+abi3-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+abi3-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+abi3-devel.sha256sum] = "a0ed0878244872942e1e30ddd1ff39f1f0999c4504ec4c82216203d4620b030d"

URI_aarch64_rust-pyo3_0.26+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+abi3-py310-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+abi3-py310-devel.sha256sum] = "32d5b1814716866d1e398331066f693891cbcef25096cadee0053e66ff7a3879"

URI_aarch64_rust-pyo3_0.26+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+abi3-py311-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+abi3-py311-devel.sha256sum] = "38e5603781f69e2583e798901aec71f4061c6f7917073f931ae8e56bc41dcd31"

URI_aarch64_rust-pyo3_0.26+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+abi3-py312-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+abi3-py312-devel.sha256sum] = "0323111d07c7516abb3d80fa4a0eef2772b0d10acb6979743fbf39e70a1ab7e4"

URI_aarch64_rust-pyo3_0.26+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+abi3-py313-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+abi3-py313-devel.sha256sum] = "edcf08e13371c7fd34ed068c1bd3e500a43f4e6cbf09421a8827cf2dadd1bf2d"

URI_aarch64_rust-pyo3_0.26+abi3-py314-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+abi3-py314-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+abi3-py314-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+abi3-py314-devel.sha256sum] = "bfe1af3a328790f9c97da060f685a28ce92665cd652e74f76f8a97820ccd81a7"

URI_aarch64_rust-pyo3_0.26+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+abi3-py37-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+abi3-py37-devel.sha256sum] = "5df671ecf7d168d0588aeb8e7a6007dfc531cca605bdaa860f9c500ca8c2d9d4"

URI_aarch64_rust-pyo3_0.26+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+abi3-py38-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+abi3-py38-devel.sha256sum] = "db8c0468e3416a590f216acfbf70bf22d90ada73d0a9efbaa3ce766d4c1990be"

URI_aarch64_rust-pyo3_0.26+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+abi3-py39-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+abi3-py39-devel.sha256sum] = "8b6d234838ea7d8c2bff4e28a86b4d9e09d64f5da07f9724d42a9a0ef38f274a"

URI_aarch64_rust-pyo3_0.26+anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+anyhow-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+anyhow-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+anyhow-devel.sha256sum] = "2bf56b491784bb5f241a1032d33f5c651eb145d30c8b558d7b096695a33270dc"

URI_aarch64_rust-pyo3_0.26+arc_lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+arc_lock-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+arc_lock-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+arc_lock-devel.sha256sum] = "6f5675300ce33bdf002d9eda708ff1b8f9b9c3da8ddc31703e69a410cf7639bd"

URI_aarch64_rust-pyo3_0.26+auto-initialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+auto-initialize-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+auto-initialize-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+auto-initialize-devel.sha256sum] = "4aa6171a95f380f17e75bef3b84e2fe3e6a27de40aa7cc4bc8a9b5b2fe007b15"

URI_aarch64_rust-pyo3_0.26+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+bigdecimal-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+bigdecimal-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+bigdecimal-devel.sha256sum] = "189040d5943daf1c81547b48b7c7847af5644125ef674f4985b5bc008434f7b5"

URI_aarch64_rust-pyo3_0.26+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+bytes-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+bytes-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+bytes-devel.sha256sum] = "7acb9c8ee08000096f62a42abfbf0a915713ffb48e846bed74a7a60b91c59efc"

URI_aarch64_rust-pyo3_0.26+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+chrono-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+chrono-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+chrono-devel.sha256sum] = "bd29d2e705d0cff5fc663be8fd77e444fc9892ca51f804d5bfcd3f2b6841b229"

URI_aarch64_rust-pyo3_0.26+chrono-local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+chrono-local-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+chrono-local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+chrono-local-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+chrono-local-devel.sha256sum] = "e28613fde43198c460fa20b7db515530c58e7433e6de1601da52d6e9ebb251f7"

URI_aarch64_rust-pyo3_0.26+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+chrono-tz-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+chrono-tz-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+chrono-tz-devel.sha256sum] = "7998bbbe61948d810af48efbb81fd0c38d0067ac1f01685c68ae322e20b38725"

URI_aarch64_rust-pyo3_0.26+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+default-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+default-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+default-devel.sha256sum] = "294949498c11a2b60cf624e0962c2f0ea052a9bddba02ff59b1b47936257f292"

URI_aarch64_rust-pyo3_0.26+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+either-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+either-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+either-devel.sha256sum] = "430bd4e458c2f0ec4615dbeda28de149dc11969e83ff0b58094ec75eb7b865f0"

URI_aarch64_rust-pyo3_0.26+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+experimental-async-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+experimental-async-devel.sha256sum] = "e711bfbded5b26862099724977743baf59c9175361ffd0a4e4fc3a6e1ae3b3a3"

URI_aarch64_rust-pyo3_0.26+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+experimental-inspect-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+experimental-inspect-devel.sha256sum] = "a32db2e3dbd14564b29319837069a8291d9b2a8d11b79c76e678510a6c960268"

URI_aarch64_rust-pyo3_0.26+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+extension-module-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+extension-module-devel.sha256sum] = "0e652d33f25ac1797dcb303c7cd8c8065ca50af3d86fb5891c866db4c88d2be2"

URI_aarch64_rust-pyo3_0.26+eyre-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+eyre-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+eyre-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+eyre-devel.sha256sum] = "454683be72c7297acbb622380ef18e9bc2873ccadc8f64024b69337b46661746"

URI_aarch64_rust-pyo3_0.26+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+full-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+full-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+full-devel.sha256sum] = "bbfb3fa1218e45b31373f6e2ec7fa6ef805020510757bfd5547c4148be2e1066"

URI_aarch64_rust-pyo3_0.26+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+hashbrown-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+hashbrown-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+hashbrown-devel.sha256sum] = "a1c825afcb3d69c076dd969f4c4ad6c463573150a6018876aca4aeffbae4cc91"

URI_aarch64_rust-pyo3_0.26+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+indexmap-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+indexmap-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+indexmap-devel.sha256sum] = "2dca63eac64dfd2e2d89307b0cf024e8cbbb372e7cce69d7faf3544a87714885"

URI_aarch64_rust-pyo3_0.26+indoc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+indoc-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+indoc-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+indoc-devel.sha256sum] = "363e06fe84420dcc90d0ffdd9231bdffd2b0e87b39758a052ac7c41ccbdd464b"

URI_aarch64_rust-pyo3_0.26+inventory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+inventory-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+inventory-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+inventory-devel.sha256sum] = "3f62de90e2485a29874503b4558c338f7896f9e2244a1f4309dfb08d80fdd81d"

URI_aarch64_rust-pyo3_0.26+jiff-02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+jiff-02-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+jiff-02-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+jiff-02-devel.sha256sum] = "6f0bc86d5f9a9d3e6ebd4d85f55ab73c84b139c0cb8ecbd021ae14fc9b76feeb"

URI_aarch64_rust-pyo3_0.26+lock_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+lock_api-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+lock_api-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+lock_api-devel.sha256sum] = "76e0f3a51d2f9e7b98c78c622158bc0e38c8c76e711e7e1977ca16f7b2ac338f"

URI_aarch64_rust-pyo3_0.26+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+macros-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+macros-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+macros-devel.sha256sum] = "62d915b0b6be47ec19c9f6cbba758db9dddeeb680ac379c30a54ce1b867dce7c"

URI_aarch64_rust-pyo3_0.26+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+multiple-pymethods-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+multiple-pymethods-devel.sha256sum] = "0d97b061e50321f34ec6f13c1aa8d781e55923fcbf7dffdf7bcce9164d9ab1c0"

URI_aarch64_rust-pyo3_0.26+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+nightly-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+nightly-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+nightly-devel.sha256sum] = "885dc9c10a02fd662cdc6762d0d0068225db220aeb352cb5878b1331fd53e951"

URI_aarch64_rust-pyo3_0.26+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+num-bigint-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+num-bigint-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+num-bigint-devel.sha256sum] = "120e8bab764da610929202607da4356470693902296a0852d6465a6cc3a4b23f"

URI_aarch64_rust-pyo3_0.26+num-complex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+num-complex-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+num-complex-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+num-complex-devel.sha256sum] = "6552a507b1441a4b10d1bc109e4802ac904e6957ffcb771f80c97393a5a3f6a8"

URI_aarch64_rust-pyo3_0.26+num-rational-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+num-rational-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+num-rational-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+num-rational-devel.sha256sum] = "9ea73f68232609b1353c3c1a01ef820fa40270b989a2368b9a7ec44b8ec0d57e"

URI_aarch64_rust-pyo3_0.26+ordered-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+ordered-float-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+ordered-float-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+ordered-float-devel.sha256sum] = "9cba5f77225ca1a8b7c60dec6687710ab0608005abf84a17c863340a67bded05"

URI_aarch64_rust-pyo3_0.26+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+parking_lot-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+parking_lot-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+parking_lot-devel.sha256sum] = "e82f5c16afb2eb3f137289e37b82f948cfcf5d172ae57a01aba2941cd7fa897a"

URI_aarch64_rust-pyo3_0.26+py-clone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+py-clone-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+py-clone-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+py-clone-devel.sha256sum] = "f80a8c16294420121a6bcc326ac94cda9220d05943c3a4c9027ca0338511384b"

URI_aarch64_rust-pyo3_0.26+pyo3-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+pyo3-macros-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+pyo3-macros-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+pyo3-macros-devel.sha256sum] = "4daaa561436295e484a8fcab80d135f04fbfa23cffbeeff2837914881c94380c"

URI_aarch64_rust-pyo3_0.26+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+rust_decimal-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+rust_decimal-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+rust_decimal-devel.sha256sum] = "729b75907c640fe0d6d89bd4e6df0039fabd397c28313744f6e69a964b0c8aca"

URI_aarch64_rust-pyo3_0.26+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+serde-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+serde-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+serde-devel.sha256sum] = "f18da32af8c21562442341858bb79650466517e247b77b963972ce0db44610d2"

URI_aarch64_rust-pyo3_0.26+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+smallvec-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+smallvec-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+smallvec-devel.sha256sum] = "783ab7c62c6b0866acc72825d33d992f4e071c27143bcb07249684dfb8e2adab"

URI_aarch64_rust-pyo3_0.26+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+time-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+time-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+time-devel.sha256sum] = "6887e296a92fbce09eeb765f3a7db2f3f1e3b74f10ded530952f4083944f164a"

URI_aarch64_rust-pyo3_0.26+unindent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+unindent-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+unindent-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+unindent-devel.sha256sum] = "55228da9c94eeb280db5c288b0000bf269d01f3014d9bdfc624a1cf0fcd057fb"

URI_aarch64_rust-pyo3_0.26+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26+uuid-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26+uuid-devel}"
SRC_URI[aarch64_rust-pyo3_0.26+uuid-devel.sha256sum] = "11b5aa2fcfcf29f72bd324ea8385a19698143c41457bd3c1561176ccfaec6c08"

URI_aarch64_rust-pyo3_0.26-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.26-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3_0.26-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.26-devel}"
SRC_URI[aarch64_rust-pyo3_0.26-devel.sha256sum] = "abec126a298a7f9f4ff29bd6c2af7e4ee31bafb33a9d6f9563090680e167d6e5"

RDEPENDS:rust-pyo3_0.26+abi3-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-py310-devel \
 rust-pyo3_0.26+abi3-py311-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-py311-devel \
 rust-pyo3_0.26+abi3-py312-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-py312-devel \
 rust-pyo3_0.26+abi3-py313-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+abi3-py313-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-py313-devel \
 rust-pyo3_0.26+abi3-py314-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+abi3-py314-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-py314-devel \
 rust-pyo3_0.26+abi3-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-py37-devel \
 rust-pyo3_0.26+abi3-py38-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-py38-devel \
 rust-pyo3_0.26+abi3-py39-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi0.26+abi3-py39-devel \
 rust-pyo3_0.26+abi3-py310-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+anyhow-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+arc_lock-devel = " \
 cargo \
 rust-lock_api+arc_lock-devel \
 rust-lock_api+default-devel \
 rust-parking_lot+arc_lock-devel \
 rust-parking_lot+default-devel \
 rust-pyo3_0.26+lock_api-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+auto-initialize-devel = " \
 cargo \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+bigdecimal-devel = " \
 cargo \
 rust-bigdecimal+default-devel \
 rust-pyo3_0.26+num-bigint-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+chrono-local-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-iana-time-zone+default-devel \
 rust-iana-time-zone+fallback-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+default-devel = " \
 cargo \
 rust-pyo3_0.26+macros-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+either-devel = " \
 cargo \
 rust-either+default-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros0.26+default-devel \
 rust-pyo3-macros0.26+experimental-async-devel \
 rust-pyo3_0.26+macros-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-macros0.26+default-devel \
 rust-pyo3-macros0.26+experimental-inspect-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi0.26+extension-module-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+eyre-devel = " \
 cargo \
 rust-eyre+default-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+full-devel = " \
 cargo \
 rust-pyo3_0.26+anyhow-devel \
 rust-pyo3_0.26+arc_lock-devel \
 rust-pyo3_0.26+bigdecimal-devel \
 rust-pyo3_0.26+bytes-devel \
 rust-pyo3_0.26+chrono-devel \
 rust-pyo3_0.26+chrono-local-devel \
 rust-pyo3_0.26+chrono-tz-devel \
 rust-pyo3_0.26+either-devel \
 rust-pyo3_0.26+experimental-async-devel \
 rust-pyo3_0.26+experimental-inspect-devel \
 rust-pyo3_0.26+eyre-devel \
 rust-pyo3_0.26+hashbrown-devel \
 rust-pyo3_0.26+indexmap-devel \
 rust-pyo3_0.26+jiff-02-devel \
 rust-pyo3_0.26+lock_api-devel \
 rust-pyo3_0.26+macros-devel \
 rust-pyo3_0.26+num-bigint-devel \
 rust-pyo3_0.26+num-complex-devel \
 rust-pyo3_0.26+num-rational-devel \
 rust-pyo3_0.26+ordered-float-devel \
 rust-pyo3_0.26+parking_lot-devel \
 rust-pyo3_0.26+py-clone-devel \
 rust-pyo3_0.26+rust_decimal-devel \
 rust-pyo3_0.26+serde-devel \
 rust-pyo3_0.26+smallvec-devel \
 rust-pyo3_0.26+time-devel \
 rust-pyo3_0.26+uuid-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+hashbrown-devel = " \
 cargo \
 rust-hashbrown0.15-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+indoc-devel = " \
 cargo \
 rust-indoc+default-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+inventory-devel = " \
 cargo \
 rust-inventory+default-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+jiff-02-devel = " \
 cargo \
 rust-jiff+default-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+lock_api-devel = " \
 cargo \
 rust-lock_api+default-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+macros-devel = " \
 cargo \
 rust-pyo3_0.26+indoc-devel \
 rust-pyo3_0.26+pyo3-macros-devel \
 rust-pyo3_0.26+unindent-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros0.26+default-devel \
 rust-pyo3-macros0.26+multiple-pymethods-devel \
 rust-pyo3_0.26+inventory-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+nightly-devel = " \
 cargo \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+num-bigint-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+num-complex-devel = " \
 cargo \
 rust-num-complex+default-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+num-rational-devel = " \
 cargo \
 rust-num-rational+default-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+ordered-float-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+parking_lot-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-pyo3_0.26+lock_api-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+py-clone-devel = " \
 cargo \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+pyo3-macros-devel = " \
 cargo \
 rust-pyo3-macros0.26+default-devel \
 rust-pyo3_0.26-devel \
 "
RDEPENDS:rust-pyo3_0.26+rust_decimal-devel = " \
 cargo \
 rust-pyo3_0.26-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-pyo3_0.26+serde-devel = " \
 cargo \
 rust-pyo3_0.26-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-pyo3_0.26+smallvec-devel = " \
 cargo \
 rust-pyo3_0.26-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-pyo3_0.26+time-devel = " \
 cargo \
 rust-pyo3_0.26-devel \
 rust-time-devel \
 "
RDEPENDS:rust-pyo3_0.26+unindent-devel = " \
 cargo \
 rust-pyo3_0.26-devel \
 rust-unindent+default-devel \
 "
RDEPENDS:rust-pyo3_0.26+uuid-devel = " \
 cargo \
 rust-pyo3_0.26-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-pyo3_0.26-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 rust-memoffset+default-devel \
 rust-once_cell+default-devel \
 rust-pyo3-build-config0.26+default-devel \
 rust-pyo3-build-config0.26+resolve-config-devel \
 rust-pyo3-ffi0.26+default-devel \
 "
