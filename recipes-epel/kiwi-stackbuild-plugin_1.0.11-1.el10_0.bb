# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi-stackbuild-plugin"
PV = "1.0.11"
PR = "1.el10_0"
PACKAGES = " \
 kiwi-stackbuild-plugin \
 python3-kiwi-stackbuild-plugin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kiwi-stackbuild-plugin-1.0.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e93fd4ddb8316bab13de2a7aa5d074062a8d1141d5fc0162ccc9e3581a37d84"

URI_x86_64_v2_kiwi-stackbuild-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-stackbuild-plugin-1.0.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-stackbuild-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-stackbuild-plugin}"
SRC_URI[x86_64_v2_kiwi-stackbuild-plugin.sha256sum] = "81e994258fe58efa97d208c84feeae7319ab8d810a53891f053441b08af2eade"

URI_x86_64_v2_python3-kiwi-stackbuild-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-stackbuild-plugin-1.0.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi-stackbuild-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kiwi-stackbuild-plugin}"
SRC_URI[x86_64_v2_python3-kiwi-stackbuild-plugin.sha256sum] = "5e2b59a0d5ec6007a2120240461f2c2918d8b12872f1bdc7fab8321bc4902a78"

URI_aarch64_kiwi-stackbuild-plugin = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-stackbuild-plugin-1.0.11-1.el10_0.noarch.rpm;name=aarch64_kiwi-stackbuild-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-stackbuild-plugin}"
SRC_URI[aarch64_kiwi-stackbuild-plugin.sha256sum] = "fda6d4bf0d325b6a00b8029389a82dab0e9e148b869bc944e0156aaf6cb96c6d"

URI_aarch64_python3-kiwi-stackbuild-plugin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-stackbuild-plugin-1.0.11-1.el10_0.noarch.rpm;name=aarch64_python3-kiwi-stackbuild-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kiwi-stackbuild-plugin}"
SRC_URI[aarch64_python3-kiwi-stackbuild-plugin.sha256sum] = "a162b570d59fcc7166d4f62fffd9fd6ef56792fd3b64b0ce2f937e41331fef72"

RDEPENDS:kiwi-stackbuild-plugin = " \
 python3-kiwi-stackbuild-plugin \
 "
RDEPENDS:python3-kiwi-stackbuild-plugin = " \
 kiwi-systemdeps-containers \
 python3 \
 python3-docopt-ng \
 python3-kiwi \
 "
