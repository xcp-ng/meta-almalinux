# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-priority-queue"
PV = "2.7.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-priority-queue+benchmarks-devel \
 rust-priority-queue+default-devel \
 rust-priority-queue+serde-devel \
 rust-priority-queue+std-devel \
 rust-priority-queue-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-priority-queue-2.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47ffab09e30e7837154c01da585fbdab38a328e5dbebe2b17efd6fd82ebf7cfa"

URI_x86_64_v2_rust-priority-queue+benchmarks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-priority-queue+benchmarks-devel-2.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-priority-queue+benchmarks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-priority-queue+benchmarks-devel}"
SRC_URI[x86_64_v2_rust-priority-queue+benchmarks-devel.sha256sum] = "14485b4363d37cc965f0b5dca50d233d542ef92c6b217fdb132c3be3a65f0b94"

URI_x86_64_v2_rust-priority-queue+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-priority-queue+default-devel-2.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-priority-queue+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-priority-queue+default-devel}"
SRC_URI[x86_64_v2_rust-priority-queue+default-devel.sha256sum] = "4a82453736035418a9af87763f5321133e4facae5b7e972b7f6e21e7f8be09df"

URI_x86_64_v2_rust-priority-queue+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-priority-queue+serde-devel-2.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-priority-queue+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-priority-queue+serde-devel}"
SRC_URI[x86_64_v2_rust-priority-queue+serde-devel.sha256sum] = "3150b656108244b66b43473942b0ff8c998e8616d56ae32f45ea576b44f2924b"

URI_x86_64_v2_rust-priority-queue+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-priority-queue+std-devel-2.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-priority-queue+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-priority-queue+std-devel}"
SRC_URI[x86_64_v2_rust-priority-queue+std-devel.sha256sum] = "9763ed953b5864fa4160e94340c040e428e127608062f1a3bba2c5b88ace9f86"

URI_x86_64_v2_rust-priority-queue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-priority-queue-devel-2.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-priority-queue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-priority-queue-devel}"
SRC_URI[x86_64_v2_rust-priority-queue-devel.sha256sum] = "ce6486bce0b45c972cd4ea3fa8dfb7fa5d667c45633b6bbcb457e222eb1cfc99"

URI_aarch64_rust-priority-queue+benchmarks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-priority-queue+benchmarks-devel-2.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-priority-queue+benchmarks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-priority-queue+benchmarks-devel}"
SRC_URI[aarch64_rust-priority-queue+benchmarks-devel.sha256sum] = "99dd399197fde5b87ed35c660a8a8b82fa3cbf754b2232942d9668ce93e35cc4"

URI_aarch64_rust-priority-queue+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-priority-queue+default-devel-2.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-priority-queue+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-priority-queue+default-devel}"
SRC_URI[aarch64_rust-priority-queue+default-devel.sha256sum] = "0ee9d359b4d38ce2bd30808d3330faf2888029a399f6dce5ddc242f4cedc2608"

URI_aarch64_rust-priority-queue+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-priority-queue+serde-devel-2.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-priority-queue+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-priority-queue+serde-devel}"
SRC_URI[aarch64_rust-priority-queue+serde-devel.sha256sum] = "520f3c47e274385db8e71b5e99e71641a3df4ca372228a40d7f35b90f77b088b"

URI_aarch64_rust-priority-queue+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-priority-queue+std-devel-2.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-priority-queue+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-priority-queue+std-devel}"
SRC_URI[aarch64_rust-priority-queue+std-devel.sha256sum] = "386866a200866cf2aeb4d53e56e8e5116169ac94a9d1e27564de00f68f3896e1"

URI_aarch64_rust-priority-queue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-priority-queue-devel-2.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-priority-queue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-priority-queue-devel}"
SRC_URI[aarch64_rust-priority-queue-devel.sha256sum] = "a8eefad1e2b95fefa3e7691d9aba15cbf52bda5ceb6461c1269094e4709f01fa"

RDEPENDS:rust-priority-queue+benchmarks-devel = " \
 cargo \
 rust-priority-queue-devel \
 "
RDEPENDS:rust-priority-queue+default-devel = " \
 cargo \
 rust-priority-queue+std-devel \
 rust-priority-queue-devel \
 "
RDEPENDS:rust-priority-queue+serde-devel = " \
 cargo \
 rust-priority-queue-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-priority-queue+std-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-priority-queue-devel \
 rust-serde+alloc-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-priority-queue-devel = " \
 cargo \
 rust \
 rust-equivalent+default-devel \
 rust-indexmap-devel \
 "
