# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-freezegun"
PV = "1.5.1"
PR = "2.el10_0"
PACKAGES = " \
 python3-freezegun \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-freezegun-1.5.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74f4ab78ea5e169ecc5a0e33d873f420b033ce24c8cad6f2a58c3a2558a42fe5"

URI_x86_64_v2_python3-freezegun = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-freezegun-1.5.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-freezegun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-freezegun}"
SRC_URI[x86_64_v2_python3-freezegun.sha256sum] = "3739ceb61fd682b7647c6de879c57d8d1ef22ac5e6df51cb507a7fd9d72da33d"

URI_aarch64_python3-freezegun = "${EPEL_MIRROR}/aarch64/Packages/p/python3-freezegun-1.5.1-2.el10_0.noarch.rpm;name=aarch64_python3-freezegun;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-freezegun}"
SRC_URI[aarch64_python3-freezegun.sha256sum] = "48ec1a55bb904e3e38ddb967914ba01c5238dd174a3cb795766b2706ea648f58"

RDEPENDS:python3-freezegun = " \
 python3 \
 python3-dateutil \
 "
