# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-frameworkintegration"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-frameworkintegration \
 kf6-frameworkintegration-devel \
 kf6-frameworkintegration-doc \
 kf6-frameworkintegration-html \
 kf6-frameworkintegration-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-frameworkintegration-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7799acc6436f1173a200b311b167c8572eebc35cfe5d4da95b85733663920379"

URI_x86_64_v2_kf6-frameworkintegration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-frameworkintegration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration}"
SRC_URI[x86_64_v2_kf6-frameworkintegration.sha256sum] = "4302c91dc603852f46ac2a8cff3779f98fa2e9b9bd189013a3cdb09b016faa5b"

URI_x86_64_v2_kf6-frameworkintegration-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-frameworkintegration-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration-devel}"
SRC_URI[x86_64_v2_kf6-frameworkintegration-devel.sha256sum] = "20959c79121c22751c4d16febcdb5197c7a76e38c697bb081ed033af6edff544"

URI_x86_64_v2_kf6-frameworkintegration-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-frameworkintegration-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration-doc}"
SRC_URI[x86_64_v2_kf6-frameworkintegration-doc.sha256sum] = "9d13468910993795064019a00be5e451a9689bab259028f4ce8cd75cfbefad07"

URI_x86_64_v2_kf6-frameworkintegration-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-frameworkintegration-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration-html}"
SRC_URI[x86_64_v2_kf6-frameworkintegration-html.sha256sum] = "2eeb5454ad60546d4102018f45a6ac0ba6a4c8e23cd93d2709aa3d8e7b251834"

URI_x86_64_v2_kf6-frameworkintegration-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-libs-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-frameworkintegration-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration-libs}"
SRC_URI[x86_64_v2_kf6-frameworkintegration-libs.sha256sum] = "fbb8a987daa79655410dcd9a37ec489f41335c0384714988c4f0b806cf4b308e"

URI_aarch64_kf6-frameworkintegration = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-frameworkintegration;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration}"
SRC_URI[aarch64_kf6-frameworkintegration.sha256sum] = "1b536126182ab1d2afe75c1d2d7a4c5782c969a8b8d17d11da329e2cb9126951"

URI_aarch64_kf6-frameworkintegration-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-frameworkintegration-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration-devel}"
SRC_URI[aarch64_kf6-frameworkintegration-devel.sha256sum] = "2ffd3bbe9a208c069342aaecfb7b9e83616d16bdee7e77f2a7ed8c27ba4e11f1"

URI_aarch64_kf6-frameworkintegration-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-frameworkintegration-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration-doc}"
SRC_URI[aarch64_kf6-frameworkintegration-doc.sha256sum] = "3f75b974b9cf6efb2dabddf95dab0667be64afa84ad5ce170e78d383a844f7f8"

URI_aarch64_kf6-frameworkintegration-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-frameworkintegration-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration-html}"
SRC_URI[aarch64_kf6-frameworkintegration-html.sha256sum] = "72854e8f09e78252416e05bcb44f4862877926b8c7bb7cfca620c0e430ce9a25"

URI_aarch64_kf6-frameworkintegration-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-libs-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-frameworkintegration-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration-libs}"
SRC_URI[aarch64_kf6-frameworkintegration-libs.sha256sum] = "8bcd41473877338ffe7e4e12acb234a0b9020be590b51cd034305217aca7f30f"

RDEPENDS:kf6-frameworkintegration = " \
 glibc \
 kf6-filesystem \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-knotifications \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-frameworkintegration-devel = " \
 cmake-filesystem \
 kf6-frameworkintegration-libs \
 kf6-kconfigwidgets-devel \
 kf6-kiconthemes-devel \
 "
RDEPENDS:kf6-frameworkintegration-doc = " \
 "
RDEPENDS:kf6-frameworkintegration-html = " \
 "
RDEPENDS:kf6-frameworkintegration-libs = " \
 PackageKit-Qt6 \
 appstream-qt \
 glibc \
 kf6-frameworkintegration \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kiconthemes \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
