# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uvw"
PV = "3.4.0"
PR = "3.el10_2"
PACKAGES = " \
 uvw-devel \
 uvw-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uvw-3.4.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7b8fd5ff2deb82023849dff010ce055c0ba8681eb27297d65f719ae09d6ee7a"

URI_x86_64_v2_uvw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uvw-devel-3.4.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uvw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uvw-devel}"
SRC_URI[x86_64_v2_uvw-devel.sha256sum] = "b9058095b7637c9a5bac5121eef0380f4325897bf4c5d30874d160f6c7118438"

URI_x86_64_v2_uvw-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uvw-doc-3.4.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_uvw-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uvw-doc}"
SRC_URI[x86_64_v2_uvw-doc.sha256sum] = "b71a338954ad27692784e03ed7363764cedac781e7a5d631739c3ac5ea193b02"

URI_aarch64_uvw-devel = "${EPEL_MIRROR}/aarch64/Packages/u/uvw-devel-3.4.0-3.el10_2.aarch64.rpm;name=aarch64_uvw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_uvw-devel}"
SRC_URI[aarch64_uvw-devel.sha256sum] = "88d60982d8141f48bc7ae998e929f791eba694afa4207f45e43d5583a48c82ac"

URI_aarch64_uvw-doc = "${EPEL_MIRROR}/aarch64/Packages/u/uvw-doc-3.4.0-3.el10_2.noarch.rpm;name=aarch64_uvw-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_uvw-doc}"
SRC_URI[aarch64_uvw-doc.sha256sum] = "e4b34a41bec77f4d1eba56da038a47591de1a9f72da0a8ec7c66d74162fa3a5f"

RDEPENDS:uvw-devel = " \
 cmake-filesystem \
 libuv-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:uvw-doc = " \
 "
