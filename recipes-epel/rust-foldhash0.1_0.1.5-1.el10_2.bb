# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-foldhash0.1"
PV = "0.1.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-foldhash0.1+default-devel \
 rust-foldhash0.1+std-devel \
 rust-foldhash0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-foldhash0.1-0.1.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a07ba2c9dde6ee8339af55dfd1beef3fe91b7d3f4c93fbf9440f697f8858a0be"

URI_x86_64_v2_rust-foldhash0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foldhash0.1+default-devel-0.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foldhash0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foldhash0.1+default-devel}"
SRC_URI[x86_64_v2_rust-foldhash0.1+default-devel.sha256sum] = "2bd9a2aee2cbc406d912f3b848441e4513435b2cec8a580c8d90a2ae8979f5b0"

URI_x86_64_v2_rust-foldhash0.1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foldhash0.1+std-devel-0.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foldhash0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foldhash0.1+std-devel}"
SRC_URI[x86_64_v2_rust-foldhash0.1+std-devel.sha256sum] = "fce8542201db562981fbb7f0006564ac757a8c4e5b7fb06b05798a5ec3a1e853"

URI_x86_64_v2_rust-foldhash0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foldhash0.1-devel-0.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foldhash0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foldhash0.1-devel}"
SRC_URI[x86_64_v2_rust-foldhash0.1-devel.sha256sum] = "4fc1c32b7fe01ddcd3e223bd069d9886270e3836eb914b8825bc7573e58c2853"

URI_aarch64_rust-foldhash0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foldhash0.1+default-devel-0.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-foldhash0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foldhash0.1+default-devel}"
SRC_URI[aarch64_rust-foldhash0.1+default-devel.sha256sum] = "8d4c90bc0e62ab39de57899b3b1f8e0683b6e66420bbba7ae4b110af3b8eb9f6"

URI_aarch64_rust-foldhash0.1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foldhash0.1+std-devel-0.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-foldhash0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foldhash0.1+std-devel}"
SRC_URI[aarch64_rust-foldhash0.1+std-devel.sha256sum] = "f7d294d4d869171bba401483abad4bbe8e9ecab14785ff670bd22c346244dd3c"

URI_aarch64_rust-foldhash0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foldhash0.1-devel-0.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-foldhash0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foldhash0.1-devel}"
SRC_URI[aarch64_rust-foldhash0.1-devel.sha256sum] = "732ef5d29d791c07e66bcec2222374e5b1f8054bba38832c67ba795ba427e579"

RDEPENDS:rust-foldhash0.1+default-devel = " \
 cargo \
 rust-foldhash0.1+std-devel \
 rust-foldhash0.1-devel \
 "
RDEPENDS:rust-foldhash0.1+std-devel = " \
 cargo \
 rust-foldhash0.1-devel \
 "
RDEPENDS:rust-foldhash0.1-devel = " \
 cargo \
 rust \
 "
