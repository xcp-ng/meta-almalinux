# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pydantic"
PV = "2.9.2"
PR = "4.el10_1"
PACKAGES = " \
 python-pydantic-doc \
 python3-pydantic \
 python3-pydantic+email \
 python3-pydantic+timezone \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pydantic-2.9.2-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e62d7431ad7c5641882df3682dbf9fdddf2e03c6efb899f2d6d756bb2fd0087"

URI_x86_64_v2_python-pydantic-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pydantic-doc-2.9.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-pydantic-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pydantic-doc}"
SRC_URI[x86_64_v2_python-pydantic-doc.sha256sum] = "471a96e8198be7e48b441f2daae3696a15cf407c715fe863264306757852a647"

URI_x86_64_v2_python3-pydantic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-2.9.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic}"
SRC_URI[x86_64_v2_python3-pydantic.sha256sum] = "0a57d36137091898262db76a33187bbb7f95e35dded05162efe11db28340d3f9"

URI_x86_64_v2_python3-pydantic+email = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic+email-2.9.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic+email;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic+email}"
SRC_URI[x86_64_v2_python3-pydantic+email.sha256sum] = "8c2f723072672895b5cbb47d7e25bf763384d25805c5efc8d77aacb17e55d215"

URI_x86_64_v2_python3-pydantic+timezone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic+timezone-2.9.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic+timezone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic+timezone}"
SRC_URI[x86_64_v2_python3-pydantic+timezone.sha256sum] = "3d397dd296c411824e72c8ba96b3824b03ef4dddda5ec859d9780a2da0046234"

URI_aarch64_python-pydantic-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-pydantic-doc-2.9.2-4.el10_1.noarch.rpm;name=aarch64_python-pydantic-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pydantic-doc}"
SRC_URI[aarch64_python-pydantic-doc.sha256sum] = "577935895bc2c22ba4de04bb474d92abedcf597fde1e3cb775518f222f2aab5d"

URI_aarch64_python3-pydantic = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-2.9.2-4.el10_1.noarch.rpm;name=aarch64_python3-pydantic;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic}"
SRC_URI[aarch64_python3-pydantic.sha256sum] = "2654b43bc0af9e4c3463400847aec66a40433ee8eb44d03ec4d62bd6a8a7f12b"

URI_aarch64_python3-pydantic+email = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic+email-2.9.2-4.el10_1.noarch.rpm;name=aarch64_python3-pydantic+email;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic+email}"
SRC_URI[aarch64_python3-pydantic+email.sha256sum] = "b8cdb6974b8eabc8748b806f002bdd26e72ef042a3d05cc283844b2d84e4598d"

URI_aarch64_python3-pydantic+timezone = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic+timezone-2.9.2-4.el10_1.noarch.rpm;name=aarch64_python3-pydantic+timezone;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic+timezone}"
SRC_URI[aarch64_python3-pydantic+timezone.sha256sum] = "f7b5d17d9b5ca37f2231b483453e1d4a908e766955a7711f843f3466476eca29"

RDEPENDS:python-pydantic-doc = " \
 "
RDEPENDS:python3-pydantic = " \
 python3 \
 python3-annotated-types \
 python3-pydantic-core \
 python3-typing-extensions \
 "
RDEPENDS:python3-pydantic+email = " \
 python3 \
 python3-email-validator \
 python3-pydantic \
 "
RDEPENDS:python3-pydantic+timezone = " \
 python3 \
 python3-pydantic \
 "
