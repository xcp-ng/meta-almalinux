# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "log4c"
PV = "1.2.4"
PR = "32.el10_0"
PACKAGES = " \
 log4c \
 log4c-devel \
 log4c-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/log4c-1.2.4-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "994e0054b0248ea7c206a81f159f302ac7d73e715aadd94b5833d08fdf876c56"

URI_x86_64_v2_log4c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4c-1.2.4-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4c}"
SRC_URI[x86_64_v2_log4c.sha256sum] = "c9af7e83779e646f81c9eda2f3cace910bf1ccede23dc9b1929a88d778f5c80d"

URI_x86_64_v2_log4c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4c-devel-1.2.4-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4c-devel}"
SRC_URI[x86_64_v2_log4c-devel.sha256sum] = "3d671dd00efb1158702dae255879d9f975071c5a7bc1d2d53aa10064dabcc217"

URI_x86_64_v2_log4c-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4c-doc-1.2.4-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_log4c-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4c-doc}"
SRC_URI[x86_64_v2_log4c-doc.sha256sum] = "de73bad16e9fed06ccea4011623677d5130bcd5f9cab9072bd777024274167a4"

URI_aarch64_log4c = "${EPEL_MIRROR}/aarch64/Packages/l/log4c-1.2.4-32.el10_0.aarch64.rpm;name=aarch64_log4c;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4c}"
SRC_URI[aarch64_log4c.sha256sum] = "6172cf96c9779a6abaeef9c3365e9efa9529ac1523d72603e1ef4138ce14e039"

URI_aarch64_log4c-devel = "${EPEL_MIRROR}/aarch64/Packages/l/log4c-devel-1.2.4-32.el10_0.aarch64.rpm;name=aarch64_log4c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4c-devel}"
SRC_URI[aarch64_log4c-devel.sha256sum] = "c46b9779d24cc2e79463551a37ce3c08b18c0121e6b20263bbb5b0eb81e25135"

URI_aarch64_log4c-doc = "${EPEL_MIRROR}/aarch64/Packages/l/log4c-doc-1.2.4-32.el10_0.noarch.rpm;name=aarch64_log4c-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4c-doc}"
SRC_URI[aarch64_log4c-doc.sha256sum] = "1d6d363c83edc867798ba081be8320a23924f37054c37c25123a582458de8557"

RDEPENDS:log4c = " \
 expat \
 glibc \
 "
RDEPENDS:log4c-devel = " \
 bash \
 log4c \
 pkgconf-pkg-config \
 "
RDEPENDS:log4c-doc = " \
 "
