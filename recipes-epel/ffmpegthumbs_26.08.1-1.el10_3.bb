# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ffmpegthumbs"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ffmpegthumbs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/ffmpegthumbs-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b25c40deed0569eb090eec908647c77aa9dfac1f65a3a27b5da3d68df7fd562d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ffmpegthumbs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ffmpegthumbs;unpack=0"
SRC_URI[x86_64_v2_ffmpegthumbs.sha256sum] = "28f965a57467d49f933920c0d4bac82046ca310340be419754fc3728c40fdb82"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/ffmpegthumbs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ffmpegthumbs;unpack=0"
SRC_URI[aarch64_ffmpegthumbs.sha256sum] = "60964a518ceadb3eeb31251ec3423c04b134a1324420d8fcea5675b802e5ec9d"

RDEPENDS:ffmpegthumbs = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libstdc++ \
 libswscale-free \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
