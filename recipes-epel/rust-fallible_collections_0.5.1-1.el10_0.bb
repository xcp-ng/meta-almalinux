# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fallible_collections"
PV = "0.5.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-fallible_collections+default-devel \
 rust-fallible_collections+hashmap-devel \
 rust-fallible_collections+rust_1_57-devel \
 rust-fallible_collections+std-devel \
 rust-fallible_collections+std_io-devel \
 rust-fallible_collections+unstable-devel \
 rust-fallible_collections-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fallible_collections-0.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c05d5473bae3df4923c78f31343adc91af7f9da799d8ec8be3e8da8ff664f87"

URI_x86_64_v2_rust-fallible_collections+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fallible_collections+default-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fallible_collections+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fallible_collections+default-devel}"
SRC_URI[x86_64_v2_rust-fallible_collections+default-devel.sha256sum] = "6b8b5c50489e5f290f676123073d9e62831b43c7a3de9c7ef504eea3560a96d3"

URI_x86_64_v2_rust-fallible_collections+hashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fallible_collections+hashmap-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fallible_collections+hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fallible_collections+hashmap-devel}"
SRC_URI[x86_64_v2_rust-fallible_collections+hashmap-devel.sha256sum] = "b60127acd764b878ae39d03f7d7b0fe2f2dd4bbb7cde550e8cec4364ab113e40"

URI_x86_64_v2_rust-fallible_collections+rust_1_57-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fallible_collections+rust_1_57-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fallible_collections+rust_1_57-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fallible_collections+rust_1_57-devel}"
SRC_URI[x86_64_v2_rust-fallible_collections+rust_1_57-devel.sha256sum] = "675ebf2b22ac224a92fb3bbc533910a6122dd898294ff7fd4dd887618466eb63"

URI_x86_64_v2_rust-fallible_collections+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fallible_collections+std-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fallible_collections+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fallible_collections+std-devel}"
SRC_URI[x86_64_v2_rust-fallible_collections+std-devel.sha256sum] = "d76363d4522fcee07a7140bd091cef3f7d4171185ec13804addf75cffba0b00b"

URI_x86_64_v2_rust-fallible_collections+std_io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fallible_collections+std_io-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fallible_collections+std_io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fallible_collections+std_io-devel}"
SRC_URI[x86_64_v2_rust-fallible_collections+std_io-devel.sha256sum] = "ab5b767e798a5990f2757567c2e1147c5547881523cba9e5370c1cd1689dd588"

URI_x86_64_v2_rust-fallible_collections+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fallible_collections+unstable-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fallible_collections+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fallible_collections+unstable-devel}"
SRC_URI[x86_64_v2_rust-fallible_collections+unstable-devel.sha256sum] = "d0e4fd911f98203fb641d54807ebfa04a920b25ff6d944f62adadc0e26538989"

URI_x86_64_v2_rust-fallible_collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fallible_collections-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fallible_collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fallible_collections-devel}"
SRC_URI[x86_64_v2_rust-fallible_collections-devel.sha256sum] = "738a23f753eedaef05b7c31a1440501662bbf0649cbfa4b1d36c60e271fc129a"

URI_aarch64_rust-fallible_collections+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fallible_collections+default-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-fallible_collections+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fallible_collections+default-devel}"
SRC_URI[aarch64_rust-fallible_collections+default-devel.sha256sum] = "ae2feeca686017b3231f84814fa25c42a28a2139f1b55de642339329eedb1bcb"

URI_aarch64_rust-fallible_collections+hashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fallible_collections+hashmap-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-fallible_collections+hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fallible_collections+hashmap-devel}"
SRC_URI[aarch64_rust-fallible_collections+hashmap-devel.sha256sum] = "ccd98a9c0dc7be8e79b27e1cd429b36ce3310f04bc0e863094e95dd8e68c8e9c"

URI_aarch64_rust-fallible_collections+rust_1_57-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fallible_collections+rust_1_57-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-fallible_collections+rust_1_57-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fallible_collections+rust_1_57-devel}"
SRC_URI[aarch64_rust-fallible_collections+rust_1_57-devel.sha256sum] = "e94d5c60a45a8a01acb62de0a4764c318f880f6d80d38290f454550f89123a3c"

URI_aarch64_rust-fallible_collections+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fallible_collections+std-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-fallible_collections+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fallible_collections+std-devel}"
SRC_URI[aarch64_rust-fallible_collections+std-devel.sha256sum] = "2ebe2aeee582078575e0fe38b1ae86b1ef413eb96725554756e32bd300d8ed7b"

URI_aarch64_rust-fallible_collections+std_io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fallible_collections+std_io-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-fallible_collections+std_io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fallible_collections+std_io-devel}"
SRC_URI[aarch64_rust-fallible_collections+std_io-devel.sha256sum] = "4c4286984b05465f70d198a7831f57cd6471965bd44216525f22de1187edd7ae"

URI_aarch64_rust-fallible_collections+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fallible_collections+unstable-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-fallible_collections+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fallible_collections+unstable-devel}"
SRC_URI[aarch64_rust-fallible_collections+unstable-devel.sha256sum] = "06d4047b4b1619a24063fa16e889114c3c719f4c06df07bf9eca597136f3e020"

URI_aarch64_rust-fallible_collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fallible_collections-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-fallible_collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fallible_collections-devel}"
SRC_URI[aarch64_rust-fallible_collections-devel.sha256sum] = "fe3a8d158851174f519cba04b1f939e2079c0c3f4addb06e733781c9a83e8940"

RDEPENDS:rust-fallible_collections+default-devel = " \
 cargo \
 rust-fallible_collections+hashmap-devel \
 rust-fallible_collections-devel \
 "
RDEPENDS:rust-fallible_collections+hashmap-devel = " \
 cargo \
 rust-fallible_collections-devel \
 rust-hashbrown0.14+default-devel \
 "
RDEPENDS:rust-fallible_collections+rust_1_57-devel = " \
 cargo \
 rust-fallible_collections-devel \
 "
RDEPENDS:rust-fallible_collections+std-devel = " \
 cargo \
 rust-fallible_collections-devel \
 "
RDEPENDS:rust-fallible_collections+std_io-devel = " \
 cargo \
 rust-fallible_collections+std-devel \
 rust-fallible_collections-devel \
 "
RDEPENDS:rust-fallible_collections+unstable-devel = " \
 cargo \
 rust-fallible_collections-devel \
 "
RDEPENDS:rust-fallible_collections-devel = " \
 cargo \
 rust \
 "
