# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tera"
PV = "1.20.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-tera+builtins-devel \
 rust-tera+chrono-devel \
 rust-tera+chrono-tz-devel \
 rust-tera+date-locale-devel \
 rust-tera+default-devel \
 rust-tera+humansize-devel \
 rust-tera+percent-encoding-devel \
 rust-tera+preserve_order-devel \
 rust-tera+rand-devel \
 rust-tera+slug-devel \
 rust-tera+urlencode-devel \
 rust-tera-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tera-1.20.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "065643daa9d9aead192b09ee29e42551a000aa922dc9b69b9f59e8cb04eb368f"

URI_x86_64_v2_rust-tera+builtins-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+builtins-devel-1.20.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+builtins-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+builtins-devel}"
SRC_URI[x86_64_v2_rust-tera+builtins-devel.sha256sum] = "46da6e4b84c20de84cb599876972a761095d197ebe103475f4e52d8ab63dd017"

URI_x86_64_v2_rust-tera+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+chrono-devel-1.20.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+chrono-devel}"
SRC_URI[x86_64_v2_rust-tera+chrono-devel.sha256sum] = "678e80fcb6fd4661f7949832b14e207bb5a3f5382b66b543f791fc38703d6389"

URI_x86_64_v2_rust-tera+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+chrono-tz-devel-1.20.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-tera+chrono-tz-devel.sha256sum] = "30974257aa27d4f1ee898c676ea6bb9ae4e26d75408a104c097bf2f48b143af8"

URI_x86_64_v2_rust-tera+date-locale-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+date-locale-devel-1.20.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+date-locale-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+date-locale-devel}"
SRC_URI[x86_64_v2_rust-tera+date-locale-devel.sha256sum] = "b0b462cbc25e9d88a75999271e91401992bdbe207909df601081e3effc6d38d3"

URI_x86_64_v2_rust-tera+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+default-devel-1.20.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+default-devel}"
SRC_URI[x86_64_v2_rust-tera+default-devel.sha256sum] = "b994d7c08d3609eeee5282a26c1befe2efa20f66acded85b1aaf742ac12b186a"

URI_x86_64_v2_rust-tera+humansize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+humansize-devel-1.20.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+humansize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+humansize-devel}"
SRC_URI[x86_64_v2_rust-tera+humansize-devel.sha256sum] = "34db1cda8943266da24972dee54c44ebee9623b7e0a9f2fae1b12acaeaf68994"

URI_x86_64_v2_rust-tera+percent-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+percent-encoding-devel-1.20.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+percent-encoding-devel}"
SRC_URI[x86_64_v2_rust-tera+percent-encoding-devel.sha256sum] = "242df16a652b9d3c4a3d4d937886c2068bb0e418b90ae70e1e26166e03e8ea3c"

URI_x86_64_v2_rust-tera+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+preserve_order-devel-1.20.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-tera+preserve_order-devel.sha256sum] = "cc1a71e9df06fa24f7e6877c70ee2adada3c168cc4b38a8b34382fc73466bcda"

URI_x86_64_v2_rust-tera+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+rand-devel-1.20.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+rand-devel}"
SRC_URI[x86_64_v2_rust-tera+rand-devel.sha256sum] = "5b24828f7440ddf53cd38d3d3190b473db39c21d13563ee0b1ad4a38ec45668d"

URI_x86_64_v2_rust-tera+slug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+slug-devel-1.20.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+slug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+slug-devel}"
SRC_URI[x86_64_v2_rust-tera+slug-devel.sha256sum] = "02d003d83716dda355942c035a6a4f997e3cb371805c63790024358e04902f83"

URI_x86_64_v2_rust-tera+urlencode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+urlencode-devel-1.20.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+urlencode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+urlencode-devel}"
SRC_URI[x86_64_v2_rust-tera+urlencode-devel.sha256sum] = "d0a8b72151c4ea769abe47da736b580c7e4e6a3e5708a7bf648ac3a0077ac47c"

URI_x86_64_v2_rust-tera-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera-devel-1.20.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera-devel}"
SRC_URI[x86_64_v2_rust-tera-devel.sha256sum] = "74aef89c4fa8e868bb69a9651fed58b45d6dc507031eb1f73bcfec778f45fb6a"

URI_aarch64_rust-tera+builtins-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+builtins-devel-1.20.1-1.el10_1.noarch.rpm;name=aarch64_rust-tera+builtins-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+builtins-devel}"
SRC_URI[aarch64_rust-tera+builtins-devel.sha256sum] = "5c55ffd882a8b46feb6a601242b5231943a784f8f4d82d7e12d14565f641e907"

URI_aarch64_rust-tera+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+chrono-devel-1.20.1-1.el10_1.noarch.rpm;name=aarch64_rust-tera+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+chrono-devel}"
SRC_URI[aarch64_rust-tera+chrono-devel.sha256sum] = "e38a43ac2ecf2a7ac8a054be556921768c9200af11e9eff62016b23b260f0283"

URI_aarch64_rust-tera+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+chrono-tz-devel-1.20.1-1.el10_1.noarch.rpm;name=aarch64_rust-tera+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+chrono-tz-devel}"
SRC_URI[aarch64_rust-tera+chrono-tz-devel.sha256sum] = "84a52372fb5c2cca9bb7b9cd3573f784c5201476b1792e17c9fd3797d092cb83"

URI_aarch64_rust-tera+date-locale-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+date-locale-devel-1.20.1-1.el10_1.noarch.rpm;name=aarch64_rust-tera+date-locale-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+date-locale-devel}"
SRC_URI[aarch64_rust-tera+date-locale-devel.sha256sum] = "3218c58a659c904db782ef0885b560734ff6c6c2ac5f96506bf81599725a2ddf"

URI_aarch64_rust-tera+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+default-devel-1.20.1-1.el10_1.noarch.rpm;name=aarch64_rust-tera+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+default-devel}"
SRC_URI[aarch64_rust-tera+default-devel.sha256sum] = "1d16e491c396b1caca461751bcce82e12a25830404cc8ce7a0c55fa6af105fd8"

URI_aarch64_rust-tera+humansize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+humansize-devel-1.20.1-1.el10_1.noarch.rpm;name=aarch64_rust-tera+humansize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+humansize-devel}"
SRC_URI[aarch64_rust-tera+humansize-devel.sha256sum] = "16227df987487c1ac5903848d83d77346a800ac0657a39201daf9a1d63cb44c5"

URI_aarch64_rust-tera+percent-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+percent-encoding-devel-1.20.1-1.el10_1.noarch.rpm;name=aarch64_rust-tera+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+percent-encoding-devel}"
SRC_URI[aarch64_rust-tera+percent-encoding-devel.sha256sum] = "abc7234c1bb197a8aeb7434e2738b5579a6024719ab0f9e881c1a8b17688d2c6"

URI_aarch64_rust-tera+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+preserve_order-devel-1.20.1-1.el10_1.noarch.rpm;name=aarch64_rust-tera+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+preserve_order-devel}"
SRC_URI[aarch64_rust-tera+preserve_order-devel.sha256sum] = "cda70903a9d912ec6a3a2db4d5afac3d92ea6395f59eccf947b74647aa7385e9"

URI_aarch64_rust-tera+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+rand-devel-1.20.1-1.el10_1.noarch.rpm;name=aarch64_rust-tera+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+rand-devel}"
SRC_URI[aarch64_rust-tera+rand-devel.sha256sum] = "4581dcda96054ec36e94700bc48b91d85bebddc38979f29b312e4ac6621a77b7"

URI_aarch64_rust-tera+slug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+slug-devel-1.20.1-1.el10_1.noarch.rpm;name=aarch64_rust-tera+slug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+slug-devel}"
SRC_URI[aarch64_rust-tera+slug-devel.sha256sum] = "b574f5a85ef9de49cc7e268e5abfab478ef25644d6fb6da52f6a5fa22b9477ab"

URI_aarch64_rust-tera+urlencode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+urlencode-devel-1.20.1-1.el10_1.noarch.rpm;name=aarch64_rust-tera+urlencode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+urlencode-devel}"
SRC_URI[aarch64_rust-tera+urlencode-devel.sha256sum] = "8f23eb1f35e4012d6beb4a52998b890dd13ba232b3170dbe3af4b784b70fe935"

URI_aarch64_rust-tera-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera-devel-1.20.1-1.el10_1.noarch.rpm;name=aarch64_rust-tera-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera-devel}"
SRC_URI[aarch64_rust-tera-devel.sha256sum] = "523d21d97cd4b25fad7035c71673952370888d0cdb2fc1c8be0aa026c0479b80"

RDEPENDS:rust-tera+builtins-devel = " \
 cargo \
 rust-tera+chrono-devel \
 rust-tera+chrono-tz-devel \
 rust-tera+humansize-devel \
 rust-tera+rand-devel \
 rust-tera+slug-devel \
 rust-tera+urlencode-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz+default-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+date-locale-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono+unstable-locales-devel \
 rust-chrono-devel \
 rust-tera+builtins-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+default-devel = " \
 cargo \
 rust-tera+builtins-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+humansize-devel = " \
 cargo \
 rust-humansize+default-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+percent-encoding-devel = " \
 cargo \
 rust-percent-encoding+default-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+preserve_order-devel = " \
 cargo \
 rust-serde_json+preserve_order-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+rand-devel = " \
 cargo \
 rust-rand0.8+default-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+slug-devel = " \
 cargo \
 rust-slug+default-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+urlencode-devel = " \
 cargo \
 rust-tera+percent-encoding-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera-devel = " \
 cargo \
 rust \
 rust-globwalk+default-devel \
 rust-lazy_static+default-devel \
 rust-pest+default-devel \
 rust-pest_derive+default-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 rust-unicode-segmentation+default-devel \
 "
