# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bacula"
PV = "15.0.3"
PR = "2.el10_0"
PACKAGES = " \
 bacula-client \
 bacula-common \
 bacula-console \
 bacula-console-bat \
 bacula-devel \
 bacula-director \
 bacula-libs \
 bacula-libs-sql \
 bacula-logwatch \
 bacula-storage \
 bacula-traymonitor \
 nagios-plugins-bacula \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bacula-15.0.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0a25e1fd7010cad2e4b2b46a6e36dfff0d491530e86d4bb334ba7ba1a786618"

URI_x86_64_v2_bacula-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-client-15.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-client}"
SRC_URI[x86_64_v2_bacula-client.sha256sum] = "5563c1b8897a164b4cd57f4ce1faf4098eed00b9e7f427354cada2cacd1ff62f"

URI_x86_64_v2_bacula-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-common-15.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-common}"
SRC_URI[x86_64_v2_bacula-common.sha256sum] = "8b1c2544a8c7a3fbb3b91e23b7a885be9a02556668b348dbf75822547b6ec0e9"

URI_x86_64_v2_bacula-console = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-console-15.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-console;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-console}"
SRC_URI[x86_64_v2_bacula-console.sha256sum] = "5ac698577237fc10a96da8dd2bad211d9c5141f7320aafe1f1c6db733f6a91ef"

URI_x86_64_v2_bacula-console-bat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-console-bat-15.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-console-bat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-console-bat}"
SRC_URI[x86_64_v2_bacula-console-bat.sha256sum] = "875e6ae9975d5a465a6224382994905f04d33e0fac841d84db91f38c6c663a07"

URI_x86_64_v2_bacula-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-devel-15.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-devel}"
SRC_URI[x86_64_v2_bacula-devel.sha256sum] = "f9fe6719ff1ae260cc4b945c31c43b5de22b4b7f126bc752a3ad6d60b0a95a1e"

URI_x86_64_v2_bacula-director = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-director-15.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-director;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-director}"
SRC_URI[x86_64_v2_bacula-director.sha256sum] = "c97e46f056a700dc083aa4e5c129e8abb43b0eb7b28108d08a8634bf67296f7e"

URI_x86_64_v2_bacula-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-libs-15.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-libs}"
SRC_URI[x86_64_v2_bacula-libs.sha256sum] = "107e80f287c6ccc672f08e8747935571d0fc85bba105140cd6b32b49f0de7875"

URI_x86_64_v2_bacula-libs-sql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-libs-sql-15.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-libs-sql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-libs-sql}"
SRC_URI[x86_64_v2_bacula-libs-sql.sha256sum] = "6a01da4513cf184d2584a3f3f5f54c1a2b2ba71ec340fff5ea0966bf1f65ffc6"

URI_x86_64_v2_bacula-logwatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-logwatch-15.0.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bacula-logwatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-logwatch}"
SRC_URI[x86_64_v2_bacula-logwatch.sha256sum] = "b34c8e87d0667ee81daa4a437d6e31683130c590549240959e5921f9fd7cc473"

URI_x86_64_v2_bacula-storage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-storage-15.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-storage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-storage}"
SRC_URI[x86_64_v2_bacula-storage.sha256sum] = "df9d39f54383e1e4667bac5d34240e26ba97b41e1f079d9e3ed9e6422276d4ba"

URI_x86_64_v2_bacula-traymonitor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-traymonitor-15.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-traymonitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-traymonitor}"
SRC_URI[x86_64_v2_bacula-traymonitor.sha256sum] = "e29aa71a0c81e5fb36a9ea4a30a2353c3938635b4dddd980e5ce2e2647a94ea1"

URI_x86_64_v2_nagios-plugins-bacula = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-bacula-15.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-bacula;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-bacula}"
SRC_URI[x86_64_v2_nagios-plugins-bacula.sha256sum] = "1b65e8b9a47112ffe3eb25662b2e3f17a3b6aee69c5221b2def7ea87b2f84f43"

URI_aarch64_bacula-client = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-client-15.0.3-2.el10_0.aarch64.rpm;name=aarch64_bacula-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-client}"
SRC_URI[aarch64_bacula-client.sha256sum] = "e76223a7c7dfda938ff5afef43f0bdb4b678c82b2557da4889030733893bcf30"

URI_aarch64_bacula-common = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-common-15.0.3-2.el10_0.aarch64.rpm;name=aarch64_bacula-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-common}"
SRC_URI[aarch64_bacula-common.sha256sum] = "eae678b3a8ceeef75e91ad5ead8637db282a25173ff88eba51ede6ec2383d347"

URI_aarch64_bacula-console = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-console-15.0.3-2.el10_0.aarch64.rpm;name=aarch64_bacula-console;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-console}"
SRC_URI[aarch64_bacula-console.sha256sum] = "e77a1d026e7a87f6d794a92daf686d94329ac5b27880e69ffeca185b9626296a"

URI_aarch64_bacula-console-bat = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-console-bat-15.0.3-2.el10_0.aarch64.rpm;name=aarch64_bacula-console-bat;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-console-bat}"
SRC_URI[aarch64_bacula-console-bat.sha256sum] = "6ba4d5eeb4933d8a859cc27ed29a20338981890907a163b6a1fc6caca3c8dcb4"

URI_aarch64_bacula-devel = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-devel-15.0.3-2.el10_0.aarch64.rpm;name=aarch64_bacula-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-devel}"
SRC_URI[aarch64_bacula-devel.sha256sum] = "473f4f9e9836bc5338c3cca09e5bc19e44183d208f743a7647bbbb6883573e1b"

URI_aarch64_bacula-director = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-director-15.0.3-2.el10_0.aarch64.rpm;name=aarch64_bacula-director;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-director}"
SRC_URI[aarch64_bacula-director.sha256sum] = "777d49ad2e4ad6769457be9a16bc8fc3121510c7466d9b8d5c608084a555fac2"

URI_aarch64_bacula-libs = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-libs-15.0.3-2.el10_0.aarch64.rpm;name=aarch64_bacula-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-libs}"
SRC_URI[aarch64_bacula-libs.sha256sum] = "0b6f531472000b1302b533e304c95667cd15d1a1a109d5e597c959f0c98ba9d3"

URI_aarch64_bacula-libs-sql = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-libs-sql-15.0.3-2.el10_0.aarch64.rpm;name=aarch64_bacula-libs-sql;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-libs-sql}"
SRC_URI[aarch64_bacula-libs-sql.sha256sum] = "a74fa370c890f71930958e447d5712460af1a0980373649c0436b30b34527edd"

URI_aarch64_bacula-logwatch = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-logwatch-15.0.3-2.el10_0.noarch.rpm;name=aarch64_bacula-logwatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-logwatch}"
SRC_URI[aarch64_bacula-logwatch.sha256sum] = "1bd7b316a40f570d65e57b513c38eab72863beb656c486919db9d64d5d8d2476"

URI_aarch64_bacula-storage = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-storage-15.0.3-2.el10_0.aarch64.rpm;name=aarch64_bacula-storage;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-storage}"
SRC_URI[aarch64_bacula-storage.sha256sum] = "e7ea171d46650d7ff969b380d5f148739a10f172a6747788de67e45c80053f02"

URI_aarch64_bacula-traymonitor = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-traymonitor-15.0.3-2.el10_0.aarch64.rpm;name=aarch64_bacula-traymonitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-traymonitor}"
SRC_URI[aarch64_bacula-traymonitor.sha256sum] = "0f1802ddf9e760ca0cc7b0b35e955248ce15984e97074b1e84f314395a70786a"

URI_aarch64_nagios-plugins-bacula = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-bacula-15.0.3-2.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-bacula;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-bacula}"
SRC_URI[aarch64_nagios-plugins-bacula.sha256sum] = "24c79103c9cd48d5c1a485fb802a786f2a840f0a4368082b831bd86d0471e8bc"

RDEPENDS:bacula-client = " \
 bacula-common \
 bacula-libs \
 bash \
 glibc \
 libacl \
 libgcc \
 libstdc++ \
 libzstd \
 lzo \
 systemd \
 zlib-ng-compat \
 "
RDEPENDS:bacula-common = " \
 bacula-libs \
 bash \
 shadow-utils \
 "
RDEPENDS:bacula-console = " \
 bacula-libs \
 glibc \
 libgcc \
 libstdc++ \
 readline \
 "
RDEPENDS:bacula-console-bat = " \
 bacula-libs \
 dejavu-lgc-sans-fonts \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:bacula-devel = " \
 bacula-libs \
 bacula-libs-sql \
 "
RDEPENDS:bacula-director = " \
 bacula-common \
 bacula-libs \
 bacula-libs-sql \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 openldap \
 openssl-libs \
 perl-Fcntl \
 perl-File-Basename \
 perl-interpreter \
 perl-libs \
 python3 \
 systemd \
 "
RDEPENDS:bacula-libs = " \
 glibc \
 libcap \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:bacula-libs-sql = " \
 bash \
 glibc \
 libgcc \
 libpq \
 libstdc++ \
 libxcrypt \
 mariadb-connector-c \
 sqlite-libs \
 "
RDEPENDS:bacula-logwatch = " \
 bacula-director \
 logwatch \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:bacula-storage = " \
 bacula-common \
 bacula-libs \
 bacula-libs-sql \
 bash \
 glibc \
 libcap \
 libgcc \
 libstdc++ \
 libzstd \
 lzo \
 mt-st \
 mtx \
 sdparm \
 systemd \
 zlib-ng-compat \
 "
RDEPENDS:bacula-traymonitor = " \
 bacula-libs \
 dejavu-lgc-sans-fonts \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:nagios-plugins-bacula = " \
 bacula-libs \
 glibc \
 nagios-common \
 "
