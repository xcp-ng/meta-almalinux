# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-c-sharp"
PV = "0.23.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-c-sharp+default-devel \
 rust-tree-sitter-c-sharp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-c-sharp-0.23.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12ec85b50edacce1de52f2257d478319e616643500e0db125d6d567da226ffd2"

URI_x86_64_v2_rust-tree-sitter-c-sharp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-c-sharp+default-devel-0.23.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-c-sharp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-c-sharp+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-c-sharp+default-devel.sha256sum] = "370618ca6c006b7a940a3988288b6d7cb5e5a2c62592b8dc6c9461a9a15ae958"

URI_x86_64_v2_rust-tree-sitter-c-sharp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-c-sharp-devel-0.23.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-c-sharp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-c-sharp-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-c-sharp-devel.sha256sum] = "4806e3137625289e0328f69dfa03cba5e0b3f301fd1764c1e63ed242ee2caaed"

URI_aarch64_rust-tree-sitter-c-sharp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-c-sharp+default-devel-0.23.5-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-c-sharp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-c-sharp+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-c-sharp+default-devel.sha256sum] = "095042632d364a03fd89613a22df5c60835db0378a8796189bc9da049fe96e74"

URI_aarch64_rust-tree-sitter-c-sharp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-c-sharp-devel-0.23.5-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-c-sharp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-c-sharp-devel}"
SRC_URI[aarch64_rust-tree-sitter-c-sharp-devel.sha256sum] = "2ef6dcb0092e03ae051d066808b4a14c57a62b44170a205518a6a60ca4d16bf1"

RDEPENDS:rust-tree-sitter-c-sharp+default-devel = " \
 cargo \
 rust-tree-sitter-c-sharp-devel \
 "
RDEPENDS:rust-tree-sitter-c-sharp-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
