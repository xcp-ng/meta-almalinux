# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cli11"
PV = "2.5.0"
PR = "1.el10_0"
PACKAGES = " \
 cli11-devel \
 cli11-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cli11-2.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e219a7d126e24bec5d22e59c12b5b334956a17ff83a032a06741dd57e4b6a3c"

URI_x86_64_v2_cli11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cli11-devel-2.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_cli11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cli11-devel}"
SRC_URI[x86_64_v2_cli11-devel.sha256sum] = "8d290c66da1749765b757e4f53712ef70036b3d3a3986d3c130c32c9d2051f7d"

URI_x86_64_v2_cli11-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cli11-docs-2.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_cli11-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cli11-docs}"
SRC_URI[x86_64_v2_cli11-docs.sha256sum] = "3590bc3cf2507841b80aca368be526a979d2528553aef1ba00b6f049c41ee2f4"

URI_aarch64_cli11-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cli11-devel-2.5.0-1.el10_0.noarch.rpm;name=aarch64_cli11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cli11-devel}"
SRC_URI[aarch64_cli11-devel.sha256sum] = "a708877c950cdc062b61f48c87e5983d5e96265fe6779cd864bd3700926e005e"

URI_aarch64_cli11-docs = "${EPEL_MIRROR}/aarch64/Packages/c/cli11-docs-2.5.0-1.el10_0.noarch.rpm;name=aarch64_cli11-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cli11-docs}"
SRC_URI[aarch64_cli11-docs.sha256sum] = "76f8a50a2a1fa6a5b06f7301eb55da4b6e2d29b6c39575870b44700e6aebf1ae"

RDEPENDS:cli11-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:cli11-docs = " \
 "
