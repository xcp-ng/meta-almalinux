# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ocean-sound-theme"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 ocean-sound-theme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/ocean-sound-theme-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a3467e5e60726d554fbeaf435b6a60d446eb20c060657f60e44539a62f208d5"

URI_x86_64_v2_ocean-sound-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ocean-sound-theme-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ocean-sound-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocean-sound-theme}"
SRC_URI[x86_64_v2_ocean-sound-theme.sha256sum] = "007d61d175253ed98e6b2ce52df81c81201d451a90cfa6c9ea5def01bbbe4778"

URI_aarch64_ocean-sound-theme = "${EPEL_MIRROR}/aarch64/Packages/o/ocean-sound-theme-6.3.6-1.el10_0.noarch.rpm;name=aarch64_ocean-sound-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocean-sound-theme}"
SRC_URI[aarch64_ocean-sound-theme.sha256sum] = "c90c7fca8eb44f145b101afc81d820a9b26da8e351c1f169d42a8d57c5ac4a17"

RDEPENDS:ocean-sound-theme = " \
 kf6-filesystem \
 "
