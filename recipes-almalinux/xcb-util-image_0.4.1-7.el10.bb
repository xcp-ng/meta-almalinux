# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xcb-util-image"
PV = "0.4.1"
PR = "7.el10"
PACKAGES = " \
 xcb-util-image \
 xcb-util-image-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xcb-util-image-0.4.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1dde9c72cbfbb93e6bbd7c4edbf0829d59457e0210931153bfb979ffade461e7"

URI_x86_64_v2_xcb-util-image = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xcb-util-image-0.4.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_xcb-util-image;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xcb-util-image}"
SRC_URI[x86_64_v2_xcb-util-image.sha256sum] = "181893ac6ce831141869a79253526881cbba5e02b613079295b0d817cdef5d72"

URI_x86_64_v2_xcb-util-image-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xcb-util-image-devel-0.4.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_xcb-util-image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xcb-util-image-devel}"
SRC_URI[x86_64_v2_xcb-util-image-devel.sha256sum] = "3cfa8ca61232bd0edd746476de3cde293d26bb35d34fcb910047880b5153d057"

URI_aarch64_xcb-util-image = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xcb-util-image-0.4.1-7.el10.aarch64.rpm;name=aarch64_xcb-util-image;unpack=0"
SRC_URI:append = " ${URI_aarch64_xcb-util-image}"
SRC_URI[aarch64_xcb-util-image.sha256sum] = "a8d7509c394f7ff4e2d65f8ab8c0793856daaa39449dfff445ee9918bfa07340"

URI_aarch64_xcb-util-image-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xcb-util-image-devel-0.4.1-7.el10.aarch64.rpm;name=aarch64_xcb-util-image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xcb-util-image-devel}"
SRC_URI[aarch64_xcb-util-image-devel.sha256sum] = "72f9ffb96958988e604d93376dabd841cd52faeab92449b7c45ee2e9724ea1eb"

RDEPENDS:xcb-util-image = " \
 glibc \
 libxcb \
 xcb-util \
 "
RDEPENDS:xcb-util-image-devel = " \
 libxcb-devel \
 pkgconf-pkg-config \
 xcb-util-image \
 "
