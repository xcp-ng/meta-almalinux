# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rpki"
PV = "0.19.3"
PR = "2.el10_3"
PACKAGES = " \
 rpki \
 rust-rpki+__windows_ci_all-devel \
 rust-rpki+arbitrary-devel \
 rust-rpki+bcder-devel \
 rust-rpki+ca-devel \
 rust-rpki+compat-devel \
 rust-rpki+crypto-devel \
 rust-rpki+default-devel \
 rust-rpki+futures-util-devel \
 rust-rpki+openssl-devel \
 rust-rpki+quick-xml-devel \
 rust-rpki+repository-devel \
 rust-rpki+ring-devel \
 rust-rpki+rrdp-devel \
 rust-rpki+rtr-devel \
 rust-rpki+serde-devel \
 rust-rpki+serde-support-devel \
 rust-rpki+serde_json-devel \
 rust-rpki+slurm-devel \
 rust-rpki+softkeys-devel \
 rust-rpki+tokio-devel \
 rust-rpki+untrusted-devel \
 rust-rpki+xml-devel \
 rust-rpki-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rpki-0.19.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "503dc2a1cb8407f65b4a8567b66b3a645ab709a6b29cb40fccb8cbb7c5bd561c"

URI_x86_64_v2_rpki = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpki-0.19.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rpki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpki}"
SRC_URI[x86_64_v2_rpki.sha256sum] = "c3b63834f2f1fd9eebf1d359dea15a6f3e29ec24a80034de2b4794646cefc6a6"

URI_x86_64_v2_rust-rpki+__windows_ci_all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+__windows_ci_all-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+__windows_ci_all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+__windows_ci_all-devel}"
SRC_URI[x86_64_v2_rust-rpki+__windows_ci_all-devel.sha256sum] = "a22fb8df1bf10051cf3d22c4808ef866f20a2dad4679e2df5910fae6b512b945"

URI_x86_64_v2_rust-rpki+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+arbitrary-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-rpki+arbitrary-devel.sha256sum] = "eca52f614998524d44538a906f958b79bd33ad3960fe94ba09bafd84e7841d16"

URI_x86_64_v2_rust-rpki+bcder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+bcder-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+bcder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+bcder-devel}"
SRC_URI[x86_64_v2_rust-rpki+bcder-devel.sha256sum] = "96bb7cc715a9eaf80e874a7ff1394df310fd90ec5304e61cdc49c32215b813fe"

URI_x86_64_v2_rust-rpki+ca-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+ca-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+ca-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+ca-devel}"
SRC_URI[x86_64_v2_rust-rpki+ca-devel.sha256sum] = "83e8ec7c5043d5e51e9b276ebc0774f15f41d307543bee006353c2529e78db1d"

URI_x86_64_v2_rust-rpki+compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+compat-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+compat-devel}"
SRC_URI[x86_64_v2_rust-rpki+compat-devel.sha256sum] = "a1e462f5207e1ec7e442cf362e8ec0aa42e9f95a44b62688afb5701c1812712c"

URI_x86_64_v2_rust-rpki+crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+crypto-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+crypto-devel}"
SRC_URI[x86_64_v2_rust-rpki+crypto-devel.sha256sum] = "20689c9fc3e2068b07dd8a6b2be017887d4a6e5c23ef138343ed324085a2c0ab"

URI_x86_64_v2_rust-rpki+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+default-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+default-devel}"
SRC_URI[x86_64_v2_rust-rpki+default-devel.sha256sum] = "7b8b10e9dda3efbd4c44980d7afe78f1f88c77a362343eb8979976865d8c204b"

URI_x86_64_v2_rust-rpki+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+futures-util-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+futures-util-devel}"
SRC_URI[x86_64_v2_rust-rpki+futures-util-devel.sha256sum] = "4f8570230500f6a31b9479c6f5ece2c99344f4816d69d1cad86e8787072b919f"

URI_x86_64_v2_rust-rpki+openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+openssl-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+openssl-devel}"
SRC_URI[x86_64_v2_rust-rpki+openssl-devel.sha256sum] = "73baac4899d61e3a5f517fd373e22866b09481bada103f3763301fd48d1d7e1c"

URI_x86_64_v2_rust-rpki+quick-xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+quick-xml-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+quick-xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+quick-xml-devel}"
SRC_URI[x86_64_v2_rust-rpki+quick-xml-devel.sha256sum] = "fff6dc279a688298af234f70728395119c2b1a9ad3879f5bc98bfe7842c67f64"

URI_x86_64_v2_rust-rpki+repository-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+repository-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+repository-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+repository-devel}"
SRC_URI[x86_64_v2_rust-rpki+repository-devel.sha256sum] = "763c13a2beb61895efc9a3e874cd4e1dda7b88adf1a13e0a4c929d4b88ece201"

URI_x86_64_v2_rust-rpki+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+ring-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+ring-devel}"
SRC_URI[x86_64_v2_rust-rpki+ring-devel.sha256sum] = "b46521e80019ecbfc8f648d169c1cbf63fb059951cea77b4b008716e1838d2ca"

URI_x86_64_v2_rust-rpki+rrdp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+rrdp-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+rrdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+rrdp-devel}"
SRC_URI[x86_64_v2_rust-rpki+rrdp-devel.sha256sum] = "ef84036526d34a8f86de30d6856c906bb3321f82dd5ca56550a0f4df1a5d75bb"

URI_x86_64_v2_rust-rpki+rtr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+rtr-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+rtr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+rtr-devel}"
SRC_URI[x86_64_v2_rust-rpki+rtr-devel.sha256sum] = "d1f1b0064b218bc1110faafe33abfd8aed5f1d88986013b2742d3747860a9000"

URI_x86_64_v2_rust-rpki+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+serde-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+serde-devel}"
SRC_URI[x86_64_v2_rust-rpki+serde-devel.sha256sum] = "54fd4076cbcd4ea0c179a5221c13cfc08b2f1c8b7fa4ac5b5e2842a2c1620c91"

URI_x86_64_v2_rust-rpki+serde-support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+serde-support-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+serde-support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+serde-support-devel}"
SRC_URI[x86_64_v2_rust-rpki+serde-support-devel.sha256sum] = "7a008cb0ea8820c38ce7b10bc0af394119de63c940a6dd66ea855cdaa2848c81"

URI_x86_64_v2_rust-rpki+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+serde_json-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+serde_json-devel}"
SRC_URI[x86_64_v2_rust-rpki+serde_json-devel.sha256sum] = "35a8fe12f27265954745b3957cca861f197ad5c2c3ff5bb9740d56846d188f9c"

URI_x86_64_v2_rust-rpki+slurm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+slurm-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+slurm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+slurm-devel}"
SRC_URI[x86_64_v2_rust-rpki+slurm-devel.sha256sum] = "6a24f5dfd97ce1043879bd6eb55ddf42b53f6bb93f5a92dce5915d9ad381d751"

URI_x86_64_v2_rust-rpki+softkeys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+softkeys-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+softkeys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+softkeys-devel}"
SRC_URI[x86_64_v2_rust-rpki+softkeys-devel.sha256sum] = "e263fd92b9f82477a8ea860b5aa32377a675d31c26cd0eb3d0e42c3d4a7f4010"

URI_x86_64_v2_rust-rpki+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+tokio-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+tokio-devel}"
SRC_URI[x86_64_v2_rust-rpki+tokio-devel.sha256sum] = "ec907f07fc766a1f55c113ff90f361a4507164aeac2a0519ce08ef9ed7cab2c7"

URI_x86_64_v2_rust-rpki+untrusted-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+untrusted-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+untrusted-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+untrusted-devel}"
SRC_URI[x86_64_v2_rust-rpki+untrusted-devel.sha256sum] = "24630eef7ffefd671246d337dd0c8d80de5ad3ba0befd5fadd1be17594421b6c"

URI_x86_64_v2_rust-rpki+xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+xml-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+xml-devel}"
SRC_URI[x86_64_v2_rust-rpki+xml-devel.sha256sum] = "12d40d16554dd7dee7abcb3ecd5a97162419a36ebe8acdd85ab158b4200b47ab"

URI_x86_64_v2_rust-rpki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki-devel-0.19.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki-devel}"
SRC_URI[x86_64_v2_rust-rpki-devel.sha256sum] = "ecefd12b673039dd0bbd1f288c1a63304372b3be7bbe1ef2a268251c205eee65"

URI_aarch64_rpki = "${EPEL_MIRROR}/aarch64/Packages/r/rpki-0.19.3-2.el10_3.aarch64.rpm;name=aarch64_rpki;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpki}"
SRC_URI[aarch64_rpki.sha256sum] = "fae2c7963118234b01609d6fc2af821022d70d2660bcd5d992e72904bf177566"

URI_aarch64_rust-rpki+__windows_ci_all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+__windows_ci_all-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+__windows_ci_all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+__windows_ci_all-devel}"
SRC_URI[aarch64_rust-rpki+__windows_ci_all-devel.sha256sum] = "d7141e731795472f557f73b235c9f79d43f12d571df58b1b6b17c3f4b0d66fee"

URI_aarch64_rust-rpki+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+arbitrary-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+arbitrary-devel}"
SRC_URI[aarch64_rust-rpki+arbitrary-devel.sha256sum] = "4cdb62c4a3f52d86938f9d40eaaa2f47edd4be61f50cb2e8230593f149ef7947"

URI_aarch64_rust-rpki+bcder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+bcder-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+bcder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+bcder-devel}"
SRC_URI[aarch64_rust-rpki+bcder-devel.sha256sum] = "1fd54b21529a361a34ad1009bfdf669f08d821cff5066d154a20c0ebeab1ea20"

URI_aarch64_rust-rpki+ca-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+ca-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+ca-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+ca-devel}"
SRC_URI[aarch64_rust-rpki+ca-devel.sha256sum] = "0db8e9beb006f30d9f4bd4d33255547306495573a401992f005f7eb4fcb1f03c"

URI_aarch64_rust-rpki+compat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+compat-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+compat-devel}"
SRC_URI[aarch64_rust-rpki+compat-devel.sha256sum] = "d47241a92c5c5a25f91c6304eb44eef535dd4c64b83b5c8626fe76866f8b497e"

URI_aarch64_rust-rpki+crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+crypto-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+crypto-devel}"
SRC_URI[aarch64_rust-rpki+crypto-devel.sha256sum] = "8ca594c2343a52167c24b272aa55c1140bb3ba7f526c81cac326a6b3fe6e0807"

URI_aarch64_rust-rpki+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+default-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+default-devel}"
SRC_URI[aarch64_rust-rpki+default-devel.sha256sum] = "9184fac755fe383069a61528b4be68961b7e6cb9b6f23cae2db204080d043d23"

URI_aarch64_rust-rpki+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+futures-util-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+futures-util-devel}"
SRC_URI[aarch64_rust-rpki+futures-util-devel.sha256sum] = "a8e6451f49fbb1825ea35287cbcc0e1986ecfba58aa13c589cac8dc7746ba17b"

URI_aarch64_rust-rpki+openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+openssl-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+openssl-devel}"
SRC_URI[aarch64_rust-rpki+openssl-devel.sha256sum] = "80055e794a45fc50461e32ee779fc30ea51d56be6ae468c9d90dd3610ed86af2"

URI_aarch64_rust-rpki+quick-xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+quick-xml-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+quick-xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+quick-xml-devel}"
SRC_URI[aarch64_rust-rpki+quick-xml-devel.sha256sum] = "ab9341eaab574b0a5375fe0ada3a14593312f8301f76a6b9f9bd2e474cce475b"

URI_aarch64_rust-rpki+repository-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+repository-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+repository-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+repository-devel}"
SRC_URI[aarch64_rust-rpki+repository-devel.sha256sum] = "e7a730918d1c7509903dc207dc53f0432edd9518ee904b505a5ab15468fc14db"

URI_aarch64_rust-rpki+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+ring-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+ring-devel}"
SRC_URI[aarch64_rust-rpki+ring-devel.sha256sum] = "f2958d7545d366f952e729df5b103d0f43a833f126a0c150e86159d633b57767"

URI_aarch64_rust-rpki+rrdp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+rrdp-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+rrdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+rrdp-devel}"
SRC_URI[aarch64_rust-rpki+rrdp-devel.sha256sum] = "69fd5ca09458c2d3ea1468baee51ed422840d5703bde4269f8afd2222d4f78a2"

URI_aarch64_rust-rpki+rtr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+rtr-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+rtr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+rtr-devel}"
SRC_URI[aarch64_rust-rpki+rtr-devel.sha256sum] = "35239ab6d9aba2249369dcfdc662a37505089620a165c6bf57d919203d1b2ab0"

URI_aarch64_rust-rpki+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+serde-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+serde-devel}"
SRC_URI[aarch64_rust-rpki+serde-devel.sha256sum] = "efc6287fe444b4bbd3fd2b95d031c4e98386e76f27f334be5aa2d56b8b8f1c82"

URI_aarch64_rust-rpki+serde-support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+serde-support-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+serde-support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+serde-support-devel}"
SRC_URI[aarch64_rust-rpki+serde-support-devel.sha256sum] = "9adba5c58e1b03b9138cf2026af1c7f30c9b2acc7716260150618379118c3c0e"

URI_aarch64_rust-rpki+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+serde_json-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+serde_json-devel}"
SRC_URI[aarch64_rust-rpki+serde_json-devel.sha256sum] = "3ce46d8a9c54b033219c04e14bc63e16516d545efd8c86ee6dfeee1547fbcae0"

URI_aarch64_rust-rpki+slurm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+slurm-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+slurm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+slurm-devel}"
SRC_URI[aarch64_rust-rpki+slurm-devel.sha256sum] = "9a6347226cdba5156c68c2b462d43370acc62efc8a68feb1ff4c9ed108aeeee4"

URI_aarch64_rust-rpki+softkeys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+softkeys-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+softkeys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+softkeys-devel}"
SRC_URI[aarch64_rust-rpki+softkeys-devel.sha256sum] = "94ede49b4fb94c1f1a7af1e1b15531de9351d0e82915da8072a9256995d0d95c"

URI_aarch64_rust-rpki+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+tokio-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+tokio-devel}"
SRC_URI[aarch64_rust-rpki+tokio-devel.sha256sum] = "fe3f6e2c8cf18295bb310c143d8c34446f56cc974d8cda671fe1f4c680af3552"

URI_aarch64_rust-rpki+untrusted-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+untrusted-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+untrusted-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+untrusted-devel}"
SRC_URI[aarch64_rust-rpki+untrusted-devel.sha256sum] = "c9a56cc2dba1b55cb534bd529b26af02b5ce2cddb7d64ed541374713643e3a89"

URI_aarch64_rust-rpki+xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+xml-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki+xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+xml-devel}"
SRC_URI[aarch64_rust-rpki+xml-devel.sha256sum] = "b1ae562d83fc39744e097dda0d9cb5a5a0f3ac2a07c2fb0a2fc139d7a3c3fcbe"

URI_aarch64_rust-rpki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki-devel-0.19.3-2.el10_3.noarch.rpm;name=aarch64_rust-rpki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki-devel}"
SRC_URI[aarch64_rust-rpki-devel.sha256sum] = "b23b3a560adac81851ab8461ef04c9cb71e3d9b2da70b30391b2783bfa559582"

RDEPENDS:rpki = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-rpki+__windows_ci_all-devel = " \
 cargo \
 rust-rpki+ca-devel \
 rust-rpki+rrdp-devel \
 rust-rpki+rtr-devel \
 rust-rpki+serde-support-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-chrono+arbitrary-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+bcder-devel = " \
 cargo \
 rust-bcder+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+ca-devel = " \
 cargo \
 rust-rpki+repository-devel \
 rust-rpki+rrdp-devel \
 rust-rpki+serde-support-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+compat-devel = " \
 cargo \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+crypto-devel = " \
 cargo \
 rust-rpki+bcder-devel \
 rust-rpki+ring-devel \
 rust-rpki+untrusted-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+default-devel = " \
 cargo \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+futures-util-devel = " \
 cargo \
 rust-futures-util+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+openssl-devel = " \
 cargo \
 rust-openssl+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+quick-xml-devel = " \
 cargo \
 rust-quick-xml+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+repository-devel = " \
 cargo \
 rust-rpki+bcder-devel \
 rust-rpki+crypto-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+ring-devel = " \
 cargo \
 rust-ring+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+rrdp-devel = " \
 cargo \
 rust-rpki+ring-devel \
 rust-rpki+xml-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+rtr-devel = " \
 cargo \
 rust-rpki+futures-util-devel \
 rust-rpki+tokio-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+serde-devel = " \
 cargo \
 rust-rpki-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rpki+serde-support-devel = " \
 cargo \
 rust-rpki+serde-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+serde_json-devel = " \
 cargo \
 rust-rpki-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-rpki+slurm-devel = " \
 cargo \
 rust-rpki+rtr-devel \
 rust-rpki+serde-support-devel \
 rust-rpki+serde_json-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+softkeys-devel = " \
 cargo \
 rust-rpki+openssl-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+tokio-devel = " \
 cargo \
 rust-rpki-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-rpki+untrusted-devel = " \
 cargo \
 rust-rpki-devel \
 rust-untrusted+default-devel \
 "
RDEPENDS:rust-rpki+xml-devel = " \
 cargo \
 rust-rpki+quick-xml-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki-devel = " \
 cargo \
 rust \
 rust-base64_0.22+default-devel \
 rust-bytes+default-devel \
 rust-chrono+default-devel \
 rust-chrono+serde-devel \
 rust-log+default-devel \
 rust-uuid+default-devel \
 "
