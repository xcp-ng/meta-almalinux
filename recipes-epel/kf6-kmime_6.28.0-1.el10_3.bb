# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kmime"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kmime \
 kf6-kmime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kmime-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06b7a3f4dd112e26eaefad6e02d659400844b7f873e628f880cc96659e1ca69e"

URI_x86_64_v2_kf6-kmime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kmime-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kmime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kmime}"
SRC_URI[x86_64_v2_kf6-kmime.sha256sum] = "ead9641dad3280728505227e952a74fd524e3d002ebb2d810e26818ed199a4b2"

URI_x86_64_v2_kf6-kmime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kmime-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kmime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kmime-devel}"
SRC_URI[x86_64_v2_kf6-kmime-devel.sha256sum] = "eed0801d17567a55822fe5eb359c58e3744ebe8b47f4778b0e356aa3fdb91fe9"

URI_aarch64_kf6-kmime = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kmime-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kmime;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kmime}"
SRC_URI[aarch64_kf6-kmime.sha256sum] = "c74c78fb4f2df4a807a92da040cdd1fb7612e1f4a6ee5d166287b56ac3379d09"

URI_aarch64_kf6-kmime-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kmime-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kmime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kmime-devel}"
SRC_URI[aarch64_kf6-kmime-devel.sha256sum] = "54a121047e5167971875cffa8eb967025754a593bbf0c7af026169b52459aa74"

RDEPENDS:kf6-kmime = " \
 glibc \
 kf6-kcodecs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kmime-devel = " \
 cmake-filesystem \
 kf6-kcodecs-devel \
 kf6-kmime \
 "
