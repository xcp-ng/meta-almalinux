# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-metrics"
PV = "0.24.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-metrics+default-devel \
 rust-metrics-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-metrics-0.24.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "977c4ce2b96b5c9c778c7d2109888eb84d39b5261da2f0a14722c0bec7574041"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics+default-devel-0.24.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics+default-devel.sha256sum] = "e802901d00b2c6146f2dabe49df9ebb5fda54b30523f0ce3fc973db4da9ea1f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-devel-0.24.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-devel.sha256sum] = "c5e28ad013fecec38ce3cc1e5d14ba0a735ec3b7aa044e58d0a1eb90be959bbe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics+default-devel-0.24.6-1.el10_3.noarch.rpm;name=aarch64_rust-metrics+default-devel;unpack=0"
SRC_URI[aarch64_rust-metrics+default-devel.sha256sum] = "33ed7529737d18711118da4460b0ebeb71b79e266eea357ce474dd0252ed2623"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-devel-0.24.6-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-devel.sha256sum] = "2d47f5a1656177058120701f9e0f91f507a3d5d98a38955c59ec49a7289549c9"

RDEPENDS:rust-metrics+default-devel = " \
 cargo \
 rust-metrics-devel \
 "
RDEPENDS:rust-metrics-devel = " \
 cargo \
 rust \
 rust-portable-atomic+fallback-devel \
 rust-portable-atomic-devel \
 rust-rapidhash-devel \
 "
