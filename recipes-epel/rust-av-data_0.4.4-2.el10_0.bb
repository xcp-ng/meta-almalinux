# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-av-data"
PV = "0.4.4"
PR = "2.el10_0"
PACKAGES = " \
 rust-av-data+default-devel \
 rust-av-data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-av-data-0.4.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17fe35a49779aba2692dcd1debed19afff171ca64939fbbc548c5d00a09b280d"

URI_x86_64_v2_rust-av-data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-data+default-devel-0.4.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-data+default-devel}"
SRC_URI[x86_64_v2_rust-av-data+default-devel.sha256sum] = "f2ade5502634dd4b16b7d0bae37ce2f88a67456a93d4b62b899a2cdd928f153e"

URI_x86_64_v2_rust-av-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-data-devel-0.4.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-data-devel}"
SRC_URI[x86_64_v2_rust-av-data-devel.sha256sum] = "56f61f34f495a2869429a246251f59fd46d2eb92b7346fa98425f3882d1b91b7"

URI_aarch64_rust-av-data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-data+default-devel-0.4.4-2.el10_0.noarch.rpm;name=aarch64_rust-av-data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-data+default-devel}"
SRC_URI[aarch64_rust-av-data+default-devel.sha256sum] = "a0e31c8d4345dbef0cd73dffbe939cb1d52dce9a14ec8df561d7863820c91ab7"

URI_aarch64_rust-av-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-data-devel-0.4.4-2.el10_0.noarch.rpm;name=aarch64_rust-av-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-data-devel}"
SRC_URI[aarch64_rust-av-data-devel.sha256sum] = "f56f61a1e08dc28adf56954d9262c11a403afe05df7f5e21ed4fa572589945b8"

RDEPENDS:rust-av-data+default-devel = " \
 cargo \
 rust-av-data-devel \
 "
RDEPENDS:rust-av-data-devel = " \
 cargo \
 rust-byte-slice-cast+default-devel \
 rust-bytes+default-devel \
 rust-num-derive+default-devel \
 rust-num-rational+default-devel \
 rust-num-traits+default-devel \
 "
