# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lockfile-progs"
PV = "0.1.17"
PR = "23.el10_1"
PACKAGES = " \
 lockfile-progs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lockfile-progs-0.1.17-23.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bf83b48ce27bc408cc42f7bb3b701fe6611866d574782898a4feb961c4a0f0c"

URI_x86_64_v2_lockfile-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lockfile-progs-0.1.17-23.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lockfile-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lockfile-progs}"
SRC_URI[x86_64_v2_lockfile-progs.sha256sum] = "9d95b80d5c75b8841d493a091571f6b15fa24d7535a7a084624bc1dc6af53fa5"

URI_aarch64_lockfile-progs = "${EPEL_MIRROR}/aarch64/Packages/l/lockfile-progs-0.1.17-23.el10_1.aarch64.rpm;name=aarch64_lockfile-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lockfile-progs}"
SRC_URI[aarch64_lockfile-progs.sha256sum] = "75392d5eaca503dc93eaac135eb06ad78aad445df72434d4568f0000b0a93b56"

RDEPENDS:lockfile-progs = " \
 glibc \
 liblockfile \
 "
