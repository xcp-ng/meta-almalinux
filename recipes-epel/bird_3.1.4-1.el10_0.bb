# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bird"
PV = "3.1.4"
PR = "1.el10_0"
PACKAGES = " \
 bird \
 bird-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bird-3.1.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8436a4786e04733572245683bb2d7aef603326e5ccfc1253466c85a4559ea22d"

URI_x86_64_v2_bird = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bird-3.1.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bird;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bird}"
SRC_URI[x86_64_v2_bird.sha256sum] = "8d986405d526b6b6f83a6d8bf9ff7530812f477e5d7cc3b9e34b9004f802690a"

URI_x86_64_v2_bird-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bird-doc-3.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bird-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bird-doc}"
SRC_URI[x86_64_v2_bird-doc.sha256sum] = "98dad6707ef081d2cbd37423f0e32aeb7e658fa7c775a78f0478f1798ce364f7"

URI_aarch64_bird = "${EPEL_MIRROR}/aarch64/Packages/b/bird-3.1.4-1.el10_0.aarch64.rpm;name=aarch64_bird;unpack=0"
SRC_URI:append = " ${URI_aarch64_bird}"
SRC_URI[aarch64_bird.sha256sum] = "7c4a4ae1138cb3f906954fb826a224e023d8e1773da7db84a5b712a952ada2ca"

URI_aarch64_bird-doc = "${EPEL_MIRROR}/aarch64/Packages/b/bird-doc-3.1.4-1.el10_0.noarch.rpm;name=aarch64_bird-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bird-doc}"
SRC_URI[aarch64_bird-doc.sha256sum] = "ca98c9516b2f12c7491675b72723a86ccc095706a14a2060f7b7e6bb42e70705"

RDEPENDS:bird = " \
 bash \
 glibc \
 libgcc \
 libssh \
 ncurses-libs \
 readline \
 shadow-utils \
 systemd \
 "
RDEPENDS:bird-doc = " \
 "
