# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keepassxc"
PV = "2.7.10"
PR = "2.el10_0"
PACKAGES = " \
 keepassxc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/keepassxc-2.7.10-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e9dd94ae19b27f6d295179760c7eba0ea0a762f703ce16b73a1d6f5aa34a787"

URI_x86_64_v2_keepassxc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keepassxc-2.7.10-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keepassxc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keepassxc}"
SRC_URI[x86_64_v2_keepassxc.sha256sum] = "4908c084b71de21f047b8519c865800fddabe2e25d5e13fd427e655f62d25176"

URI_aarch64_keepassxc = "${EPEL_MIRROR}/aarch64/Packages/k/keepassxc-2.7.10-2.el10_0.aarch64.rpm;name=aarch64_keepassxc;unpack=0"
SRC_URI:append = " ${URI_aarch64_keepassxc}"
SRC_URI[aarch64_keepassxc.sha256sum] = "cf9a249308abb56158bb6ee583219667334a0c7315469e6b9940dae6c93f59b7"

RDEPENDS:keepassxc = " \
 botan2 \
 glibc \
 libX11 \
 libXtst \
 libargon2 \
 libgcc \
 libstdc++ \
 libusb1 \
 minizip-ng-compat \
 pcsc-lite-libs \
 qrencode-libs \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtsvg \
 qt5-qtx11extras \
 readline \
 zlib-ng-compat \
 "
