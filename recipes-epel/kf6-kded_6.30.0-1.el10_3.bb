# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kded"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kded \
 kf6-kded-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kded-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "45a0347237838e22ef00a967f428577e7fca580827786f907cd0556e4aba5287"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kded-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kded;unpack=0"
SRC_URI[x86_64_v2_kf6-kded.sha256sum] = "24842ab976455a15736eab717060d6fe9cbfd8ada6b7b2b86fae1217323d9503"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kded-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kded-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kded-devel.sha256sum] = "e44f57a982e903fdc4a94ad8387a457e7a0e8aa87932c109ff39c5907faa29c6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kded-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kded;unpack=0"
SRC_URI[aarch64_kf6-kded.sha256sum] = "74a41b706af75c02f725861ce6dd6d0f6f012935118161a6588a7daa7abe715a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kded-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kded-devel;unpack=0"
SRC_URI[aarch64_kf6-kded-devel.sha256sum] = "41d0e091a3ec43355b23ca349a6823e402120b8e55ed3defe49f9485090ec2f2"

RDEPENDS:kf6-kded = " \
 bash \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kded-devel = " \
 cmake-filesystem \
 kf6-kded \
 "
