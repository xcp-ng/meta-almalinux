# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audit"
PV = "4.0.3"
PR = "5.el10"
PACKAGES = " \
 audispd-plugins \
 audispd-plugins-zos \
 audit \
 audit-libs \
 audit-libs-devel \
 audit-rules \
 python3-audit \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/audit-4.0.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd135f4e8baf4f035199887b277a1d7f444f5edac387cbf1169896d39ee584b8"

URI_x86_64_v2_audispd-plugins = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audispd-plugins-4.0.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_audispd-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audispd-plugins}"
SRC_URI[x86_64_v2_audispd-plugins.sha256sum] = "9fccb48248787a8e4a67a275caa6551db479803c914a29a71a4a18f2a42e5887"

URI_x86_64_v2_audispd-plugins-zos = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audispd-plugins-zos-4.0.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_audispd-plugins-zos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audispd-plugins-zos}"
SRC_URI[x86_64_v2_audispd-plugins-zos.sha256sum] = "376092fb34b81c2a0233e5b9d55a1a3e5a7d37fb455cbc75e18f594f5fccc4cf"

URI_x86_64_v2_audit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audit-4.0.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_audit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audit}"
SRC_URI[x86_64_v2_audit.sha256sum] = "1163f2f180c379c644924aa3019bba7af2f3898cbf55474623246fe08d66f216"

URI_x86_64_v2_audit-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audit-libs-4.0.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_audit-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audit-libs}"
SRC_URI[x86_64_v2_audit-libs.sha256sum] = "a575c868e10c5851b20abe5d59f7ef518cc79dac741c92a2a527c8b2edc98b7e"

URI_x86_64_v2_audit-libs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/audit-libs-devel-4.0.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_audit-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audit-libs-devel}"
SRC_URI[x86_64_v2_audit-libs-devel.sha256sum] = "f53de072e8e85aa8c0d0d6a8a6f980a4b3ee1d12bb58358411ecb66c00eef721"

URI_x86_64_v2_audit-rules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audit-rules-4.0.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_audit-rules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audit-rules}"
SRC_URI[x86_64_v2_audit-rules.sha256sum] = "572a44d7ec680e0c3bed1053b722b7957ec76a4727dbbd04c0893d9c0a42e641"

URI_x86_64_v2_python3-audit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-audit-4.0.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-audit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-audit}"
SRC_URI[x86_64_v2_python3-audit.sha256sum] = "3e80a9c9f9b01d410caf8e9e4e2626f157e2e58de5a8d5bbca68d472527c2c64"

URI_aarch64_audispd-plugins = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audispd-plugins-4.0.3-5.el10.aarch64.rpm;name=aarch64_audispd-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_audispd-plugins}"
SRC_URI[aarch64_audispd-plugins.sha256sum] = "3d2607068979bd9af1a9f8ac985d6a826f45dcae8565ddd809b5283fe2247e93"

URI_aarch64_audispd-plugins-zos = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audispd-plugins-zos-4.0.3-5.el10.aarch64.rpm;name=aarch64_audispd-plugins-zos;unpack=0"
SRC_URI:append = " ${URI_aarch64_audispd-plugins-zos}"
SRC_URI[aarch64_audispd-plugins-zos.sha256sum] = "b8b2674a657eb3a72b2932c5a0a1d2f11151915498082850c8ebb347e62feab1"

URI_aarch64_audit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audit-4.0.3-5.el10.aarch64.rpm;name=aarch64_audit;unpack=0"
SRC_URI:append = " ${URI_aarch64_audit}"
SRC_URI[aarch64_audit.sha256sum] = "47ec996b9d1a02efc0b1912844f98e625a698ce411b573c225b0bbe1e9c4a81c"

URI_aarch64_audit-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audit-libs-4.0.3-5.el10.aarch64.rpm;name=aarch64_audit-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_audit-libs}"
SRC_URI[aarch64_audit-libs.sha256sum] = "816f2e6bcd4c4508f7467b88600449a533441cbe03ec1a9833613b4446b6a367"

URI_aarch64_audit-libs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/audit-libs-devel-4.0.3-5.el10.aarch64.rpm;name=aarch64_audit-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_audit-libs-devel}"
SRC_URI[aarch64_audit-libs-devel.sha256sum] = "ac71e78080774352b26a5d2d668f243655e012e3fad4a76d187b28a2f68fe532"

URI_aarch64_audit-rules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audit-rules-4.0.3-5.el10.aarch64.rpm;name=aarch64_audit-rules;unpack=0"
SRC_URI:append = " ${URI_aarch64_audit-rules}"
SRC_URI[aarch64_audit-rules.sha256sum] = "bc6ce774332664d9bfdd90416792e374de36b365ef097c247783a57d081afb06"

URI_aarch64_python3-audit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-audit-4.0.3-5.el10.aarch64.rpm;name=aarch64_python3-audit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-audit}"
SRC_URI[aarch64_python3-audit.sha256sum] = "a3bfdef22c320c381d6a713c3e564a0f965677e1803d9907f0181def988da9c4"

RDEPENDS:audispd-plugins = " \
 audit \
 audit-libs \
 glibc \
 krb5-libs \
 libcap-ng \
 "
RDEPENDS:audispd-plugins-zos = " \
 audit \
 audit-libs \
 glibc \
 libcap-ng \
 openldap \
 "
RDEPENDS:audit = " \
 audit-libs \
 bash \
 glibc \
 krb5-libs \
 systemd \
 virtual/coreutils \
 "
RDEPENDS:audit-libs = " \
 glibc \
 libcap-ng \
 "
RDEPENDS:audit-libs-devel = " \
 audit-libs \
 kernel-headers \
 libcap-ng-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:audit-rules = " \
 audit-libs \
 bash \
 glibc \
 "
RDEPENDS:python3-audit = " \
 audit-libs \
 glibc \
 libcap-ng \
 python3 \
 "
