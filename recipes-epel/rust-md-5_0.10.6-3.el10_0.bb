# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-md-5"
PV = "0.10.6"
PR = "3.el10_0"
PACKAGES = " \
 rust-md-5+asm-devel \
 rust-md-5+default-devel \
 rust-md-5+force-soft-devel \
 rust-md-5+loongarch64_asm-devel \
 rust-md-5+md5-asm-devel \
 rust-md-5+oid-devel \
 rust-md-5+std-devel \
 rust-md-5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-md-5-0.10.6-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18542e60f9cfdc15f2aedcc8ca0226c0e1fa4be6f1523a30a0f22fb783085b6b"

URI_x86_64_v2_rust-md-5+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5+asm-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5+asm-devel}"
SRC_URI[x86_64_v2_rust-md-5+asm-devel.sha256sum] = "e295b704a4ce682bf54fa85ca7b1ce60692feed58f674298133a9ff482c7a4dc"

URI_x86_64_v2_rust-md-5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5+default-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5+default-devel}"
SRC_URI[x86_64_v2_rust-md-5+default-devel.sha256sum] = "d1b535c8495b5df47ccffb627c1137087225132a97ce7bf56c03cc6e9dc8a03a"

URI_x86_64_v2_rust-md-5+force-soft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5+force-soft-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5+force-soft-devel}"
SRC_URI[x86_64_v2_rust-md-5+force-soft-devel.sha256sum] = "a80d8677f81619e778a866ef82be1ba44cee56105baf264314c26ca1d6e2fdc1"

URI_x86_64_v2_rust-md-5+loongarch64_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5+loongarch64_asm-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5+loongarch64_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5+loongarch64_asm-devel}"
SRC_URI[x86_64_v2_rust-md-5+loongarch64_asm-devel.sha256sum] = "eac61e4d555d99010cc94a90baea00a6503ab4f4e0074626759a11d0720c7f19"

URI_x86_64_v2_rust-md-5+md5-asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5+md5-asm-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5+md5-asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5+md5-asm-devel}"
SRC_URI[x86_64_v2_rust-md-5+md5-asm-devel.sha256sum] = "a336446a2389d4cc628d3a938a650e93289975770b1bb621ddfaee2ad60bdc46"

URI_x86_64_v2_rust-md-5+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5+oid-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5+oid-devel}"
SRC_URI[x86_64_v2_rust-md-5+oid-devel.sha256sum] = "e6b39f020729e409ca7dfe01cae3f1adbe1175d03f595b68f8d1fb50aebf7baf"

URI_x86_64_v2_rust-md-5+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5+std-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5+std-devel}"
SRC_URI[x86_64_v2_rust-md-5+std-devel.sha256sum] = "a9728b75309a9592a6520655a787b7fd83d7262159dc7d6fc607a17cf405402c"

URI_x86_64_v2_rust-md-5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md-5-devel-0.10.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md-5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md-5-devel}"
SRC_URI[x86_64_v2_rust-md-5-devel.sha256sum] = "f12a44ea22bc3707eed454e183e3f20fc07b045afe1dadbc2b85c5620171274f"

URI_aarch64_rust-md-5+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5+asm-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-md-5+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5+asm-devel}"
SRC_URI[aarch64_rust-md-5+asm-devel.sha256sum] = "863fbfe69f3259646bb5dec71459d29806c3eb534873c4f61d89c98b1307e6f4"

URI_aarch64_rust-md-5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5+default-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-md-5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5+default-devel}"
SRC_URI[aarch64_rust-md-5+default-devel.sha256sum] = "913808d0694cf974c86cf68dd1cb3df8db739d8d1c847255d773b2d5fbab90c5"

URI_aarch64_rust-md-5+force-soft-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5+force-soft-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-md-5+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5+force-soft-devel}"
SRC_URI[aarch64_rust-md-5+force-soft-devel.sha256sum] = "47442ead1748178e7b4afc757346bfaba9765d28a2e75d9f5365b86bfc370837"

URI_aarch64_rust-md-5+loongarch64_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5+loongarch64_asm-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-md-5+loongarch64_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5+loongarch64_asm-devel}"
SRC_URI[aarch64_rust-md-5+loongarch64_asm-devel.sha256sum] = "7daf382d94972e4d3b5c0b714064270da63e40422f96808d027d9010c708aab5"

URI_aarch64_rust-md-5+md5-asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5+md5-asm-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-md-5+md5-asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5+md5-asm-devel}"
SRC_URI[aarch64_rust-md-5+md5-asm-devel.sha256sum] = "4970b76e00d6f539901533130aa463f87935b6fd0c60e835a1de2407bfffc00b"

URI_aarch64_rust-md-5+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5+oid-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-md-5+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5+oid-devel}"
SRC_URI[aarch64_rust-md-5+oid-devel.sha256sum] = "3c9ce5c7a9b05f876556171f1a9267a6ad8fde86aaad3c28fd2cdd47a7b734c6"

URI_aarch64_rust-md-5+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5+std-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-md-5+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5+std-devel}"
SRC_URI[aarch64_rust-md-5+std-devel.sha256sum] = "b9e4e4c7823267d58e0090a17e2dcb145b39bbc4ed4f321af1f950b82a2d68a1"

URI_aarch64_rust-md-5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md-5-devel-0.10.6-3.el10_0.noarch.rpm;name=aarch64_rust-md-5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md-5-devel}"
SRC_URI[aarch64_rust-md-5-devel.sha256sum] = "69a962df8279f644786c51b05cebb9b94ced7c5df85f5f11db3bfbcd89308b56"

RDEPENDS:rust-md-5+asm-devel = " \
 cargo \
 rust-md-5+md5-asm-devel \
 rust-md-5-devel \
 "
RDEPENDS:rust-md-5+default-devel = " \
 cargo \
 rust-md-5+std-devel \
 rust-md-5-devel \
 "
RDEPENDS:rust-md-5+force-soft-devel = " \
 cargo \
 rust-md-5-devel \
 "
RDEPENDS:rust-md-5+loongarch64_asm-devel = " \
 cargo \
 rust-md-5-devel \
 "
RDEPENDS:rust-md-5+md5-asm-devel = " \
 cargo \
 rust-md-5-devel \
 rust-md5-asm+default-devel \
 "
RDEPENDS:rust-md-5+oid-devel = " \
 cargo \
 rust-digest+oid-devel \
 rust-md-5-devel \
 "
RDEPENDS:rust-md-5+std-devel = " \
 cargo \
 rust-digest+std-devel \
 rust-md-5-devel \
 "
RDEPENDS:rust-md-5-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-digest+default-devel \
 "
