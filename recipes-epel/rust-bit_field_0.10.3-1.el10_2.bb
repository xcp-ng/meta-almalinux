# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bit_field"
PV = "0.10.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-bit_field+default-devel \
 rust-bit_field-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bit_field-0.10.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96022f698f2fe4f4133de612a308316dc79cc5037efde2405bcecbea157d8b69"

URI_x86_64_v2_rust-bit_field+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit_field+default-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit_field+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit_field+default-devel}"
SRC_URI[x86_64_v2_rust-bit_field+default-devel.sha256sum] = "1b0af57349ae54aed3eb5cf3d2aec2611b88f8f46eb9df11b4ca12da4c24cc1e"

URI_x86_64_v2_rust-bit_field-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit_field-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit_field-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit_field-devel}"
SRC_URI[x86_64_v2_rust-bit_field-devel.sha256sum] = "3bc60810666b18ef6919cd04aaf0f258407c054a91abad5e406fc4b953fd2d44"

URI_aarch64_rust-bit_field+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit_field+default-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-bit_field+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit_field+default-devel}"
SRC_URI[aarch64_rust-bit_field+default-devel.sha256sum] = "9752b3b8e3e1cc38cfde1eabecb143b557f159ffeea63f2910bdc679fbae699b"

URI_aarch64_rust-bit_field-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit_field-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-bit_field-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit_field-devel}"
SRC_URI[aarch64_rust-bit_field-devel.sha256sum] = "f4c48a63582e13f377efedcd6de8b891550a6342fabbcd10ec9fedaa8e42ea40"

RDEPENDS:rust-bit_field+default-devel = " \
 cargo \
 rust-bit_field-devel \
 "
RDEPENDS:rust-bit_field-devel = " \
 cargo \
 "
