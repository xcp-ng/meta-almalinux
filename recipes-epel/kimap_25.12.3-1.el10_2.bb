# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kimap"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kimap \
 kimap-devel \
 kimap-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kimap-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89f7107e237ac80116d20d75b5a079887391390f4aa70f24b7ec2cf62a7fe03c"

URI_x86_64_v2_kimap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimap-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kimap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimap}"
SRC_URI[x86_64_v2_kimap.sha256sum] = "cefeffdcab02df259bfe76b6c978c2e1f01eeac9d69a1d523c6309e6fda5f5d3"

URI_x86_64_v2_kimap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimap-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kimap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimap-devel}"
SRC_URI[x86_64_v2_kimap-devel.sha256sum] = "f358e231be01605c14b658400758f4c9bf8cb7fff9f7d4504e336a7cb7ad0bff"

URI_x86_64_v2_kimap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimap-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kimap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimap-doc}"
SRC_URI[x86_64_v2_kimap-doc.sha256sum] = "ab1d466a6015ab471854f3087cec9e1d34c7292febc7733ed69a239ce438892d"

URI_aarch64_kimap = "${EPEL_MIRROR}/aarch64/Packages/k/kimap-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kimap;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimap}"
SRC_URI[aarch64_kimap.sha256sum] = "2775117e1971811f82766032b79754b741ad5aad5b222c158867031c05ed2a19"

URI_aarch64_kimap-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kimap-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kimap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimap-devel}"
SRC_URI[aarch64_kimap-devel.sha256sum] = "7c3d0305a203702e7e38dc34fbe69c7d38fe5553dddf8a248741066f4c43deb9"

URI_aarch64_kimap-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kimap-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kimap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimap-doc}"
SRC_URI[aarch64_kimap-doc.sha256sum] = "7e85b2a934a3a5123d922038073855f88fa3fadc23ee549cfca91fd743209c06"

RDEPENDS:kimap = " \
 cyrus-sasl-lib \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kimap-devel = " \
 boost-devel \
 cmake-filesystem \
 cyrus-sasl-devel \
 kf6-kcoreaddons-devel \
 kimap \
 "
RDEPENDS:kimap-doc = " \
 "
