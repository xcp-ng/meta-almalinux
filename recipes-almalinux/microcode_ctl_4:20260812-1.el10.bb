# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "microcode_ctl"
PE = "4"
PV = "20260812"
PR = "1.el10"
PACKAGES = " \
 microcode_ctl \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/microcode_ctl-20260812-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bdcaa9bfc5c29eb8bfa04687dac985c656adc558e0220d3da7e7fabea3c6f51f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/microcode_ctl-20260812-1.el10.noarch.rpm;name=x86_64_v2_microcode_ctl;unpack=0"
SRC_URI[x86_64_v2_microcode_ctl.sha256sum] = "be9b5a39c9702acde43d247a218021cf381c851445c295e540cfba265a34b034"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/microcode_ctl-20260812-1.el10.noarch.rpm;name=aarch64_microcode_ctl;unpack=0"
SRC_URI[aarch64_microcode_ctl.sha256sum] = "be9b5a39c9702acde43d247a218021cf381c851445c295e540cfba265a34b034"

RDEPENDS:microcode_ctl = " \
 bash \
 dracut \
 systemd \
 virtual/coreutils \
 "
