# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yara"
PV = "4.5.2"
PR = "2.el10"
PACKAGES = " \
 yara \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/yara-4.5.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85768e0f243ceb078acddde33ff21ce763b936c3c257b92549673186e94548a8"

URI_x86_64_v2_yara = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/yara-4.5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_yara;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yara}"
SRC_URI[x86_64_v2_yara.sha256sum] = "cd0546e52b8f09db556fc1ce2ddcb6f7eb14a155aaa43badb87d498134580b11"

URI_aarch64_yara = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/yara-4.5.2-2.el10.aarch64.rpm;name=aarch64_yara;unpack=0"
SRC_URI:append = " ${URI_aarch64_yara}"
SRC_URI[aarch64_yara.sha256sum] = "93d2a08999a8885f11dcb27d42f249b5af11cab9b7a1f074a4300a5c2ab78fcb"

RDEPENDS:yara = " \
 file-libs \
 glibc \
 jansson \
 openssl-libs \
 protobuf-c \
 "
