# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-strictyaml"
PV = "1.7.3"
PR = "9.el10_0"
PACKAGES = " \
 python3-strictyaml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-strictyaml-1.7.3-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db0169c8d16f02a880e8abf6a430b1170a8b2416dea1570be2172e91270850e9"

URI_x86_64_v2_python3-strictyaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-strictyaml-1.7.3-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-strictyaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-strictyaml}"
SRC_URI[x86_64_v2_python3-strictyaml.sha256sum] = "f44d0604f50f0d99e36bcb391fe5498321ab7da5063ccb914ce590c5f9cd59c7"

URI_aarch64_python3-strictyaml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-strictyaml-1.7.3-9.el10_0.noarch.rpm;name=aarch64_python3-strictyaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-strictyaml}"
SRC_URI[aarch64_python3-strictyaml.sha256sum] = "bb31b3e1d2262a4c977ddf311bc54fdeaf6a07abb6ab7ff2d534221cf9769f96"

RDEPENDS:python3-strictyaml = " \
 python3 \
 python3-dateutil \
 "
