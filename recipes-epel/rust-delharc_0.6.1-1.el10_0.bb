# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-delharc"
PV = "0.6.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-delharc+default-devel \
 rust-delharc+lh1-devel \
 rust-delharc+lhx-devel \
 rust-delharc+lz-devel \
 rust-delharc+std-devel \
 rust-delharc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-delharc-0.6.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30bd1b86ac220e900b85968aef37fc94ef13a385945f056022ed875a5d9e9c73"

URI_x86_64_v2_rust-delharc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-delharc+default-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-delharc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-delharc+default-devel}"
SRC_URI[x86_64_v2_rust-delharc+default-devel.sha256sum] = "d87b260cbc9f7b385de143a10e57512e2a4cf184355aeedd57bac18229d6fe9e"

URI_x86_64_v2_rust-delharc+lh1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-delharc+lh1-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-delharc+lh1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-delharc+lh1-devel}"
SRC_URI[x86_64_v2_rust-delharc+lh1-devel.sha256sum] = "f8a2d5bdfbe95566214920a9a1c67ad89c58dade943d3bdfc827dfe1f3cea901"

URI_x86_64_v2_rust-delharc+lhx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-delharc+lhx-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-delharc+lhx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-delharc+lhx-devel}"
SRC_URI[x86_64_v2_rust-delharc+lhx-devel.sha256sum] = "f61afb94ac00e9c619a03b9b5904b83d83474dc0982509c45fd55db9c7900908"

URI_x86_64_v2_rust-delharc+lz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-delharc+lz-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-delharc+lz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-delharc+lz-devel}"
SRC_URI[x86_64_v2_rust-delharc+lz-devel.sha256sum] = "7dc12249d61f5fd3d4f21f68878fd9975425ee29e04ec155b7088698d4fbd895"

URI_x86_64_v2_rust-delharc+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-delharc+std-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-delharc+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-delharc+std-devel}"
SRC_URI[x86_64_v2_rust-delharc+std-devel.sha256sum] = "dbb45c55945d34c26691a3a6be8eae8496d6c590466254a977acbaca7419e45d"

URI_x86_64_v2_rust-delharc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-delharc-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-delharc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-delharc-devel}"
SRC_URI[x86_64_v2_rust-delharc-devel.sha256sum] = "643109840159ac4a3f7d35cba139c328792b4140a11925bb69d75083651ecb93"

URI_aarch64_rust-delharc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-delharc+default-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-delharc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-delharc+default-devel}"
SRC_URI[aarch64_rust-delharc+default-devel.sha256sum] = "f55994e409645fd0fcb156fa6397afa904f4fe6c57fb94417faf2aed2bc82da2"

URI_aarch64_rust-delharc+lh1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-delharc+lh1-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-delharc+lh1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-delharc+lh1-devel}"
SRC_URI[aarch64_rust-delharc+lh1-devel.sha256sum] = "6b8ab1330df8705cbbf3206a22901c9e3aa8b562a589bb9707e6bf3b46baa272"

URI_aarch64_rust-delharc+lhx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-delharc+lhx-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-delharc+lhx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-delharc+lhx-devel}"
SRC_URI[aarch64_rust-delharc+lhx-devel.sha256sum] = "13feb5c999658b0d708768d6b561be0f750e74ee228f70ac231376248e8953e4"

URI_aarch64_rust-delharc+lz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-delharc+lz-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-delharc+lz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-delharc+lz-devel}"
SRC_URI[aarch64_rust-delharc+lz-devel.sha256sum] = "1e09c100ca10a25e014e1dcc237e3cc70e66e357911534296d2762929a515015"

URI_aarch64_rust-delharc+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-delharc+std-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-delharc+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-delharc+std-devel}"
SRC_URI[aarch64_rust-delharc+std-devel.sha256sum] = "4d904991e00a71abd66ef6504e962c9f45dc518029fe4aae5bd77c2bfac9e4f3"

URI_aarch64_rust-delharc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-delharc-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-delharc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-delharc-devel}"
SRC_URI[aarch64_rust-delharc-devel.sha256sum] = "f498e4237bc1dad40f4805ea1315d897482e99585861188131190cea487bf39e"

RDEPENDS:rust-delharc+default-devel = " \
 cargo \
 rust-delharc+lh1-devel \
 rust-delharc+lz-devel \
 rust-delharc+std-devel \
 rust-delharc-devel \
 "
RDEPENDS:rust-delharc+lh1-devel = " \
 cargo \
 rust-delharc-devel \
 "
RDEPENDS:rust-delharc+lhx-devel = " \
 cargo \
 rust-delharc-devel \
 "
RDEPENDS:rust-delharc+lz-devel = " \
 cargo \
 rust-delharc-devel \
 "
RDEPENDS:rust-delharc+std-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-delharc-devel \
 "
RDEPENDS:rust-delharc-devel = " \
 cargo \
 rust-bitflags+default-devel \
 rust-chrono-devel \
 rust-memchr-devel \
 "
