# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsemanage"
PV = "3.11"
PR = "3.el10"
PACKAGES = " \
 libsemanage \
 libsemanage-devel \
 python3-libsemanage \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libsemanage-3.11-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d3aaf7fa3f7a848a11e21bf0422b201c595d848b6e918de2ff544f2a2e0668da"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsemanage-3.11-3.el10.x86_64_v2.rpm;name=x86_64_v2_libsemanage;unpack=0"
SRC_URI[x86_64_v2_libsemanage.sha256sum] = "858abe28320a11549a05267ed667547d666b198f321eebd9e71077cbefdc68b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsemanage-devel-3.11-3.el10.x86_64_v2.rpm;name=x86_64_v2_libsemanage-devel;unpack=0"
SRC_URI[x86_64_v2_libsemanage-devel.sha256sum] = "48e14efac7b0753009cc686a98d6cd792635ce68747c58f1c0731b208ce918e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libsemanage-3.11-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libsemanage;unpack=0"
SRC_URI[x86_64_v2_python3-libsemanage.sha256sum] = "fb7149081fc3e89e899c5e39b8b3caef963ac11d5db95ef6f89ad91f2648a6e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsemanage-3.11-3.el10.aarch64.rpm;name=aarch64_libsemanage;unpack=0"
SRC_URI[aarch64_libsemanage.sha256sum] = "ca9ff6a4bbca45ebab8fcb7607d147f81a4a6f10afce8cd2c13ef9255f53820e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsemanage-devel-3.11-3.el10.aarch64.rpm;name=aarch64_libsemanage-devel;unpack=0"
SRC_URI[aarch64_libsemanage-devel.sha256sum] = "de47c96545394662afa3c09605a0d91b0a2788299c133cd64fc5d5f884f95033"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libsemanage-3.11-3.el10.aarch64.rpm;name=aarch64_python3-libsemanage;unpack=0"
SRC_URI[aarch64_python3-libsemanage.sha256sum] = "b424ea310cc93bc82016c901bc15569ff923b9631c3869c4060b50a55bf816d4"

RDEPENDS:libsemanage = " \
 audit-libs \
 bzip2-libs \
 glibc \
 libselinux \
 libsepol \
 "
RDEPENDS:libsemanage-devel = " \
 libselinux-devel \
 libsemanage \
 libsepol-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libsemanage = " \
 glibc \
 libsemanage \
 python3 \
 python3-libselinux \
 "
