# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hidapi"
PV = "0.15.0"
PR = "2.el10_1"
PACKAGES = " \
 hidapi \
 hidapi-devel \
 mingw32-hidapi \
 mingw64-hidapi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hidapi-0.15.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f1e52d7d7cfa9d331316fc8ae88ff7bbd632e05c7cd39b0b6b32c7690639eed"

URI_x86_64_v2_hidapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hidapi-0.15.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hidapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hidapi}"
SRC_URI[x86_64_v2_hidapi.sha256sum] = "65a13112222f6d9a24d172400ea1a0c108c43556739bac02cc3b19dca0a0a0c3"

URI_x86_64_v2_hidapi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hidapi-devel-0.15.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hidapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hidapi-devel}"
SRC_URI[x86_64_v2_hidapi-devel.sha256sum] = "824881e0306761dfba6cb0928de4d3e8399eadcca93dea94d2575d224e6d1ac4"

URI_x86_64_v2_mingw32-hidapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-hidapi-0.15.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mingw32-hidapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-hidapi}"
SRC_URI[x86_64_v2_mingw32-hidapi.sha256sum] = "175aa084e5a01bd9d8ad8ae5b225580b57b1a94a3b4788a4a92511d20016074b"

URI_x86_64_v2_mingw64-hidapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-hidapi-0.15.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mingw64-hidapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-hidapi}"
SRC_URI[x86_64_v2_mingw64-hidapi.sha256sum] = "8f2702c1a054d475b67dd94acf6d29690cffe6de58b23872d9cd55d33e219671"

URI_aarch64_hidapi = "${EPEL_MIRROR}/aarch64/Packages/h/hidapi-0.15.0-2.el10_1.aarch64.rpm;name=aarch64_hidapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_hidapi}"
SRC_URI[aarch64_hidapi.sha256sum] = "36514b39f28ab13b695dfc0e20e02dcc4f63fd149097e7227a5862b724875fc8"

URI_aarch64_hidapi-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hidapi-devel-0.15.0-2.el10_1.aarch64.rpm;name=aarch64_hidapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hidapi-devel}"
SRC_URI[aarch64_hidapi-devel.sha256sum] = "2233679dc215d48ff8e0028e4470fedc988d3cc34275f9d72e2871eee6335f03"

URI_aarch64_mingw32-hidapi = "${EPEL_MIRROR}/aarch64/Packages/m/mingw32-hidapi-0.15.0-2.el10_1.aarch64.rpm;name=aarch64_mingw32-hidapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-hidapi}"
SRC_URI[aarch64_mingw32-hidapi.sha256sum] = "5a4fcfbb3ab4e4189176560d6b6cd64eda786d414d7c1e31237ff425f447a0cf"

URI_aarch64_mingw64-hidapi = "${EPEL_MIRROR}/aarch64/Packages/m/mingw64-hidapi-0.15.0-2.el10_1.aarch64.rpm;name=aarch64_mingw64-hidapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-hidapi}"
SRC_URI[aarch64_mingw64-hidapi.sha256sum] = "0a227ec5ba7a7c61cd3b316ae2c6cac8b666b794cf03f3954153b71e8b089b37"

RDEPENDS:hidapi = " \
 glibc \
 libgcc \
 libusb1 \
 systemd-libs \
 "
RDEPENDS:hidapi-devel = " \
 cmake-filesystem \
 hidapi \
 pkgconf-pkg-config \
 "
RDEPENDS:mingw32-hidapi = " \
 mingw32-crt \
 mingw32-filesystem \
 "
RDEPENDS:mingw64-hidapi = " \
 mingw64-crt \
 mingw64-filesystem \
 "
