# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "blinken"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 blinken \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/blinken-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51ed6e53d6db42d63b006949be59fbf90d6680d553982c0023528501f4d00271"

URI_x86_64_v2_blinken = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blinken-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blinken;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blinken}"
SRC_URI[x86_64_v2_blinken.sha256sum] = "1aef89a255a5d9003d8de31cf5e6bb6ab2380bae732b118e702a78b93d6e3ba1"

URI_aarch64_blinken = "${EPEL_MIRROR}/aarch64/Packages/b/blinken-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_blinken;unpack=0"
SRC_URI:append = " ${URI_aarch64_blinken}"
SRC_URI[aarch64_blinken.sha256sum] = "fa5bd16649d4c33312f8236ac8d785ca46b303d23462aedec6dae79fb19a9ea2"

RDEPENDS:blinken = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 sj-stevehand-fonts \
 "
