# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "extra-enforcer-rules"
PV = "1.7.0"
PR = "7.el10"
PACKAGES = " \
 extra-enforcer-rules \
 extra-enforcer-rules-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/extra-enforcer-rules-1.7.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d68b1bd6e9274866a92b5d1d18097c6af91d0c26912b4c8effaf43b71f55d29"

URI_x86_64_v2_extra-enforcer-rules = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/extra-enforcer-rules-1.7.0-7.el10.noarch.rpm;name=x86_64_v2_extra-enforcer-rules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_extra-enforcer-rules}"
SRC_URI[x86_64_v2_extra-enforcer-rules.sha256sum] = "bbf949d7e45eceaeec284bed3d05b64d3dad2e6b31d0f679385488161dc782e5"

URI_x86_64_v2_extra-enforcer-rules-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/extra-enforcer-rules-javadoc-1.7.0-7.el10.noarch.rpm;name=x86_64_v2_extra-enforcer-rules-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_extra-enforcer-rules-javadoc}"
SRC_URI[x86_64_v2_extra-enforcer-rules-javadoc.sha256sum] = "68f35542700dd92cc3d94e676dbd1858b0e23b0d09aea867ab81aa21a9647dd9"

URI_aarch64_extra-enforcer-rules = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/extra-enforcer-rules-1.7.0-7.el10.noarch.rpm;name=aarch64_extra-enforcer-rules;unpack=0"
SRC_URI:append = " ${URI_aarch64_extra-enforcer-rules}"
SRC_URI[aarch64_extra-enforcer-rules.sha256sum] = "bbf949d7e45eceaeec284bed3d05b64d3dad2e6b31d0f679385488161dc782e5"

URI_aarch64_extra-enforcer-rules-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/extra-enforcer-rules-javadoc-1.7.0-7.el10.noarch.rpm;name=aarch64_extra-enforcer-rules-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_extra-enforcer-rules-javadoc}"
SRC_URI[aarch64_extra-enforcer-rules-javadoc.sha256sum] = "68f35542700dd92cc3d94e676dbd1858b0e23b0d09aea867ab81aa21a9647dd9"

RDEPENDS:extra-enforcer-rules = " \
 apache-commons-codec \
 javapackages-filesystem \
 maven-common-artifact-filters \
 maven-dependency-tree \
 "
RDEPENDS:extra-enforcer-rules-javadoc = " \
 javapackages-filesystem \
 "
