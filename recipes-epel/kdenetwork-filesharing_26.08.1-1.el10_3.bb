# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdenetwork-filesharing"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kdenetwork-filesharing \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdenetwork-filesharing-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cf6e831f55cb88d402bfa1bc0345fdcc89bc99e640c36b603a8478fd33e3846a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdenetwork-filesharing-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdenetwork-filesharing;unpack=0"
SRC_URI[x86_64_v2_kdenetwork-filesharing.sha256sum] = "08e96ff0bf82a7ac1813ec70e6feb46fed0cda30a2e14a87336f8ad4dccdac2c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdenetwork-filesharing-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdenetwork-filesharing;unpack=0"
SRC_URI[aarch64_kdenetwork-filesharing.sha256sum] = "d3a2e79c0dad0e314044038a211ab5f289156f2334d2dfc52266b55341f914aa"

RDEPENDS:kdenetwork-filesharing = " \
 PackageKit-Qt6 \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 libstdc++ \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
