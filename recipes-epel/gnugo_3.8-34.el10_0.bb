# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnugo"
PV = "3.8"
PR = "34.el10_0"
PACKAGES = " \
 gnugo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnugo-3.8-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cf60dbc90a9f40b17288100f0e2252486848c2a841d7d74ec14b82d548318e2"

URI_x86_64_v2_gnugo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnugo-3.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnugo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnugo}"
SRC_URI[x86_64_v2_gnugo.sha256sum] = "a01f40f03b8c027fb8b08d3def49afc651216505e9bfbdb5c2afcd23de199e88"

URI_aarch64_gnugo = "${EPEL_MIRROR}/aarch64/Packages/g/gnugo-3.8-34.el10_0.aarch64.rpm;name=aarch64_gnugo;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnugo}"
SRC_URI[aarch64_gnugo.sha256sum] = "8903f49957023af61387d1edfc5542e40335b4db10da8037bf2e41566d176666"

RDEPENDS:gnugo = " \
 glibc \
 ncurses-libs \
 readline \
 "
