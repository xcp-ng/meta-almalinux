# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "proxychains-ng"
PV = "4.17"
PR = "8.el10_2"
PACKAGES = " \
 proxychains-ng \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/proxychains-ng-4.17-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e143d5c7df63568b0b2bbcc8c96214002965c8a46a045cf54c95dd09e0d2099d"

URI_x86_64_v2_proxychains-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proxychains-ng-4.17-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proxychains-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proxychains-ng}"
SRC_URI[x86_64_v2_proxychains-ng.sha256sum] = "0ac181835f0cfe2bb4e60953b28167e2e74c4f5390420faa432dc48fb472e839"

URI_aarch64_proxychains-ng = "${EPEL_MIRROR}/aarch64/Packages/p/proxychains-ng-4.17-8.el10_2.aarch64.rpm;name=aarch64_proxychains-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_proxychains-ng}"
SRC_URI[aarch64_proxychains-ng.sha256sum] = "0a054a8104122afd4007cc1576bee5a5c39cc55a3446bb33892074dbd46687d2"

RDEPENDS:proxychains-ng = " \
 glibc \
 "
