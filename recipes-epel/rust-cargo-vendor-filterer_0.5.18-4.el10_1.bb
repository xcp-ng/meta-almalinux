# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-vendor-filterer"
PV = "0.5.18"
PR = "4.el10_1"
PACKAGES = " \
 cargo-vendor-filterer \
 rust-cargo-vendor-filterer+default-devel \
 rust-cargo-vendor-filterer+openssl-devel \
 rust-cargo-vendor-filterer+sha-rs-devel \
 rust-cargo-vendor-filterer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-vendor-filterer-0.5.18-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdc9bc34aa62cdb73fcbceaadb01f4eb4eb85343f3b1c907794b8ee46604d994"

URI_x86_64_v2_cargo-vendor-filterer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cargo-vendor-filterer-0.5.18-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cargo-vendor-filterer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo-vendor-filterer}"
SRC_URI[x86_64_v2_cargo-vendor-filterer.sha256sum] = "7d0560619b696b015eea0285fe8be4c2e6ac71323818b2faacffa3e54daef835"

URI_x86_64_v2_rust-cargo-vendor-filterer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-vendor-filterer+default-devel-0.5.18-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-vendor-filterer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-vendor-filterer+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-vendor-filterer+default-devel.sha256sum] = "d4111a0d0f169fd6d226375f65d5126a231f8698ad42f6778eabbf28699d095e"

URI_x86_64_v2_rust-cargo-vendor-filterer+openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-vendor-filterer+openssl-devel-0.5.18-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-vendor-filterer+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-vendor-filterer+openssl-devel}"
SRC_URI[x86_64_v2_rust-cargo-vendor-filterer+openssl-devel.sha256sum] = "092997cc0b1e9a08c5f67f2f7da38763c154800b8585b66bdec27587c4a32718"

URI_x86_64_v2_rust-cargo-vendor-filterer+sha-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-vendor-filterer+sha-rs-devel-0.5.18-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-vendor-filterer+sha-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-vendor-filterer+sha-rs-devel}"
SRC_URI[x86_64_v2_rust-cargo-vendor-filterer+sha-rs-devel.sha256sum] = "0f9a1c2a60f614473f4aa4490d08e22f8dcaf29766b7f913ed8f5381b8732c2b"

URI_x86_64_v2_rust-cargo-vendor-filterer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-vendor-filterer-devel-0.5.18-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-vendor-filterer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-vendor-filterer-devel}"
SRC_URI[x86_64_v2_rust-cargo-vendor-filterer-devel.sha256sum] = "a4cb3ac120f42a081b6b9c6ef79ceca5eff49487f16ddcdc9fed03944817ef95"

URI_aarch64_cargo-vendor-filterer = "${EPEL_MIRROR}/aarch64/Packages/c/cargo-vendor-filterer-0.5.18-4.el10_1.aarch64.rpm;name=aarch64_cargo-vendor-filterer;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo-vendor-filterer}"
SRC_URI[aarch64_cargo-vendor-filterer.sha256sum] = "cd85a5f0727e2a497f4756ed57fbd93c4f7a9238ef9bedcc136b22f759630a82"

URI_aarch64_rust-cargo-vendor-filterer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-vendor-filterer+default-devel-0.5.18-4.el10_1.noarch.rpm;name=aarch64_rust-cargo-vendor-filterer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-vendor-filterer+default-devel}"
SRC_URI[aarch64_rust-cargo-vendor-filterer+default-devel.sha256sum] = "40fc9a56111869839a6778a3e7756c8f0794a2c8102a7187183572cba4b372c3"

URI_aarch64_rust-cargo-vendor-filterer+openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-vendor-filterer+openssl-devel-0.5.18-4.el10_1.noarch.rpm;name=aarch64_rust-cargo-vendor-filterer+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-vendor-filterer+openssl-devel}"
SRC_URI[aarch64_rust-cargo-vendor-filterer+openssl-devel.sha256sum] = "37449e08594002f34f48974293b04d43aafa69e51b4afef6dd2ac5f513b637c0"

URI_aarch64_rust-cargo-vendor-filterer+sha-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-vendor-filterer+sha-rs-devel-0.5.18-4.el10_1.noarch.rpm;name=aarch64_rust-cargo-vendor-filterer+sha-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-vendor-filterer+sha-rs-devel}"
SRC_URI[aarch64_rust-cargo-vendor-filterer+sha-rs-devel.sha256sum] = "d9db0438afe88ed080ed69e85a14f0f7573ce18d987a84b7521d35aaa42c1d99"

URI_aarch64_rust-cargo-vendor-filterer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-vendor-filterer-devel-0.5.18-4.el10_1.noarch.rpm;name=aarch64_rust-cargo-vendor-filterer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-vendor-filterer-devel}"
SRC_URI[aarch64_rust-cargo-vendor-filterer-devel.sha256sum] = "3057cb2ba2a0f207d12b736512cbfbaaf3bfaeb585e4259c6609f6dc31c1c546"

RDEPENDS:cargo-vendor-filterer = " \
 glibc \
 libgcc \
 openssl-libs \
 "
RDEPENDS:rust-cargo-vendor-filterer+default-devel = " \
 cargo \
 rust-cargo-vendor-filterer+sha-rs-devel \
 rust-cargo-vendor-filterer-devel \
 "
RDEPENDS:rust-cargo-vendor-filterer+openssl-devel = " \
 cargo \
 rust-cargo-vendor-filterer-devel \
 rust-openssl+default-devel \
 "
RDEPENDS:rust-cargo-vendor-filterer+sha-rs-devel = " \
 cargo \
 rust-cargo-vendor-filterer-devel \
 rust-sha2+default-devel \
 "
RDEPENDS:rust-cargo-vendor-filterer-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-camino+default-devel \
 rust-cargo-lock+default-devel \
 rust-cargo_metadata0.18+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+wrap_help-devel \
 rust-either+default-devel \
 rust-flate2+default-devel \
 rust-glob+default-devel \
 rust-hex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_ignored+default-devel \
 rust-serde_json+default-devel \
 rust-smallvec+default-devel \
 rust-tar-devel \
 rust-tempfile+default-devel \
 rust-toml0.8+default-devel \
 rust-walkdir+default-devel \
 "
