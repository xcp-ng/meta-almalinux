# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmines"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kmines \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmines-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab82f6564959a100bcb2f26d0b19c362420c103901508c8aa51180441d2b5dc3"

URI_x86_64_v2_kmines = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmines-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmines;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmines}"
SRC_URI[x86_64_v2_kmines.sha256sum] = "1068c428c5ffa000d98d7e2d1061f86b794f3519d90fecbd54092d7a915ddea9"

URI_aarch64_kmines = "${EPEL_MIRROR}/aarch64/Packages/k/kmines-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kmines;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmines}"
SRC_URI[aarch64_kmines.sha256sum] = "1538bf852f4cfd3457322c5858e1c1679043beac307acc7730426afabdc734e3"

RDEPENDS:kmines = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
