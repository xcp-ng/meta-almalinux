# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-gnupg"
PV = "0.5.4"
PR = "6.el10_1"
PACKAGES = " \
 python3-gnupg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-gnupg-0.5.4-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5712758bec0f96ad85994985b7bfae156393e40234ea881553d86b02cab2a63b"

URI_x86_64_v2_python3-gnupg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gnupg-0.5.4-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gnupg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gnupg}"
SRC_URI[x86_64_v2_python3-gnupg.sha256sum] = "3c4f9cee6ee9d01d3fe064d1aa7c37fab5675b5e06a9d86cbfbc759d89c62021"

URI_aarch64_python3-gnupg = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gnupg-0.5.4-6.el10_1.noarch.rpm;name=aarch64_python3-gnupg;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gnupg}"
SRC_URI[aarch64_python3-gnupg.sha256sum] = "5f0bc5c0400949be8974b78c80fa4c8388026a42bafc39e197dff50b6b0b52eb"

RDEPENDS:python3-gnupg = " \
 gnupg2 \
 python3 \
 "
