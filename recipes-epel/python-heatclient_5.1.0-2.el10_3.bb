# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-heatclient"
PV = "5.1.0"
PR = "2.el10_3"
PACKAGES = " \
 python-heatclient-doc \
 python3-heatclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-heatclient-5.1.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99da84fe4c27f6bf2ca274156ee977a43675816a98b6992dded2c05b278e85ce"

URI_x86_64_v2_python-heatclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-heatclient-doc-5.1.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-heatclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-heatclient-doc}"
SRC_URI[x86_64_v2_python-heatclient-doc.sha256sum] = "c81ee3bd954fa54b6f020b652ab65eac8fb9da6fbab6bec01799d92608f315f8"

URI_x86_64_v2_python3-heatclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-heatclient-5.1.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-heatclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-heatclient}"
SRC_URI[x86_64_v2_python3-heatclient.sha256sum] = "7c8d40285dea9d506cf43976515f47da4ca2daefa89c308f33b09aacaf616fbc"

URI_aarch64_python-heatclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-heatclient-doc-5.1.0-2.el10_3.noarch.rpm;name=aarch64_python-heatclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-heatclient-doc}"
SRC_URI[aarch64_python-heatclient-doc.sha256sum] = "c5df2f8334f96d0478ce6309adafb8354c1d14497a14d3761edb3b33f18afaf5"

URI_aarch64_python3-heatclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-heatclient-5.1.0-2.el10_3.noarch.rpm;name=aarch64_python3-heatclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-heatclient}"
SRC_URI[aarch64_python3-heatclient.sha256sum] = "4f06c8796f5a48fdd3092d0c132a5b9f5e9cfe0dd291065dbb8d4a7f75081bdb"

RDEPENDS:python-heatclient-doc = " \
 "
RDEPENDS:python3-heatclient = " \
 python3 \
 python3-cliff \
 python3-iso8601 \
 python3-keystoneauth1 \
 python3-osc-lib \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-prettytable \
 python3-pyyaml \
 python3-requests \
 python3-swiftclient \
 "
