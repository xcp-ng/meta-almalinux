# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-mustache"
PV = "1.1.1"
PR = "10.el10_0"
PACKAGES = " \
 rubygem-mustache \
 rubygem-mustache-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-mustache-1.1.1-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "371abe3bfb9bf279b41849e2d635ee4531e3f3a9bbbf83b2b665a6e38ef4d2b4"

URI_x86_64_v2_rubygem-mustache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-mustache-1.1.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-mustache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-mustache}"
SRC_URI[x86_64_v2_rubygem-mustache.sha256sum] = "1c1ea6560f01b59c2f536ccdf4f86a65269dc6ca28e4719f06818b00aee281c9"

URI_x86_64_v2_rubygem-mustache-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-mustache-doc-1.1.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-mustache-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-mustache-doc}"
SRC_URI[x86_64_v2_rubygem-mustache-doc.sha256sum] = "3463a8ac354da6128f9e1d2968f8197b975ab0fd27b744120bfde2de8320d278"

URI_aarch64_rubygem-mustache = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-mustache-1.1.1-10.el10_0.noarch.rpm;name=aarch64_rubygem-mustache;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-mustache}"
SRC_URI[aarch64_rubygem-mustache.sha256sum] = "c564d00af9e87b98b8cda679c73c5d0eb63423acd0f5d3d859815f5efd417d7e"

URI_aarch64_rubygem-mustache-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-mustache-doc-1.1.1-10.el10_0.noarch.rpm;name=aarch64_rubygem-mustache-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-mustache-doc}"
SRC_URI[aarch64_rubygem-mustache-doc.sha256sum] = "8725ccea992eccdcc69649b8a707c64a1199506b14673cb3bd959a95120dcb67"

RDEPENDS:rubygem-mustache = " \
 ruby \
 rubygems \
 "
RDEPENDS:rubygem-mustache-doc = " \
 rubygem-mustache \
 "
