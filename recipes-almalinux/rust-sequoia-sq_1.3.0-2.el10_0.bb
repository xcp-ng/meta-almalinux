# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-sq"
PV = "1.3.0"
PR = "2.el10_0"
PACKAGES = " \
 sequoia-sq \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-sequoia-sq-1.3.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65d0eb8e942d1466c4eaf65c3122cab5de02484e17bc86a4c67efcb52558c25f"

URI_x86_64_v2_sequoia-sq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sequoia-sq-1.3.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_sequoia-sq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sequoia-sq}"
SRC_URI[x86_64_v2_sequoia-sq.sha256sum] = "5669e759cfc928cf9519cc38f04d96a83ae8d3f180b912868407a498ca556093"

URI_aarch64_sequoia-sq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sequoia-sq-1.3.0-2.el10_0.aarch64.rpm;name=aarch64_sequoia-sq;unpack=0"
SRC_URI:append = " ${URI_aarch64_sequoia-sq}"
SRC_URI[aarch64_sequoia-sq.sha256sum] = "5013e41e35d80daec3c4beccad1abddea800f598b576fcc355e4072e3a02dfed"

RDEPENDS:sequoia-sq = " \
 glibc \
 libgcc \
 openssl-libs \
 sqlite-libs \
 "
