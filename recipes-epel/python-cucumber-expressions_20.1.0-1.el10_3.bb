# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cucumber-expressions"
PV = "20.1.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-cucumber-expressions \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-cucumber-expressions-20.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9f7210b22eecf8cc0aef2d167fe6a9bc7e3002b4a76ea3be84ed0fae1287a46e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cucumber-expressions-20.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cucumber-expressions;unpack=0"
SRC_URI[x86_64_v2_python3-cucumber-expressions.sha256sum] = "61ab23023dbcc97d8207df40bbbabb5c42fa14dc09da90b6b6f608ffebc4654a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-cucumber-expressions-20.1.0-1.el10_3.noarch.rpm;name=aarch64_python3-cucumber-expressions;unpack=0"
SRC_URI[aarch64_python3-cucumber-expressions.sha256sum] = "dc86775e3e291d8b15696ee0f779734db7c5db090b482fc3562bdad73d9e41b5"

RDEPENDS:python3-cucumber-expressions = " \
 python3 \
 "
