# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pdns"
PV = "5.0.7"
PR = "1.el10_2"
PACKAGES = " \
 pdns \
 pdns-backend-ldap \
 pdns-backend-lmdb \
 pdns-backend-lua2 \
 pdns-backend-mysql \
 pdns-backend-pipe \
 pdns-backend-postgresql \
 pdns-backend-remote \
 pdns-backend-sqlite \
 pdns-backend-tinydns \
 pdns-ixfrdist \
 pdns-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pdns-5.0.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5196cda36d342b964f831e3ebec2b6ddb1017f08dac6cccb448606456b619b50"

URI_x86_64_v2_pdns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-5.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns}"
SRC_URI[x86_64_v2_pdns.sha256sum] = "bb2cbc21f6ed301ef22233f7c983f31edca56bbb537dd408053b77e433a57690"

URI_x86_64_v2_pdns-backend-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-ldap-5.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-ldap}"
SRC_URI[x86_64_v2_pdns-backend-ldap.sha256sum] = "2440bfe1af4acf194b3e4db2c101bb79b19e8b31a1f50f5332a5bc69a7897e71"

URI_x86_64_v2_pdns-backend-lmdb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-lmdb-5.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-lmdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-lmdb}"
SRC_URI[x86_64_v2_pdns-backend-lmdb.sha256sum] = "47e9169282ee9b5ef18be2396fd9f73c744e4598eff4b468455d7faeee2e753e"

URI_x86_64_v2_pdns-backend-lua2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-lua2-5.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-lua2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-lua2}"
SRC_URI[x86_64_v2_pdns-backend-lua2.sha256sum] = "510cc5701e6f94c9fb7ffb1b0edf23e6c952d065f3a74da11fc8ae1833e7e116"

URI_x86_64_v2_pdns-backend-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-mysql-5.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-mysql}"
SRC_URI[x86_64_v2_pdns-backend-mysql.sha256sum] = "d6335fc38dc0daacd9e84f2518a4f640299e8c19ca3798aa9c67cd3972266d8c"

URI_x86_64_v2_pdns-backend-pipe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-pipe-5.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-pipe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-pipe}"
SRC_URI[x86_64_v2_pdns-backend-pipe.sha256sum] = "051720aee7ae8c9927d1939b7c158a3ee072773d2dfaa0ea1f9a55b0c7df8f1e"

URI_x86_64_v2_pdns-backend-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-postgresql-5.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-postgresql}"
SRC_URI[x86_64_v2_pdns-backend-postgresql.sha256sum] = "09ca11e79006fa0142333843653a3085dad52cf5823223dd35aceb10d4ae8e9d"

URI_x86_64_v2_pdns-backend-remote = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-remote-5.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-remote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-remote}"
SRC_URI[x86_64_v2_pdns-backend-remote.sha256sum] = "78de3fb9344ccdfd4ad93162e9c9d8f09086e162f48c5142e319fd7be15d2820"

URI_x86_64_v2_pdns-backend-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-sqlite-5.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-sqlite}"
SRC_URI[x86_64_v2_pdns-backend-sqlite.sha256sum] = "4e20be58cf658f322c7006e93efc12889cb7f07832880938227285b830a1045b"

URI_x86_64_v2_pdns-backend-tinydns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-tinydns-5.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-tinydns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-tinydns}"
SRC_URI[x86_64_v2_pdns-backend-tinydns.sha256sum] = "4bd90a55ea626a3209627a2fa4266e96905b20b169a408c64ff3c3b1ba09bd79"

URI_x86_64_v2_pdns-ixfrdist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-ixfrdist-5.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-ixfrdist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-ixfrdist}"
SRC_URI[x86_64_v2_pdns-ixfrdist.sha256sum] = "cc5483af364dde69b375860ecec7a434aa64dd497e83b5861ae25eaf3a9e4b54"

URI_x86_64_v2_pdns-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-tools-5.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-tools}"
SRC_URI[x86_64_v2_pdns-tools.sha256sum] = "83af3235461f822970224429049c0ab223ce581eb5a30cb038f2a0fadde09aa5"

URI_aarch64_pdns = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-5.0.7-1.el10_2.aarch64.rpm;name=aarch64_pdns;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns}"
SRC_URI[aarch64_pdns.sha256sum] = "9f5bc167a85997440c02d42a4e1670126ccaaaafec5b970ec3bd0b7e733ed217"

URI_aarch64_pdns-backend-ldap = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-ldap-5.0.7-1.el10_2.aarch64.rpm;name=aarch64_pdns-backend-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-ldap}"
SRC_URI[aarch64_pdns-backend-ldap.sha256sum] = "f5f0090428bde90050be81f659f49e1cfac3c58658f2289480e4fcf45edcdea5"

URI_aarch64_pdns-backend-lmdb = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-lmdb-5.0.7-1.el10_2.aarch64.rpm;name=aarch64_pdns-backend-lmdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-lmdb}"
SRC_URI[aarch64_pdns-backend-lmdb.sha256sum] = "d831c6cbeac6de527c8ede61baeb5d680050c003ac04cb193a104b534f21c6de"

URI_aarch64_pdns-backend-lua2 = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-lua2-5.0.7-1.el10_2.aarch64.rpm;name=aarch64_pdns-backend-lua2;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-lua2}"
SRC_URI[aarch64_pdns-backend-lua2.sha256sum] = "aa69979ad98b5ead3e561aca2b48e1d569a0ad68443f7d17273f14c6a075ccf9"

URI_aarch64_pdns-backend-mysql = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-mysql-5.0.7-1.el10_2.aarch64.rpm;name=aarch64_pdns-backend-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-mysql}"
SRC_URI[aarch64_pdns-backend-mysql.sha256sum] = "ea934ffadfdd766422bc5622bff46d10263fbf0e539057712bdc9f079ccd9ce1"

URI_aarch64_pdns-backend-pipe = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-pipe-5.0.7-1.el10_2.aarch64.rpm;name=aarch64_pdns-backend-pipe;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-pipe}"
SRC_URI[aarch64_pdns-backend-pipe.sha256sum] = "62d986a5a1fc170f5f46d9587ee3097ddb09b65c0d75a02f10d7e3ccf9a5e59c"

URI_aarch64_pdns-backend-postgresql = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-postgresql-5.0.7-1.el10_2.aarch64.rpm;name=aarch64_pdns-backend-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-postgresql}"
SRC_URI[aarch64_pdns-backend-postgresql.sha256sum] = "0d421c5fa875575fed8303986fa55ee7c1b986b78ba234cfb2e8982a04531482"

URI_aarch64_pdns-backend-remote = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-remote-5.0.7-1.el10_2.aarch64.rpm;name=aarch64_pdns-backend-remote;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-remote}"
SRC_URI[aarch64_pdns-backend-remote.sha256sum] = "f0399f60e6836717cf445290f0a9b45a62ea620a7f1ee6329043f3a912336e15"

URI_aarch64_pdns-backend-sqlite = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-sqlite-5.0.7-1.el10_2.aarch64.rpm;name=aarch64_pdns-backend-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-sqlite}"
SRC_URI[aarch64_pdns-backend-sqlite.sha256sum] = "9cc4cdd39ab232b85bf09f08cbebe1ad5adc5de60e1090b35df5cf5b28cc4b78"

URI_aarch64_pdns-backend-tinydns = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-tinydns-5.0.7-1.el10_2.aarch64.rpm;name=aarch64_pdns-backend-tinydns;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-tinydns}"
SRC_URI[aarch64_pdns-backend-tinydns.sha256sum] = "65280e786aa91ec68781d36c9748875a3570c1f85ab27b1f33022a64a13cef29"

URI_aarch64_pdns-ixfrdist = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-ixfrdist-5.0.7-1.el10_2.aarch64.rpm;name=aarch64_pdns-ixfrdist;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-ixfrdist}"
SRC_URI[aarch64_pdns-ixfrdist.sha256sum] = "db6ca5fbab28e61a09976bbcdd285348601711a9fcba15ba0224f8b84123251a"

URI_aarch64_pdns-tools = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-tools-5.0.7-1.el10_2.aarch64.rpm;name=aarch64_pdns-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-tools}"
SRC_URI[aarch64_pdns-tools.sha256sum] = "044d785bb70cb0583274f2010750e111e18592c785f7f083ee405ec951d1a9a9"

RDEPENDS:pdns = " \
 bash \
 boost-program-options \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 luajit \
 openssl-libs \
 p11-kit \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:pdns-backend-ldap = " \
 glibc \
 krb5-libs \
 libgcc \
 libstdc++ \
 openldap \
 pdns \
 "
RDEPENDS:pdns-backend-lmdb = " \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 lmdb-libs \
 pdns \
 systemd-libs \
 "
RDEPENDS:pdns-backend-lua2 = " \
 glibc \
 libgcc \
 libstdc++ \
 luajit \
 pdns \
 "
RDEPENDS:pdns-backend-mysql = " \
 glibc \
 libgcc \
 libstdc++ \
 mariadb-connector-c \
 pdns \
 "
RDEPENDS:pdns-backend-pipe = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-postgresql = " \
 glibc \
 libgcc \
 libpq \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-remote = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-sqlite = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-tinydns = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 tinycdb \
 "
RDEPENDS:pdns-ixfrdist = " \
 boost-program-options \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 openssl-libs \
 p11-kit \
 yaml-cpp \
 "
RDEPENDS:pdns-tools = " \
 boost-program-options \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 openssl-libs \
 p11-kit \
 virtual/libcurl.so.4___64bit_ \
 "
