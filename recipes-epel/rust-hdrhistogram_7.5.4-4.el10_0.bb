# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hdrhistogram"
PV = "7.5.4"
PR = "4.el10_0"
PACKAGES = " \
 rust-hdrhistogram+base64-devel \
 rust-hdrhistogram+bench_private-devel \
 rust-hdrhistogram+crossbeam-channel-devel \
 rust-hdrhistogram+default-devel \
 rust-hdrhistogram+flate2-devel \
 rust-hdrhistogram+nom-devel \
 rust-hdrhistogram+serialization-devel \
 rust-hdrhistogram+sync-devel \
 rust-hdrhistogram-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hdrhistogram-7.5.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33bf087c2e64a8775a62f0a2021a9a739371e55516cfd41a98c69868b7925430"

URI_x86_64_v2_rust-hdrhistogram+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hdrhistogram+base64-devel-7.5.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hdrhistogram+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hdrhistogram+base64-devel}"
SRC_URI[x86_64_v2_rust-hdrhistogram+base64-devel.sha256sum] = "1784f7e1055789515d844143923b78b5d1fa99ef4a6fa4c1f10c5b8f21a14535"

URI_x86_64_v2_rust-hdrhistogram+bench_private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hdrhistogram+bench_private-devel-7.5.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hdrhistogram+bench_private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hdrhistogram+bench_private-devel}"
SRC_URI[x86_64_v2_rust-hdrhistogram+bench_private-devel.sha256sum] = "55b7ec5638a31a475a67a9d186fd21b8e323a3a075bae60cb8d9a9cc4b418df1"

URI_x86_64_v2_rust-hdrhistogram+crossbeam-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hdrhistogram+crossbeam-channel-devel-7.5.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hdrhistogram+crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hdrhistogram+crossbeam-channel-devel}"
SRC_URI[x86_64_v2_rust-hdrhistogram+crossbeam-channel-devel.sha256sum] = "448dbc737f67d49c0bcc15d209c8f2836350bbf0a8341d4a0fed8c0d175c8ee9"

URI_x86_64_v2_rust-hdrhistogram+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hdrhistogram+default-devel-7.5.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hdrhistogram+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hdrhistogram+default-devel}"
SRC_URI[x86_64_v2_rust-hdrhistogram+default-devel.sha256sum] = "135130acd78e361120f7240dd084c49629b0c6ac035463f21a0693920dd0722f"

URI_x86_64_v2_rust-hdrhistogram+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hdrhistogram+flate2-devel-7.5.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hdrhistogram+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hdrhistogram+flate2-devel}"
SRC_URI[x86_64_v2_rust-hdrhistogram+flate2-devel.sha256sum] = "29ebe05ec80375d05b0c7dfce1cb0d0d0f7eaec646b001025ff2ddf319d6d49f"

URI_x86_64_v2_rust-hdrhistogram+nom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hdrhistogram+nom-devel-7.5.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hdrhistogram+nom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hdrhistogram+nom-devel}"
SRC_URI[x86_64_v2_rust-hdrhistogram+nom-devel.sha256sum] = "959ef024d5b3a90304c4d3cfde8c20c1a629175944012780eafb0aa2b61b670c"

URI_x86_64_v2_rust-hdrhistogram+serialization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hdrhistogram+serialization-devel-7.5.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hdrhistogram+serialization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hdrhistogram+serialization-devel}"
SRC_URI[x86_64_v2_rust-hdrhistogram+serialization-devel.sha256sum] = "b52828789a0cffafa986688b21d096dbfc71480fbf72e6fa1d00841cfdf86855"

URI_x86_64_v2_rust-hdrhistogram+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hdrhistogram+sync-devel-7.5.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hdrhistogram+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hdrhistogram+sync-devel}"
SRC_URI[x86_64_v2_rust-hdrhistogram+sync-devel.sha256sum] = "45ccae815bcf7447caf415f853b267e80b08354bf54c0dedbe3dfd2a78d3459e"

URI_x86_64_v2_rust-hdrhistogram-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hdrhistogram-devel-7.5.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hdrhistogram-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hdrhistogram-devel}"
SRC_URI[x86_64_v2_rust-hdrhistogram-devel.sha256sum] = "6947d1346637fb0adfcbfae61fa3468144676a9b4c9928c8552298a563a94d70"

URI_aarch64_rust-hdrhistogram+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hdrhistogram+base64-devel-7.5.4-4.el10_0.noarch.rpm;name=aarch64_rust-hdrhistogram+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hdrhistogram+base64-devel}"
SRC_URI[aarch64_rust-hdrhistogram+base64-devel.sha256sum] = "f1646ae67f18f17321b3e3a38ff152196d1b185ec79befc96ffb91d109fab519"

URI_aarch64_rust-hdrhistogram+bench_private-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hdrhistogram+bench_private-devel-7.5.4-4.el10_0.noarch.rpm;name=aarch64_rust-hdrhistogram+bench_private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hdrhistogram+bench_private-devel}"
SRC_URI[aarch64_rust-hdrhistogram+bench_private-devel.sha256sum] = "28d4a047e26d00424571a941b26c99b05835353cd9a25fdc6c4f1bd32587fa5e"

URI_aarch64_rust-hdrhistogram+crossbeam-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hdrhistogram+crossbeam-channel-devel-7.5.4-4.el10_0.noarch.rpm;name=aarch64_rust-hdrhistogram+crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hdrhistogram+crossbeam-channel-devel}"
SRC_URI[aarch64_rust-hdrhistogram+crossbeam-channel-devel.sha256sum] = "730f35ce499f543f6c17c947a41368a03aed5cc2bbfbf6fee313a1588bb1685d"

URI_aarch64_rust-hdrhistogram+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hdrhistogram+default-devel-7.5.4-4.el10_0.noarch.rpm;name=aarch64_rust-hdrhistogram+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hdrhistogram+default-devel}"
SRC_URI[aarch64_rust-hdrhistogram+default-devel.sha256sum] = "15754e1ab73fa3b435f218dc565874200986aadb79cc2eb449d6b27ff5fe4c06"

URI_aarch64_rust-hdrhistogram+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hdrhistogram+flate2-devel-7.5.4-4.el10_0.noarch.rpm;name=aarch64_rust-hdrhistogram+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hdrhistogram+flate2-devel}"
SRC_URI[aarch64_rust-hdrhistogram+flate2-devel.sha256sum] = "96f761b762b2112ee434c3152f90de12c6c11108d2a3ced530e9551a23b01975"

URI_aarch64_rust-hdrhistogram+nom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hdrhistogram+nom-devel-7.5.4-4.el10_0.noarch.rpm;name=aarch64_rust-hdrhistogram+nom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hdrhistogram+nom-devel}"
SRC_URI[aarch64_rust-hdrhistogram+nom-devel.sha256sum] = "c3c20da0cd3f361a2ad750bda73071e7e4727592aa4c25e94677da711c251c9c"

URI_aarch64_rust-hdrhistogram+serialization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hdrhistogram+serialization-devel-7.5.4-4.el10_0.noarch.rpm;name=aarch64_rust-hdrhistogram+serialization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hdrhistogram+serialization-devel}"
SRC_URI[aarch64_rust-hdrhistogram+serialization-devel.sha256sum] = "da9fe0eb738401c3b39c276ce14b7cbe1762d03967f1edda5ba94e77f5a255db"

URI_aarch64_rust-hdrhistogram+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hdrhistogram+sync-devel-7.5.4-4.el10_0.noarch.rpm;name=aarch64_rust-hdrhistogram+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hdrhistogram+sync-devel}"
SRC_URI[aarch64_rust-hdrhistogram+sync-devel.sha256sum] = "83253922e7ed97094f4b8459156e84c51f556107ca969572bcb13d0507cbc001"

URI_aarch64_rust-hdrhistogram-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hdrhistogram-devel-7.5.4-4.el10_0.noarch.rpm;name=aarch64_rust-hdrhistogram-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hdrhistogram-devel}"
SRC_URI[aarch64_rust-hdrhistogram-devel.sha256sum] = "940ccff9b86edd1fa231869e104bc2844bfa5a823d50d8bbb063dd568e5e2386"

RDEPENDS:rust-hdrhistogram+base64-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-hdrhistogram-devel \
 "
RDEPENDS:rust-hdrhistogram+bench_private-devel = " \
 cargo \
 rust-hdrhistogram-devel \
 "
RDEPENDS:rust-hdrhistogram+crossbeam-channel-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-hdrhistogram-devel \
 "
RDEPENDS:rust-hdrhistogram+default-devel = " \
 cargo \
 rust-hdrhistogram+serialization-devel \
 rust-hdrhistogram+sync-devel \
 rust-hdrhistogram-devel \
 "
RDEPENDS:rust-hdrhistogram+flate2-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-hdrhistogram-devel \
 "
RDEPENDS:rust-hdrhistogram+nom-devel = " \
 cargo \
 rust-hdrhistogram-devel \
 rust-nom+default-devel \
 "
RDEPENDS:rust-hdrhistogram+serialization-devel = " \
 cargo \
 rust-hdrhistogram+base64-devel \
 rust-hdrhistogram+flate2-devel \
 rust-hdrhistogram+nom-devel \
 rust-hdrhistogram-devel \
 "
RDEPENDS:rust-hdrhistogram+sync-devel = " \
 cargo \
 rust-hdrhistogram+crossbeam-channel-devel \
 rust-hdrhistogram-devel \
 "
RDEPENDS:rust-hdrhistogram-devel = " \
 cargo \
 rust-byteorder+default-devel \
 rust-num-traits+default-devel \
 "
