# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "duf"
PV = "0.9.1"
PR = "3.el10_3"
PACKAGES = " \
 duf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/duf-0.9.1-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0de15b90bac52a362afc7c4f2d1db8b3bd9237af18e4d0e0e2b765758758743a"

URI_x86_64_v2_duf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duf-0.9.1-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_duf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duf}"
SRC_URI[x86_64_v2_duf.sha256sum] = "b28ae75119705ba61c79223a575b879eed5075009d5d66eb1962bf5ac733bf11"

URI_aarch64_duf = "${EPEL_MIRROR}/aarch64/Packages/d/duf-0.9.1-3.el10_3.aarch64.rpm;name=aarch64_duf;unpack=0"
SRC_URI:append = " ${URI_aarch64_duf}"
SRC_URI[aarch64_duf.sha256sum] = "e0710dbe7e9776ddf0ea5efdc142df52301215ea5e4a211c864656fb0854ead7"

RDEPENDS:duf = " \
 glibc \
 "
