# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-forked"
PV = "1.6.0"
PR = "8.el10_0"
PACKAGES = " \
 python3-pytest-forked \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-forked-1.6.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "891a97b7b2fc033b8250a20cefdfb28160f225106bf9f7b16c7ba0101e3965de"

URI_x86_64_v2_python3-pytest-forked = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-forked-1.6.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-forked;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-forked}"
SRC_URI[x86_64_v2_python3-pytest-forked.sha256sum] = "02e222b577fcefab9f12995cb810e02ad31c738dcb6873b73ada26a1dda3a14c"

URI_aarch64_python3-pytest-forked = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-forked-1.6.0-8.el10_0.noarch.rpm;name=aarch64_python3-pytest-forked;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-forked}"
SRC_URI[aarch64_python3-pytest-forked.sha256sum] = "2b300e816461e231c05925241ba01e64a7e2777f074119af32d8ff15e0acca6d"

RDEPENDS:python3-pytest-forked = " \
 python3 \
 python3-py \
 python3-pytest \
 "
