# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-desktop-portal-kde"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 xdg-desktop-portal-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xdg-desktop-portal-kde-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12ec93f08f36b66cf9e44707f785920ddfb5a3194826d36c42b00eb91bf0ecb0"

URI_x86_64_v2_xdg-desktop-portal-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xdg-desktop-portal-kde-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xdg-desktop-portal-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-desktop-portal-kde}"
SRC_URI[x86_64_v2_xdg-desktop-portal-kde.sha256sum] = "a23365e8ed9bb68a7340a1fc8b9e968689eedd57de011215f852d62d83a04cd5"

URI_aarch64_xdg-desktop-portal-kde = "${EPEL_MIRROR}/aarch64/Packages/x/xdg-desktop-portal-kde-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_xdg-desktop-portal-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-desktop-portal-kde}"
SRC_URI[aarch64_xdg-desktop-portal-kde.sha256sum] = "2d88a33995db0ae71e62a55c026b64b9956c51c96713daf661feb1e296b61a48"

RDEPENDS:xdg-desktop-portal-kde = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifications \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kwayland \
 libstdc++ \
 libwayland-client \
 libxkbcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 xdg-desktop-portal \
 xdg-desktop-portal-gtk \
 "
