# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-pandoc-types"
PV = "1.23.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-pandoc-types \
 ghc-pandoc-types-devel \
 ghc-pandoc-types-doc \
 ghc-pandoc-types-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-pandoc-types-1.23.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7561b17b0008479a0c7db1d0c810310d5c6b4ea804d41d35da810045d7cb6995"

URI_x86_64_v2_ghc-pandoc-types = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-types-1.23.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-types;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-types}"
SRC_URI[x86_64_v2_ghc-pandoc-types.sha256sum] = "eb4205db26955227732f3a70707326d713bf78c0e7ef5f5eb1b3d961909a3864"

URI_x86_64_v2_ghc-pandoc-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-types-devel-1.23.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-types-devel}"
SRC_URI[x86_64_v2_ghc-pandoc-types-devel.sha256sum] = "f5ede5983aebdd38f10da86ae8c148be1a2f497ae17bd0c2cd5c5334f9bb7dd7"

URI_x86_64_v2_ghc-pandoc-types-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-types-doc-1.23.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-pandoc-types-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-types-doc}"
SRC_URI[x86_64_v2_ghc-pandoc-types-doc.sha256sum] = "a70596e02920de85c92e6f043a3b69fc896cf4a0d2555ae59193481fd38b0d51"

URI_x86_64_v2_ghc-pandoc-types-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-types-prof-1.23.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-types-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-types-prof}"
SRC_URI[x86_64_v2_ghc-pandoc-types-prof.sha256sum] = "e4759e14951d33d4aae3d0a7e1f65a12c8fd57c7da24a670c8f617a834c494a7"

URI_aarch64_ghc-pandoc-types = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-types-1.23.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-pandoc-types;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-types}"
SRC_URI[aarch64_ghc-pandoc-types.sha256sum] = "9545748f6a7cb858cf33582b23db7892c44b8b9e61e282eab3212e093f7c2e6c"

URI_aarch64_ghc-pandoc-types-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-types-devel-1.23.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-pandoc-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-types-devel}"
SRC_URI[aarch64_ghc-pandoc-types-devel.sha256sum] = "cfe52c19ea4426d3e512a37598bb4247582ce421b937d0c7054aee81448310a6"

URI_aarch64_ghc-pandoc-types-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-types-doc-1.23.1-1.el10_0.noarch.rpm;name=aarch64_ghc-pandoc-types-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-types-doc}"
SRC_URI[aarch64_ghc-pandoc-types-doc.sha256sum] = "0708f4f03763ea2dab550cadde10822c8767a48aecdc509771f8e7afb0852ce0"

URI_aarch64_ghc-pandoc-types-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-types-prof-1.23.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-pandoc-types-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-types-prof}"
SRC_URI[aarch64_ghc-pandoc-types-prof.sha256sum] = "0259a4e1bcc08812839bd56e6452d0e573b40b40733a3851f70f9023e4ed003d"

RDEPENDS:ghc-pandoc-types = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-syb \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-pandoc-types-devel = " \
 ghc-QuickCheck-devel \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-pandoc-types \
 ghc-syb-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-pandoc-types-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-pandoc-types-prof = " \
 ghc-QuickCheck-prof \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-pandoc-types-devel \
 ghc-syb-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 "
