# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql18"
PV = "18.3"
PR = "1.el10"
PACKAGES = " \
 postgresql18 \
 postgresql18-contrib \
 postgresql18-docs \
 postgresql18-plperl \
 postgresql18-plpython3 \
 postgresql18-private-devel \
 postgresql18-private-libs \
 postgresql18-server \
 postgresql18-server-devel \
 postgresql18-static \
 postgresql18-test \
 postgresql18-test-rpm-macros \
 postgresql18-upgrade \
 postgresql18-upgrade-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql18-18.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96f12de3f0c24e31f1d9e887c7246805920b440e396c30d34dad985cc76225bd"

URI_x86_64_v2_postgresql18 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-18.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18}"
SRC_URI[x86_64_v2_postgresql18.sha256sum] = "8e17c64a5ff24105d51cf91988b52837f56de7ce974d67298592c5cac5f70291"

URI_x86_64_v2_postgresql18-contrib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-contrib-18.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-contrib}"
SRC_URI[x86_64_v2_postgresql18-contrib.sha256sum] = "f37905f9fc22ca9c3d0a47931de40d4225af06b0eced210233d1128e55479327"

URI_x86_64_v2_postgresql18-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-docs-18.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-docs}"
SRC_URI[x86_64_v2_postgresql18-docs.sha256sum] = "85a0105758679d39e42f961c3609c069f6ac7d45421264012fc96593434dc757"

URI_x86_64_v2_postgresql18-plperl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-plperl-18.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-plperl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-plperl}"
SRC_URI[x86_64_v2_postgresql18-plperl.sha256sum] = "82a7a7e8af7716b5577ba1ab524c559d3f6b130f394004892bee769f8810011f"

URI_x86_64_v2_postgresql18-plpython3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-plpython3-18.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-plpython3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-plpython3}"
SRC_URI[x86_64_v2_postgresql18-plpython3.sha256sum] = "06b7c5de5beba46c4acbded20c1c71a2daf8afc2935d1697ad1fe280c9c9f0f3"

URI_x86_64_v2_postgresql18-private-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-private-devel-18.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-private-devel}"
SRC_URI[x86_64_v2_postgresql18-private-devel.sha256sum] = "eeddc074b47f75de8d4fcd71e8f2e9a6067b53e9f75ef3884478f1e021e5e553"

URI_x86_64_v2_postgresql18-private-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-private-libs-18.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-private-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-private-libs}"
SRC_URI[x86_64_v2_postgresql18-private-libs.sha256sum] = "86b6eb63f500946b2a656ea6cb9040b71537b0bed1832046ba96548e79775f22"

URI_x86_64_v2_postgresql18-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-server-18.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-server}"
SRC_URI[x86_64_v2_postgresql18-server.sha256sum] = "7f2c253158a39451799ace57737c931461bd747667c1a9775c4923fe109deaa8"

URI_x86_64_v2_postgresql18-server-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-server-devel-18.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-server-devel}"
SRC_URI[x86_64_v2_postgresql18-server-devel.sha256sum] = "d9e4b7108d00c32dc1bc1e1cffe3cfec55b7324b59c3d7bdf4db0120336dd319"

URI_x86_64_v2_postgresql18-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-static-18.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-static}"
SRC_URI[x86_64_v2_postgresql18-static.sha256sum] = "648c21b05ad000d77fc0b2ead32d6d834e42c6abad9a2bcb6b42f5793285d9fb"

URI_x86_64_v2_postgresql18-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-test-18.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-test}"
SRC_URI[x86_64_v2_postgresql18-test.sha256sum] = "f5c45621b48153d2521beccd1cafb9b89ec8566a58aee1630e02f19a6e6e4b26"

URI_x86_64_v2_postgresql18-test-rpm-macros = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/postgresql18-test-rpm-macros-18.3-1.el10.noarch.rpm;name=x86_64_v2_postgresql18-test-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-test-rpm-macros}"
SRC_URI[x86_64_v2_postgresql18-test-rpm-macros.sha256sum] = "14b26c46c0e6ee41dc58e175fdea52e7df40bd8bb3d0e3ae4202c5b31ff164dd"

URI_x86_64_v2_postgresql18-upgrade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-upgrade-18.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-upgrade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-upgrade}"
SRC_URI[x86_64_v2_postgresql18-upgrade.sha256sum] = "36c5e40a790ef5a5bc9dcfd7394a68a4e9f7393b5e988c714b31ca4ae1a7a1dc"

URI_x86_64_v2_postgresql18-upgrade-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-upgrade-devel-18.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-upgrade-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-upgrade-devel}"
SRC_URI[x86_64_v2_postgresql18-upgrade-devel.sha256sum] = "799722346887f92fb7b142535f2646a7b0e64e99cebdb5c84bb9cebdcca4c9f6"

URI_aarch64_postgresql18 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-18.3-1.el10.aarch64.rpm;name=aarch64_postgresql18;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18}"
SRC_URI[aarch64_postgresql18.sha256sum] = "bd6e114798e1519a3ef66f1bc8e1e854afa13d32a29b7563a8efa68c8446b428"

URI_aarch64_postgresql18-contrib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-contrib-18.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-contrib}"
SRC_URI[aarch64_postgresql18-contrib.sha256sum] = "8e62c8b2fb130e04ed989e8a4fc79817f3d56c55dc390022bb17337cbb643667"

URI_aarch64_postgresql18-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-docs-18.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-docs}"
SRC_URI[aarch64_postgresql18-docs.sha256sum] = "48e4108d8df0ea3af595e601b7a2a7968c9fe87ae1c74c625903021d7fd9eca1"

URI_aarch64_postgresql18-plperl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-plperl-18.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-plperl;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-plperl}"
SRC_URI[aarch64_postgresql18-plperl.sha256sum] = "7cd9d5e7dc6fbe2cd5ec4f64a957d51d110600e28bc1719f5a519d61ab7fe113"

URI_aarch64_postgresql18-plpython3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-plpython3-18.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-plpython3;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-plpython3}"
SRC_URI[aarch64_postgresql18-plpython3.sha256sum] = "3ea93460c01341920dc13ecd3ffe64b38f1c8b8f5a3a8e5f4aa6acec96e937b0"

URI_aarch64_postgresql18-private-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-private-devel-18.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-private-devel}"
SRC_URI[aarch64_postgresql18-private-devel.sha256sum] = "720798d7c0ffd74e324d6b90025ca1f2f89b43da0f1983735dd15b397b203d5e"

URI_aarch64_postgresql18-private-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-private-libs-18.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-private-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-private-libs}"
SRC_URI[aarch64_postgresql18-private-libs.sha256sum] = "cf1a073f0b40afa86fa06896ea88dd5daa739acd8a02c1ecb5d9250ff0a775af"

URI_aarch64_postgresql18-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-server-18.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-server}"
SRC_URI[aarch64_postgresql18-server.sha256sum] = "5e9143f34c66ad8bd691bbaf8e05ea9d552d6f262eeb5eb24b9b81bd3c8ecaef"

URI_aarch64_postgresql18-server-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-server-devel-18.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-server-devel}"
SRC_URI[aarch64_postgresql18-server-devel.sha256sum] = "37b4c6f0a481079d6080c4da9d47dc26b101be68f897c50507880caee8400432"

URI_aarch64_postgresql18-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-static-18.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-static}"
SRC_URI[aarch64_postgresql18-static.sha256sum] = "dfccece2385d78f03754b06f586e37cafca8c37a49985756012d4f8b6ebd4e82"

URI_aarch64_postgresql18-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-test-18.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-test}"
SRC_URI[aarch64_postgresql18-test.sha256sum] = "42da5b3ed5c77530349247acb199315eafa153d6abc67a3e8d467452f62449b3"

URI_aarch64_postgresql18-test-rpm-macros = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/postgresql18-test-rpm-macros-18.3-1.el10.noarch.rpm;name=aarch64_postgresql18-test-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-test-rpm-macros}"
SRC_URI[aarch64_postgresql18-test-rpm-macros.sha256sum] = "14b26c46c0e6ee41dc58e175fdea52e7df40bd8bb3d0e3ae4202c5b31ff164dd"

URI_aarch64_postgresql18-upgrade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-upgrade-18.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-upgrade;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-upgrade}"
SRC_URI[aarch64_postgresql18-upgrade.sha256sum] = "a05badb864f1e9cc64a3cdedda2e2e421a8461d693d57c821e37533be86dea27"

URI_aarch64_postgresql18-upgrade-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-upgrade-devel-18.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-upgrade-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-upgrade-devel}"
SRC_URI[aarch64_postgresql18-upgrade-devel.sha256sum] = "6a51756463d32c68485601042930ebde94d605e73689d5ce1450fa5ce2e656ca"

RDEPENDS:postgresql18 = " \
 glibc \
 libzstd \
 lz4-libs \
 openssl-libs \
 postgresql18-private-libs \
 readline \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-contrib = " \
 glibc \
 libselinux \
 libxml2 \
 libxslt \
 libzstd \
 lz4-libs \
 openssl-libs \
 perl-libs \
 postgresql18 \
 postgresql18-private-libs \
 python3-libs \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-docs = " \
 glibc \
 postgresql18 \
 "
RDEPENDS:postgresql18-plperl = " \
 glibc \
 perl-libs \
 postgresql18-server \
 "
RDEPENDS:postgresql18-plpython3 = " \
 glibc \
 postgresql18-server \
 python3-libs \
 "
RDEPENDS:postgresql18-private-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 postgresql18-private-libs \
 "
RDEPENDS:postgresql18-private-libs = " \
 glibc \
 krb5-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:postgresql18-server = " \
 bash \
 glibc \
 krb5-libs \
 libicu \
 libxml2 \
 libzstd \
 lz4-libs \
 openldap \
 openssl-libs \
 pam-libs \
 postgresql18 \
 postgresql18-private-libs \
 systemd \
 systemd-libs \
 util-linux \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-server-devel = " \
 bash \
 glibc \
 krb5-devel \
 libicu-devel \
 postgresql18-private-devel \
 postgresql18-private-libs \
 "
RDEPENDS:postgresql18-static = " \
 postgresql18-server-devel \
 "
RDEPENDS:postgresql18-test = " \
 bash \
 glibc \
 postgresql18-contrib \
 postgresql18-server \
 postgresql18-server-devel \
 "
RDEPENDS:postgresql18-test-rpm-macros = " \
 postgresql18-server \
 "
RDEPENDS:postgresql18-upgrade = " \
 glibc \
 krb5-libs \
 libicu \
 libselinux \
 libxml2 \
 libxslt \
 libzstd \
 lz4-libs \
 openldap \
 openssl-libs \
 pam-libs \
 perl-libs \
 postgresql18-private-libs \
 postgresql18-server \
 python3-libs \
 tcl \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-upgrade-devel = " \
 bash \
 glibc \
 postgresql18-private-libs \
 postgresql18-upgrade \
 "
