# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-Find-Iterator"
PV = "0.4"
PR = "39.el10_0"
PACKAGES = " \
 perl-File-Find-Iterator \
 perl-File-Find-Iterator-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-Find-Iterator-0.4-39.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82eed29f11395d9b53b1fbd330a43a28efed31399282a7622ad65c37cbf34b96"

URI_x86_64_v2_perl-File-Find-Iterator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Find-Iterator-0.4-39.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Find-Iterator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Find-Iterator}"
SRC_URI[x86_64_v2_perl-File-Find-Iterator.sha256sum] = "d76882c3a9d2d1f0c9f7782079ecfccf646ab29064b3cad733666f7d18a96506"

URI_x86_64_v2_perl-File-Find-Iterator-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Find-Iterator-tests-0.4-39.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Find-Iterator-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Find-Iterator-tests}"
SRC_URI[x86_64_v2_perl-File-Find-Iterator-tests.sha256sum] = "23c24e214387b4e2e7e1ebc7db289b72cfd3dda1358c7cba8f98e08eeb2a82ea"

URI_aarch64_perl-File-Find-Iterator = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Find-Iterator-0.4-39.el10_0.noarch.rpm;name=aarch64_perl-File-Find-Iterator;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Find-Iterator}"
SRC_URI[aarch64_perl-File-Find-Iterator.sha256sum] = "7db46ba62017f7263253933936c4b0c3548a6f13dbe77b4a5210115946c360f1"

URI_aarch64_perl-File-Find-Iterator-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Find-Iterator-tests-0.4-39.el10_0.noarch.rpm;name=aarch64_perl-File-Find-Iterator-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Find-Iterator-tests}"
SRC_URI[aarch64_perl-File-Find-Iterator-tests.sha256sum] = "6144940dde5b236129e0fa441c3037acdc25178cb3fe94eecc7b8fb6dba6ff29"

RDEPENDS:perl-File-Find-Iterator = " \
 perl-Carp \
 perl-Class-Iterator \
 perl-Exporter \
 perl-IO \
 perl-Storable \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-File-Find-Iterator-tests = " \
 bash \
 perl-File-Find-Iterator \
 perl-File-Temp \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 "
