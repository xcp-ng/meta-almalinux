# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mariadb11.8"
PE = "3"
PV = "11.8.8"
PR = "1.el10_2.alma.2"
PACKAGES = " \
 mariadb11.8 \
 mariadb11.8-backup \
 mariadb11.8-client-utils \
 mariadb11.8-common \
 mariadb11.8-devel \
 mariadb11.8-embedded \
 mariadb11.8-embedded-devel \
 mariadb11.8-errmsg \
 mariadb11.8-gssapi-server \
 mariadb11.8-oqgraph-engine \
 mariadb11.8-pam \
 mariadb11.8-server \
 mariadb11.8-server-galera \
 mariadb11.8-server-utils \
 mariadb11.8-test \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mariadb11.8-11.8.8-1.el10_2.alma.2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d463b5fe5ca525537bc979f6c31455bc8aca2b69ffd72b0cdb8c5f934c12dd80"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-11.8.8-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8;unpack=0"
SRC_URI[x86_64_v2_mariadb11.8.sha256sum] = "ab287ec447e5b9bbc1333ed9813c9622abd4d3464e654812fecb30cc58a437de"
RPROVIDES:mariadb11.8:append:x86_64_v2 = " virtual//usr/bin/mariadb-dump virtual//usr/bin/mysqldump"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-backup-11.8.8-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-backup;unpack=0"
SRC_URI[x86_64_v2_mariadb11.8-backup.sha256sum] = "8b994ed284056449f83be5528cc15a0e158a3b063e30741f5175934b42ff7916"
RPROVIDES:mariadb11.8-backup:append:x86_64_v2 = " virtual//usr/bin/mariabackup"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-client-utils-11.8.8-1.el10_2.alma.2.noarch.rpm;name=x86_64_v2_mariadb11.8-client-utils;unpack=0"
SRC_URI[x86_64_v2_mariadb11.8-client-utils.sha256sum] = "7d3ee78f6c478ad0b7548040fb0ebe5e01475bcb823f7d66e62a7c8c1a619652"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-common-11.8.8-1.el10_2.alma.2.noarch.rpm;name=x86_64_v2_mariadb11.8-common;unpack=0"
SRC_URI[x86_64_v2_mariadb11.8-common.sha256sum] = "b7d5f863aab83ca297ef44500b20c639c7c8f43fe8b83bce534208e7387396c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-devel-11.8.8-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-devel;unpack=0"
SRC_URI[x86_64_v2_mariadb11.8-devel.sha256sum] = "c7dc226090f9e1ae6a1bb09bb9b60ec610adf7f640a8ec0be9654d64712f1f7a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-embedded-11.8.8-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-embedded;unpack=0"
SRC_URI[x86_64_v2_mariadb11.8-embedded.sha256sum] = "862d50d2345b125eee6373600b39b35551d17d69038f3826fe4a1b3a34dd02c3"
RPROVIDES:mariadb11.8-embedded:append:x86_64_v2 = " virtual/libmariadbd.so.19___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-embedded-devel-11.8.8-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-embedded-devel;unpack=0"
SRC_URI[x86_64_v2_mariadb11.8-embedded-devel.sha256sum] = "7ccf8bbb3533b587d417d2b7df122b4ceaa6c7494f044c48797c4ae047ee2aab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-errmsg-11.8.8-1.el10_2.alma.2.noarch.rpm;name=x86_64_v2_mariadb11.8-errmsg;unpack=0"
SRC_URI[x86_64_v2_mariadb11.8-errmsg.sha256sum] = "adf80a3ef819a38f4a5d706c1f8c03d255feaf6f0b5beee34b9d1127ab1b8f19"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-gssapi-server-11.8.8-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-gssapi-server;unpack=0"
SRC_URI[x86_64_v2_mariadb11.8-gssapi-server.sha256sum] = "0ae980d6afcbe63e723513606ad063f66f05565953191b9cacf2747bfa25b7d8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-oqgraph-engine-11.8.8-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-oqgraph-engine;unpack=0"
SRC_URI[x86_64_v2_mariadb11.8-oqgraph-engine.sha256sum] = "a29f31fc5295a2ffd6d55f65f8a3a1523668e29bf8a6e8c712715ee99b1e7db9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-pam-11.8.8-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-pam;unpack=0"
SRC_URI[x86_64_v2_mariadb11.8-pam.sha256sum] = "7273f5b34e802c953079a3345ef89fed7ab04695337469607fd5fd1699bf7254"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-server-11.8.8-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-server;unpack=0"
SRC_URI[x86_64_v2_mariadb11.8-server.sha256sum] = "b3808a0175ba17f1fad3137f17ce0a54de33dc52e0d8ace1dfe90f288ddca4bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-server-galera-11.8.8-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-server-galera;unpack=0"
SRC_URI[x86_64_v2_mariadb11.8-server-galera.sha256sum] = "7d554334f8499b7b1341b40da7d690c105f357ad18fd5d6c4db9749a73659137"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-server-utils-11.8.8-1.el10_2.alma.2.noarch.rpm;name=x86_64_v2_mariadb11.8-server-utils;unpack=0"
SRC_URI[x86_64_v2_mariadb11.8-server-utils.sha256sum] = "fabb70ae5b1f60bdc7ef37aa4cb3b8f0a1e565879a52c3fd65ff4dfdb6555033"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb11.8-test-11.8.8-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb11.8-test;unpack=0"
SRC_URI[x86_64_v2_mariadb11.8-test.sha256sum] = "4c945bca23a8574674c230e19b2610d417ccab89e385af9c0c4e83230744e0eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-11.8.8-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb11.8;unpack=0"
SRC_URI[aarch64_mariadb11.8.sha256sum] = "517291b9e9a001dbcb3537010a08447988eec7eb8a85c1f159d10f45b11770a5"
RPROVIDES:mariadb11.8:append:aarch64 = " virtual//usr/bin/mariadb-dump virtual//usr/bin/mysqldump"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-backup-11.8.8-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb11.8-backup;unpack=0"
SRC_URI[aarch64_mariadb11.8-backup.sha256sum] = "aa5008defb9c656367e389114260403697c9d0a796de696703fdb58196627542"
RPROVIDES:mariadb11.8-backup:append:aarch64 = " virtual//usr/bin/mariabackup"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-client-utils-11.8.8-1.el10_2.alma.2.noarch.rpm;name=aarch64_mariadb11.8-client-utils;unpack=0"
SRC_URI[aarch64_mariadb11.8-client-utils.sha256sum] = "7d3ee78f6c478ad0b7548040fb0ebe5e01475bcb823f7d66e62a7c8c1a619652"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-common-11.8.8-1.el10_2.alma.2.noarch.rpm;name=aarch64_mariadb11.8-common;unpack=0"
SRC_URI[aarch64_mariadb11.8-common.sha256sum] = "b7d5f863aab83ca297ef44500b20c639c7c8f43fe8b83bce534208e7387396c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-devel-11.8.8-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb11.8-devel;unpack=0"
SRC_URI[aarch64_mariadb11.8-devel.sha256sum] = "cb0cc336e884f659ce5a3d121b5571ec37f5933b5b2f6faabebe16f34c26e92f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-embedded-11.8.8-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb11.8-embedded;unpack=0"
SRC_URI[aarch64_mariadb11.8-embedded.sha256sum] = "01585ebe78bd2e23f3c3092e9a2b5038976e8d925f57a39abe69a5236d476239"
RPROVIDES:mariadb11.8-embedded:append:aarch64 = " virtual/libmariadbd.so.19___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-embedded-devel-11.8.8-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb11.8-embedded-devel;unpack=0"
SRC_URI[aarch64_mariadb11.8-embedded-devel.sha256sum] = "f25f523c76ffd2490033f6cb45c937c0538cc1c31e84960e75c38f2a3f07ddc6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-errmsg-11.8.8-1.el10_2.alma.2.noarch.rpm;name=aarch64_mariadb11.8-errmsg;unpack=0"
SRC_URI[aarch64_mariadb11.8-errmsg.sha256sum] = "adf80a3ef819a38f4a5d706c1f8c03d255feaf6f0b5beee34b9d1127ab1b8f19"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-gssapi-server-11.8.8-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb11.8-gssapi-server;unpack=0"
SRC_URI[aarch64_mariadb11.8-gssapi-server.sha256sum] = "ab3481396036f446702f9ae6f6433b9a76d628991f6095827ffb6aad4ba8ba38"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-oqgraph-engine-11.8.8-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb11.8-oqgraph-engine;unpack=0"
SRC_URI[aarch64_mariadb11.8-oqgraph-engine.sha256sum] = "9baf0e18109393d0ef5a9b2352b5ec7f56b03fd3cfe985ca67ae910e96f3265e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-pam-11.8.8-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb11.8-pam;unpack=0"
SRC_URI[aarch64_mariadb11.8-pam.sha256sum] = "043e503c72cf5ae01f830bcf6960766a4b9652696decce10a6f04650137aa75b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-server-11.8.8-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb11.8-server;unpack=0"
SRC_URI[aarch64_mariadb11.8-server.sha256sum] = "b3d5a9a719759f4673ac552025f2d702cc621680d82138d3eb1a5373bd6bc7a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-server-galera-11.8.8-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb11.8-server-galera;unpack=0"
SRC_URI[aarch64_mariadb11.8-server-galera.sha256sum] = "a47ca74154f7f36571fed7ce0f7bde8415dad8f16f08b9c112cf5826c4f9040f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-server-utils-11.8.8-1.el10_2.alma.2.noarch.rpm;name=aarch64_mariadb11.8-server-utils;unpack=0"
SRC_URI[aarch64_mariadb11.8-server-utils.sha256sum] = "fabb70ae5b1f60bdc7ef37aa4cb3b8f0a1e565879a52c3fd65ff4dfdb6555033"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb11.8-test-11.8.8-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb11.8-test;unpack=0"
SRC_URI[aarch64_mariadb11.8-test.sha256sum] = "05e3f6ffd15a34e0c65697186403f752c895794acbbf934286778295246fdce3"

RDEPENDS:mariadb11.8 = " \
 bash \
 glibc \
 grep \
 libedit \
 libgcc \
 libstdc++ \
 mariadb-connector-c \
 mariadb11.8-common \
 ncurses-libs \
 openssl-libs \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:mariadb11.8-backup = " \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb11.8-server \
 openssl-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:mariadb11.8-client-utils = " \
 mariadb11.8 \
 perl-DBI \
 perl-Data-Dumper \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-Sys-Hostname \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:mariadb11.8-common = " \
 mariadb-connector-c-config \
 "
RDEPENDS:mariadb11.8-devel = " \
 mariadb-connector-c-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:mariadb11.8-embedded = " \
 glibc \
 libaio \
 libedit \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb11.8-common \
 mariadb11.8-errmsg \
 ncurses-libs \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:mariadb11.8-embedded-devel = " \
 libaio-devel \
 mariadb11.8-devel \
 mariadb11.8-embedded \
 virtual/libmariadbd.so.19___64bit_ \
 "
RDEPENDS:mariadb11.8-errmsg = " \
 mariadb11.8-common \
 "
RDEPENDS:mariadb11.8-gssapi-server = " \
 glibc \
 krb5-libs \
 mariadb11.8-server \
 "
RDEPENDS:mariadb11.8-oqgraph-engine = " \
 Judy \
 glibc \
 libgcc \
 libstdc++ \
 mariadb11.8-server \
 "
RDEPENDS:mariadb11.8-pam = " \
 glibc \
 mariadb11.8-server \
 pam-libs \
 "
RDEPENDS:mariadb11.8-server = " \
 bash \
 bzip2-libs \
 glibc \
 iproute \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 lz4-libs \
 lzo \
 mariadb-connector-c-config \
 mariadb11.8 \
 mariadb11.8-common \
 mariadb11.8-errmsg \
 mysql-selinux \
 openssl-libs \
 shadow-utils \
 snappy \
 systemd \
 systemd-libs \
 virtual/coreutils \
 which \
 zlib-ng-compat \
 "
RDEPENDS:mariadb11.8-server-galera = " \
 bash \
 galera \
 glibc \
 libgcc \
 libselinux-utils \
 libstdc++ \
 lsof \
 mariadb11.8-common \
 mariadb11.8-server \
 policycoreutils \
 policycoreutils-python-utils \
 rsync \
 selinux-policy-targeted \
 "
RDEPENDS:mariadb11.8-server-utils = " \
 mariadb11.8-server \
 perl-DBD-MariaDB \
 perl-DBI \
 perl-File-Path \
 perl-Getopt-Long \
 perl-POSIX \
 perl-interpreter \
 "
RDEPENDS:mariadb11.8-test = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb11.8 \
 mariadb11.8-common \
 mariadb11.8-server \
 openssl-libs \
 pam-libs \
 patch \
 perl-Carp \
 perl-Data-Dumper \
 perl-English \
 perl-Env \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-Memoize \
 perl-Net-SSLeay \
 perl-POSIX \
 perl-PathTools \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Test-Simple \
 perl-Text-Tabs+Wrap \
 perl-Time \
 perl-Time-HiRes \
 perl-autodie \
 perl-base \
 perl-constant \
 perl-if \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 perl-threads \
 perl-threads-shared \
 zlib-ng-compat \
 "
