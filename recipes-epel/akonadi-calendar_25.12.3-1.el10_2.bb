# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-calendar"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 akonadi-calendar \
 akonadi-calendar-devel \
 akonadi-calendar-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-calendar-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "463062e6dda0c772057d62db1712135c16c0935d44ddbdff69e534e8a39abab7"

URI_x86_64_v2_akonadi-calendar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-calendar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar}"
SRC_URI[x86_64_v2_akonadi-calendar.sha256sum] = "29e613bce7e9f55c723d8a70714051c8ec8a62302f7daf2f48917309b5fd51d9"

URI_x86_64_v2_akonadi-calendar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar-devel}"
SRC_URI[x86_64_v2_akonadi-calendar-devel.sha256sum] = "be4b01eb5399be30eb01cac65ccb064f8a00b3c918b51ac9eec93b49a338fd4c"

URI_x86_64_v2_akonadi-calendar-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-calendar-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar-doc}"
SRC_URI[x86_64_v2_akonadi-calendar-doc.sha256sum] = "da1f363aea5358d2853bcf2e2f9a13bf0b909bf6de7ee161cc8ff138aeac38ae"

URI_aarch64_akonadi-calendar = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akonadi-calendar;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar}"
SRC_URI[aarch64_akonadi-calendar.sha256sum] = "55d6577e25560f41cc96738008d6bdc236e69680b556ebb7aabd36f3a24cc44e"

URI_aarch64_akonadi-calendar-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akonadi-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar-devel}"
SRC_URI[aarch64_akonadi-calendar-devel.sha256sum] = "6a689e7d42f467f2b33d612e36bd13688569941e84ada3126de6b0dc9af924cf"

URI_aarch64_akonadi-calendar-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_akonadi-calendar-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar-doc}"
SRC_URI[aarch64_akonadi-calendar-doc.sha256sum] = "5ad63cc0407f286cc44317212245b67b4bad2d125834ad4f2a6e222be356c74e"

RDEPENDS:akonadi-calendar = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 glibc \
 gpgmepp \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 kmime \
 libgcc \
 libkleo \
 libstdc++ \
 messagelib \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-calendar-devel = " \
 akonadi-calendar \
 akonadi-contacts-devel \
 akonadi-server-devel \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kidentitymanagement-devel \
 "
RDEPENDS:akonadi-calendar-doc = " \
 "
