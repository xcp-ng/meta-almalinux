# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-sq"
PV = "1.4.0.1"
PR = "2.el10_2"
PACKAGES = " \
 sequoia-sq \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-sequoia-sq-1.4.0.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a3ee247a866d543e2f14db6b32f7ce4258fd7afe385a49ab6b073c2679ccd0ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sequoia-sq-1.4.0.1-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_sequoia-sq;unpack=0"
SRC_URI[x86_64_v2_sequoia-sq.sha256sum] = "989fe80e1e2aefda918d6581e9b3d7ba42be2f7e7fb374a79c47e4c6af7957bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sequoia-sq-1.4.0.1-2.el10_2.aarch64.rpm;name=aarch64_sequoia-sq;unpack=0"
SRC_URI[aarch64_sequoia-sq.sha256sum] = "557be66131eeab45438f63eb9349e09731ffddbc26fd5053ac606f94d7433a05"

RDEPENDS:sequoia-sq = " \
 glibc \
 libgcc \
 openssl-libs \
 sqlite-libs \
 "
