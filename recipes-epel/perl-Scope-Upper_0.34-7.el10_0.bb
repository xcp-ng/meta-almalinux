# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Scope-Upper"
PV = "0.34"
PR = "7.el10_0"
PACKAGES = " \
 perl-Scope-Upper \
 perl-Scope-Upper-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Scope-Upper-0.34-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "207f3ea57024a3d84ab1e3dd2a714687cbceb0bc3b922629eaeae4d4672e06ae"

URI_x86_64_v2_perl-Scope-Upper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Scope-Upper-0.34-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Scope-Upper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Scope-Upper}"
SRC_URI[x86_64_v2_perl-Scope-Upper.sha256sum] = "fd58b750b08a4cf9c808bf2a89eb66a6e9a8de470180759431862af9d1947084"

URI_x86_64_v2_perl-Scope-Upper-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Scope-Upper-tests-0.34-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Scope-Upper-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Scope-Upper-tests}"
SRC_URI[x86_64_v2_perl-Scope-Upper-tests.sha256sum] = "0d4a505bfb22be55038a9349bc49a76f80bd1a20d6c4460b7b0b180caef74097"

URI_aarch64_perl-Scope-Upper = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Scope-Upper-0.34-7.el10_0.aarch64.rpm;name=aarch64_perl-Scope-Upper;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Scope-Upper}"
SRC_URI[aarch64_perl-Scope-Upper.sha256sum] = "5b5f21dbc461c252d82ec126fe80e2b680fb55502232ae8f65148545ecd19847"

URI_aarch64_perl-Scope-Upper-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Scope-Upper-tests-0.34-7.el10_0.aarch64.rpm;name=aarch64_perl-Scope-Upper-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Scope-Upper-tests}"
SRC_URI[aarch64_perl-Scope-Upper-tests.sha256sum] = "013f13add7387d1f77e1de31eca0fce4ad4903d8f39fed0e08859db9d168a8cd"

RDEPENDS:perl-Scope-Upper = " \
 glibc \
 perl-Exporter \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-Scope-Upper-tests = " \
 bash \
 perl-Exporter \
 perl-Scope-Upper \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Time-HiRes \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 "
