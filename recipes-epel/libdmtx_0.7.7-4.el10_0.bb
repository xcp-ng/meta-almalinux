# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdmtx"
PV = "0.7.7"
PR = "4.el10_0"
PACKAGES = " \
 libdmtx \
 libdmtx-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libdmtx-0.7.7-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a411af4e04a67b07d9ddbfb562670738eda0186b4b9f1269542ddcec1bbb0e4d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdmtx-0.7.7-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdmtx;unpack=0"
SRC_URI[x86_64_v2_libdmtx.sha256sum] = "82eea9838e2806ca79a0a26915ca0af5da8f44202bff1a3cb407089acfe221ff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdmtx-devel-0.7.7-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdmtx-devel;unpack=0"
SRC_URI[x86_64_v2_libdmtx-devel.sha256sum] = "4b4f27517c115344984a5243f6c25525c3a484adb5b2bf2ceca682051665da7a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdmtx-0.7.7-4.el10_0.aarch64.rpm;name=aarch64_libdmtx;unpack=0"
SRC_URI[aarch64_libdmtx.sha256sum] = "4f04755eea0d3e7ee890ddb2f234f201ea6d37d95233bfeb348365364cefb46a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdmtx-devel-0.7.7-4.el10_0.aarch64.rpm;name=aarch64_libdmtx-devel;unpack=0"
SRC_URI[aarch64_libdmtx-devel.sha256sum] = "10575b171368c304517824bce9337ac7dbf492f1c44dfa0312735f254e66bf18"

RDEPENDS:libdmtx = " \
 glibc \
 "
RDEPENDS:libdmtx-devel = " \
 libdmtx \
 pkgconf-pkg-config \
 "
