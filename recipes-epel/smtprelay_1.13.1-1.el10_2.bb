# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "smtprelay"
PV = "1.13.1"
PR = "1.el10_2"
PACKAGES = " \
 smtprelay \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/smtprelay-1.13.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "33861ef372e4be84aada650f79eca9004a6921376c464250f9b9f2a3ee7b48f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/smtprelay-1.13.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_smtprelay;unpack=0"
SRC_URI[x86_64_v2_smtprelay.sha256sum] = "fdf47549f3f8dc3fe2fd9fe07f362b319a7cf914da07f609a28d17ae87e887ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/smtprelay-1.13.1-1.el10_2.aarch64.rpm;name=aarch64_smtprelay;unpack=0"
SRC_URI[aarch64_smtprelay.sha256sum] = "407bc87c3d22a2cb485164c58aa5b401f833a370de03eaa07638d796896230ea"

RDEPENDS:smtprelay = " \
 bash \
 glibc \
 shadow-utils \
 "
