# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdegames"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 libkdegames \
 libkdegames-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkdegames-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "636a800ee879a59b7f0ea4786d52c28143e3716917432c0cba389cfa728a393f"

URI_x86_64_v2_libkdegames = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdegames-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdegames;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdegames}"
SRC_URI[x86_64_v2_libkdegames.sha256sum] = "da4aad66e91c564e745e5ee9d266d69fdc7e092fb9345cb15d9462c5e1941cd4"

URI_x86_64_v2_libkdegames-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdegames-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdegames-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdegames-devel}"
SRC_URI[x86_64_v2_libkdegames-devel.sha256sum] = "544e863bd294dca740badf13ad12d4383a3bfd5393384c694d6308e3102c3537"

URI_aarch64_libkdegames = "${EPEL_MIRROR}/aarch64/Packages/l/libkdegames-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkdegames;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdegames}"
SRC_URI[aarch64_libkdegames.sha256sum] = "bb609dc9339e66a922183a37a7673ea3f608edd90e8457348d60f498b2d51efb"

URI_aarch64_libkdegames-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkdegames-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkdegames-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdegames-devel}"
SRC_URI[aarch64_libkdegames-devel.sha256sum] = "202580c2bfdf25b38d1a0e480a0393b738c8f98c768c477db4ba1c37b9cc53f0"

RDEPENDS:libkdegames = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdnssd \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libsndfile \
 libstdc++ \
 openal-soft \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:libkdegames-devel = " \
 cmake-filesystem \
 kf6-kcompletion-devel \
 kf6-kconfig-devel \
 kf6-kconfigwidgets-devel \
 kf6-ki18n-devel \
 kf6-kwidgetsaddons-devel \
 libkdegames \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
