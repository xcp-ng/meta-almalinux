# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spandsp"
PV = "0.0.6"
PR = "13.el10_0"
PACKAGES = " \
 spandsp \
 spandsp-apidoc \
 spandsp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spandsp-0.0.6-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "158c8ad2ca9a3082eb590006dd5bcf3a1d39ca4bea1f243f803c0b1ad66a64e8"

URI_x86_64_v2_spandsp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spandsp-0.0.6-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spandsp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spandsp}"
SRC_URI[x86_64_v2_spandsp.sha256sum] = "4d144c14d9ace68375e06d51ce9adcdef0c29985341b655c4c5bf28a7c59fb41"

URI_x86_64_v2_spandsp-apidoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spandsp-apidoc-0.0.6-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spandsp-apidoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spandsp-apidoc}"
SRC_URI[x86_64_v2_spandsp-apidoc.sha256sum] = "03748594f75d37c90b14f8e5089cb12efd10f4ea0a90333b3e7769f1e0f9bed5"

URI_x86_64_v2_spandsp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spandsp-devel-0.0.6-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spandsp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spandsp-devel}"
SRC_URI[x86_64_v2_spandsp-devel.sha256sum] = "5b2e618720f2e3950fed4c6f37fc57a3c0b0944a71e7a0244c7d04e6f84d3346"

URI_aarch64_spandsp = "${EPEL_MIRROR}/aarch64/Packages/s/spandsp-0.0.6-13.el10_0.aarch64.rpm;name=aarch64_spandsp;unpack=0"
SRC_URI:append = " ${URI_aarch64_spandsp}"
SRC_URI[aarch64_spandsp.sha256sum] = "4cc6b2eb5034e6224807b47057869c22bf221210b2906bb450c68eeb65d03831"

URI_aarch64_spandsp-apidoc = "${EPEL_MIRROR}/aarch64/Packages/s/spandsp-apidoc-0.0.6-13.el10_0.aarch64.rpm;name=aarch64_spandsp-apidoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_spandsp-apidoc}"
SRC_URI[aarch64_spandsp-apidoc.sha256sum] = "09af4e8a3783ab72562cee806ee405e9c931230708b7d79e585e4e7ca98bc679"

URI_aarch64_spandsp-devel = "${EPEL_MIRROR}/aarch64/Packages/s/spandsp-devel-0.0.6-13.el10_0.aarch64.rpm;name=aarch64_spandsp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_spandsp-devel}"
SRC_URI[aarch64_spandsp-devel.sha256sum] = "567c0a36b129dbb82502b3c436b684df817b0965274d6521ccc35ea4b47e31eb"

RDEPENDS:spandsp = " \
 glibc \
 libjpeg-turbo \
 libtiff \
 "
RDEPENDS:spandsp-apidoc = " \
 "
RDEPENDS:spandsp-devel = " \
 libtiff-devel \
 pkgconf-pkg-config \
 spandsp \
 "
