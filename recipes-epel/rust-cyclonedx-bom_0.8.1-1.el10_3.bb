# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cyclonedx-bom"
PV = "0.8.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-cyclonedx-bom+default-devel \
 rust-cyclonedx-bom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cyclonedx-bom-0.8.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4892c3553e735f57c5627b4120fd8465b73f57d4aa440650d49caaafab4b7b93"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-cyclonedx-bom-devel: (crate(xml-rs/default) >= 0.8.16 with crate(xml-rs/default) < 0.9.0~)

URI_x86_64_v2_rust-cyclonedx-bom+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cyclonedx-bom+default-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cyclonedx-bom+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cyclonedx-bom+default-devel}"
SRC_URI[x86_64_v2_rust-cyclonedx-bom+default-devel.sha256sum] = "147f7efbfa402b29e8fde5cf4516c89bdbca47c219e64ba5a0fbc7706f62e70b"

URI_x86_64_v2_rust-cyclonedx-bom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cyclonedx-bom-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cyclonedx-bom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cyclonedx-bom-devel}"
SRC_URI[x86_64_v2_rust-cyclonedx-bom-devel.sha256sum] = "e793fea53a759db815bf1edab955f3f6107f8c079dccc261747a71371caa6acf"

URI_aarch64_rust-cyclonedx-bom+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cyclonedx-bom+default-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-cyclonedx-bom+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cyclonedx-bom+default-devel}"
SRC_URI[aarch64_rust-cyclonedx-bom+default-devel.sha256sum] = "619d7eef3f5690607457c81093a980023726d678a74e5dec6c1218f7035c330d"

URI_aarch64_rust-cyclonedx-bom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cyclonedx-bom-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-cyclonedx-bom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cyclonedx-bom-devel}"
SRC_URI[aarch64_rust-cyclonedx-bom-devel.sha256sum] = "16dc393ad99634262788f78d5cdf1e35fe422039014d1c58904bd6f5c4c1b4a9"

RDEPENDS:rust-cyclonedx-bom+default-devel = " \
 cargo \
 rust-cyclonedx-bom-devel \
 "
RDEPENDS:rust-cyclonedx-bom-devel:x86_64_v2 = " \
 cargo \
 rust \
 rust-base64_0.22+default-devel \
 rust-cyclonedx-bom-macros+default-devel \
 rust-fluent-uri+default-devel \
 rust-indexmap+default-devel \
 rust-once_cell+default-devel \
 rust-ordered-float-devel \
 rust-purl-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-spdx+default-devel \
 rust-strum+default-devel \
 rust-strum+derive-devel \
 rust-thiserror+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-uuid+default-devel \
 rust-uuid+v4-devel \
"
RDEPENDS:rust-cyclonedx-bom-devel:aarch64 = " \
 cargo \
 rust \
 rust-base64_0.22+default-devel \
 rust-cyclonedx-bom-macros+default-devel \
 rust-fluent-uri+default-devel \
 rust-indexmap+default-devel \
 rust-once_cell+default-devel \
 rust-ordered-float-devel \
 rust-purl-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-spdx+default-devel \
 rust-strum+default-devel \
 rust-strum+derive-devel \
 rust-thiserror+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-uuid+default-devel \
 rust-uuid+v4-devel \
 rust-xml-rs+default-devel \
"
