# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nftables"
PE = "1"
PV = "1.1.1"
PR = "9.el10_1"
PACKAGES = " \
 nftables \
 nftables-devel \
 python3-nftables \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nftables-1.1.1-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac9d80959b945d16dcb9500934a094fdcc4efe56534e28b973c63287fc470b35"

URI_x86_64_v2_nftables = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nftables-1.1.1-9.el10_1.x86_64_v2.rpm;name=x86_64_v2_nftables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nftables}"
SRC_URI[x86_64_v2_nftables.sha256sum] = "e672e163681e852e27339b697f2e7cfd58d8cca11dadaf984bd488239012efed"

URI_x86_64_v2_nftables-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nftables-devel-1.1.1-9.el10_1.x86_64_v2.rpm;name=x86_64_v2_nftables-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nftables-devel}"
SRC_URI[x86_64_v2_nftables-devel.sha256sum] = "5e2d83bdff27132326614fcedf94c3df6b5f82a63b0b4325bf98fe0285f67a39"

URI_x86_64_v2_python3-nftables = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-nftables-1.1.1-9.el10_1.x86_64_v2.rpm;name=x86_64_v2_python3-nftables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nftables}"
SRC_URI[x86_64_v2_python3-nftables.sha256sum] = "67acdc4f1abbc74aa7412a1f1f0b5dbeb6c2e603e567c3ffbfea7b20bf2b047f"

URI_aarch64_nftables = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nftables-1.1.1-9.el10_1.aarch64.rpm;name=aarch64_nftables;unpack=0"
SRC_URI:append = " ${URI_aarch64_nftables}"
SRC_URI[aarch64_nftables.sha256sum] = "436cecbfafae3fb0b964e6bbd2d90e1b667dcd351521b2ba5b40d4042bfb6049"

URI_aarch64_nftables-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nftables-devel-1.1.1-9.el10_1.aarch64.rpm;name=aarch64_nftables-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nftables-devel}"
SRC_URI[aarch64_nftables-devel.sha256sum] = "03440f6c5c070339770f62b030a226c6d7f2c8569554c011691262039a2b9e5b"

URI_aarch64_python3-nftables = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-nftables-1.1.1-9.el10_1.aarch64.rpm;name=aarch64_python3-nftables;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nftables}"
SRC_URI[aarch64_python3-nftables.sha256sum] = "10861878cead5bf80c429a3d601a35aed4c530f6fdf4488f9d5b239515e29c24"

RDEPENDS:nftables = " \
 bash \
 glibc \
 gmp \
 iptables-libs \
 jansson \
 libmnl \
 libnftnl \
 readline \
 "
RDEPENDS:nftables-devel = " \
 nftables \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-nftables = " \
 nftables \
 python3 \
 "
