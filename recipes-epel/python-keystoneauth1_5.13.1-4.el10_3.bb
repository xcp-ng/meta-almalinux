# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-keystoneauth1"
PV = "5.13.1"
PR = "4.el10_3"
PACKAGES = " \
 python-keystoneauth1-doc \
 python3-keystoneauth1 \
 python3-keystoneauth1+betamax \
 python3-keystoneauth1+kerberos \
 python3-keystoneauth1+oauth1 \
 python3-keystoneauth1+saml2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-keystoneauth1-5.13.1-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0e9a50bade9b8ab3b895bfa679722100439c5f1d3cd5e221f46e75da69d55db"

URI_x86_64_v2_python-keystoneauth1-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-keystoneauth1-doc-5.13.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-keystoneauth1-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-keystoneauth1-doc}"
SRC_URI[x86_64_v2_python-keystoneauth1-doc.sha256sum] = "38f7591a0a38a92ccbd68938dd2c67cb6a84618daf289daa52f0c9e01c9a96ac"

URI_x86_64_v2_python3-keystoneauth1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keystoneauth1-5.13.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keystoneauth1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keystoneauth1}"
SRC_URI[x86_64_v2_python3-keystoneauth1.sha256sum] = "d14dbaee03644fbadd0f242ce5f5caf65c7837604cc54b6e1cc5a5cba25b5a69"

URI_x86_64_v2_python3-keystoneauth1+betamax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keystoneauth1+betamax-5.13.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keystoneauth1+betamax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keystoneauth1+betamax}"
SRC_URI[x86_64_v2_python3-keystoneauth1+betamax.sha256sum] = "3631da63d145f7c5a3b12ac3a9f88da4a7635ac3264e623073b2dc14c30ee510"

URI_x86_64_v2_python3-keystoneauth1+kerberos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keystoneauth1+kerberos-5.13.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keystoneauth1+kerberos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keystoneauth1+kerberos}"
SRC_URI[x86_64_v2_python3-keystoneauth1+kerberos.sha256sum] = "c94f535e6956c35ff2002443a82b2ba0bb57ac066c851251f75db0525e709c66"

URI_x86_64_v2_python3-keystoneauth1+oauth1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keystoneauth1+oauth1-5.13.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keystoneauth1+oauth1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keystoneauth1+oauth1}"
SRC_URI[x86_64_v2_python3-keystoneauth1+oauth1.sha256sum] = "4062c4008f79989f8e83d2960423ad866b84a983f76f2f4c5f033d939544cc5d"

URI_x86_64_v2_python3-keystoneauth1+saml2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keystoneauth1+saml2-5.13.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keystoneauth1+saml2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keystoneauth1+saml2}"
SRC_URI[x86_64_v2_python3-keystoneauth1+saml2.sha256sum] = "a5ca8baeeb63bd41dcc419f312d30c1dbe22b69c176d7a837bfe22b93bed98d3"

URI_aarch64_python-keystoneauth1-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-keystoneauth1-doc-5.13.1-4.el10_3.noarch.rpm;name=aarch64_python-keystoneauth1-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-keystoneauth1-doc}"
SRC_URI[aarch64_python-keystoneauth1-doc.sha256sum] = "c29f34bd6a9451ed4299c5d4bad976f9e63c3450c8dddc7d122f59b3bae8ddb7"

URI_aarch64_python3-keystoneauth1 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keystoneauth1-5.13.1-4.el10_3.noarch.rpm;name=aarch64_python3-keystoneauth1;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keystoneauth1}"
SRC_URI[aarch64_python3-keystoneauth1.sha256sum] = "207d0561603109ec60d0d7f5ef8931e0c20bd8b2fcddf798d3f4a8cec22b36e4"

URI_aarch64_python3-keystoneauth1+betamax = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keystoneauth1+betamax-5.13.1-4.el10_3.noarch.rpm;name=aarch64_python3-keystoneauth1+betamax;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keystoneauth1+betamax}"
SRC_URI[aarch64_python3-keystoneauth1+betamax.sha256sum] = "03fcbb091f3f5558d5115454aa032405abef1b0245f87e41c1bfb257882d34ee"

URI_aarch64_python3-keystoneauth1+kerberos = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keystoneauth1+kerberos-5.13.1-4.el10_3.noarch.rpm;name=aarch64_python3-keystoneauth1+kerberos;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keystoneauth1+kerberos}"
SRC_URI[aarch64_python3-keystoneauth1+kerberos.sha256sum] = "18a0f151ab2146bb2f2205d867eb492bca883fbed2e747490d8133db5ea3d02d"

URI_aarch64_python3-keystoneauth1+oauth1 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keystoneauth1+oauth1-5.13.1-4.el10_3.noarch.rpm;name=aarch64_python3-keystoneauth1+oauth1;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keystoneauth1+oauth1}"
SRC_URI[aarch64_python3-keystoneauth1+oauth1.sha256sum] = "9132d7bd20638f9d3f879754a58b349282d3ebb33367d0884730efb1f8e2e7ac"

URI_aarch64_python3-keystoneauth1+saml2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keystoneauth1+saml2-5.13.1-4.el10_3.noarch.rpm;name=aarch64_python3-keystoneauth1+saml2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keystoneauth1+saml2}"
SRC_URI[aarch64_python3-keystoneauth1+saml2.sha256sum] = "558a89e21ffe1ef8f114ea98df86d75cacf8a77b488e08bf199fedca12c4359c"

RDEPENDS:python-keystoneauth1-doc = " \
 "
RDEPENDS:python3-keystoneauth1 = " \
 python3 \
 python3-iso8601 \
 python3-os-service-types \
 python3-pbr \
 python3-requests \
 python3-stevedore \
 python3-typing-extensions \
 "
RDEPENDS:python3-keystoneauth1+betamax = " \
 python3 \
 python3-betamax \
 python3-fixtures \
 python3-keystoneauth1 \
 python3-pyyaml \
 "
RDEPENDS:python3-keystoneauth1+kerberos = " \
 python3 \
 python3-keystoneauth1 \
 python3-requests-kerberos \
 "
RDEPENDS:python3-keystoneauth1+oauth1 = " \
 python3 \
 python3-keystoneauth1 \
 python3-oauthlib \
 "
RDEPENDS:python3-keystoneauth1+saml2 = " \
 python3 \
 python3-keystoneauth1 \
 python3-lxml \
 "
