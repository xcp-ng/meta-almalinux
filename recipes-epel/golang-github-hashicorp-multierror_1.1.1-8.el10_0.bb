# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hashicorp-multierror"
PV = "1.1.1"
PR = "8.el10_0"
PACKAGES = " \
 golang-github-hashicorp-multierror-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-hashicorp-multierror-1.1.1-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f7bd4046d4ef3600efe4ac84d4c9386502a213c27de760a929d9c59ad091ea85"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hashicorp-multierror-devel-1.1.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hashicorp-multierror-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-hashicorp-multierror-devel.sha256sum] = "518c2a5ff947c5b291a54f0d245178f3366fa4b8192bbf972d813a63a5981c09"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hashicorp-multierror-devel-1.1.1-8.el10_0.noarch.rpm;name=aarch64_golang-github-hashicorp-multierror-devel;unpack=0"
SRC_URI[aarch64_golang-github-hashicorp-multierror-devel.sha256sum] = "974b90b9eefccc64e4154a6e635710da8235491c2f1168c777f604d2bdb6633b"

RDEPENDS:golang-github-hashicorp-multierror-devel = " \
 go-filesystem \
 golang-github-hashicorp-errwrap-devel \
 "
