# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bird"
PV = "3.3.2"
PR = "1.el10_2"
PACKAGES = " \
 bird \
 bird-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bird-3.3.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a98cfef45086d397a3c012ece15de0624d01c51c6fc7ad4a17d30425a2a854c"

URI_x86_64_v2_bird = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bird-3.3.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bird;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bird}"
SRC_URI[x86_64_v2_bird.sha256sum] = "b59e24c98f94f8539fcdd38ed819ac0513f780af4f9080279d2f6448d99add5d"

URI_x86_64_v2_bird-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bird-doc-3.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_bird-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bird-doc}"
SRC_URI[x86_64_v2_bird-doc.sha256sum] = "11dbcdebc93fd77d15571632e02305aff5ab70696e545f9f4d505cc6e5860785"

URI_aarch64_bird = "${EPEL_MIRROR}/aarch64/Packages/b/bird-3.3.2-1.el10_2.aarch64.rpm;name=aarch64_bird;unpack=0"
SRC_URI:append = " ${URI_aarch64_bird}"
SRC_URI[aarch64_bird.sha256sum] = "1fc028b4d081470c7bd2564147d662e98481178a16f168047be6e73e36714f06"

URI_aarch64_bird-doc = "${EPEL_MIRROR}/aarch64/Packages/b/bird-doc-3.3.2-1.el10_2.noarch.rpm;name=aarch64_bird-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bird-doc}"
SRC_URI[aarch64_bird-doc.sha256sum] = "ae85b072273490b6c2e3bf4cc71d352548e5882d4194117722f7e6bc3f01f503"

RDEPENDS:bird = " \
 bash \
 glibc \
 libgcc \
 libssh \
 ncurses-libs \
 readline \
 shadow-utils \
 systemd \
 "
RDEPENDS:bird-doc = " \
 "
