# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-p256"
PV = "0.13.2"
PR = "5.el10_2"
PACKAGES = " \
 rust-p256+alloc-devel \
 rust-p256+arithmetic-devel \
 rust-p256+bits-devel \
 rust-p256+default-devel \
 rust-p256+digest-devel \
 rust-p256+ecdh-devel \
 rust-p256+ecdsa-core-devel \
 rust-p256+ecdsa-devel \
 rust-p256+expose-field-devel \
 rust-p256+hash2curve-devel \
 rust-p256+jwk-devel \
 rust-p256+pem-devel \
 rust-p256+pkcs8-devel \
 rust-p256+serde-devel \
 rust-p256+serdect-devel \
 rust-p256+sha2-devel \
 rust-p256+sha256-devel \
 rust-p256+std-devel \
 rust-p256+test-vectors-devel \
 rust-p256+voprf-devel \
 rust-p256-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-p256-0.13.2-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "75e13b928bd75f09144331111f48b261a415f1e2eb4643b3bf4b4accaec5aded"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+alloc-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+alloc-devel.sha256sum] = "3dfeba46e531691bbc24dcce0c3ff529b17fe6672fdbf120ecfe2b1f55353130"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+arithmetic-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+arithmetic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+arithmetic-devel.sha256sum] = "5defb778d6d543403e577dcd2925cc326ae2454ab8b77901157d4d89d06f1da7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+bits-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+bits-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+bits-devel.sha256sum] = "626dbe5ff19b42b926cf89e120fbac0697f6ffc941860fa750639aad1681e886"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+default-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+default-devel.sha256sum] = "d4c0784ae05034bb0d0ace6ad8e99ffa87a9ce2cc0fde0413d90e2df3eb1a3fb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+digest-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+digest-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+digest-devel.sha256sum] = "dbcb65de9558cd525be6ad69a18e4aa796866edda4fb7a38c88bc59794465784"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+ecdh-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+ecdh-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+ecdh-devel.sha256sum] = "64415b78809e1faf9e78fd6d08f976fb2de0a2ac275041bbfd4e5af08449d74b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+ecdsa-core-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+ecdsa-core-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+ecdsa-core-devel.sha256sum] = "13303d6ae8730e42862fae246052daf240be64800025f6021264c8de28210b00"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+ecdsa-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+ecdsa-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+ecdsa-devel.sha256sum] = "011d1015bb674c21a42f4173613e544d3e9eda60e52cd86b1ab36ddffc290cb9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+expose-field-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+expose-field-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+expose-field-devel.sha256sum] = "7b0b76456ee07c2af6fa0dc69cafadc96701ad2af28ca1779fda6ae3c82b625e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+hash2curve-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+hash2curve-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+hash2curve-devel.sha256sum] = "dc2f999eb791ebf42011342364d88297daae1be3d3563af2bee64072c0beddf2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+jwk-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+jwk-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+jwk-devel.sha256sum] = "007caa5b5c9737b074a19d211bc590e82d2a6653230618f2956cd1a43a919cfc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+pem-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+pem-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+pem-devel.sha256sum] = "5140b08fbdeb21180f29dc3bc8bf8f66d05c207d76431e45e48b66eed8cd15fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+pkcs8-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+pkcs8-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+pkcs8-devel.sha256sum] = "0d9b53ccd2e392145a358234608bf52f73c7852fc4c4608e4ee8c98426379122"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+serde-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+serde-devel.sha256sum] = "13c5c90ffb1a6cb943857ab167a8f1e0efbab420b9f2ab7458c32181f6a228c5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+serdect-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+serdect-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+serdect-devel.sha256sum] = "7e6c1704e25c3be85643c658bd6784f77adcf36faf1041544b02b5a0fc91ceb0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+sha2-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+sha2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+sha2-devel.sha256sum] = "bcda6a7cb5fd5d23b540e1510f42f05dac96b4227220850bc008c482b5621006"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+sha256-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+sha256-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+sha256-devel.sha256sum] = "9f5c9c65ea9e51467cdf1a43ac495b308a2c6bce4458893abd9564fe691afc86"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+std-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+std-devel.sha256sum] = "30d9389afb24681f12e3d223f6f77db54b6596fbe590bafe33d0903bca35b95b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+test-vectors-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+test-vectors-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+test-vectors-devel.sha256sum] = "d8694c647b8c84fc9bd73761b1e1dd071bb62720dfa7ff6acceeade9fcc8dab6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256+voprf-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256+voprf-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256+voprf-devel.sha256sum] = "1407db4d016603efdc8f3e723ebd9e7d0e3e6bf69823f9391feea71429874743"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p256-devel-0.13.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p256-devel;unpack=0"
SRC_URI[x86_64_v2_rust-p256-devel.sha256sum] = "5b5932777b91721eeb72ddc7f0eca6104c8fb29e2894d31755843626f5ee56fe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+alloc-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-p256+alloc-devel.sha256sum] = "a452f94b36bc75c0d22c9d267ed9c6370fd537b677fe3471ed3e5a990f033cec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+arithmetic-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+arithmetic-devel;unpack=0"
SRC_URI[aarch64_rust-p256+arithmetic-devel.sha256sum] = "b28b63a7ffb86f20a36472c12144e91e6222148d99ca7a18d6a22aa089a3bf8f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+bits-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+bits-devel;unpack=0"
SRC_URI[aarch64_rust-p256+bits-devel.sha256sum] = "6d3edb4609cd6760f1349ddb38642f143665fec80dc5fc576afd10ab73949021"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+default-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+default-devel;unpack=0"
SRC_URI[aarch64_rust-p256+default-devel.sha256sum] = "b4664fbb2868c4f8cf6d14847b57f15eb000137ea03a82c76188fa8eb9609db5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+digest-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+digest-devel;unpack=0"
SRC_URI[aarch64_rust-p256+digest-devel.sha256sum] = "1f518c4f0f48dba4d0ae87e4cd6194f4970d1e40a00a7142d82439e7f1d78bea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+ecdh-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+ecdh-devel;unpack=0"
SRC_URI[aarch64_rust-p256+ecdh-devel.sha256sum] = "ab88450d2bc63584045ee96cdf01b7b26dd0911b2a3103a172e33fba541c2fb7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+ecdsa-core-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+ecdsa-core-devel;unpack=0"
SRC_URI[aarch64_rust-p256+ecdsa-core-devel.sha256sum] = "b716f9801766b5ba537b7d4e36f749c184f9da3feb8bd49632fa73cf366d0c20"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+ecdsa-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+ecdsa-devel;unpack=0"
SRC_URI[aarch64_rust-p256+ecdsa-devel.sha256sum] = "96e3ee56344c72f98583a4c52d3a8e60bd9b4e95ef61055cb143f6b4d4eb87cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+expose-field-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+expose-field-devel;unpack=0"
SRC_URI[aarch64_rust-p256+expose-field-devel.sha256sum] = "2b22964765ec355bb434829e6c3015e16d26ecb49e9b1344ebbfc97298f8a8e3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+hash2curve-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+hash2curve-devel;unpack=0"
SRC_URI[aarch64_rust-p256+hash2curve-devel.sha256sum] = "a1e9a0ba48a4a82b9cf8f5b4ed466590b218a5c329060bb33ae6e833fff2ca01"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+jwk-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+jwk-devel;unpack=0"
SRC_URI[aarch64_rust-p256+jwk-devel.sha256sum] = "c36a674e1585c82acc63dbb2c5eaf5771c5da250b46635d529c1f0c9727e2083"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+pem-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+pem-devel;unpack=0"
SRC_URI[aarch64_rust-p256+pem-devel.sha256sum] = "19fd84f9179145b6483c0f9f69dceb39cd88bc3ced3e38c4a7f3654611207525"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+pkcs8-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+pkcs8-devel;unpack=0"
SRC_URI[aarch64_rust-p256+pkcs8-devel.sha256sum] = "47252b2655dc55ca234a38b144499c1245ecb552c02b903f0749582990f0ea5d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+serde-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+serde-devel;unpack=0"
SRC_URI[aarch64_rust-p256+serde-devel.sha256sum] = "eca089158b5c332f7a5edfbd19e9b1a58f50e12c33596a059b5d62071f8882ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+serdect-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+serdect-devel;unpack=0"
SRC_URI[aarch64_rust-p256+serdect-devel.sha256sum] = "ade92a00a373efd29295d3f10caa4c1280c4a556bced3a783ef6e7baa4d45a65"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+sha2-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+sha2-devel;unpack=0"
SRC_URI[aarch64_rust-p256+sha2-devel.sha256sum] = "ae49c36757e378ac829e49abaf6e2d5e690c94b8094f94ca47b39a4f8133485b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+sha256-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+sha256-devel;unpack=0"
SRC_URI[aarch64_rust-p256+sha256-devel.sha256sum] = "d50e16c7e6ec6026ef1a198271570f6ecf26b135a8857e1680c9c135ee367179"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+std-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+std-devel;unpack=0"
SRC_URI[aarch64_rust-p256+std-devel.sha256sum] = "030db8003d528ee1c2d6d60197b38d42db6eb6d8db5acdceb3ffa888168c8a0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+test-vectors-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+test-vectors-devel;unpack=0"
SRC_URI[aarch64_rust-p256+test-vectors-devel.sha256sum] = "8041223e8973bf2c062c15a2f44582b3cab445e641aa9e34ef33bcef3635f838"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256+voprf-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256+voprf-devel;unpack=0"
SRC_URI[aarch64_rust-p256+voprf-devel.sha256sum] = "392b3ff740aa5ff6db713ef971fe055cecf70f5ef013603613d421a88ec0423a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-p256-devel-0.13.2-5.el10_2.noarch.rpm;name=aarch64_rust-p256-devel;unpack=0"
SRC_URI[aarch64_rust-p256-devel.sha256sum] = "d5d5c7d4c5f82331b0b7e2961169e3ca5406be015b21dd9fefff70f6fe902cde"

RDEPENDS:rust-p256+alloc-devel = " \
 cargo \
 rust-ecdsa+alloc-devel \
 rust-ecdsa+der-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+alloc-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256+arithmetic-devel = " \
 cargo \
 rust-elliptic-curve+arithmetic-devel \
 rust-p256-devel \
 rust-primeorder+default-devel \
 "
RDEPENDS:rust-p256+bits-devel = " \
 cargo \
 rust-elliptic-curve+bits-devel \
 rust-p256+arithmetic-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256+default-devel = " \
 cargo \
 rust-p256+arithmetic-devel \
 rust-p256+ecdsa-devel \
 rust-p256+pem-devel \
 rust-p256+std-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256+digest-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+digest-devel \
 rust-ecdsa+hazmat-devel \
 rust-ecdsa-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256+ecdh-devel = " \
 cargo \
 rust-elliptic-curve+ecdh-devel \
 rust-p256+arithmetic-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256+ecdsa-core-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256+ecdsa-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+signing-devel \
 rust-ecdsa+verifying-devel \
 rust-ecdsa-devel \
 rust-p256+arithmetic-devel \
 rust-p256+sha256-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256+expose-field-devel = " \
 cargo \
 rust-p256+arithmetic-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256+hash2curve-devel = " \
 cargo \
 rust-elliptic-curve+hash2curve-devel \
 rust-p256+arithmetic-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256+jwk-devel = " \
 cargo \
 rust-elliptic-curve+jwk-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256+pem-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+pem-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+pem-devel \
 rust-p256+pkcs8-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256+pkcs8-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+pkcs8-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+pkcs8-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256+serde-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+serde-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+serde-devel \
 rust-p256+serdect-devel \
 rust-p256-devel \
 rust-primeorder+default-devel \
 rust-primeorder+serde-devel \
 "
RDEPENDS:rust-p256+serdect-devel = " \
 cargo \
 rust-p256-devel \
 rust-serdect0.2-devel \
 "
RDEPENDS:rust-p256+sha2-devel = " \
 cargo \
 rust-p256-devel \
 rust-sha2_0.10-devel \
 "
RDEPENDS:rust-p256+sha256-devel = " \
 cargo \
 rust-p256+digest-devel \
 rust-p256+sha2-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256+std-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+std-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+std-devel \
 rust-p256+alloc-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256+test-vectors-devel = " \
 cargo \
 rust-hex-literal+default-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256+voprf-devel = " \
 cargo \
 rust-elliptic-curve+voprf-devel \
 rust-p256+sha2-devel \
 rust-p256-devel \
 "
RDEPENDS:rust-p256-devel = " \
 cargo \
 rust \
 rust-elliptic-curve+hazmat-devel \
 rust-elliptic-curve+sec1-devel \
 rust-elliptic-curve-devel \
 "
