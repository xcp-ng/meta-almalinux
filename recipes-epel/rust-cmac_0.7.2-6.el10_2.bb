# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cmac"
PV = "0.7.2"
PR = "6.el10_2"
PACKAGES = " \
 rust-cmac+default-devel \
 rust-cmac+std-devel \
 rust-cmac+zeroize-devel \
 rust-cmac-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cmac-0.7.2-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88aadad3a4d0cb7345888a45cab3b263f4bb1c7cf57ee6c996cc9ec38451ebab"

URI_x86_64_v2_rust-cmac+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmac+default-devel-0.7.2-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmac+default-devel}"
SRC_URI[x86_64_v2_rust-cmac+default-devel.sha256sum] = "18d356b6feca4e0d6abba938aeaee065a449c90204baf993cf78afd08af218a8"

URI_x86_64_v2_rust-cmac+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmac+std-devel-0.7.2-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmac+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmac+std-devel}"
SRC_URI[x86_64_v2_rust-cmac+std-devel.sha256sum] = "2dd625971b25de5bc031ae3e6bd6255e7b4704ea1e8ec68ef904718bb3a0f9c7"

URI_x86_64_v2_rust-cmac+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmac+zeroize-devel-0.7.2-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmac+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmac+zeroize-devel}"
SRC_URI[x86_64_v2_rust-cmac+zeroize-devel.sha256sum] = "ecd255d8b9b2e26969e5c48524d2493b734d815e0548abe34302192c54ff0e5e"

URI_x86_64_v2_rust-cmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmac-devel-0.7.2-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmac-devel}"
SRC_URI[x86_64_v2_rust-cmac-devel.sha256sum] = "6df9877ced3d19effb020a093842951be476dea6266d191a7b7ea3e21c0d0946"

URI_aarch64_rust-cmac+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmac+default-devel-0.7.2-6.el10_2.noarch.rpm;name=aarch64_rust-cmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmac+default-devel}"
SRC_URI[aarch64_rust-cmac+default-devel.sha256sum] = "04f7972dd43e64f20c9641bcca3e1388b203d56bc5646cfd76ccde7e4bb93cd5"

URI_aarch64_rust-cmac+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmac+std-devel-0.7.2-6.el10_2.noarch.rpm;name=aarch64_rust-cmac+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmac+std-devel}"
SRC_URI[aarch64_rust-cmac+std-devel.sha256sum] = "ae9c6c199ac53fbecc9d1cb08d150a6d8d20bb498e15022fca5e69a5d3d48191"

URI_aarch64_rust-cmac+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmac+zeroize-devel-0.7.2-6.el10_2.noarch.rpm;name=aarch64_rust-cmac+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmac+zeroize-devel}"
SRC_URI[aarch64_rust-cmac+zeroize-devel.sha256sum] = "5566446699728a354e8eedad790c73841a597759c68a5cafdac6b043fff74eb0"

URI_aarch64_rust-cmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmac-devel-0.7.2-6.el10_2.noarch.rpm;name=aarch64_rust-cmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmac-devel}"
SRC_URI[aarch64_rust-cmac-devel.sha256sum] = "cda052a6ba50c6f1355254befa845f8480432849c05145872eaf835e8f7f65d5"

RDEPENDS:rust-cmac+default-devel = " \
 cargo \
 rust-cmac-devel \
 "
RDEPENDS:rust-cmac+std-devel = " \
 cargo \
 rust-cmac-devel \
 rust-digest+std-devel \
 "
RDEPENDS:rust-cmac+zeroize-devel = " \
 cargo \
 rust-cipher0.4+zeroize-devel \
 rust-cmac-devel \
 "
RDEPENDS:rust-cmac-devel = " \
 cargo \
 rust \
 rust-cipher0.4+default-devel \
 rust-dbl+default-devel \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 "
