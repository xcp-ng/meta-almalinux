# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_proxy_cluster"
PV = "1.3.22"
PR = "2.el10"
PACKAGES = " \
 mod_proxy_cluster \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_proxy_cluster-1.3.22-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4881a2094411ab24ffff525a8b6be72c0a6b467655676935086a01f011a7489"

URI_x86_64_v2_mod_proxy_cluster = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_proxy_cluster-1.3.22-2.el10.x86_64_v2.rpm;name=x86_64_v2_mod_proxy_cluster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_proxy_cluster}"
SRC_URI[x86_64_v2_mod_proxy_cluster.sha256sum] = "254ac4cf12f4845025b07a68b966f6ff0b7001a558605396cf0e42cbf422575c"

URI_aarch64_mod_proxy_cluster = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_proxy_cluster-1.3.22-2.el10.aarch64.rpm;name=aarch64_mod_proxy_cluster;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_proxy_cluster}"
SRC_URI[aarch64_mod_proxy_cluster.sha256sum] = "8a0b129e1e0dc0de81b0322300aa6b0b013392632d5423e8d80b05c7ddb84ed9"

RDEPENDS:mod_proxy_cluster = " \
 apr \
 apr-util \
 bash \
 glibc \
 httpd \
 policycoreutils-python-utils \
 python3-policycoreutils \
 "
