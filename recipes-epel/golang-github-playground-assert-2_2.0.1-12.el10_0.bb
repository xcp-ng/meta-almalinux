# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-playground-assert-2"
PV = "2.0.1"
PR = "12.el10_0"
PACKAGES = " \
 compat-golang-gopkg-playground-assert-2-devel \
 golang-github-playground-assert-2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-playground-assert-2-2.0.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3eb55cf67022dd2296c4a084fe36851a89dbdf56b2a2a2efc621d0b0c997b4d"

URI_x86_64_v2_compat-golang-gopkg-playground-assert-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-gopkg-playground-assert-2-devel-2.0.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-gopkg-playground-assert-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-gopkg-playground-assert-2-devel}"
SRC_URI[x86_64_v2_compat-golang-gopkg-playground-assert-2-devel.sha256sum] = "1a3a6ebcf8063db628cb7618fdb3d283bdff4cd9c50a2918122fb5ff664f1d1b"

URI_x86_64_v2_golang-github-playground-assert-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-playground-assert-2-devel-2.0.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-playground-assert-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-playground-assert-2-devel}"
SRC_URI[x86_64_v2_golang-github-playground-assert-2-devel.sha256sum] = "d1d89db4e3983bb2a8d3df039ee5eaf3490cc882502acbe1780f494cea8a08b6"

URI_aarch64_compat-golang-gopkg-playground-assert-2-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-gopkg-playground-assert-2-devel-2.0.1-12.el10_0.noarch.rpm;name=aarch64_compat-golang-gopkg-playground-assert-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-gopkg-playground-assert-2-devel}"
SRC_URI[aarch64_compat-golang-gopkg-playground-assert-2-devel.sha256sum] = "8012c9f73bf55d71e148129555dc04d20b6a82caab226653fb002fd4cb74fc67"

URI_aarch64_golang-github-playground-assert-2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-playground-assert-2-devel-2.0.1-12.el10_0.noarch.rpm;name=aarch64_golang-github-playground-assert-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-playground-assert-2-devel}"
SRC_URI[aarch64_golang-github-playground-assert-2-devel.sha256sum] = "db1b0315edcb97cb7a184a4fd94f56e5034a3f007c06733a209df997bfa03879"

RDEPENDS:compat-golang-gopkg-playground-assert-2-devel = " \
 go-filesystem \
 golang-github-playground-assert-2-devel \
 "
RDEPENDS:golang-github-playground-assert-2-devel = " \
 go-filesystem \
 "
