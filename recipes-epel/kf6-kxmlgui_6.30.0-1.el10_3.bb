# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kxmlgui"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kxmlgui \
 kf6-kxmlgui-devel \
 kf6-kxmlgui-doc \
 kf6-kxmlgui-html \
 python3-kf6-kxmlgui \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kxmlgui-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1d1e6448f3350b97406b537791e2360266cb7886d660c10c4a60352b670be26a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kxmlgui;unpack=0"
SRC_URI[x86_64_v2_kf6-kxmlgui.sha256sum] = "57aacf717272177da29d046b7644a5d522226bc4ca50dc6916495d4bacd135ff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kxmlgui-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kxmlgui-devel.sha256sum] = "7a87004d7767b3b5c2b9fd0e1cb604030af3f0fdcc0c6b3fe8b6a200cc0297cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kxmlgui-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kxmlgui-doc.sha256sum] = "d9a62f05cddbfcfa445ebd7c42b902dee069f4dbcb13942ebe050117cc3aa9a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kxmlgui-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kxmlgui-html.sha256sum] = "e3a867aee0ee6aec4e497728a93ce856e6a923136205910a74d1110af2d89bef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kxmlgui-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kxmlgui;unpack=0"
SRC_URI[x86_64_v2_python3-kf6-kxmlgui.sha256sum] = "fdeb58fdd0a2e715335926895ef7fdec7ae0ee169f175b6032fc67aad3489968"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kxmlgui;unpack=0"
SRC_URI[aarch64_kf6-kxmlgui.sha256sum] = "b4c3d1c19ce64ee57b550ee463dcf528a6d78c22f57987d47c89fd42e8242bf8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kxmlgui-devel;unpack=0"
SRC_URI[aarch64_kf6-kxmlgui-devel.sha256sum] = "b46241c186e5014aee95e741b9427873956e54dd98b96284a37e38becd744834"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kxmlgui-doc;unpack=0"
SRC_URI[aarch64_kf6-kxmlgui-doc.sha256sum] = "1c80bf9db1dff90a3562d7c4b1147c687faebeed36a7f9ed00c5f29a05a30631"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kxmlgui-html;unpack=0"
SRC_URI[aarch64_kf6-kxmlgui-html.sha256sum] = "9bb3ce625fee2ca3e851978a19f95d25850d24957ecf7f90aa9bfa3a91f84d0f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kxmlgui-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kxmlgui;unpack=0"
SRC_URI[aarch64_python3-kf6-kxmlgui.sha256sum] = "2f1e42e6621a2c07502ed375edfc48ef1c727072a841a01b94852d0d00a25428"

RDEPENDS:kf6-kxmlgui = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kxmlgui-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kconfig-devel \
 kf6-kconfigwidgets-devel \
 kf6-kguiaddons-devel \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kxmlgui-doc = " \
 "
RDEPENDS:kf6-kxmlgui-html = " \
 "
RDEPENDS:python3-kf6-kxmlgui = " \
 glibc \
 kf6-kxmlgui \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
