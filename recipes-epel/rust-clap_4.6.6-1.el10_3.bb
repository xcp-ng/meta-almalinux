# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap"
PV = "4.6.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+debug-devel \
 rust-clap+default-devel \
 rust-clap+deprecated-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+error-context-devel \
 rust-clap+help-devel \
 rust-clap+std-devel \
 rust-clap+string-devel \
 rust-clap+suggestions-devel \
 rust-clap+unicode-devel \
 rust-clap+unstable-doc-devel \
 rust-clap+unstable-ext-devel \
 rust-clap+unstable-markdown-devel \
 rust-clap+unstable-styles-devel \
 rust-clap+unstable-v5-devel \
 rust-clap+usage-devel \
 rust-clap+wrap_help-devel \
 rust-clap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap-4.6.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02bf405abbbb71354e7dcc397d717425c55e583d06799d9dc39fd43c2db9a05e"

URI_x86_64_v2_rust-clap+cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+cargo-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+cargo-devel}"
SRC_URI[x86_64_v2_rust-clap+cargo-devel.sha256sum] = "039b22da279e7d8e8b59f48d4addda60b8fec528fe64d2877addd3153f5b72d0"

URI_x86_64_v2_rust-clap+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+color-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+color-devel}"
SRC_URI[x86_64_v2_rust-clap+color-devel.sha256sum] = "7a80db9c3787b10cb6fa0b83438656cb3368a3cf3c25ac7dce20a763be4fa64f"

URI_x86_64_v2_rust-clap+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+debug-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+debug-devel}"
SRC_URI[x86_64_v2_rust-clap+debug-devel.sha256sum] = "227ed7d9e1d9cc306ef369d9f06ab021119ed5e1ab2d19f8a5b2d26fcb11e4bf"

URI_x86_64_v2_rust-clap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+default-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+default-devel}"
SRC_URI[x86_64_v2_rust-clap+default-devel.sha256sum] = "2b151a887f39d0b4d792f6b2e78cbae202ffae5b71d23a49eca39aa8de183749"

URI_x86_64_v2_rust-clap+deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+deprecated-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap+deprecated-devel.sha256sum] = "8f7c30ec503343b367ba64bc9209e2c3b52ea835f5ab05d6a7bb5096e9f7e511"

URI_x86_64_v2_rust-clap+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+derive-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+derive-devel}"
SRC_URI[x86_64_v2_rust-clap+derive-devel.sha256sum] = "f3dad278f442c6bd4d25c736322712a6c1566d24d6ff3a40398f753b7ac1f116"

URI_x86_64_v2_rust-clap+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+env-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+env-devel}"
SRC_URI[x86_64_v2_rust-clap+env-devel.sha256sum] = "c2c2dba284e01f10ce5ee28084ad41a11fa73e66ef35b2ce81c8ce12f62761bd"

URI_x86_64_v2_rust-clap+error-context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+error-context-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+error-context-devel}"
SRC_URI[x86_64_v2_rust-clap+error-context-devel.sha256sum] = "830926636137967891bcc6ea2684adc37fb098c503f0f69701e617b8af2466e5"

URI_x86_64_v2_rust-clap+help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+help-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+help-devel}"
SRC_URI[x86_64_v2_rust-clap+help-devel.sha256sum] = "f64f9adbe6b629eac41aa00ac946834072fd7cf1ee4c947a462f06fd56f6aa22"

URI_x86_64_v2_rust-clap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+std-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+std-devel}"
SRC_URI[x86_64_v2_rust-clap+std-devel.sha256sum] = "07bf9fa02ff77fa26865fd15bdcbccfd6a695ac85a7f84b8c0bf2d6c2b91025c"

URI_x86_64_v2_rust-clap+string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+string-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+string-devel}"
SRC_URI[x86_64_v2_rust-clap+string-devel.sha256sum] = "1e12804fcda3875c15a134a80ff28b475599b2f019f216e15f93005b51477c60"

URI_x86_64_v2_rust-clap+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+suggestions-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+suggestions-devel}"
SRC_URI[x86_64_v2_rust-clap+suggestions-devel.sha256sum] = "704722057b96dff58cc8036e2cb17996e1a3f76f2eba94a85989daa6e3974d4d"

URI_x86_64_v2_rust-clap+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unicode-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unicode-devel}"
SRC_URI[x86_64_v2_rust-clap+unicode-devel.sha256sum] = "4e0de7a00938ce6f9e3c225bc0732395a8c5969e114e10d28204f6656c0e5e47"

URI_x86_64_v2_rust-clap+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-doc-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-doc-devel.sha256sum] = "adb87dfadbc34069137f8ba04b5f8f0a222bc352b66cb048c7d7626541077014"

URI_x86_64_v2_rust-clap+unstable-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-ext-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-ext-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-ext-devel.sha256sum] = "a30fdae72fb0cb2bc80c0ca349214060cbe17fafc54839296ec8780daee86c4d"

URI_x86_64_v2_rust-clap+unstable-markdown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-markdown-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-markdown-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-markdown-devel.sha256sum] = "690202107971af688e111abe0e162cd5fb5be5fdfecbf46a24cb1fbf76fdd40a"

URI_x86_64_v2_rust-clap+unstable-styles-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-styles-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-styles-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-styles-devel.sha256sum] = "ebdb9f0568d0d6183612bc3e199a4c06002d29f1d1c87588bd67cee348e7722d"

URI_x86_64_v2_rust-clap+unstable-v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-v5-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-v5-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-v5-devel.sha256sum] = "ffa44e3fdb6dc960d90b9a6dd9ef095c06bca59e3c69b737e568cb5927ebc8e6"

URI_x86_64_v2_rust-clap+usage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+usage-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+usage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+usage-devel}"
SRC_URI[x86_64_v2_rust-clap+usage-devel.sha256sum] = "52b10886af2bb054f84cd4d80cd2e80a78b87aea4da31f21a0715a87aec4c4d6"

URI_x86_64_v2_rust-clap+wrap_help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+wrap_help-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+wrap_help-devel}"
SRC_URI[x86_64_v2_rust-clap+wrap_help-devel.sha256sum] = "6804e217359df114476332ce95f636e3f054cedd1bd55014314203c8bb28d8ba"

URI_x86_64_v2_rust-clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-devel}"
SRC_URI[x86_64_v2_rust-clap-devel.sha256sum] = "9eeec39533bd4ff80418412f17547258f979e6ead293a266e50ce781d577f22f"

URI_aarch64_rust-clap+cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+cargo-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+cargo-devel}"
SRC_URI[aarch64_rust-clap+cargo-devel.sha256sum] = "b50f07483aa82fc0d1d3247ac385fdaed2457b1696b51b17dae4d89b70b50e10"

URI_aarch64_rust-clap+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+color-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+color-devel}"
SRC_URI[aarch64_rust-clap+color-devel.sha256sum] = "20ebf345603fec93dd84abce2144ddc260ce99884524b0afdba99fa5d21f8811"

URI_aarch64_rust-clap+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+debug-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+debug-devel}"
SRC_URI[aarch64_rust-clap+debug-devel.sha256sum] = "d7e9b9e1267f6afc43ffa189ad3aff91c642362c53d8c4457c9907b85d922380"

URI_aarch64_rust-clap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+default-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+default-devel}"
SRC_URI[aarch64_rust-clap+default-devel.sha256sum] = "3dd34cbce9dd8e52621e93b511d53d79d5f5d46ac50a7f41e0cb169dea675f75"

URI_aarch64_rust-clap+deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+deprecated-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+deprecated-devel}"
SRC_URI[aarch64_rust-clap+deprecated-devel.sha256sum] = "de09a4decfa92100341b38b62798af276ac5352f6b8a3da2ee1c5b60763fcac3"

URI_aarch64_rust-clap+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+derive-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+derive-devel}"
SRC_URI[aarch64_rust-clap+derive-devel.sha256sum] = "9f6dbb86eae9cd1d928d62c4af9c2eb0253ff532c52c279df4c1f18fffd5debd"

URI_aarch64_rust-clap+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+env-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+env-devel}"
SRC_URI[aarch64_rust-clap+env-devel.sha256sum] = "1416b86ffea350f263f457a4bbbe4b1985c787688d526c480cf7d03902957063"

URI_aarch64_rust-clap+error-context-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+error-context-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+error-context-devel}"
SRC_URI[aarch64_rust-clap+error-context-devel.sha256sum] = "bb5ec73e8f9ea634aa3e62415377b4356ea705fff7b9c973cf05df1fe4796d4b"

URI_aarch64_rust-clap+help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+help-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+help-devel}"
SRC_URI[aarch64_rust-clap+help-devel.sha256sum] = "73ac3d6194e20951ad2a3ed0307026b51f2bd9d1f5be05ad54065b4386d5bfa7"

URI_aarch64_rust-clap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+std-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+std-devel}"
SRC_URI[aarch64_rust-clap+std-devel.sha256sum] = "29a7abb1b0fef462641bffbba9acf92c015ec951926866388920b958c104f5cf"

URI_aarch64_rust-clap+string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+string-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+string-devel}"
SRC_URI[aarch64_rust-clap+string-devel.sha256sum] = "78f1a71827797d88ee600ada4aba2f9b22dab2c64bfdd6d3d1add682438afe54"

URI_aarch64_rust-clap+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+suggestions-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+suggestions-devel}"
SRC_URI[aarch64_rust-clap+suggestions-devel.sha256sum] = "de45b2364579443d3a5b5d86c15c1e7f3b93ea2621eb93e84cc8492bdec2c669"

URI_aarch64_rust-clap+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unicode-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unicode-devel}"
SRC_URI[aarch64_rust-clap+unicode-devel.sha256sum] = "e60a03ec9a4ab7864abcb17e7273846992616d76d795c7a7a870a49c82ed22d3"

URI_aarch64_rust-clap+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-doc-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-doc-devel}"
SRC_URI[aarch64_rust-clap+unstable-doc-devel.sha256sum] = "0d9c0375bb0d7ecdce67a07b81000084ad50ae569e02786109d19b899e7bb20c"

URI_aarch64_rust-clap+unstable-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-ext-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-ext-devel}"
SRC_URI[aarch64_rust-clap+unstable-ext-devel.sha256sum] = "fd1e47195143b5410ba7b35ea5461cd56572ea6de01cf16b3fc79e391601e3f9"

URI_aarch64_rust-clap+unstable-markdown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-markdown-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-markdown-devel}"
SRC_URI[aarch64_rust-clap+unstable-markdown-devel.sha256sum] = "4f5b5afcdfd3fce4a33ee3d47a1e6310525252989a2fcc260dd041b63ee7e6e5"

URI_aarch64_rust-clap+unstable-styles-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-styles-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-styles-devel}"
SRC_URI[aarch64_rust-clap+unstable-styles-devel.sha256sum] = "e712b9a5dce73afe2600e27f699e8579c7ccc5ed70c9661413df99b4330544f9"

URI_aarch64_rust-clap+unstable-v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-v5-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-v5-devel}"
SRC_URI[aarch64_rust-clap+unstable-v5-devel.sha256sum] = "66bad09d7db6d25af1edc439afc38ae1ecf6953236d00406f0b9e349e3f27fe3"

URI_aarch64_rust-clap+usage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+usage-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+usage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+usage-devel}"
SRC_URI[aarch64_rust-clap+usage-devel.sha256sum] = "342e8ed658e5c90028a11afe48b8bf1e1da5bb9112c98e74943c111669153edf"

URI_aarch64_rust-clap+wrap_help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+wrap_help-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+wrap_help-devel}"
SRC_URI[aarch64_rust-clap+wrap_help-devel.sha256sum] = "0a7e55a4b0cc6713b501eab35815cbb3d120f6dcf8e6aee364df277d8dfbf5e0"

URI_aarch64_rust-clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-devel}"
SRC_URI[aarch64_rust-clap-devel.sha256sum] = "7ebf7d0dd825ab242079441e1ebbc52ecfc9504f8bcf2e30778b5d99aa3b0436"

RDEPENDS:rust-clap+cargo-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+cargo-devel \
 "
RDEPENDS:rust-clap+color-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+color-devel \
 "
RDEPENDS:rust-clap+debug-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+debug-devel \
 rust-clap_derive+debug-devel \
 rust-clap_derive+default-devel \
 "
RDEPENDS:rust-clap+default-devel = " \
 cargo \
 rust-clap+color-devel \
 rust-clap+error-context-devel \
 rust-clap+help-devel \
 rust-clap+std-devel \
 rust-clap+suggestions-devel \
 rust-clap+usage-devel \
 rust-clap-devel \
 "
RDEPENDS:rust-clap+deprecated-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+deprecated-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+deprecated-devel \
 "
RDEPENDS:rust-clap+derive-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_derive+default-devel \
 "
RDEPENDS:rust-clap+env-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+env-devel \
 "
RDEPENDS:rust-clap+error-context-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+error-context-devel \
 "
RDEPENDS:rust-clap+help-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+help-devel \
 "
RDEPENDS:rust-clap+std-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+std-devel \
 "
RDEPENDS:rust-clap+string-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+string-devel \
 "
RDEPENDS:rust-clap+suggestions-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+suggestions-devel \
 "
RDEPENDS:rust-clap+unicode-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+unicode-devel \
 "
RDEPENDS:rust-clap+unstable-doc-devel = " \
 cargo \
 rust-clap+derive-devel \
 rust-clap-devel \
 rust-clap_builder+unstable-doc-devel \
 "
RDEPENDS:rust-clap+unstable-ext-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+unstable-ext-devel \
 "
RDEPENDS:rust-clap+unstable-markdown-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+unstable-markdown-devel \
 "
RDEPENDS:rust-clap+unstable-styles-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+unstable-styles-devel \
 "
RDEPENDS:rust-clap+unstable-v5-devel = " \
 cargo \
 rust-clap+deprecated-devel \
 rust-clap-devel \
 rust-clap_builder+unstable-v5-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+unstable-v5-devel \
 "
RDEPENDS:rust-clap+usage-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+usage-devel \
 "
RDEPENDS:rust-clap+wrap_help-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+wrap_help-devel \
 "
RDEPENDS:rust-clap-devel = " \
 cargo \
 rust \
 rust-clap_builder-devel \
 "
