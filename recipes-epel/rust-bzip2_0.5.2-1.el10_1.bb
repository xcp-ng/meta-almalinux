# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bzip2"
PV = "0.5.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-bzip2+default-devel \
 rust-bzip2+libbz2-rs-sys-devel \
 rust-bzip2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bzip2-0.5.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c66d0d78b9d37fcb7755f48198f616887d39bf8aad113bdbb19068c53ab2a57"

URI_x86_64_v2_rust-bzip2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2+default-devel-0.5.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2+default-devel}"
SRC_URI[x86_64_v2_rust-bzip2+default-devel.sha256sum] = "8a91527a2812d9aa8e9c3a935f3f3edcc31946c92d2093dcb168f5aea53f5eed"

URI_x86_64_v2_rust-bzip2+libbz2-rs-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2+libbz2-rs-sys-devel-0.5.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2+libbz2-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2+libbz2-rs-sys-devel}"
SRC_URI[x86_64_v2_rust-bzip2+libbz2-rs-sys-devel.sha256sum] = "2ec638f82a2eadfc68358c586d08670c639a575c9bf6d2761f89a83c57963e18"

URI_x86_64_v2_rust-bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2-devel-0.5.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2-devel}"
SRC_URI[x86_64_v2_rust-bzip2-devel.sha256sum] = "09e1961e6e6d84997906a1ac67f07bf328bfb602d7b1346d90fe2cff054b4149"

URI_aarch64_rust-bzip2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2+default-devel-0.5.2-1.el10_1.noarch.rpm;name=aarch64_rust-bzip2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2+default-devel}"
SRC_URI[aarch64_rust-bzip2+default-devel.sha256sum] = "4439073f00856b66b0a879d8dc614c7d3c7f0cc922110195112b85f351acc8c6"

URI_aarch64_rust-bzip2+libbz2-rs-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2+libbz2-rs-sys-devel-0.5.2-1.el10_1.noarch.rpm;name=aarch64_rust-bzip2+libbz2-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2+libbz2-rs-sys-devel}"
SRC_URI[aarch64_rust-bzip2+libbz2-rs-sys-devel.sha256sum] = "3f6427a1d9d97d1c15543da8022511cab3e90e3ad233665ad4b543289360220f"

URI_aarch64_rust-bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2-devel-0.5.2-1.el10_1.noarch.rpm;name=aarch64_rust-bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2-devel}"
SRC_URI[aarch64_rust-bzip2-devel.sha256sum] = "dfad8c8d83d649422bf5671cf48a8a741d635177f3b3cbbbd03c25533c4f558d"

RDEPENDS:rust-bzip2+default-devel = " \
 cargo \
 rust-bzip2-devel \
 rust-bzip2-sys+default-devel \
 "
RDEPENDS:rust-bzip2+libbz2-rs-sys-devel = " \
 cargo \
 rust-bzip2-devel \
 rust-bzip2-sys+__disabled-devel \
 rust-bzip2-sys+default-devel \
 rust-libbz2-rs-sys+rust-allocator-devel \
 rust-libbz2-rs-sys+semver-prefix-devel \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-bzip2-devel = " \
 cargo \
 rust \
 "
