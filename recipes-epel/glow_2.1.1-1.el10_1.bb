# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glow"
PV = "2.1.1"
PR = "1.el10_1"
PACKAGES = " \
 glow \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/glow-2.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1a5115ac1c1e8e63cf0b5e002cb366ad2aaeba8b92f7e20b1467c58889bea31"

URI_x86_64_v2_glow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glow-2.1.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glow}"
SRC_URI[x86_64_v2_glow.sha256sum] = "22b6cb5d4c5a19fc737ccd5ae003b0565bb89e76a4040ab82a711ceb97f5342c"

URI_aarch64_glow = "${EPEL_MIRROR}/aarch64/Packages/g/glow-2.1.1-1.el10_1.aarch64.rpm;name=aarch64_glow;unpack=0"
SRC_URI:append = " ${URI_aarch64_glow}"
SRC_URI[aarch64_glow.sha256sum] = "816dd3018ed16269b756e7d835e17e6350b7bef99d6c24c679c3f7493e2f33fb"

RDEPENDS:glow = " \
 glibc \
 "
