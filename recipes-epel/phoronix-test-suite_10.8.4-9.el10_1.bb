# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "phoronix-test-suite"
PV = "10.8.4"
PR = "9.el10_1"
PACKAGES = " \
 phoronix-test-suite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/phoronix-test-suite-10.8.4-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c040d709b14a9fe41210dea9b9132d40ca025cd62ba8e2dd68a40fbe6acb52f7"

URI_x86_64_v2_phoronix-test-suite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/phoronix-test-suite-10.8.4-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_phoronix-test-suite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_phoronix-test-suite}"
SRC_URI[x86_64_v2_phoronix-test-suite.sha256sum] = "101d1738a7867f32f315abe7567780021c89cfdd2f26b0833a1eae48a8759a0d"

URI_aarch64_phoronix-test-suite = "${EPEL_MIRROR}/aarch64/Packages/p/phoronix-test-suite-10.8.4-9.el10_1.noarch.rpm;name=aarch64_phoronix-test-suite;unpack=0"
SRC_URI:append = " ${URI_aarch64_phoronix-test-suite}"
SRC_URI[aarch64_phoronix-test-suite.sha256sum] = "dda2a665a40fe361a18f901f4b408cc95f0dd46c4443256b1bc807fd7df837b3"

RDEPENDS:phoronix-test-suite = " \
 bash \
 hicolor-icon-theme \
 systemd \
 virtual/php-cli \
 virtual/php-curl \
 virtual/php-gd \
 virtual/php-json \
 virtual/php-openssl \
 virtual/php-posix \
 virtual/php-sqlite3 \
 virtual/php-xml \
 "
