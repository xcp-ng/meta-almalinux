# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-libffi"
PV = "0.2.1"
PR = "7.el10_0"
PACKAGES = " \
 ghc-libffi \
 ghc-libffi-devel \
 ghc-libffi-doc \
 ghc-libffi-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-libffi-0.2.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96f927860bdad267814c498bbbe337543e8844aff65c6e8af79cc10b4173ddd7"

URI_x86_64_v2_ghc-libffi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-libffi-0.2.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-libffi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-libffi}"
SRC_URI[x86_64_v2_ghc-libffi.sha256sum] = "7c25d7f1592e75f4b6946fabb12eaa2de2df424144c2cc411bab694bf68a2012"

URI_x86_64_v2_ghc-libffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-libffi-devel-0.2.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-libffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-libffi-devel}"
SRC_URI[x86_64_v2_ghc-libffi-devel.sha256sum] = "3419a344741395c7b0c9a3bcf7829480654e9301cd58f1da57b1d78ef68e53b0"

URI_x86_64_v2_ghc-libffi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-libffi-doc-0.2.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-libffi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-libffi-doc}"
SRC_URI[x86_64_v2_ghc-libffi-doc.sha256sum] = "978d70e9ebfe5a4aa8367c0737d54d22d06d67eca7bbf2ad18d3ba58bd5b462d"

URI_x86_64_v2_ghc-libffi-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-libffi-prof-0.2.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-libffi-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-libffi-prof}"
SRC_URI[x86_64_v2_ghc-libffi-prof.sha256sum] = "ce35e231cafbc29eb197269a6503c723dea7c154b7de85d694deb6a4d8619e88"

URI_aarch64_ghc-libffi = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-libffi-0.2.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-libffi;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-libffi}"
SRC_URI[aarch64_ghc-libffi.sha256sum] = "c2b2dfcacf1240104642dbed20b21c6699a3601f7781d66ba91fa85d35184598"

URI_aarch64_ghc-libffi-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-libffi-devel-0.2.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-libffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-libffi-devel}"
SRC_URI[aarch64_ghc-libffi-devel.sha256sum] = "edbbe02d6b72b7695e3fa2437fee8c451abe2bb032f5dad67cbe5b4537729d17"

URI_aarch64_ghc-libffi-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-libffi-doc-0.2.1-7.el10_0.noarch.rpm;name=aarch64_ghc-libffi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-libffi-doc}"
SRC_URI[aarch64_ghc-libffi-doc.sha256sum] = "7125ac4a4288c770bccdbd1be42d16b5ef2ef8152b6cd5081a0e90a03ff8e2b3"

URI_aarch64_ghc-libffi-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-libffi-prof-0.2.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-libffi-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-libffi-prof}"
SRC_URI[aarch64_ghc-libffi-prof.sha256sum] = "e0bcfea8d2535bab94912de2d9b55a05492e382f966fb30b3c0269540e991d74"

RDEPENDS:ghc-libffi = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-libffi-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-libffi \
 "
RDEPENDS:ghc-libffi-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-libffi-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-libffi-devel \
 "
