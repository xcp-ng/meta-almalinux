# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-eo"
PE = "1"
PV = "0.20100218"
PR = "17.el10"
PACKAGES = " \
 hunspell-eo \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-eo-0.20100218-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2391e1a4743ae5cf9d41b5d5e751fcea7e109d8791191250bfbf2fc08cab7031"

URI_x86_64_v2_hunspell-eo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-eo-0.20100218-17.el10.noarch.rpm;name=x86_64_v2_hunspell-eo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-eo}"
SRC_URI[x86_64_v2_hunspell-eo.sha256sum] = "5585dc7064c1b2c8db89f5a0296a772c44034ef3fd5ecd7bee696a120ae7bd8f"

URI_aarch64_hunspell-eo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-eo-0.20100218-17.el10.noarch.rpm;name=aarch64_hunspell-eo;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-eo}"
SRC_URI[aarch64_hunspell-eo.sha256sum] = "5585dc7064c1b2c8db89f5a0296a772c44034ef3fd5ecd7bee696a120ae7bd8f"

RDEPENDS:hunspell-eo = " \
 hunspell-filesystem \
 "
