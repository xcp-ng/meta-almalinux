# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "proftpd"
PV = "1.3.9c"
PR = "3.el10_2"
PACKAGES = " \
 proftpd \
 proftpd-devel \
 proftpd-ldap \
 proftpd-mysql \
 proftpd-postgresql \
 proftpd-proxy \
 proftpd-sqlite \
 proftpd-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/proftpd-1.3.9c-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ae53a887a47e6f363f043d456a5beb76d55b5df2fd01abd110d08413819e3d0"

URI_x86_64_v2_proftpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-1.3.9c-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd}"
SRC_URI[x86_64_v2_proftpd.sha256sum] = "f8b3f02151cfe890d0158c8b50f38580c74e524dc995a2b56b6aa7be105ac972"

URI_x86_64_v2_proftpd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-devel-1.3.9c-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-devel}"
SRC_URI[x86_64_v2_proftpd-devel.sha256sum] = "6ad32c0542d6ad416047e7cb1ba82becb8b4b15303c7145268d0fa3702d336f7"

URI_x86_64_v2_proftpd-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-ldap-1.3.9c-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-ldap}"
SRC_URI[x86_64_v2_proftpd-ldap.sha256sum] = "55562aaf1511e1ce2f9c0f12c93d6ac0c2d157e790c9a222864987b8bec911d9"

URI_x86_64_v2_proftpd-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-mysql-1.3.9c-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-mysql}"
SRC_URI[x86_64_v2_proftpd-mysql.sha256sum] = "deb6fa21f89a9ad7f8b7b457256ff0ccc7cf886ccdca563ef271bd57069f1445"

URI_x86_64_v2_proftpd-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-postgresql-1.3.9c-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-postgresql}"
SRC_URI[x86_64_v2_proftpd-postgresql.sha256sum] = "f056b97ee1864ae4e6c4c85d3a5e277e025a8aea02846ef2657e8eecd72336d3"

URI_x86_64_v2_proftpd-proxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-proxy-1.3.9c-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-proxy}"
SRC_URI[x86_64_v2_proftpd-proxy.sha256sum] = "220a0332a95252c30f8ea90e7aed40adbef9d93ace3b5f8e086ff072349752f2"

URI_x86_64_v2_proftpd-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-sqlite-1.3.9c-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-sqlite}"
SRC_URI[x86_64_v2_proftpd-sqlite.sha256sum] = "f128ebfee6766ddfed5c24344ea1c657dcf16f06464810cfce1a8126a23a5fa1"

URI_x86_64_v2_proftpd-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-utils-1.3.9c-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-utils}"
SRC_URI[x86_64_v2_proftpd-utils.sha256sum] = "047fc06fbee69d278a5e88aa201557bc2eb4ffbe50d5de05576cf932fb6194fe"

URI_aarch64_proftpd = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-1.3.9c-3.el10_2.aarch64.rpm;name=aarch64_proftpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd}"
SRC_URI[aarch64_proftpd.sha256sum] = "d09d1baf363db461098d1ca255fd49bc338976f7fec760b3d5474bbe11c165b4"

URI_aarch64_proftpd-devel = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-devel-1.3.9c-3.el10_2.aarch64.rpm;name=aarch64_proftpd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-devel}"
SRC_URI[aarch64_proftpd-devel.sha256sum] = "597f63df13ad62cbc21eb48a3ca948de00285e286ec4bf4d365336f79b2859a8"

URI_aarch64_proftpd-ldap = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-ldap-1.3.9c-3.el10_2.aarch64.rpm;name=aarch64_proftpd-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-ldap}"
SRC_URI[aarch64_proftpd-ldap.sha256sum] = "cb112b56105f82dc8a32a4c32111db62e7733efedb1325857bd444f18f446be5"

URI_aarch64_proftpd-mysql = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-mysql-1.3.9c-3.el10_2.aarch64.rpm;name=aarch64_proftpd-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-mysql}"
SRC_URI[aarch64_proftpd-mysql.sha256sum] = "06b82f0ab64a275548bb696e0cc4204c71cd1e8db149222a012c600c347217e7"

URI_aarch64_proftpd-postgresql = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-postgresql-1.3.9c-3.el10_2.aarch64.rpm;name=aarch64_proftpd-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-postgresql}"
SRC_URI[aarch64_proftpd-postgresql.sha256sum] = "0663387fc72c0074df43b52ee2ec3b26bcebfbf5984055320624b1da5a2ceccd"

URI_aarch64_proftpd-proxy = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-proxy-1.3.9c-3.el10_2.aarch64.rpm;name=aarch64_proftpd-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-proxy}"
SRC_URI[aarch64_proftpd-proxy.sha256sum] = "caf9a35afc8fdf7f8c0c459f4e509404b683b08a65ecbb5d57facc84c22f94f6"

URI_aarch64_proftpd-sqlite = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-sqlite-1.3.9c-3.el10_2.aarch64.rpm;name=aarch64_proftpd-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-sqlite}"
SRC_URI[aarch64_proftpd-sqlite.sha256sum] = "99aaed17dad9ff0dabfe5f356c4d8c15d25dff4022f012584c3c56033882d2d3"

URI_aarch64_proftpd-utils = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-utils-1.3.9c-3.el10_2.aarch64.rpm;name=aarch64_proftpd-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-utils}"
SRC_URI[aarch64_proftpd-utils.sha256sum] = "c2e296215e930376bbe4a7043c544064fdc1b9b15866e6f093ecb8d3c647d9d8"

RDEPENDS:proftpd = " \
 bash \
 findutils \
 glibc \
 libacl \
 libcap \
 libidn2 \
 libmemcached-awesome \
 libsodium \
 libxcrypt \
 logrotate \
 openssl-libs \
 pam-libs \
 pcre2 \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-devel = " \
 gcc \
 libacl-devel \
 libcap-devel \
 libmemcached-awesome-devel \
 libpq-devel \
 libsodium-devel \
 mariadb-connector-c-devel \
 ncurses-devel \
 openldap-devel \
 openssl-devel \
 pam-devel \
 pcre2-devel \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 proftpd \
 sqlite-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:proftpd-ldap = " \
 glibc \
 libidn2 \
 libsodium \
 openldap \
 proftpd \
 "
RDEPENDS:proftpd-mysql = " \
 glibc \
 libidn2 \
 libsodium \
 mariadb-connector-c \
 proftpd \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-postgresql = " \
 glibc \
 libidn2 \
 libpq \
 libsodium \
 proftpd \
 "
RDEPENDS:proftpd-proxy = " \
 glibc \
 libidn2 \
 libsodium \
 openssl-libs \
 proftpd \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-sqlite = " \
 glibc \
 libidn2 \
 libsodium \
 proftpd \
 sqlite-libs \
 "
RDEPENDS:proftpd-utils = " \
 glibc \
 ncurses-libs \
 perl-Crypt-Cracklib \
 perl-Fcntl \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-IO \
 perl-MIME-Base64 \
 perl-Mail-Sendmail \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 proftpd \
 "
