# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "whichfont"
PV = "3.0.1"
PR = "1.el10_3"
PACKAGES = " \
 whichfont \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/whichfont-3.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a236e87b31a395c800cff0f71a09cb062d7e02cb4ee1e0bcce6463ee9a05ee1d"

URI_x86_64_v2_whichfont = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/whichfont-3.0.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_whichfont;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_whichfont}"
SRC_URI[x86_64_v2_whichfont.sha256sum] = "8f14d7d40224c6806df53a04d48f60f81f272286a01982e8ff83fb4b6973bfbd"

URI_aarch64_whichfont = "${EPEL_MIRROR}/aarch64/Packages/w/whichfont-3.0.1-1.el10_3.aarch64.rpm;name=aarch64_whichfont;unpack=0"
SRC_URI:append = " ${URI_aarch64_whichfont}"
SRC_URI[aarch64_whichfont.sha256sum] = "01514e757193a1daa2ac9da0ce3ad45362425f97e82bd7116f3d245b30a6470a"

RDEPENDS:whichfont = " \
 fontconfig \
 glib2 \
 glibc \
 pango \
 "
