# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-getrandom0.3"
PV = "0.3.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-getrandom0.3+default-devel \
 rust-getrandom0.3+std-devel \
 rust-getrandom0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-getrandom0.3-0.3.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d05ad5e87fc1b71f7b8d4ffe7c4499e59194f824a86668caf8876e7e4ac2333"

URI_x86_64_v2_rust-getrandom0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.3+default-devel-0.3.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.3+default-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.3+default-devel.sha256sum] = "4f907cf37b90663e4949ded0b8bdcaae02fc7ad13504ede0e4efe328d5e6cabb"
RPROVIDES:rust-getrandom0.3+default-devel:x86_64_v2 = "virtual/crate_getrandom/default__ge_0.3.0_with_crate_getrandom/default__lt_0.5.0~"

URI_x86_64_v2_rust-getrandom0.3+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.3+std-devel-0.3.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.3+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.3+std-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.3+std-devel.sha256sum] = "b50d28498322d11ed4c26b757450bedda9cacd65bbf6309795d200ad05f78b61"

URI_x86_64_v2_rust-getrandom0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.3-devel-0.3.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.3-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.3-devel.sha256sum] = "9e6173a5db9f2b93ad132678ef359b2e1b5b8de8a9988c3bbb33188f87dffa78"
RPROVIDES:rust-getrandom0.3-devel:x86_64_v2 = "virtual/crate_getrandom__ge_0.3.0_with_crate_getrandom__lt_0.5.0~"

URI_aarch64_rust-getrandom0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.3+default-devel-0.3.4-1.el10_2.noarch.rpm;name=aarch64_rust-getrandom0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.3+default-devel}"
SRC_URI[aarch64_rust-getrandom0.3+default-devel.sha256sum] = "52c28388e7ff35dbbf6d8c1bbf91ffe8974b82ecc344282c739e3ef949f509ac"
RPROVIDES:rust-getrandom0.3+default-devel:aarch64 = "virtual/crate_getrandom/default__ge_0.3.0_with_crate_getrandom/default__lt_0.5.0~"

URI_aarch64_rust-getrandom0.3+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.3+std-devel-0.3.4-1.el10_2.noarch.rpm;name=aarch64_rust-getrandom0.3+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.3+std-devel}"
SRC_URI[aarch64_rust-getrandom0.3+std-devel.sha256sum] = "543712c981a19310fba81199f1cf42396cdd60fab66c6480220c792dbad6ad82"

URI_aarch64_rust-getrandom0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.3-devel-0.3.4-1.el10_2.noarch.rpm;name=aarch64_rust-getrandom0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.3-devel}"
SRC_URI[aarch64_rust-getrandom0.3-devel.sha256sum] = "2d6f7b32dadcd71c82eea22f7d76a4354ce20844730a127fe05ee7291a6034dd"
RPROVIDES:rust-getrandom0.3-devel:aarch64 = "virtual/crate_getrandom__ge_0.3.0_with_crate_getrandom__lt_0.5.0~"

RDEPENDS:rust-getrandom0.3+default-devel = " \
 cargo \
 rust-getrandom0.3-devel \
 "
RDEPENDS:rust-getrandom0.3+std-devel = " \
 cargo \
 rust-getrandom0.3-devel \
 "
RDEPENDS:rust-getrandom0.3-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_getrandom/default__ge_0.3.0_with_crate_getrandom/default__lt_0.5.0~ rpm/virtual/crate_getrandom__ge_0.3.0_with_crate_getrandom__lt_0.5.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_getrandom/default__ge_0.3.0_with_crate_getrandom/default__lt_0.5.0~ rpm/virtual/crate_getrandom__ge_0.3.0_with_crate_getrandom__lt_0.5.0~"
