# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fastrpc"
PV = "1.0.6"
PR = "4.el10_3"
PACKAGES = " \
 fastrpc \
 fastrpc-devel \
 fastrpc-services \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fastrpc-1.0.6-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2ba1b4f7e348e71c7f4304ee1642e71d0c15981fac1df2cd5f5345de8cf5211"

URI_aarch64_fastrpc = "${EPEL_MIRROR}/aarch64/Packages/f/fastrpc-1.0.6-4.el10_3.aarch64.rpm;name=aarch64_fastrpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fastrpc}"
SRC_URI[aarch64_fastrpc.sha256sum] = "0aa70687713729f6574013c56c4b59d53d128e81785d14d41a1a954b8be8bab2"

URI_aarch64_fastrpc-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fastrpc-devel-1.0.6-4.el10_3.aarch64.rpm;name=aarch64_fastrpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fastrpc-devel}"
SRC_URI[aarch64_fastrpc-devel.sha256sum] = "d784ab86a7261a4772d38d56682f14412ac0cb00b656625312159bd7dffef9b3"

URI_aarch64_fastrpc-services = "${EPEL_MIRROR}/aarch64/Packages/f/fastrpc-services-1.0.6-4.el10_3.aarch64.rpm;name=aarch64_fastrpc-services;unpack=0"
SRC_URI:append = " ${URI_aarch64_fastrpc-services}"
SRC_URI[aarch64_fastrpc-services.sha256sum] = "a1db90e1308d6f1f583fdfbd2685a5b2b96d52e85d4dcfaaae4ba612984a7246"

RDEPENDS:fastrpc = " \
 glibc \
 libbsd \
 libyaml \
 "
RDEPENDS:fastrpc-devel = " \
 fastrpc \
 "
RDEPENDS:fastrpc-services = " \
 bash \
 fastrpc \
 glibc \
 "
