# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "haproxy"
PV = "3.0.5"
PR = "6.el10_2.2"
PACKAGES = " \
 haproxy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/haproxy-3.0.5-6.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78fa1e8989761c9ef652d1ed389d30c9914ce4a7e0b7a361bc9296747dfb33a7"

URI_x86_64_v2_haproxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/haproxy-3.0.5-6.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_haproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_haproxy}"
SRC_URI[x86_64_v2_haproxy.sha256sum] = "c6b86236d5a68f5b208e9b5ee8ffd65cc181a06b527ab4e477076b9cfd2c6612"

URI_aarch64_haproxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/haproxy-3.0.5-6.el10_2.2.aarch64.rpm;name=aarch64_haproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_haproxy}"
SRC_URI[aarch64_haproxy.sha256sum] = "d9295cc2a61e85ee59a4f02c87e92a43dc8504cf0768aa8423f1fbe15f7c6d0c"

RDEPENDS:haproxy = " \
 bash \
 glibc \
 libxcrypt \
 lua-libs \
 openssl-libs \
 pcre2 \
 shadow-utils \
 systemd \
 "
