# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bzip3"
PV = "1.5.4"
PR = "1.el10_3"
PACKAGES = " \
 bzip3 \
 bzip3-devel \
 bzip3-grep \
 bzip3-less \
 bzip3-libs \
 bzip3-more \
 bzip3-tools \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/bzip3-1.5.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d45c4ea0b67ca6040b4a68c4f996a28a7d0b9c2a58fb11a9b1c7bf096811546e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-1.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3;unpack=0"
SRC_URI[x86_64_v2_bzip3.sha256sum] = "7210c98f7dfbbed217b7fd1d804d3af4f6bae0ac69823403e2b718f8a174a94f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-devel-1.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3-devel;unpack=0"
SRC_URI[x86_64_v2_bzip3-devel.sha256sum] = "bd8a5724e07ff20a2c6f63b6b714867a8233d27e3039b2ff66b1840336a6ea00"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-grep-1.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_bzip3-grep;unpack=0"
SRC_URI[x86_64_v2_bzip3-grep.sha256sum] = "8dff1e69d5b734cd57c3c1732a66d040906e74cb72e02c74a3cac9ea76b6fbee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-less-1.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_bzip3-less;unpack=0"
SRC_URI[x86_64_v2_bzip3-less.sha256sum] = "1603f0af3cf18087b79f6d26dd7156481e7fa25d0feca88690a35a645e8b9c20"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-libs-1.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3-libs;unpack=0"
SRC_URI[x86_64_v2_bzip3-libs.sha256sum] = "08c6504b46916b38bbca9aacb3b0519a2dd76b772aab2ce2c374c5a043e9d32a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-more-1.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_bzip3-more;unpack=0"
SRC_URI[x86_64_v2_bzip3-more.sha256sum] = "e20a898ea76ee00737af5148f6735964ed50884ce216a05b159b6742b451b761"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-tools-1.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3-tools;unpack=0"
SRC_URI[x86_64_v2_bzip3-tools.sha256sum] = "948398bbd7c66900b05d571a76d26c88dc33bc4eec7fd230f8a0596f2cbaf9b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bzip3-1.5.4-1.el10_3.aarch64.rpm;name=aarch64_bzip3;unpack=0"
SRC_URI[aarch64_bzip3.sha256sum] = "bb1ebcdcb8ca8bd7a5716109467ad907815e8f118f7b8667e75b3897138e1720"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bzip3-devel-1.5.4-1.el10_3.aarch64.rpm;name=aarch64_bzip3-devel;unpack=0"
SRC_URI[aarch64_bzip3-devel.sha256sum] = "2728891c40b102a84d034485f4ccf18377628c432cc9a556369efd09843aab1c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bzip3-grep-1.5.4-1.el10_3.noarch.rpm;name=aarch64_bzip3-grep;unpack=0"
SRC_URI[aarch64_bzip3-grep.sha256sum] = "c32d03864914d873eea91852386b3a62afd868e192c25d635d271034b1b7d1cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bzip3-less-1.5.4-1.el10_3.noarch.rpm;name=aarch64_bzip3-less;unpack=0"
SRC_URI[aarch64_bzip3-less.sha256sum] = "33f44e5308bbd816653118cef3d8dfacf78283188600284d0b29e823604e0973"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bzip3-libs-1.5.4-1.el10_3.aarch64.rpm;name=aarch64_bzip3-libs;unpack=0"
SRC_URI[aarch64_bzip3-libs.sha256sum] = "1e40a7f9aa293a53286931107aa79294471fef2e33be6b55931afc23f7cc502c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bzip3-more-1.5.4-1.el10_3.noarch.rpm;name=aarch64_bzip3-more;unpack=0"
SRC_URI[aarch64_bzip3-more.sha256sum] = "5f799de5ea564b6ac1ba8adcc72267def92c999b17f9f03c9d77b042c7f4dbe2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bzip3-tools-1.5.4-1.el10_3.aarch64.rpm;name=aarch64_bzip3-tools;unpack=0"
SRC_URI[aarch64_bzip3-tools.sha256sum] = "af818442220ab18a2549aa0a86cf8ad2790208beeff06fe6a9a4bcb3824f4573"

RDEPENDS:bzip3 = " \
 bzip3-grep \
 bzip3-less \
 bzip3-more \
 bzip3-tools \
 "
RDEPENDS:bzip3-devel = " \
 bzip3-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:bzip3-grep = " \
 bash \
 bzip3-tools \
 grep \
 "
RDEPENDS:bzip3-less = " \
 bash \
 bzip3-tools \
 less \
 "
RDEPENDS:bzip3-libs = " \
 glibc \
 "
RDEPENDS:bzip3-more = " \
 bash \
 bzip3-tools \
 util-linux-core \
 "
RDEPENDS:bzip3-tools = " \
 bash \
 bzip3-libs \
 glibc \
 "
