# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bind"
PE = "32"
PV = "9.18.33"
PR = "15.el10_2.12"
PACKAGES = " \
 bind \
 bind-chroot \
 bind-devel \
 bind-dnssec-utils \
 bind-doc \
 bind-libs \
 bind-license \
 bind-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bind-9.18.33-15.el10_2.12.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5ac1f9acd8f79fc1df71b077040e686bbb9338723de04203762de1c0d1ba74d9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-9.18.33-15.el10_2.12.x86_64_v2.rpm;name=x86_64_v2_bind;unpack=0"
SRC_URI[x86_64_v2_bind.sha256sum] = "436569e2aaa2beb0f9537baf66cc6f11f6e89fdeea077cd42911b4d113f140c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-chroot-9.18.33-15.el10_2.12.x86_64_v2.rpm;name=x86_64_v2_bind-chroot;unpack=0"
SRC_URI[x86_64_v2_bind-chroot.sha256sum] = "8a5e7f9e4fbee25cf6e0588de06b2df51d7c7c7c45eff7564a23cfaa42e926d4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bind-devel-9.18.33-15.el10_2.12.x86_64_v2.rpm;name=x86_64_v2_bind-devel;unpack=0"
SRC_URI[x86_64_v2_bind-devel.sha256sum] = "43e916118832610531c4fc41293c9f3f7fff710bb13f7abe0a28a0df24454c87"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-dnssec-utils-9.18.33-15.el10_2.12.x86_64_v2.rpm;name=x86_64_v2_bind-dnssec-utils;unpack=0"
SRC_URI[x86_64_v2_bind-dnssec-utils.sha256sum] = "3319306e0466b77bd1d2f15ea3e9dc7c555f12f180fcb7768affaae0d08b6a72"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bind-doc-9.18.33-15.el10_2.12.noarch.rpm;name=x86_64_v2_bind-doc;unpack=0"
SRC_URI[x86_64_v2_bind-doc.sha256sum] = "3b9755ac6c753830e0794ed357299cbb5cac035c2fa318660643252d4b0780ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-libs-9.18.33-15.el10_2.12.x86_64_v2.rpm;name=x86_64_v2_bind-libs;unpack=0"
SRC_URI[x86_64_v2_bind-libs.sha256sum] = "bd4a7047eb251094472b3d94f6302603fd2ebbecd57ed82298caa409b380b0a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-license-9.18.33-15.el10_2.12.noarch.rpm;name=x86_64_v2_bind-license;unpack=0"
SRC_URI[x86_64_v2_bind-license.sha256sum] = "cf3c504a9857ffd2222e1db77e1c60344ac788c5662696ad6ef92bbac52bdf0b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-utils-9.18.33-15.el10_2.12.x86_64_v2.rpm;name=x86_64_v2_bind-utils;unpack=0"
SRC_URI[x86_64_v2_bind-utils.sha256sum] = "b0c224e2c522ecb66a92a546b0a51805983f53d01909de9f2500ea9d8fe4f099"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-9.18.33-15.el10_2.12.aarch64.rpm;name=aarch64_bind;unpack=0"
SRC_URI[aarch64_bind.sha256sum] = "3b3c21669141623cd7395a21cbf64cf11a8209aea442835b0644d039072bf5f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-chroot-9.18.33-15.el10_2.12.aarch64.rpm;name=aarch64_bind-chroot;unpack=0"
SRC_URI[aarch64_bind-chroot.sha256sum] = "e8aeeed1122974ee7f28cf8221a265ba01f7e63257dc8c6c89de050af236db34"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bind-devel-9.18.33-15.el10_2.12.aarch64.rpm;name=aarch64_bind-devel;unpack=0"
SRC_URI[aarch64_bind-devel.sha256sum] = "e5b02fc954598c6a6a23e574a251b5915a8aa2acb9e92e4e35605714c95af6d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-dnssec-utils-9.18.33-15.el10_2.12.aarch64.rpm;name=aarch64_bind-dnssec-utils;unpack=0"
SRC_URI[aarch64_bind-dnssec-utils.sha256sum] = "65e72e74670434112a2257912db207edc40fac85ad7dad0eb388ad55a7157426"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bind-doc-9.18.33-15.el10_2.12.noarch.rpm;name=aarch64_bind-doc;unpack=0"
SRC_URI[aarch64_bind-doc.sha256sum] = "3b9755ac6c753830e0794ed357299cbb5cac035c2fa318660643252d4b0780ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-libs-9.18.33-15.el10_2.12.aarch64.rpm;name=aarch64_bind-libs;unpack=0"
SRC_URI[aarch64_bind-libs.sha256sum] = "3cf985569aadfb5e34936e6057f5edf5a63445e3e2e1a641e32d227e214e70e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-license-9.18.33-15.el10_2.12.noarch.rpm;name=aarch64_bind-license;unpack=0"
SRC_URI[aarch64_bind-license.sha256sum] = "cf3c504a9857ffd2222e1db77e1c60344ac788c5662696ad6ef92bbac52bdf0b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-utils-9.18.33-15.el10_2.12.aarch64.rpm;name=aarch64_bind-utils;unpack=0"
SRC_URI[aarch64_bind-utils.sha256sum] = "76c0095ee2bac8de2830529afc46e391914145f1033f6096f02d8a309150fa41"

RDEPENDS:bind = " \
 bash \
 bind-libs \
 fstrm \
 glibc \
 glibc-common \
 grep \
 json-c \
 libcap \
 libmaxminddb \
 libnghttp2 \
 libuv \
 libxml2 \
 lmdb-libs \
 openssl-libs \
 protobuf-c \
 shadow-utils \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:bind-chroot = " \
 bash \
 bind \
 grep \
 "
RDEPENDS:bind-devel = " \
 bind-libs \
 fstrm-devel \
 json-c-devel \
 krb5-devel \
 libcap-devel \
 libmaxminddb-devel \
 libxml2-devel \
 lmdb-devel \
 openssl-devel \
 protobuf-c-devel \
 "
RDEPENDS:bind-dnssec-utils = " \
 bind-libs \
 glibc \
 "
RDEPENDS:bind-doc = " \
 bind-license \
 python3-sphinx_rtd_theme \
 "
RDEPENDS:bind-libs = " \
 bind-license \
 fstrm \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libmaxminddb \
 libnghttp2 \
 libuv \
 libxml2 \
 lmdb-libs \
 openssl-libs \
 protobuf-c \
 zlib-ng-compat \
 "
RDEPENDS:bind-license = " \
 "
RDEPENDS:bind-utils = " \
 bind-libs \
 glibc \
 krb5-libs \
 libidn2 \
 lmdb-libs \
 protobuf-c \
 "
