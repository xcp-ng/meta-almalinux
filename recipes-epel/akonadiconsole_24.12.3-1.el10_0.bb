# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadiconsole"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 akonadiconsole \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadiconsole-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c650b249a5359654a05eb3031cd918d35b17748f4211b9fc2d7cff5d19f93588"

URI_x86_64_v2_akonadiconsole = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadiconsole-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadiconsole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadiconsole}"
SRC_URI[x86_64_v2_akonadiconsole.sha256sum] = "99045e7a2ea3a031819985c78ce82c53912244faa1f40ca5291972f4f356ce96"

URI_aarch64_akonadiconsole = "${EPEL_MIRROR}/aarch64/Packages/a/akonadiconsole-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akonadiconsole;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadiconsole}"
SRC_URI[aarch64_akonadiconsole.sha256sum] = "2ecdb6512a08b2537d2da3b83f6fc881c9534b64bb692a0a2e7e46d53f9e93e3"

RDEPENDS:akonadiconsole = " \
 akonadi-calendar-tools \
 akonadi-contacts \
 akonadi-search \
 akonadi-server \
 calendarsupport \
 glibc \
 kf6-kcalendarcore \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kmime \
 libgcc \
 libkdepim \
 libstdc++ \
 messagelib \
 qt6-qtbase \
 qt6-qtbase-gui \
 xapian-core-libs \
 "
