# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-josepy"
PV = "2.0.0"
PR = "2.el10_1"
PACKAGES = " \
 python-josepy-doc \
 python3-josepy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-josepy-2.0.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78287b602f260e2a8250c8718ddd382d01abda657d95cb6d2b8eb202d1562412"

URI_x86_64_v2_python-josepy-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-josepy-doc-2.0.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-josepy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-josepy-doc}"
SRC_URI[x86_64_v2_python-josepy-doc.sha256sum] = "dd9fe8835186aa118ce266682ac9d09988e46f94f07a6e8c27f30b5e858486f0"

URI_x86_64_v2_python3-josepy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-josepy-2.0.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-josepy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-josepy}"
SRC_URI[x86_64_v2_python3-josepy.sha256sum] = "03b6df22fe94bd8c1b481f36a42803061018565870035ed6ae4fcc2d436e42d1"

URI_aarch64_python-josepy-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-josepy-doc-2.0.0-2.el10_1.noarch.rpm;name=aarch64_python-josepy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-josepy-doc}"
SRC_URI[aarch64_python-josepy-doc.sha256sum] = "5dbd6e3dbcc03d9fdf18a0b22496cce6d99ce547ec554e47a6335ac2c15afb0d"

URI_aarch64_python3-josepy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-josepy-2.0.0-2.el10_1.noarch.rpm;name=aarch64_python3-josepy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-josepy}"
SRC_URI[aarch64_python3-josepy.sha256sum] = "7add9c93d58ab696e661845ab39403d86252662c25cdba057969be9487b8dee4"

RDEPENDS:python-josepy-doc = " \
 "
RDEPENDS:python3-josepy = " \
 python3 \
 python3-cryptography \
 "
