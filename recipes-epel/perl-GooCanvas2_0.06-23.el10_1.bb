# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-GooCanvas2"
PV = "0.06"
PR = "23.el10_1"
PACKAGES = " \
 perl-GooCanvas2 \
 perl-GooCanvas2-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-GooCanvas2-0.06-23.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "930248afafe8f3fdf7535af89b601f830b9c6f5434608d0e1653ac5359b77c96"

URI_x86_64_v2_perl-GooCanvas2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GooCanvas2-0.06-23.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GooCanvas2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GooCanvas2}"
SRC_URI[x86_64_v2_perl-GooCanvas2.sha256sum] = "8edf0cb06fe3f28c3843a2d678ff1e2e16739b9152b795d793d13d33c59e111f"

URI_x86_64_v2_perl-GooCanvas2-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GooCanvas2-tests-0.06-23.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GooCanvas2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GooCanvas2-tests}"
SRC_URI[x86_64_v2_perl-GooCanvas2-tests.sha256sum] = "35c7c8571106b97ae07b084f525e63041ec5da3d32c8bf48b76b37a528e801e0"

URI_aarch64_perl-GooCanvas2 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GooCanvas2-0.06-23.el10_1.noarch.rpm;name=aarch64_perl-GooCanvas2;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GooCanvas2}"
SRC_URI[aarch64_perl-GooCanvas2.sha256sum] = "d53d1c42553a4b69112875862d70525db9f787939deaf23e696a521bb898ff48"

URI_aarch64_perl-GooCanvas2-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GooCanvas2-tests-0.06-23.el10_1.noarch.rpm;name=aarch64_perl-GooCanvas2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GooCanvas2-tests}"
SRC_URI[aarch64_perl-GooCanvas2-tests.sha256sum] = "c53514803a5f9a94655ac0886c4cbca19e41a05415c9e8c71f300e8fb0bced86"

RDEPENDS:perl-GooCanvas2 = " \
 goocanvas2 \
 perl-Glib-Object-Introspection \
 perl-libs \
 "
RDEPENDS:perl-GooCanvas2-tests = " \
 bash \
 perl-GooCanvas2 \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 "
