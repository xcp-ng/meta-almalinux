# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nwipe"
PV = "0.37"
PR = "4.el10_0"
PACKAGES = " \
 nwipe \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nwipe-0.37-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e849e6299f63c3bac92f51eda6ca02f0762908c5fb65b0dfa730bb8254643c72"

URI_x86_64_v2_nwipe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nwipe-0.37-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nwipe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nwipe}"
SRC_URI[x86_64_v2_nwipe.sha256sum] = "0e8c166e79751b6e0cc8d79112d5af496c202d7e04710a0cbc06cebf8517f138"

URI_aarch64_nwipe = "${EPEL_MIRROR}/aarch64/Packages/n/nwipe-0.37-4.el10_0.aarch64.rpm;name=aarch64_nwipe;unpack=0"
SRC_URI:append = " ${URI_aarch64_nwipe}"
SRC_URI[aarch64_nwipe.sha256sum] = "c599f0d6d641fde5591732a528b2c01e14287c538f0866834424f7d60cda936f"

RDEPENDS:nwipe = " \
 dmidecode \
 glibc \
 hdparm \
 kmod \
 libconfig \
 ncurses-libs \
 parted \
 smartmontools \
 virtual//usr/bin/readlink \
 "
