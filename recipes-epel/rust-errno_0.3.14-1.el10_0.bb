# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-errno"
PV = "0.3.14"
PR = "1.el10_0"
PACKAGES = " \
 rust-errno+default-devel \
 rust-errno+std-devel \
 rust-errno-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-errno-0.3.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ba0e41ba83c64af2ef8e4f95a76dded1a6871f4b4deee668c528ee94686ed2f"

URI_x86_64_v2_rust-errno+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-errno+default-devel-0.3.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-errno+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-errno+default-devel}"
SRC_URI[x86_64_v2_rust-errno+default-devel.sha256sum] = "95282a5268c7a439abbbcc16417dd74d6a83359b218231cf47ec0ac5985a01e9"

URI_x86_64_v2_rust-errno+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-errno+std-devel-0.3.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-errno+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-errno+std-devel}"
SRC_URI[x86_64_v2_rust-errno+std-devel.sha256sum] = "c0835e152f15c89980f48c27774a4a64665d8774b9be15b69fd4d457315087e2"

URI_x86_64_v2_rust-errno-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-errno-devel-0.3.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-errno-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-errno-devel}"
SRC_URI[x86_64_v2_rust-errno-devel.sha256sum] = "872fa835d121344e091366896a91594dba52fcef2a09101cf59b76c5fe097d2a"

URI_aarch64_rust-errno+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-errno+default-devel-0.3.14-1.el10_0.noarch.rpm;name=aarch64_rust-errno+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-errno+default-devel}"
SRC_URI[aarch64_rust-errno+default-devel.sha256sum] = "94951137a288cdd3d78d84aa9bce85eafde0db303ee54a76ab0422b5950f38d0"

URI_aarch64_rust-errno+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-errno+std-devel-0.3.14-1.el10_0.noarch.rpm;name=aarch64_rust-errno+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-errno+std-devel}"
SRC_URI[aarch64_rust-errno+std-devel.sha256sum] = "27fde067095818b056e1c94636e4a2c0cb8e0a3a8d23d20cbee44b0fe8414027"

URI_aarch64_rust-errno-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-errno-devel-0.3.14-1.el10_0.noarch.rpm;name=aarch64_rust-errno-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-errno-devel}"
SRC_URI[aarch64_rust-errno-devel.sha256sum] = "5856ad328983f46462e75039f3db4c99387e700026197d6ecf03fdf5a9e5d43e"

RDEPENDS:rust-errno+default-devel = " \
 cargo \
 rust-errno+std-devel \
 rust-errno-devel \
 "
RDEPENDS:rust-errno+std-devel = " \
 cargo \
 rust-errno-devel \
 rust-libc+std-devel \
 "
RDEPENDS:rust-errno-devel = " \
 cargo \
 rust \
 rust-libc-devel \
 "
