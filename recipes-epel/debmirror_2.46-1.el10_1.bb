# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "debmirror"
PV = "2.46"
PR = "1.el10_1"
PACKAGES = " \
 debmirror \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/debmirror-2.46-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c707a889d8c59bb37c975e0f1231cf36697d7e38b42bfeea494b6443de54fa0"

URI_aarch64_debmirror = "${EPEL_MIRROR}/aarch64/Packages/d/debmirror-2.46-1.el10_1.noarch.rpm;name=aarch64_debmirror;unpack=0"
SRC_URI:append = " ${URI_aarch64_debmirror}"
SRC_URI[aarch64_debmirror.sha256sum] = "a2cf9ab5d5de7575c52693c14f0343830ecfd65ddff5d87edeb246a9f6b5bffc"

RDEPENDS:debmirror = " \
 bzip2 \
 ed \
 findutils \
 gnupg2 \
 gzip \
 patch \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Fcntl \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IO-Compress \
 perl-LockFile-Simple \
 perl-MIME-Base64 \
 perl-PathTools \
 perl-Storable \
 perl-URI \
 perl-if \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 perl-libwww-perl \
 rsync \
 virtual/coreutils \
 "
