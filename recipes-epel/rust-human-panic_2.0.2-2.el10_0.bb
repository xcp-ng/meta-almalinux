# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-human-panic"
PV = "2.0.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-human-panic+color-devel \
 rust-human-panic+default-devel \
 rust-human-panic+nightly-devel \
 rust-human-panic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-human-panic-2.0.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6c1087330029ecdd6ed697b1eda9c27ef9326e3ec1c06648a95eb9970dcaa53"

URI_x86_64_v2_rust-human-panic+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-panic+color-devel-2.0.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-panic+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-panic+color-devel}"
SRC_URI[x86_64_v2_rust-human-panic+color-devel.sha256sum] = "f8926e4dda49106cec873d1e3e1c97752d1c329bccfad8621f07c0a39b0896d2"

URI_x86_64_v2_rust-human-panic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-panic+default-devel-2.0.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-panic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-panic+default-devel}"
SRC_URI[x86_64_v2_rust-human-panic+default-devel.sha256sum] = "20e8a42ca654c761bc9a20fee731ea61b407064eb11f5d8c2fb0224823a47eb6"

URI_x86_64_v2_rust-human-panic+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-panic+nightly-devel-2.0.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-panic+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-panic+nightly-devel}"
SRC_URI[x86_64_v2_rust-human-panic+nightly-devel.sha256sum] = "59186fafca6bde02dc5bbdb5169fe75381e90ded2c1c4e3abad3bb52afd96b98"

URI_x86_64_v2_rust-human-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-panic-devel-2.0.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-panic-devel}"
SRC_URI[x86_64_v2_rust-human-panic-devel.sha256sum] = "d3e4739e16c7c00ad951a480034be26fe52dcb94357ac48206deb3ffbaccae15"

URI_aarch64_rust-human-panic+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-panic+color-devel-2.0.2-2.el10_0.noarch.rpm;name=aarch64_rust-human-panic+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-panic+color-devel}"
SRC_URI[aarch64_rust-human-panic+color-devel.sha256sum] = "a4632e0df7e36244b4141ac03539b80d63831ec91ed1ca3ee0ff53e9a95690c9"

URI_aarch64_rust-human-panic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-panic+default-devel-2.0.2-2.el10_0.noarch.rpm;name=aarch64_rust-human-panic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-panic+default-devel}"
SRC_URI[aarch64_rust-human-panic+default-devel.sha256sum] = "0d462cab547824b6ccc774d76f0e6af41ef48c7f9993e4d93a5e62143fbbbcdf"

URI_aarch64_rust-human-panic+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-panic+nightly-devel-2.0.2-2.el10_0.noarch.rpm;name=aarch64_rust-human-panic+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-panic+nightly-devel}"
SRC_URI[aarch64_rust-human-panic+nightly-devel.sha256sum] = "eb0eae46ff5e8e39f8f652fcee43a50deffd1987925061b26db34ed16f1516d1"

URI_aarch64_rust-human-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-panic-devel-2.0.2-2.el10_0.noarch.rpm;name=aarch64_rust-human-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-panic-devel}"
SRC_URI[aarch64_rust-human-panic-devel.sha256sum] = "36aa81c98c46a5fb344a468f57fdc5639a73367775ce5318143611f66aa23bc3"

RDEPENDS:rust-human-panic+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-human-panic-devel \
 "
RDEPENDS:rust-human-panic+default-devel = " \
 cargo \
 rust-human-panic+color-devel \
 rust-human-panic-devel \
 "
RDEPENDS:rust-human-panic+nightly-devel = " \
 cargo \
 rust-human-panic-devel \
 "
RDEPENDS:rust-human-panic-devel = " \
 cargo \
 rust \
 rust-backtrace+default-devel \
 rust-os_info+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-toml+display-devel \
 rust-toml-devel \
 rust-uuid+v4-devel \
 rust-uuid-devel \
 "
