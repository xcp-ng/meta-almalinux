# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "device-mapper-persistent-data"
PV = "1.3.0"
PR = "1.el10"
PACKAGES = " \
 device-mapper-persistent-data \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/device-mapper-persistent-data-1.3.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "279d62641492142aa69d498684df960f3f9a3e75096e777ace07bf0b02897b5e"

URI_x86_64_v2_device-mapper-persistent-data = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-persistent-data-1.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-persistent-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-persistent-data}"
SRC_URI[x86_64_v2_device-mapper-persistent-data.sha256sum] = "591b596ca79d1d1a4a98166b7d7474d6c15792fa19a677c11479d91c608ea7f5"

URI_aarch64_device-mapper-persistent-data = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-persistent-data-1.3.0-1.el10.aarch64.rpm;name=aarch64_device-mapper-persistent-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-persistent-data}"
SRC_URI[aarch64_device-mapper-persistent-data.sha256sum] = "d8d46e6378d1d99edc825873b9cba15599ca557fd7a6aaf3f9dee65c2e9809c0"

RDEPENDS:device-mapper-persistent-data = " \
 glibc \
 libgcc \
 systemd-libs \
 "
