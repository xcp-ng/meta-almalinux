# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "numad"
PV = "0.5"
PR = "50.20251104git.el10"
PACKAGES = " \
 numad \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/numad-0.5-50.20251104git.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07aaa5a3eb7f5c7c8ac1fb41db989b58b83a4b247c36157a5f575164277b05c5"

URI_x86_64_v2_numad = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/numad-0.5-50.20251104git.el10.x86_64_v2.rpm;name=x86_64_v2_numad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_numad}"
SRC_URI[x86_64_v2_numad.sha256sum] = "100f702c4db8b7febaf232163ceb8806550abe7672513641de943dc821ca5157"

URI_aarch64_numad = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/numad-0.5-50.20251104git.el10.aarch64.rpm;name=aarch64_numad;unpack=0"
SRC_URI:append = " ${URI_aarch64_numad}"
SRC_URI[aarch64_numad.sha256sum] = "82a3288673a673edd9a6439e2d057d13cac622386dbb31c0bce55b07ba6744d4"

RDEPENDS:numad = " \
 bash \
 glibc \
 "
