# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-h2"
PV = "0.4.13"
PR = "1.el10_1"
PACKAGES = " \
 rust-h2+default-devel \
 rust-h2+stream-devel \
 rust-h2+unstable-devel \
 rust-h2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-h2-0.4.13-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fff64be2bcdcb8027ecbae53422bcc577ae1ac761c4973851c8b46a2a9ce327"

URI_x86_64_v2_rust-h2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+default-devel-0.4.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2+default-devel}"
SRC_URI[x86_64_v2_rust-h2+default-devel.sha256sum] = "9d636f21b78854a59184f2daf4f06362c34146e513f5148df962b48d2a2116ba"

URI_x86_64_v2_rust-h2+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+stream-devel-0.4.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2+stream-devel}"
SRC_URI[x86_64_v2_rust-h2+stream-devel.sha256sum] = "5c6c24faf7dbe234398841a28445a2ab1da654357b3458a792e44354f31a7889"

URI_x86_64_v2_rust-h2+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+unstable-devel-0.4.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2+unstable-devel}"
SRC_URI[x86_64_v2_rust-h2+unstable-devel.sha256sum] = "f6dc37e553a5c953e0e11988ef62f28aaec14591fb0ab7bee39f928cfc94a85d"

URI_x86_64_v2_rust-h2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2-devel-0.4.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2-devel}"
SRC_URI[x86_64_v2_rust-h2-devel.sha256sum] = "11acc013d8b257c2f19200f396ed6f150edbcb06940de3718f5a53971b5e0186"

URI_aarch64_rust-h2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+default-devel-0.4.13-1.el10_1.noarch.rpm;name=aarch64_rust-h2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2+default-devel}"
SRC_URI[aarch64_rust-h2+default-devel.sha256sum] = "b6266dff1cf5a94b4e09da61f81ca2ff8a2c6b9b5c97f118cb90e853c3010cad"

URI_aarch64_rust-h2+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+stream-devel-0.4.13-1.el10_1.noarch.rpm;name=aarch64_rust-h2+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2+stream-devel}"
SRC_URI[aarch64_rust-h2+stream-devel.sha256sum] = "add1a8916019a116c81a98966097a79dfa7b3a802be9e01e023342207abc338e"

URI_aarch64_rust-h2+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+unstable-devel-0.4.13-1.el10_1.noarch.rpm;name=aarch64_rust-h2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2+unstable-devel}"
SRC_URI[aarch64_rust-h2+unstable-devel.sha256sum] = "1e34191bc0d968c3ba40b8904e8bf813f74d5af0d4ed27d1a89098589d0b49d9"

URI_aarch64_rust-h2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2-devel-0.4.13-1.el10_1.noarch.rpm;name=aarch64_rust-h2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2-devel}"
SRC_URI[aarch64_rust-h2-devel.sha256sum] = "7d1eb86b3838fadb382af894b1b71d9fa365bf89897bacb94bd5e87234e7cb97"

RDEPENDS:rust-h2+default-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2+stream-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2+unstable-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2-devel = " \
 cargo \
 rust \
 rust-atomic-waker+default-devel \
 rust-bytes+default-devel \
 rust-fnv+default-devel \
 rust-futures-core-devel \
 rust-futures-sink-devel \
 rust-http+default-devel \
 rust-indexmap+default-devel \
 rust-indexmap+std-devel \
 rust-slab+default-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio-util+codec-devel \
 rust-tokio-util+default-devel \
 rust-tokio-util+io-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
