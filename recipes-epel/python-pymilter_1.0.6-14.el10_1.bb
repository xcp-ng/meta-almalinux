# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pymilter"
PV = "1.0.6"
PR = "14.el10_1"
PACKAGES = " \
 python-pymilter-common \
 python-pymilter-selinux \
 python3-pymilter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pymilter-1.0.6-14.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ed7ee5e66d559fb20dcdc9a461c46dca228a671e6f03f2704bffff789f2717c"

URI_x86_64_v2_python-pymilter-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pymilter-common-1.0.6-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-pymilter-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pymilter-common}"
SRC_URI[x86_64_v2_python-pymilter-common.sha256sum] = "262c7585f68311cec4b68df2f8b339a79a6032fe9aa9a13d5682d16c62dd6b40"

URI_x86_64_v2_python-pymilter-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pymilter-selinux-1.0.6-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-pymilter-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pymilter-selinux}"
SRC_URI[x86_64_v2_python-pymilter-selinux.sha256sum] = "10b894d321bf76aeb4477e9f52ad71043b0fcede9df8bf70203908cd56a5ee1a"

URI_x86_64_v2_python3-pymilter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pymilter-1.0.6-14.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pymilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pymilter}"
SRC_URI[x86_64_v2_python3-pymilter.sha256sum] = "b381d703ecdbc1381d71e47ce4f76c87f698561b42c7c97e1f701c0ec883b495"

URI_aarch64_python-pymilter-common = "${EPEL_MIRROR}/aarch64/Packages/p/python-pymilter-common-1.0.6-14.el10_1.noarch.rpm;name=aarch64_python-pymilter-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pymilter-common}"
SRC_URI[aarch64_python-pymilter-common.sha256sum] = "dcd2a1f87090caea31fb199b4e605e7ec9bfe6e6005058de790cd60adb81840c"

URI_aarch64_python-pymilter-selinux = "${EPEL_MIRROR}/aarch64/Packages/p/python-pymilter-selinux-1.0.6-14.el10_1.noarch.rpm;name=aarch64_python-pymilter-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pymilter-selinux}"
SRC_URI[aarch64_python-pymilter-selinux.sha256sum] = "e186229ded57fb022e3423073a5cd71fd01446d40ff7d225f2d54a2bbbd316df"

URI_aarch64_python3-pymilter = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pymilter-1.0.6-14.el10_1.aarch64.rpm;name=aarch64_python3-pymilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pymilter}"
SRC_URI[aarch64_python3-pymilter.sha256sum] = "8c3802983eb6d852456fe687100c6f4a59c9c975ee3f7ea9f9ecfae6f53ad109"

RDEPENDS:python-pymilter-common = " \
 "
RDEPENDS:python-pymilter-selinux = " \
 bash \
 policycoreutils \
 python-pymilter-common \
 selinux-policy-targeted \
 "
RDEPENDS:python3-pymilter = " \
 glibc \
 python-pymilter-common \
 python3 \
 python3-py3dns \
 sendmail-milter \
 "
