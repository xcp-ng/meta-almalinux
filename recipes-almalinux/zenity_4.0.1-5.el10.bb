# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zenity"
PV = "4.0.1"
PR = "5.el10"
PACKAGES = " \
 zenity \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/zenity-4.0.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "013e6d33aebe01ad69722c08153a6512752586a2204dd8e056a656eb965c71e4"

URI_x86_64_v2_zenity = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/zenity-4.0.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_zenity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zenity}"
SRC_URI[x86_64_v2_zenity.sha256sum] = "eb1ce3b4df7da4d09a0e2a0589fc51ee2ef07548f21c09f2ee946f55c22ff66b"

URI_aarch64_zenity = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/zenity-4.0.1-5.el10.aarch64.rpm;name=aarch64_zenity;unpack=0"
SRC_URI:append = " ${URI_aarch64_zenity}"
SRC_URI[aarch64_zenity.sha256sum] = "9e67b78261a08b09dfc1446e8c7c93378ca70b4a14389ba867782e161de7f5eb"

RDEPENDS:zenity = " \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
 libgcc \
 pango \
 "
