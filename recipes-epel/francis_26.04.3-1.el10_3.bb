# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "francis"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 francis \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/francis-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac2a7627309af97233cf17556ec73283e4df1ae701b38a208b737f6a7407ed63"

URI_x86_64_v2_francis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/francis-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_francis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_francis}"
SRC_URI[x86_64_v2_francis.sha256sum] = "2c488c259bee97cc32ce066b07ea90fc77ebcf5f7c1bb3bba7f01eb40b041a82"

URI_aarch64_francis = "${EPEL_MIRROR}/aarch64/Packages/f/francis-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_francis;unpack=0"
SRC_URI:append = " ${URI_aarch64_francis}"
SRC_URI[aarch64_francis.sha256sum] = "65c587b6ab7c1b815a0ecd784dec6dc72f55ca420171059e74f50d531bd5c088"

RDEPENDS:francis = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
