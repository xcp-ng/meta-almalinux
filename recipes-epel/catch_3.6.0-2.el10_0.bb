# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "catch"
PV = "3.6.0"
PR = "2.el10_0"
PACKAGES = " \
 catch \
 catch-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/catch-3.6.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "966f6064ed1ac33ee0be7a4f5eb68db96df90af8c7534190e4729bf546bfbf3f"

URI_x86_64_v2_catch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/catch-3.6.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_catch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_catch}"
SRC_URI[x86_64_v2_catch.sha256sum] = "157b7ce264a3ca661571ad1272eae5cfc1921566fff7ba25bb7604aa57bafa9d"

URI_x86_64_v2_catch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/catch-devel-3.6.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_catch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_catch-devel}"
SRC_URI[x86_64_v2_catch-devel.sha256sum] = "b5264b01ae5c5b5d9a5e42dc346649f1b92bda98a19dce2a53b8450ca7c4c971"

URI_aarch64_catch = "${EPEL_MIRROR}/aarch64/Packages/c/catch-3.6.0-2.el10_0.aarch64.rpm;name=aarch64_catch;unpack=0"
SRC_URI:append = " ${URI_aarch64_catch}"
SRC_URI[aarch64_catch.sha256sum] = "63bcfa208ad2a78803f34af3abbfa23cf48b5546b800eddb6289a3cf09689e2a"

URI_aarch64_catch-devel = "${EPEL_MIRROR}/aarch64/Packages/c/catch-devel-3.6.0-2.el10_0.aarch64.rpm;name=aarch64_catch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_catch-devel}"
SRC_URI[aarch64_catch-devel.sha256sum] = "632d966dc6f06a69a76ba68b55389dcc959d6bf00f1f366911ce5954925f97dc"

RDEPENDS:catch = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:catch-devel = " \
 catch \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
