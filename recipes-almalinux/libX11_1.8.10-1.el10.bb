# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libX11"
PV = "1.8.10"
PR = "1.el10"
PACKAGES = " \
 libX11 \
 libX11-common \
 libX11-devel \
 libX11-xcb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libX11-1.8.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdc15fd571ba39d701268873fe5db6a981cb6e7b180cc9cede0b4ae2137603c6"

URI_x86_64_v2_libX11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libX11-1.8.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libX11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libX11}"
SRC_URI[x86_64_v2_libX11.sha256sum] = "cc067f3b853c945c5958b4c07d6e8132be392400341712f81636864e7e27e194"

URI_x86_64_v2_libX11-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libX11-common-1.8.10-1.el10.noarch.rpm;name=x86_64_v2_libX11-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libX11-common}"
SRC_URI[x86_64_v2_libX11-common.sha256sum] = "f02b59a9419a3d5907efb7805c915db5c26717c0061ebe1c04754764e868b562"

URI_x86_64_v2_libX11-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libX11-devel-1.8.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libX11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libX11-devel}"
SRC_URI[x86_64_v2_libX11-devel.sha256sum] = "0034e08a167d410b525a9f4ab8c305603cdaf54780a0601e26cb55aff797ae8b"

URI_x86_64_v2_libX11-xcb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libX11-xcb-1.8.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libX11-xcb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libX11-xcb}"
SRC_URI[x86_64_v2_libX11-xcb.sha256sum] = "c9fb0028b7fa3c982eda82af61b5b1bd0d170bd22b82650ea9b485351e4a5f3a"

URI_aarch64_libX11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libX11-1.8.10-1.el10.aarch64.rpm;name=aarch64_libX11;unpack=0"
SRC_URI:append = " ${URI_aarch64_libX11}"
SRC_URI[aarch64_libX11.sha256sum] = "8d0c81fce6d1225c4e2dfc69046c3d84548784dba93ecfe9d8b1e6ebe008f71b"

URI_aarch64_libX11-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libX11-common-1.8.10-1.el10.noarch.rpm;name=aarch64_libX11-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_libX11-common}"
SRC_URI[aarch64_libX11-common.sha256sum] = "f02b59a9419a3d5907efb7805c915db5c26717c0061ebe1c04754764e868b562"

URI_aarch64_libX11-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libX11-devel-1.8.10-1.el10.aarch64.rpm;name=aarch64_libX11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libX11-devel}"
SRC_URI[aarch64_libX11-devel.sha256sum] = "1987e709069ee3e179051b0b5bb4beffb80bc2a1634590e27e017a7f68b9b8b7"

URI_aarch64_libX11-xcb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libX11-xcb-1.8.10-1.el10.aarch64.rpm;name=aarch64_libX11-xcb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libX11-xcb}"
SRC_URI[aarch64_libX11-xcb.sha256sum] = "b6bef3c676e99292e14b98b765d00b2f134b9f7787f98ac9a36979687d02fece"

RDEPENDS:libX11 = " \
 glibc \
 libX11-common \
 libxcb \
 "
RDEPENDS:libX11-common = " \
 "
RDEPENDS:libX11-devel = " \
 libX11 \
 libX11-devel \
 libX11-xcb \
 libxcb-devel \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
RDEPENDS:libX11-xcb = " \
 glibc \
 "
