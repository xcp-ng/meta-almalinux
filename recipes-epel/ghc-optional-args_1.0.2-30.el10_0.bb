# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-optional-args"
PV = "1.0.2"
PR = "30.el10_0"
PACKAGES = " \
 ghc-optional-args \
 ghc-optional-args-devel \
 ghc-optional-args-doc \
 ghc-optional-args-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-optional-args-1.0.2-30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2ec02b46ee1c1337e7219c195f8b1aa5d7c622147b51f2a1e97c6d43645d67e"

URI_x86_64_v2_ghc-optional-args = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-optional-args-1.0.2-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-optional-args;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-optional-args}"
SRC_URI[x86_64_v2_ghc-optional-args.sha256sum] = "8ca97411eb7abf91e49cb225867303676b7589ae3faff51fe17dca85e308c835"

URI_x86_64_v2_ghc-optional-args-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-optional-args-devel-1.0.2-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-optional-args-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-optional-args-devel}"
SRC_URI[x86_64_v2_ghc-optional-args-devel.sha256sum] = "7a53b3839b8cea103f4970a9a2bd713435c86dc40ca6437e0af5ffc934cb5ec8"

URI_x86_64_v2_ghc-optional-args-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-optional-args-doc-1.0.2-30.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-optional-args-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-optional-args-doc}"
SRC_URI[x86_64_v2_ghc-optional-args-doc.sha256sum] = "085bc8b2a5dcd6b7d5cee341957ecb583c1da42904f3278994a89fcb4d656ed4"

URI_x86_64_v2_ghc-optional-args-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-optional-args-prof-1.0.2-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-optional-args-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-optional-args-prof}"
SRC_URI[x86_64_v2_ghc-optional-args-prof.sha256sum] = "54130d696b6eb9a86c7146657297355f8b3e37dd921f676b52dc748aae942295"

URI_aarch64_ghc-optional-args = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-optional-args-1.0.2-30.el10_0.aarch64.rpm;name=aarch64_ghc-optional-args;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-optional-args}"
SRC_URI[aarch64_ghc-optional-args.sha256sum] = "e148d2f8f2e937366aaada67a724dbc93539536a422c81b643205c783ff05467"

URI_aarch64_ghc-optional-args-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-optional-args-devel-1.0.2-30.el10_0.aarch64.rpm;name=aarch64_ghc-optional-args-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-optional-args-devel}"
SRC_URI[aarch64_ghc-optional-args-devel.sha256sum] = "103de09ed91e0d3d708c42381aafbdfc2048ff462f360e9294711249e3338423"

URI_aarch64_ghc-optional-args-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-optional-args-doc-1.0.2-30.el10_0.noarch.rpm;name=aarch64_ghc-optional-args-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-optional-args-doc}"
SRC_URI[aarch64_ghc-optional-args-doc.sha256sum] = "90e29e37b34fdaa235c45d3c7aea953e5626dafab25e605d10edc5219153fba7"

URI_aarch64_ghc-optional-args-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-optional-args-prof-1.0.2-30.el10_0.aarch64.rpm;name=aarch64_ghc-optional-args-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-optional-args-prof}"
SRC_URI[aarch64_ghc-optional-args-prof.sha256sum] = "c803fed2c2f33a001ca2b02a3e1356f89c4d0be8a89be993a1867f66583da5e0"

RDEPENDS:ghc-optional-args = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-optional-args-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-optional-args \
 "
RDEPENDS:ghc-optional-args-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-optional-args-prof = " \
 ghc-base-prof \
 ghc-optional-args-devel \
 "
