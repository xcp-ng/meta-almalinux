# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-find-msvc-tools"
PV = "0.1.10"
PR = "1.el10_2"
PACKAGES = " \
 rust-find-msvc-tools+default-devel \
 rust-find-msvc-tools-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-find-msvc-tools-0.1.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48b06f54a49ccc174df42f20465e54b14d1ebd15ebff84393db33f2191e6bcda"

URI_x86_64_v2_rust-find-msvc-tools+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-msvc-tools+default-devel-0.1.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-msvc-tools+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-find-msvc-tools+default-devel}"
SRC_URI[x86_64_v2_rust-find-msvc-tools+default-devel.sha256sum] = "273bff82041bd470f242e83eaa2fd1ade0b768af613e263263c344f592dc2383"

URI_x86_64_v2_rust-find-msvc-tools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-msvc-tools-devel-0.1.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-msvc-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-find-msvc-tools-devel}"
SRC_URI[x86_64_v2_rust-find-msvc-tools-devel.sha256sum] = "45be160d036750944efa1460b6173d76e8422cdacf03ef59b7d8b513dfc17e49"

URI_aarch64_rust-find-msvc-tools+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-find-msvc-tools+default-devel-0.1.10-1.el10_2.noarch.rpm;name=aarch64_rust-find-msvc-tools+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-find-msvc-tools+default-devel}"
SRC_URI[aarch64_rust-find-msvc-tools+default-devel.sha256sum] = "ea37cf9eb2c54474062d81adc545f0965a48edb4831a5afa6f3f546aa1e54ce0"

URI_aarch64_rust-find-msvc-tools-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-find-msvc-tools-devel-0.1.10-1.el10_2.noarch.rpm;name=aarch64_rust-find-msvc-tools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-find-msvc-tools-devel}"
SRC_URI[aarch64_rust-find-msvc-tools-devel.sha256sum] = "e492898a87a2aa956349c51d5ab545e046535be02d30e72619babcbbd50a49f2"

RDEPENDS:rust-find-msvc-tools+default-devel = " \
 cargo \
 rust-find-msvc-tools-devel \
 "
RDEPENDS:rust-find-msvc-tools-devel = " \
 cargo \
 rust \
 "
