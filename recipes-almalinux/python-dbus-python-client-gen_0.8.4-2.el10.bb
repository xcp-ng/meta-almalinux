# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dbus-python-client-gen"
PV = "0.8.4"
PR = "2.el10"
PACKAGES = " \
 python3-dbus-python-client-gen \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-dbus-python-client-gen-0.8.4-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8369125a40503787db59e2c52f0f068dec5729625627df2e5cb06bcb3059a82e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dbus-python-client-gen-0.8.4-2.el10.noarch.rpm;name=x86_64_v2_python3-dbus-python-client-gen;unpack=0"
SRC_URI[x86_64_v2_python3-dbus-python-client-gen.sha256sum] = "00c825182d4b4f0321162825e6a371394b2871e4cde1b7c07c6b27f63d81b8a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dbus-python-client-gen-0.8.4-2.el10.noarch.rpm;name=aarch64_python3-dbus-python-client-gen;unpack=0"
SRC_URI[aarch64_python3-dbus-python-client-gen.sha256sum] = "00c825182d4b4f0321162825e6a371394b2871e4cde1b7c07c6b27f63d81b8a6"

RDEPENDS:python3-dbus-python-client-gen = " \
 python3 \
 python3-dbus \
 python3-into-dbus-python \
 "
