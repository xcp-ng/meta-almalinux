# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-dustin-humanize"
PV = "1.0.1"
PR = "7.el10_0"
PACKAGES = " \
 golang-github-dustin-humanize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-dustin-humanize-1.0.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b990f47a637df9a065eed462ae6e887c3dd050408ab465baedb9ba7d4be49279"

URI_x86_64_v2_golang-github-dustin-humanize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-dustin-humanize-devel-1.0.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-dustin-humanize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-dustin-humanize-devel}"
SRC_URI[x86_64_v2_golang-github-dustin-humanize-devel.sha256sum] = "5a0c72251b4f94a54dd439e3b4586ffecd1b5863e0cecace661c4ae1821aaa59"

URI_aarch64_golang-github-dustin-humanize-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-dustin-humanize-devel-1.0.1-7.el10_0.noarch.rpm;name=aarch64_golang-github-dustin-humanize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-dustin-humanize-devel}"
SRC_URI[aarch64_golang-github-dustin-humanize-devel.sha256sum] = "fcf9e4ca099384ef70b4f338cb28edfc335e1d87ccf84b7813d5c6d8a3717f9a"

RDEPENDS:golang-github-dustin-humanize-devel = " \
 go-filesystem \
 "
