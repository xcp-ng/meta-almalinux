# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rav1e"
PV = "0.8.1"
PR = "2.el10_2"
PACKAGES = " \
 rav1e \
 rav1e-devel \
 rav1e-libs \
 rust-rav1e+asm-devel \
 rust-rav1e+av-metrics-devel \
 rust-rav1e+backtrace-devel \
 rust-rav1e+binaries-devel \
 rust-rav1e+capi-devel \
 rust-rav1e+cc-devel \
 rust-rav1e+channel-api-devel \
 rust-rav1e+check_asm-devel \
 rust-rav1e+clap-devel \
 rust-rav1e+clap_complete-devel \
 rust-rav1e+console-devel \
 rust-rav1e+crossbeam-devel \
 rust-rav1e+dav1d-sys-devel \
 rust-rav1e+decode_test_dav1d-devel \
 rust-rav1e+default-devel \
 rust-rav1e+desync_finder-devel \
 rust-rav1e+dump_ivf-devel \
 rust-rav1e+fern-devel \
 rust-rav1e+ivf-devel \
 rust-rav1e+nasm-rs-devel \
 rust-rav1e+nom-devel \
 rust-rav1e+quick_test-devel \
 rust-rav1e+scan_fmt-devel \
 rust-rav1e+serde-big-array-devel \
 rust-rav1e+serde-devel \
 rust-rav1e+serialize-devel \
 rust-rav1e+signal-hook-devel \
 rust-rav1e+signal_support-devel \
 rust-rav1e+threading-devel \
 rust-rav1e+toml-devel \
 rust-rav1e+unstable-devel \
 rust-rav1e+y4m-devel \
 rust-rav1e-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rav1e-0.8.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21d2d65f609c9615a0e9465beb46a20bdf1d5a50b7f31574e049f04d80d56b4a"

URI_x86_64_v2_rav1e = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rav1e-0.8.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rav1e;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rav1e}"
SRC_URI[x86_64_v2_rav1e.sha256sum] = "a14fe380e7934c75bcee15136c7c300c63f304a67bfb4905151b69a0e8c18c66"

URI_x86_64_v2_rav1e-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rav1e-devel-0.8.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rav1e-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rav1e-devel}"
SRC_URI[x86_64_v2_rav1e-devel.sha256sum] = "efe2663622be3eab3c554202a20830f0408b047076224a14464547d2698570dd"

URI_x86_64_v2_rav1e-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rav1e-libs-0.8.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rav1e-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rav1e-libs}"
SRC_URI[x86_64_v2_rav1e-libs.sha256sum] = "54bc163a77fdb51c26ad797f4a2478f28753681551bcb22d52f0e688d9b478ed"

URI_x86_64_v2_rust-rav1e+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+asm-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+asm-devel}"
SRC_URI[x86_64_v2_rust-rav1e+asm-devel.sha256sum] = "c5f4be0dee615e089fea8e5efe2b6d0c54c3269257e88a4d7a925eb7b30db21a"

URI_x86_64_v2_rust-rav1e+av-metrics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+av-metrics-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+av-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+av-metrics-devel}"
SRC_URI[x86_64_v2_rust-rav1e+av-metrics-devel.sha256sum] = "5ba1aa912786cfe65375c1f20acbbc2721149b702556ab2b92f8ca2acf326ee0"

URI_x86_64_v2_rust-rav1e+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+backtrace-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+backtrace-devel}"
SRC_URI[x86_64_v2_rust-rav1e+backtrace-devel.sha256sum] = "fff22452ecf0516988133abc4c46484d15d1719cf15385791da91425c0f16490"

URI_x86_64_v2_rust-rav1e+binaries-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+binaries-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+binaries-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+binaries-devel}"
SRC_URI[x86_64_v2_rust-rav1e+binaries-devel.sha256sum] = "cacc8565fdce62e63f8e62cf89f928d5baf229d429936d5935065c942281440d"

URI_x86_64_v2_rust-rav1e+capi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+capi-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+capi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+capi-devel}"
SRC_URI[x86_64_v2_rust-rav1e+capi-devel.sha256sum] = "6e85bbb22e5ba51bc815fdef49e861e6d232ad3b247a130bdbc18691df6f60b0"

URI_x86_64_v2_rust-rav1e+cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+cc-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+cc-devel}"
SRC_URI[x86_64_v2_rust-rav1e+cc-devel.sha256sum] = "b240bef30b645c5ca64388b17c88a3c3b2cdb93c7e3658e3fcaf378ba1a95ea3"

URI_x86_64_v2_rust-rav1e+channel-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+channel-api-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+channel-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+channel-api-devel}"
SRC_URI[x86_64_v2_rust-rav1e+channel-api-devel.sha256sum] = "671996f9fdca921b6d0f5651bf5ea6913f8530b8aeaa93244f0dbc237c7b53e0"

URI_x86_64_v2_rust-rav1e+check_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+check_asm-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+check_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+check_asm-devel}"
SRC_URI[x86_64_v2_rust-rav1e+check_asm-devel.sha256sum] = "0c5f7e396291de86ed196bf0a5ad53d53e52952cc444f179128037d4eae78562"

URI_x86_64_v2_rust-rav1e+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+clap-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+clap-devel}"
SRC_URI[x86_64_v2_rust-rav1e+clap-devel.sha256sum] = "6eb6b3876f9d8935b21116e4f07ab983296cd0aea3149ea5e9449e6943979b94"

URI_x86_64_v2_rust-rav1e+clap_complete-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+clap_complete-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+clap_complete-devel}"
SRC_URI[x86_64_v2_rust-rav1e+clap_complete-devel.sha256sum] = "67244e4765fa4b3d80b0ed24350277db9e2345d5046ccc093f7042cfcbc2eb72"

URI_x86_64_v2_rust-rav1e+console-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+console-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+console-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+console-devel}"
SRC_URI[x86_64_v2_rust-rav1e+console-devel.sha256sum] = "93c8d6501a338476dc51841b219a86eaafd07521e30e03987134428d27560a06"

URI_x86_64_v2_rust-rav1e+crossbeam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+crossbeam-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+crossbeam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+crossbeam-devel}"
SRC_URI[x86_64_v2_rust-rav1e+crossbeam-devel.sha256sum] = "7685575e2c336de99b10e97124f728f40819bfa607819c95c4c1d03b8b801c69"

URI_x86_64_v2_rust-rav1e+dav1d-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+dav1d-sys-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+dav1d-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+dav1d-sys-devel}"
SRC_URI[x86_64_v2_rust-rav1e+dav1d-sys-devel.sha256sum] = "3136cc6f9d4cc672caf3ac2300f2a840b8c8805c29a75ba57664d4bd445bedf7"

URI_x86_64_v2_rust-rav1e+decode_test_dav1d-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+decode_test_dav1d-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+decode_test_dav1d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+decode_test_dav1d-devel}"
SRC_URI[x86_64_v2_rust-rav1e+decode_test_dav1d-devel.sha256sum] = "a9f7353ce2ac331ae075bc9739a703608f18845d2418b2a7387a06665b5fe171"

URI_x86_64_v2_rust-rav1e+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+default-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+default-devel}"
SRC_URI[x86_64_v2_rust-rav1e+default-devel.sha256sum] = "3f4140926ac990374396e6c9dd97ebc144415c7a307f2c8f0a12c6c28be99330"

URI_x86_64_v2_rust-rav1e+desync_finder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+desync_finder-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+desync_finder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+desync_finder-devel}"
SRC_URI[x86_64_v2_rust-rav1e+desync_finder-devel.sha256sum] = "ee3d1a2bf6cdec03c4977fa4eee2314a59c765276d5c60261c7a074313b4458e"

URI_x86_64_v2_rust-rav1e+dump_ivf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+dump_ivf-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+dump_ivf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+dump_ivf-devel}"
SRC_URI[x86_64_v2_rust-rav1e+dump_ivf-devel.sha256sum] = "c423040f0490375777b82e34878d6233ea69c2db7c546255b25c6eb10a64965f"

URI_x86_64_v2_rust-rav1e+fern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+fern-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+fern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+fern-devel}"
SRC_URI[x86_64_v2_rust-rav1e+fern-devel.sha256sum] = "c5be4f6f27657cdd45ed70e0e44c66a08c9667f05266a120a683ee757ab43065"

URI_x86_64_v2_rust-rav1e+ivf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+ivf-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+ivf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+ivf-devel}"
SRC_URI[x86_64_v2_rust-rav1e+ivf-devel.sha256sum] = "07379c37fed688ca7cf8be05ee084e11d67338a3e57f0a23729f82f936cb4c20"

URI_x86_64_v2_rust-rav1e+nasm-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+nasm-rs-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+nasm-rs-devel}"
SRC_URI[x86_64_v2_rust-rav1e+nasm-rs-devel.sha256sum] = "eb7b2fb60bbb4330efa11c5728ab427ed56c8d36023c3204fa09cb409fdf01e4"

URI_x86_64_v2_rust-rav1e+nom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+nom-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+nom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+nom-devel}"
SRC_URI[x86_64_v2_rust-rav1e+nom-devel.sha256sum] = "b036f22eb2055e8c8dc11bb69a4a19fd6c67ff29e150046a6b7f196717b0e8fa"

URI_x86_64_v2_rust-rav1e+quick_test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+quick_test-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+quick_test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+quick_test-devel}"
SRC_URI[x86_64_v2_rust-rav1e+quick_test-devel.sha256sum] = "f7ab09e0eab83c326f52a29593416121818d7f22c0b5ce0076d0507033987e7f"

URI_x86_64_v2_rust-rav1e+scan_fmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+scan_fmt-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+scan_fmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+scan_fmt-devel}"
SRC_URI[x86_64_v2_rust-rav1e+scan_fmt-devel.sha256sum] = "613186673aefbee2864b9d9d607800a9d3000318057f4190ec5e11ddc433752a"

URI_x86_64_v2_rust-rav1e+serde-big-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+serde-big-array-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+serde-big-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+serde-big-array-devel}"
SRC_URI[x86_64_v2_rust-rav1e+serde-big-array-devel.sha256sum] = "c0a0dbf075b87d0a453cdc0d4cb6a140641099f8b45ca58eb4c86bc119070e5c"

URI_x86_64_v2_rust-rav1e+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+serde-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+serde-devel}"
SRC_URI[x86_64_v2_rust-rav1e+serde-devel.sha256sum] = "85d34c683c79d7dcf06bc4db11bec5ec881d72f6fb3b7836ea9b40db4f0decbc"

URI_x86_64_v2_rust-rav1e+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+serialize-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+serialize-devel}"
SRC_URI[x86_64_v2_rust-rav1e+serialize-devel.sha256sum] = "62849b9880cb261239da77c430b68a37f88c3877cada731517d0c50bde4a18f9"

URI_x86_64_v2_rust-rav1e+signal-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+signal-hook-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+signal-hook-devel}"
SRC_URI[x86_64_v2_rust-rav1e+signal-hook-devel.sha256sum] = "773ee54540047b9b90e9d8b7c182fc823bf2be15a9e583a1ad8b1e2614fd623f"

URI_x86_64_v2_rust-rav1e+signal_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+signal_support-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+signal_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+signal_support-devel}"
SRC_URI[x86_64_v2_rust-rav1e+signal_support-devel.sha256sum] = "87f614e2268380b61928f10e4ba69f5994a88af95aa9f5be59c48a041d465cfd"

URI_x86_64_v2_rust-rav1e+threading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+threading-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+threading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+threading-devel}"
SRC_URI[x86_64_v2_rust-rav1e+threading-devel.sha256sum] = "c9f7a53a6ffb79653afb51f73464d3da95e69fcfea2ebb536bb5e9957040dfe2"

URI_x86_64_v2_rust-rav1e+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+toml-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+toml-devel}"
SRC_URI[x86_64_v2_rust-rav1e+toml-devel.sha256sum] = "358ea1e5de5d5762e7c9d521a973709b720541ff192ed1bd82f69c0e538e9232"

URI_x86_64_v2_rust-rav1e+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+unstable-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+unstable-devel}"
SRC_URI[x86_64_v2_rust-rav1e+unstable-devel.sha256sum] = "5275975760d1d39d1384b9adb2f66f7137056c1b2365f63ef0006c33e859eb2a"

URI_x86_64_v2_rust-rav1e+y4m-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+y4m-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+y4m-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+y4m-devel}"
SRC_URI[x86_64_v2_rust-rav1e+y4m-devel.sha256sum] = "c29090058178b309681e944e2750368c7cb64cbedcef522b67c88b3389586d8a"

URI_x86_64_v2_rust-rav1e-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e-devel}"
SRC_URI[x86_64_v2_rust-rav1e-devel.sha256sum] = "12f4ac3a7969287ea35d44370e1b700189e77f5d8c3c8db583cfd8720a758018"

URI_aarch64_rav1e = "${EPEL_MIRROR}/aarch64/Packages/r/rav1e-0.8.1-2.el10_2.aarch64.rpm;name=aarch64_rav1e;unpack=0"
SRC_URI:append = " ${URI_aarch64_rav1e}"
SRC_URI[aarch64_rav1e.sha256sum] = "ea92fcdc4be5bd372997b7f3bf87a8c31e35fc5699154bc330651df78fcaab51"

URI_aarch64_rav1e-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rav1e-devel-0.8.1-2.el10_2.aarch64.rpm;name=aarch64_rav1e-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rav1e-devel}"
SRC_URI[aarch64_rav1e-devel.sha256sum] = "bd39ef1148546da98d25445a2710094690fb6bb069ef1f841e99c7ad750915fb"

URI_aarch64_rav1e-libs = "${EPEL_MIRROR}/aarch64/Packages/r/rav1e-libs-0.8.1-2.el10_2.aarch64.rpm;name=aarch64_rav1e-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rav1e-libs}"
SRC_URI[aarch64_rav1e-libs.sha256sum] = "badef168de48375e8dff8e932cfb7e042ae626e0a3c0541bec61a84f9c4bae83"

URI_aarch64_rust-rav1e+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+asm-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+asm-devel}"
SRC_URI[aarch64_rust-rav1e+asm-devel.sha256sum] = "87f5e9abbc3d19d6e1387492d358aa02bd7ebd2fe55ed3c6611e036213987dd3"

URI_aarch64_rust-rav1e+av-metrics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+av-metrics-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+av-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+av-metrics-devel}"
SRC_URI[aarch64_rust-rav1e+av-metrics-devel.sha256sum] = "55408f1d68dee1fc1449680cc008a43561535ee991976f41f9e476c39a2687e1"

URI_aarch64_rust-rav1e+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+backtrace-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+backtrace-devel}"
SRC_URI[aarch64_rust-rav1e+backtrace-devel.sha256sum] = "833a263cce2b39de68becd9036da1d8cea0a16ae7f51d49255847eb9d06988bc"

URI_aarch64_rust-rav1e+binaries-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+binaries-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+binaries-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+binaries-devel}"
SRC_URI[aarch64_rust-rav1e+binaries-devel.sha256sum] = "d34294fdb34b3fb3fa36c81fa371ebd4e756fc400c0ed22573b6819f8aa36c2f"

URI_aarch64_rust-rav1e+capi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+capi-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+capi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+capi-devel}"
SRC_URI[aarch64_rust-rav1e+capi-devel.sha256sum] = "9da3ac8d7ae478afad84c05ccfcfe2281c35355bd28c731905dfa914d8cffa9b"

URI_aarch64_rust-rav1e+cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+cc-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+cc-devel}"
SRC_URI[aarch64_rust-rav1e+cc-devel.sha256sum] = "646d45a67a684affa4e3ccc1b8cb1c53a968d1fc99fdf72b48d8a05444c28b48"

URI_aarch64_rust-rav1e+channel-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+channel-api-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+channel-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+channel-api-devel}"
SRC_URI[aarch64_rust-rav1e+channel-api-devel.sha256sum] = "360625f2f22e40463becd5d292d8a4fd74fb1a6920f3d52487fc3ce87f235674"

URI_aarch64_rust-rav1e+check_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+check_asm-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+check_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+check_asm-devel}"
SRC_URI[aarch64_rust-rav1e+check_asm-devel.sha256sum] = "98d62541f76f49e6d750526fe82e5490d436dea3690b9df9f138d193fed9d645"

URI_aarch64_rust-rav1e+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+clap-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+clap-devel}"
SRC_URI[aarch64_rust-rav1e+clap-devel.sha256sum] = "b40dc71998f6d84edd6e8a664393cf7f68c4d836d1eff5315e0affe4f957e252"

URI_aarch64_rust-rav1e+clap_complete-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+clap_complete-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+clap_complete-devel}"
SRC_URI[aarch64_rust-rav1e+clap_complete-devel.sha256sum] = "9a5892a6d93425689b2ea5ef88d510f64446384a927fce38f2dad264ceed125c"

URI_aarch64_rust-rav1e+console-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+console-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+console-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+console-devel}"
SRC_URI[aarch64_rust-rav1e+console-devel.sha256sum] = "82cbe5dc78d8c7a9b146cc5ca06f2661025dc82568a377d46a1812912d4b8135"

URI_aarch64_rust-rav1e+crossbeam-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+crossbeam-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+crossbeam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+crossbeam-devel}"
SRC_URI[aarch64_rust-rav1e+crossbeam-devel.sha256sum] = "ff37f8d63e90c5607037ff572f7c926df3c863157a46c5da02706e058ea26aad"

URI_aarch64_rust-rav1e+dav1d-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+dav1d-sys-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+dav1d-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+dav1d-sys-devel}"
SRC_URI[aarch64_rust-rav1e+dav1d-sys-devel.sha256sum] = "63d8c412bc7c6d05deca2d89cd7d8d18aa4f901ad8af4b26f8fee42ba0d6d6d1"

URI_aarch64_rust-rav1e+decode_test_dav1d-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+decode_test_dav1d-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+decode_test_dav1d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+decode_test_dav1d-devel}"
SRC_URI[aarch64_rust-rav1e+decode_test_dav1d-devel.sha256sum] = "f8db0fef15c7a69c6673061adedd79b84738144d67e0dd30d9fecf887c2db70a"

URI_aarch64_rust-rav1e+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+default-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+default-devel}"
SRC_URI[aarch64_rust-rav1e+default-devel.sha256sum] = "ec2eac93dd2b4d3404ed2a11fc13bb4d5de0742ba83d4c4337f38bb8841ea5f5"

URI_aarch64_rust-rav1e+desync_finder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+desync_finder-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+desync_finder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+desync_finder-devel}"
SRC_URI[aarch64_rust-rav1e+desync_finder-devel.sha256sum] = "feb09251cc521414b5354a866f132a6ac5a3e326f0e7e26fea4a2f93a7eaafa2"

URI_aarch64_rust-rav1e+dump_ivf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+dump_ivf-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+dump_ivf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+dump_ivf-devel}"
SRC_URI[aarch64_rust-rav1e+dump_ivf-devel.sha256sum] = "6d1eba80e442c5e3684cc55fd032d307fcd4221bbd64c27194129d081d2725a5"

URI_aarch64_rust-rav1e+fern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+fern-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+fern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+fern-devel}"
SRC_URI[aarch64_rust-rav1e+fern-devel.sha256sum] = "df22640e0a45f0083030f780b855e43a386c51300c00eba215e9a3e74a4fb8c9"

URI_aarch64_rust-rav1e+ivf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+ivf-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+ivf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+ivf-devel}"
SRC_URI[aarch64_rust-rav1e+ivf-devel.sha256sum] = "cd9d483689570790237afc950e5218cd831f9e4f9116bd453c2449a844a52ce0"

URI_aarch64_rust-rav1e+nasm-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+nasm-rs-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+nasm-rs-devel}"
SRC_URI[aarch64_rust-rav1e+nasm-rs-devel.sha256sum] = "c7a590240c6e534902dc7e15ad3637148dacf5749dc3ae6a7d921184e4e4a6a3"

URI_aarch64_rust-rav1e+nom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+nom-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+nom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+nom-devel}"
SRC_URI[aarch64_rust-rav1e+nom-devel.sha256sum] = "4ae0ce9fd1be59e08856e5a719314cdd8bc98a42994542a6e193c1d8bd7a8532"

URI_aarch64_rust-rav1e+quick_test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+quick_test-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+quick_test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+quick_test-devel}"
SRC_URI[aarch64_rust-rav1e+quick_test-devel.sha256sum] = "07f785b5ec2d6fac260e9ae0729c33aeddc70c9f815f68fccf56047b063e385c"

URI_aarch64_rust-rav1e+scan_fmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+scan_fmt-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+scan_fmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+scan_fmt-devel}"
SRC_URI[aarch64_rust-rav1e+scan_fmt-devel.sha256sum] = "ac478b192a55b3e9fe2522e57088150ff467f885f4dc014a0bb5fa6ccb29b7da"

URI_aarch64_rust-rav1e+serde-big-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+serde-big-array-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+serde-big-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+serde-big-array-devel}"
SRC_URI[aarch64_rust-rav1e+serde-big-array-devel.sha256sum] = "c5cdec2a97dcf21b2bee14fbaa9d5a0d4efec3b97f3d1c02884efcb7b234ad87"

URI_aarch64_rust-rav1e+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+serde-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+serde-devel}"
SRC_URI[aarch64_rust-rav1e+serde-devel.sha256sum] = "deb73d1cb9480448165165286f9dde07d8a268b9d0ab21c3017e2c5be8f95a09"

URI_aarch64_rust-rav1e+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+serialize-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+serialize-devel}"
SRC_URI[aarch64_rust-rav1e+serialize-devel.sha256sum] = "8fcaa7e8d034f83830296f2ba088abce6f9a40fbe1ad3fe0ea7cdb7cc7e29642"

URI_aarch64_rust-rav1e+signal-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+signal-hook-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+signal-hook-devel}"
SRC_URI[aarch64_rust-rav1e+signal-hook-devel.sha256sum] = "6544fa0723849b90773161e686e37b5e73083647c517b5f7cb456c47d168acf6"

URI_aarch64_rust-rav1e+signal_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+signal_support-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+signal_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+signal_support-devel}"
SRC_URI[aarch64_rust-rav1e+signal_support-devel.sha256sum] = "20662c9105f1371a6d6b8ab001369594d6061c0bbae523a77362ab1197d0df74"

URI_aarch64_rust-rav1e+threading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+threading-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+threading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+threading-devel}"
SRC_URI[aarch64_rust-rav1e+threading-devel.sha256sum] = "d8d92608e328c7f4afd8284c931b37e28afebe9a9fea1d0c4296bfaf315afb5c"

URI_aarch64_rust-rav1e+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+toml-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+toml-devel}"
SRC_URI[aarch64_rust-rav1e+toml-devel.sha256sum] = "84901d13946d5134ea77c54acf9a7c0f244d45069181e4c5fcda84102de12ea7"

URI_aarch64_rust-rav1e+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+unstable-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+unstable-devel}"
SRC_URI[aarch64_rust-rav1e+unstable-devel.sha256sum] = "5a99b4196be3b1049db1b90bb2de704ef662f5c52713d1541d23766b5f7bac6b"

URI_aarch64_rust-rav1e+y4m-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+y4m-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e+y4m-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+y4m-devel}"
SRC_URI[aarch64_rust-rav1e+y4m-devel.sha256sum] = "408b889babe963e466249803ab1345ec1f6a18fae61453bc204e2d2dad9aed34"

URI_aarch64_rust-rav1e-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-rav1e-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e-devel}"
SRC_URI[aarch64_rust-rav1e-devel.sha256sum] = "c63ebaf5d404152baa101f5a302f0c1d701c60537d25318c13e1080934c191e4"

RDEPENDS:rav1e = " \
 glibc \
 libgcc \
 "
RDEPENDS:rav1e-devel = " \
 pkgconf-pkg-config \
 rav1e-libs \
 "
RDEPENDS:rav1e-libs = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-rav1e+asm-devel = " \
 cargo \
 rust-rav1e+cc-devel \
 rust-rav1e+nasm-rs-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+av-metrics-devel = " \
 cargo \
 rust-av-metrics-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+binaries-devel = " \
 cargo \
 rust-rav1e+av-metrics-devel \
 rust-rav1e+clap-devel \
 rust-rav1e+clap_complete-devel \
 rust-rav1e+console-devel \
 rust-rav1e+fern-devel \
 rust-rav1e+ivf-devel \
 rust-rav1e+nom-devel \
 rust-rav1e+scan_fmt-devel \
 rust-rav1e+y4m-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+capi-devel = " \
 cargo \
 rust-rav1e+scan_fmt-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+cc-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+channel-api-devel = " \
 cargo \
 rust-rav1e+crossbeam-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+check_asm-devel = " \
 cargo \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+clap-devel = " \
 cargo \
 rust-clap+color-devel \
 rust-clap+derive-devel \
 rust-clap+std-devel \
 rust-clap+wrap_help-devel \
 rust-clap-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+clap_complete-devel = " \
 cargo \
 rust-clap_complete+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+console-devel = " \
 cargo \
 rust-console+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+crossbeam-devel = " \
 cargo \
 rust-crossbeam+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+dav1d-sys-devel = " \
 cargo \
 rust-dav1d-sys+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+decode_test_dav1d-devel = " \
 cargo \
 rust-rav1e+dav1d-sys-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+default-devel = " \
 cargo \
 rust-rav1e+asm-devel \
 rust-rav1e+binaries-devel \
 rust-rav1e+signal_support-devel \
 rust-rav1e+threading-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+desync_finder-devel = " \
 cargo \
 rust-rav1e+backtrace-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+dump_ivf-devel = " \
 cargo \
 rust-rav1e+ivf-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+fern-devel = " \
 cargo \
 rust-fern+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+ivf-devel = " \
 cargo \
 rust-ivf+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+nasm-rs-devel = " \
 cargo \
 rust-nasm-rs+default-devel \
 rust-nasm-rs+parallel-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+nom-devel = " \
 cargo \
 rust-nom+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+quick_test-devel = " \
 cargo \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+scan_fmt-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-scan_fmt-devel \
 "
RDEPENDS:rust-rav1e+serde-big-array-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-serde-big-array+default-devel \
 "
RDEPENDS:rust-rav1e+serde-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rav1e+serialize-devel = " \
 cargo \
 rust-av1-grain+serialize-devel \
 rust-rav1e+serde-big-array-devel \
 rust-rav1e+serde-devel \
 rust-rav1e+toml-devel \
 rust-rav1e-devel \
 rust-v_frame0.3+serialize-devel \
 "
RDEPENDS:rust-rav1e+signal-hook-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-signal-hook0.3+default-devel \
 "
RDEPENDS:rust-rav1e+signal_support-devel = " \
 cargo \
 rust-rav1e+signal-hook-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+threading-devel = " \
 cargo \
 rust-maybe-rayon+threads-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+toml-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-toml0.8+default-devel \
 "
RDEPENDS:rust-rav1e+unstable-devel = " \
 cargo \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+y4m-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-y4m+default-devel \
 "
RDEPENDS:rust-rav1e-devel = " \
 cargo \
 rust \
 rust-aligned-vec+default-devel \
 rust-arg_enum_proc_macro+default-devel \
 rust-arrayvec+default-devel \
 rust-av-scenechange0.14-devel \
 rust-av1-grain+default-devel \
 rust-bitstream-io+default-devel \
 rust-cfg-if+default-devel \
 rust-itertools0.14+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-maybe-rayon-devel \
 rust-new_debug_unreachable+default-devel \
 rust-noop_proc_macro+default-devel \
 rust-num-derive+default-devel \
 rust-num-traits+default-devel \
 rust-paste+default-devel \
 rust-simd_helpers+default-devel \
 rust-thiserror+default-devel \
 rust-v_frame0.3+default-devel \
 "
