# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-Iconv"
PV = "1.7"
PR = "54.el10_0"
PACKAGES = " \
 perl-Text-Iconv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-Iconv-1.7-54.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7224fc31aef987bc2284021ef3cc87a4e57b27052355b71a7b8fd1e834e6b8c7"

URI_x86_64_v2_perl-Text-Iconv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-Iconv-1.7-54.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Text-Iconv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-Iconv}"
SRC_URI[x86_64_v2_perl-Text-Iconv.sha256sum] = "3d365d1996b07b69a4ebe41a528edcfdc2663ea42130d8a04a87d4e99da6d0cf"

URI_aarch64_perl-Text-Iconv = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-Iconv-1.7-54.el10_0.aarch64.rpm;name=aarch64_perl-Text-Iconv;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-Iconv}"
SRC_URI[aarch64_perl-Text-Iconv.sha256sum] = "95bba37176171b97349a2469dbdc89c9ddce04479ee70f10c30fd4cefa716676"

RDEPENDS:perl-Text-Iconv = " \
 glibc \
 perl-AutoLoader \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
