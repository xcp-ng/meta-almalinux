# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tabulate"
PV = "0.9.0"
PR = "18.el10_2"
PACKAGES = " \
 python3-tabulate \
 python3-tabulate+widechars \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tabulate-0.9.0-18.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2221dff3d02622a9f00e4fbe18d43db5e3471bd263beca2d09c7ac403472aace"

URI_x86_64_v2_python3-tabulate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tabulate-0.9.0-18.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tabulate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tabulate}"
SRC_URI[x86_64_v2_python3-tabulate.sha256sum] = "d0edc8d2d404bb2a34752ad7d3d62e46a389598615976551c47db75086c24c81"

URI_x86_64_v2_python3-tabulate+widechars = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tabulate+widechars-0.9.0-18.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tabulate+widechars;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tabulate+widechars}"
SRC_URI[x86_64_v2_python3-tabulate+widechars.sha256sum] = "c4ef0932d0aa1f585dd6d1c0c25c4d7da001b4e2d5b617c7ac7e7857538b39d4"

URI_aarch64_python3-tabulate = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tabulate-0.9.0-18.el10_2.noarch.rpm;name=aarch64_python3-tabulate;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tabulate}"
SRC_URI[aarch64_python3-tabulate.sha256sum] = "ce48cea2a09cc0ece848d1dae2adcba005c9472d7b810d96d2ebf6490a601444"

URI_aarch64_python3-tabulate+widechars = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tabulate+widechars-0.9.0-18.el10_2.noarch.rpm;name=aarch64_python3-tabulate+widechars;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tabulate+widechars}"
SRC_URI[aarch64_python3-tabulate+widechars.sha256sum] = "52dc66fd398e0f4589a2d1e257b583d58f13913a1c392252d053919ef109f6f9"

RDEPENDS:python3-tabulate = " \
 python3 \
 "
RDEPENDS:python3-tabulate+widechars = " \
 python3 \
 python3-tabulate \
 python3-wcwidth \
 "
