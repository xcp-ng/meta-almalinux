# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-signal-hook-mio"
PV = "0.2.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-signal-hook-mio+default-devel \
 rust-signal-hook-mio+mio-0_8-devel \
 rust-signal-hook-mio+mio-1_0-devel \
 rust-signal-hook-mio+support-v0_8-devel \
 rust-signal-hook-mio+support-v1_0-devel \
 rust-signal-hook-mio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-signal-hook-mio-0.2.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81f11f835bb0c9da974a0c20915a64058d4bd33d8aa57453748af8bbd028ca31"

URI_x86_64_v2_rust-signal-hook-mio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio+default-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio+default-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio+default-devel.sha256sum] = "b6f4b99df3b7197459666a249243b1e78e6545d882e5d7cd812de06df7bc1064"

URI_x86_64_v2_rust-signal-hook-mio+mio-0_8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio+mio-0_8-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio+mio-0_8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio+mio-0_8-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio+mio-0_8-devel.sha256sum] = "1c74eb9eec8e67c7e0fdfdef909b89382bb9edd54fc13b61a985dfc71719f9af"

URI_x86_64_v2_rust-signal-hook-mio+mio-1_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio+mio-1_0-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio+mio-1_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio+mio-1_0-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio+mio-1_0-devel.sha256sum] = "c86b532134423b4d37ce3efbd4270cdbc959b52daf5932f3af32158c9c70d18a"

URI_x86_64_v2_rust-signal-hook-mio+support-v0_8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio+support-v0_8-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio+support-v0_8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio+support-v0_8-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio+support-v0_8-devel.sha256sum] = "84cc9d194e157709f387792cd1dd5ccafc7e13378783ef5195580f81a7b676e0"

URI_x86_64_v2_rust-signal-hook-mio+support-v1_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio+support-v1_0-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio+support-v1_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio+support-v1_0-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio+support-v1_0-devel.sha256sum] = "e8f3af0b4845d5f529087f24a1abe736404793e7a19e96fbdfee4c1f965bc160"

URI_x86_64_v2_rust-signal-hook-mio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio-devel.sha256sum] = "069a221e2069f7e43ab70caf5a0b22c9d9416151ba9ef54ae0598acc860a2748"

URI_aarch64_rust-signal-hook-mio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio+default-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-signal-hook-mio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio+default-devel}"
SRC_URI[aarch64_rust-signal-hook-mio+default-devel.sha256sum] = "4e2ecda5bae6b56d57c16d15ff048d5b3f552a4ae8243ad9b503bb707efcf6aa"

URI_aarch64_rust-signal-hook-mio+mio-0_8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio+mio-0_8-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-signal-hook-mio+mio-0_8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio+mio-0_8-devel}"
SRC_URI[aarch64_rust-signal-hook-mio+mio-0_8-devel.sha256sum] = "b6cfc5a5fe05965c6f2ab8e82d84953186a2cd26ee563bddb49283ba6e1e6f54"

URI_aarch64_rust-signal-hook-mio+mio-1_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio+mio-1_0-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-signal-hook-mio+mio-1_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio+mio-1_0-devel}"
SRC_URI[aarch64_rust-signal-hook-mio+mio-1_0-devel.sha256sum] = "e5fdec6fc217c1702a24081c03f3bfe778d788a996c986fce8af44ba2592e131"

URI_aarch64_rust-signal-hook-mio+support-v0_8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio+support-v0_8-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-signal-hook-mio+support-v0_8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio+support-v0_8-devel}"
SRC_URI[aarch64_rust-signal-hook-mio+support-v0_8-devel.sha256sum] = "013de804742aabe4fe7c503861a1577507d211a3c2959f95d4739532e39672c1"

URI_aarch64_rust-signal-hook-mio+support-v1_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio+support-v1_0-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-signal-hook-mio+support-v1_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio+support-v1_0-devel}"
SRC_URI[aarch64_rust-signal-hook-mio+support-v1_0-devel.sha256sum] = "146a876ac8503d3440ccde47700dcba08ee9ed602fc7780fe5595bbd7225f85f"

URI_aarch64_rust-signal-hook-mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-signal-hook-mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio-devel}"
SRC_URI[aarch64_rust-signal-hook-mio-devel.sha256sum] = "3536fd9c7c573029957320a6dd2fdd1445a5b2174ab100a52cdb2c007422ea01"

RDEPENDS:rust-signal-hook-mio+default-devel = " \
 cargo \
 rust-signal-hook-mio-devel \
 "
RDEPENDS:rust-signal-hook-mio+mio-0_8-devel = " \
 cargo \
 rust-mio0.8+default-devel \
 rust-mio0.8+net-devel \
 rust-mio0.8+os-ext-devel \
 rust-signal-hook-mio-devel \
 "
RDEPENDS:rust-signal-hook-mio+mio-1_0-devel = " \
 cargo \
 rust-mio+default-devel \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-signal-hook-mio-devel \
 "
RDEPENDS:rust-signal-hook-mio+support-v0_8-devel = " \
 cargo \
 rust-signal-hook-mio+mio-0_8-devel \
 rust-signal-hook-mio-devel \
 "
RDEPENDS:rust-signal-hook-mio+support-v1_0-devel = " \
 cargo \
 rust-signal-hook-mio+mio-1_0-devel \
 rust-signal-hook-mio-devel \
 "
RDEPENDS:rust-signal-hook-mio-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-signal-hook+default-devel \
 "
