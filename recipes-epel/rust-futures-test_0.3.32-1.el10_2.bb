# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-test"
PV = "0.3.32"
PR = "1.el10_2"
PACKAGES = " \
 rust-futures-test+default-devel \
 rust-futures-test+std-devel \
 rust-futures-test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-test-0.3.32-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a30707ca8cfe81188775ad9afd59145e9c663d450f6d51fa62791d086f1a4e9e"

URI_x86_64_v2_rust-futures-test+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-test+default-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-test+default-devel}"
SRC_URI[x86_64_v2_rust-futures-test+default-devel.sha256sum] = "436546ac5a249a201488d84aecab06099010d526a3e827540208d15718835eff"

URI_x86_64_v2_rust-futures-test+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-test+std-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-test+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-test+std-devel}"
SRC_URI[x86_64_v2_rust-futures-test+std-devel.sha256sum] = "c4ac0918af330664a103536e16e27bb5b0d8555dcdf7225d991cfae8bf7fff10"

URI_x86_64_v2_rust-futures-test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-test-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-test-devel}"
SRC_URI[x86_64_v2_rust-futures-test-devel.sha256sum] = "2b3c9221579db3dfda377f2e243cafdae18a1ba752fcac0dca0b76b41903685b"

URI_aarch64_rust-futures-test+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-test+default-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-test+default-devel}"
SRC_URI[aarch64_rust-futures-test+default-devel.sha256sum] = "2f1266ce3ae4ce067febc041b503e4f95844f9d9d54cd99994d9ef8f54ddb467"

URI_aarch64_rust-futures-test+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-test+std-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-test+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-test+std-devel}"
SRC_URI[aarch64_rust-futures-test+std-devel.sha256sum] = "7ceeb1e85928bc2a9d73bdf6d63949f88b37629b7a4ceb0489c25da6ba9ccf39"

URI_aarch64_rust-futures-test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-test-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-test-devel}"
SRC_URI[aarch64_rust-futures-test-devel.sha256sum] = "6547a9ec08eb13add0fcacd051e727f644e62d9b64558fd5b249834b5f511359"

RDEPENDS:rust-futures-test+default-devel = " \
 cargo \
 rust-futures-test+std-devel \
 rust-futures-test-devel \
 "
RDEPENDS:rust-futures-test+std-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-executor+std-devel \
 rust-futures-io+std-devel \
 rust-futures-task+std-devel \
 rust-futures-test-devel \
 rust-futures-util+io-devel \
 rust-futures-util+std-devel \
 "
RDEPENDS:rust-futures-test-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-futures-executor-devel \
 rust-futures-io-devel \
 rust-futures-macro-devel \
 rust-futures-sink-devel \
 rust-futures-task-devel \
 rust-futures-util-devel \
 rust-pin-project+default-devel \
 "
