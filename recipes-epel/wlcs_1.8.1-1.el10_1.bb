# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wlcs"
PV = "1.8.1"
PR = "1.el10_1"
PACKAGES = " \
 wlcs \
 wlcs-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/wlcs-1.8.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0873017e362172e7a3f036da45187997b55cd40878c6d56fb3caca1df8ed188c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wlcs-1.8.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wlcs;unpack=0"
SRC_URI[x86_64_v2_wlcs.sha256sum] = "d684c2415254bc589030d85f1fdafcacd43e74a0b17ba72567ce69e1fd79db65"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wlcs-devel-1.8.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wlcs-devel;unpack=0"
SRC_URI[x86_64_v2_wlcs-devel.sha256sum] = "a9f8ef43a3f38db40ea688aca9b143cfe4fef743c872022ac1071457c226ba6b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wlcs-1.8.1-1.el10_1.aarch64.rpm;name=aarch64_wlcs;unpack=0"
SRC_URI[aarch64_wlcs.sha256sum] = "eefd4ee816ebb65f9050649aec326afbf118f78d4e5fd34bd27690e4e0ad7afe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wlcs-devel-1.8.1-1.el10_1.aarch64.rpm;name=aarch64_wlcs-devel;unpack=0"
SRC_URI[aarch64_wlcs-devel.sha256sum] = "5892e28f90124238022b1796f56a860f01aee67511d67855a1657ae05a801ca2"

RDEPENDS:wlcs = " \
 glibc \
 gmock \
 gtest \
 libasan \
 libgcc \
 libstdc++ \
 libtsan \
 libubsan \
 libwayland-client \
 libwayland-server \
 "
RDEPENDS:wlcs-devel = " \
 pkgconf-pkg-config \
 wayland-devel \
 wlcs \
 "
