# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tracer"
PV = "1.4"
PR = "1.el10_1"
PACKAGES = " \
 python3-tracer \
 tracer-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tracer-1.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72b5ba8c246c75ce3b4fcdd65b3f12e5fa739fe4bb65be0213a73eee95886a96"

URI_x86_64_v2_python3-tracer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tracer-1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tracer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tracer}"
SRC_URI[x86_64_v2_python3-tracer.sha256sum] = "177ad02847bad204eb98597674842757e89c7892eaa98a820ddcdd6e4f34bdf7"

URI_x86_64_v2_tracer-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tracer-common-1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tracer-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tracer-common}"
SRC_URI[x86_64_v2_tracer-common.sha256sum] = "ce1250fefbf30f6645a9a6a53aa3ab406603709ced2ed266c5cb6616ef80a0ae"

URI_aarch64_python3-tracer = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tracer-1.4-1.el10_1.noarch.rpm;name=aarch64_python3-tracer;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tracer}"
SRC_URI[aarch64_python3-tracer.sha256sum] = "0afc7e737252f63ad4236a528d6cc59a201a121d1177041c35474e10b55a2e46"

URI_aarch64_tracer-common = "${EPEL_MIRROR}/aarch64/Packages/t/tracer-common-1.4-1.el10_1.noarch.rpm;name=aarch64_tracer-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_tracer-common}"
SRC_URI[aarch64_tracer-common.sha256sum] = "1a27b2fbf7ed3d9149a68c137f799b7fbe4d85083d59897c37c07cedb5e60875"

RDEPENDS:python3-tracer = " \
 python3 \
 python3-dbus \
 python3-distro \
 python3-psutil \
 python3-rpm \
 python3-six \
 tracer-common \
 "
RDEPENDS:tracer-common = " \
 "
