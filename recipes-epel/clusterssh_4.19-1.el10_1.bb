# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clusterssh"
PV = "4.19"
PR = "1.el10_1"
PACKAGES = " \
 clusterssh \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clusterssh-4.19-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93f0b3ad7b80e723525c1ec4b532fc2fc579770828dd6437cbd9839193483ee2"

URI_x86_64_v2_clusterssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clusterssh-4.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_clusterssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clusterssh}"
SRC_URI[x86_64_v2_clusterssh.sha256sum] = "70fe16789d1ba896185c98df62f4a0504cc27bdb261848535235bee2eca44673"

URI_aarch64_clusterssh = "${EPEL_MIRROR}/aarch64/Packages/c/clusterssh-4.19-1.el10_1.noarch.rpm;name=aarch64_clusterssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_clusterssh}"
SRC_URI[aarch64_clusterssh.sha256sum] = "761e9ab7281af72894586a9000022f1dab9303c36148196183a46784f0d4d8fb"

RDEPENDS:clusterssh = " \
 clusterssh \
 perl-Carp \
 perl-English \
 perl-Exception-Class \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-Locale-Maketext \
 perl-Module-Load \
 perl-Net \
 perl-POSIX \
 perl-Pod-Usage \
 perl-Socket \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Tk \
 perl-Try-Tiny \
 perl-X11-Protocol \
 perl-X11-Protocol-Other \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 perl-vars \
 perl-version \
 xorg-x11-fonts-100dpi \
 xorg-x11-fonts-75dpi \
 xterm \
 "
