# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-assert-impl"
PV = "0.1.3"
PR = "12.el10_2"
PACKAGES = " \
 rust-assert-impl+default-devel \
 rust-assert-impl-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-assert-impl-0.1.3-12.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e37b579c965dbbc07302169f9eb17adcfeb77516e90e8ab38f58c46ce0e4593d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert-impl+default-devel-0.1.3-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert-impl+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-assert-impl+default-devel.sha256sum] = "b46208eddbff05b127960ca2c5232f4729f25c6d65836cfad38b089323e7c5cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert-impl-devel-0.1.3-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert-impl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-assert-impl-devel.sha256sum] = "3f6f32e99e57367f09969a459668c3662f993ceaeb64329dcb654d3068d91669"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-assert-impl+default-devel-0.1.3-12.el10_2.noarch.rpm;name=aarch64_rust-assert-impl+default-devel;unpack=0"
SRC_URI[aarch64_rust-assert-impl+default-devel.sha256sum] = "c786f14d11cfae90b3fcc32926fcaaa9dfe7883e45ab83247d2dfc1dd4c8132b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-assert-impl-devel-0.1.3-12.el10_2.noarch.rpm;name=aarch64_rust-assert-impl-devel;unpack=0"
SRC_URI[aarch64_rust-assert-impl-devel.sha256sum] = "d40754c128fa864142336f106c6853d78099d42446b07b27cc6d9f61cca59b50"

RDEPENDS:rust-assert-impl+default-devel = " \
 cargo \
 rust-assert-impl-devel \
 "
RDEPENDS:rust-assert-impl-devel = " \
 cargo \
 "
