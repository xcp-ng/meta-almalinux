# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-normalization"
PV = "0.1.25"
PR = "3.el10_0"
PACKAGES = " \
 rust-unicode-normalization+default-devel \
 rust-unicode-normalization+std-devel \
 rust-unicode-normalization-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-normalization-0.1.25-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d21586cfdbdf9f3b06ab4ce26aabcc981ebceb4232c859423bab0581adb825f"

URI_x86_64_v2_rust-unicode-normalization+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-normalization+default-devel-0.1.25-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-normalization+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-normalization+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-normalization+default-devel.sha256sum] = "b64d2ccca0c00441caf26a8cec3acc1f7ee62588bebc951559a58f7dd738b9a3"

URI_x86_64_v2_rust-unicode-normalization+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-normalization+std-devel-0.1.25-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-normalization+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-normalization+std-devel}"
SRC_URI[x86_64_v2_rust-unicode-normalization+std-devel.sha256sum] = "e481be798845f62e2fa08bc2d08cb00c9feb52db8b8fd61fe8430b11c9ce87a9"

URI_x86_64_v2_rust-unicode-normalization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-normalization-devel-0.1.25-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-normalization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-normalization-devel}"
SRC_URI[x86_64_v2_rust-unicode-normalization-devel.sha256sum] = "77c4b32bd77e2ce0e58b68d7dba29b2049224c745e3cbf1ccc133511a43e4261"

URI_aarch64_rust-unicode-normalization+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-normalization+default-devel-0.1.25-3.el10_0.noarch.rpm;name=aarch64_rust-unicode-normalization+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-normalization+default-devel}"
SRC_URI[aarch64_rust-unicode-normalization+default-devel.sha256sum] = "2b79b73269ffa525a89615d381ac16aa6ad2a4215ec6d0e56c6067375f647b7b"

URI_aarch64_rust-unicode-normalization+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-normalization+std-devel-0.1.25-3.el10_0.noarch.rpm;name=aarch64_rust-unicode-normalization+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-normalization+std-devel}"
SRC_URI[aarch64_rust-unicode-normalization+std-devel.sha256sum] = "6feb9bd07e28f6dfbd6031ee679045422dc8cabef4e1e756f1188455fd4f9fd5"

URI_aarch64_rust-unicode-normalization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-normalization-devel-0.1.25-3.el10_0.noarch.rpm;name=aarch64_rust-unicode-normalization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-normalization-devel}"
SRC_URI[aarch64_rust-unicode-normalization-devel.sha256sum] = "6e3bffc032fa26916758edf70ce74a7f1eba680cf915f28f2364e5c91db3fc73"

RDEPENDS:rust-unicode-normalization+default-devel = " \
 cargo \
 rust-unicode-normalization+std-devel \
 rust-unicode-normalization-devel \
 "
RDEPENDS:rust-unicode-normalization+std-devel = " \
 cargo \
 rust-unicode-normalization-devel \
 "
RDEPENDS:rust-unicode-normalization-devel = " \
 cargo \
 rust \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+default-devel \
 "
