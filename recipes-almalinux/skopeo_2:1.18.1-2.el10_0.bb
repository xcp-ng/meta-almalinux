# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skopeo"
PE = "2"
PV = "1.18.1"
PR = "2.el10_0"
PACKAGES = " \
 skopeo \
 skopeo-tests \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/skopeo-1.18.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e57829a647b8fbc804aeae830a547724063aa34265a9b9f209cdb1c81986ea7b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/skopeo-1.18.1-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_skopeo;unpack=0"
SRC_URI[x86_64_v2_skopeo.sha256sum] = "0657f2cd95a4b03563e22f5ced4903e3046d89dde9c44b8b593b4f047f72ab94"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/skopeo-tests-1.18.1-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_skopeo-tests;unpack=0"
SRC_URI[x86_64_v2_skopeo-tests.sha256sum] = "423183422a81bf3dacb7fbf0df2229b1885e0ec7c75476ae5d00fed62ca6c70f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/skopeo-1.18.1-2.el10_0.aarch64.rpm;name=aarch64_skopeo;unpack=0"
SRC_URI[aarch64_skopeo.sha256sum] = "4c6f7c233eb7c92bad8369706ef2a22545afbaff3b90cf5b56d8ac28d72797d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/skopeo-tests-1.18.1-2.el10_0.aarch64.rpm;name=aarch64_skopeo-tests;unpack=0"
SRC_URI[aarch64_skopeo-tests.sha256sum] = "975be080578a4ad08462d7ac68627d323c9282653b90011e87541eca29773307"

RDEPENDS:skopeo = " \
 containers-common \
 glibc \
 gpgme \
 shadow-utils-subid \
 "
RDEPENDS:skopeo-tests = " \
 bash \
 crun \
 gnupg2 \
 golang \
 httpd-tools \
 jq \
 openssl \
 podman \
 skopeo \
 virtual//usr/bin/env \
 "
