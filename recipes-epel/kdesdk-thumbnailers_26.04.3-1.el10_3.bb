# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdesdk-thumbnailers"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdesdk-thumbnailers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdesdk-thumbnailers-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4c367c2ad56b29d96b24f56b7509198700e0bc03a9be7463037ae4d739b8fd2"

URI_x86_64_v2_kdesdk-thumbnailers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdesdk-thumbnailers-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdesdk-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdesdk-thumbnailers}"
SRC_URI[x86_64_v2_kdesdk-thumbnailers.sha256sum] = "f666b056734d72b26ef10de15fab3649530bd28ff63f88ce9f4e8e72e575f854"

URI_aarch64_kdesdk-thumbnailers = "${EPEL_MIRROR}/aarch64/Packages/k/kdesdk-thumbnailers-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdesdk-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdesdk-thumbnailers}"
SRC_URI[aarch64_kdesdk-thumbnailers.sha256sum] = "5f0f58076bc8fb2aa7a4e9cdbd8371259642f0db34d186911f5a64e65f7f59cb"

RDEPENDS:kdesdk-thumbnailers = " \
 gettext-libs \
 glibc \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
