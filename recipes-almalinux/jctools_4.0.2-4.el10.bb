# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jctools"
PV = "4.0.2"
PR = "4.el10"
PACKAGES = " \
 jctools \
 jctools-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jctools-4.0.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68f3bae318266e367f998c546de2eb8fc582798e5a0b4a063c4eb7bcf7c29c92"

URI_x86_64_v2_jctools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jctools-4.0.2-4.el10.noarch.rpm;name=x86_64_v2_jctools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jctools}"
SRC_URI[x86_64_v2_jctools.sha256sum] = "3f715de7cd5af1e01fbd894f64c6f5530d16222fb049695984ea58590f94dfe2"

URI_x86_64_v2_jctools-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jctools-javadoc-4.0.2-4.el10.noarch.rpm;name=x86_64_v2_jctools-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jctools-javadoc}"
SRC_URI[x86_64_v2_jctools-javadoc.sha256sum] = "ad392796bfbc6c08fc015d9b0e6d918e337f3707f513267847aea1cecce6661f"

URI_aarch64_jctools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jctools-4.0.2-4.el10.noarch.rpm;name=aarch64_jctools;unpack=0"
SRC_URI:append = " ${URI_aarch64_jctools}"
SRC_URI[aarch64_jctools.sha256sum] = "3f715de7cd5af1e01fbd894f64c6f5530d16222fb049695984ea58590f94dfe2"

URI_aarch64_jctools-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jctools-javadoc-4.0.2-4.el10.noarch.rpm;name=aarch64_jctools-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jctools-javadoc}"
SRC_URI[aarch64_jctools-javadoc.sha256sum] = "ad392796bfbc6c08fc015d9b0e6d918e337f3707f513267847aea1cecce6661f"

RDEPENDS:jctools = " \
 javapackages-filesystem \
 "
RDEPENDS:jctools-javadoc = " \
 javapackages-filesystem \
 "
