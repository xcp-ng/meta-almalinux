# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Tie-Cycle"
PV = "1.231"
PR = "3.el10_2"
PACKAGES = " \
 perl-Tie-Cycle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Tie-Cycle-1.231-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "281b3258cf922e4005d4f7fbcd1d9851f085b904b31f5664c1d2c4b54aca66d3"

URI_x86_64_v2_perl-Tie-Cycle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tie-Cycle-1.231-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tie-Cycle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie-Cycle}"
SRC_URI[x86_64_v2_perl-Tie-Cycle.sha256sum] = "798707877118b5d1e867cf216e4569eb1303554bd7f0e228824949b62efc73aa"

URI_aarch64_perl-Tie-Cycle = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tie-Cycle-1.231-3.el10_2.noarch.rpm;name=aarch64_perl-Tie-Cycle;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie-Cycle}"
SRC_URI[aarch64_perl-Tie-Cycle.sha256sum] = "029aba7d12c4cf0a5c22de632453ea025ebe41586abea2bb907d1705c935f8e8"

RDEPENDS:perl-Tie-Cycle = " \
 perl-Carp \
 perl-constant \
 perl-libs \
 "
