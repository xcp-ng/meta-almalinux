# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-parking_lot"
PV = "0.12.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-parking_lot+arc_lock-devel \
 rust-parking_lot+deadlock_detection-devel \
 rust-parking_lot+default-devel \
 rust-parking_lot+hardware-lock-elision-devel \
 rust-parking_lot+nightly-devel \
 rust-parking_lot+owning_ref-devel \
 rust-parking_lot+send_guard-devel \
 rust-parking_lot+serde-devel \
 rust-parking_lot-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-parking_lot-0.12.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97c9f919c881b8717ba1a0e7e14a8847c9c780942c5251b6ad8af8f3ad60485e"

URI_x86_64_v2_rust-parking_lot+arc_lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+arc_lock-devel-0.12.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+arc_lock-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+arc_lock-devel.sha256sum] = "788777b7d0a37048f69a46b528eff1d10248c13d706eefb02ae3bed47c707da0"

URI_x86_64_v2_rust-parking_lot+deadlock_detection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+deadlock_detection-devel-0.12.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+deadlock_detection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+deadlock_detection-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+deadlock_detection-devel.sha256sum] = "30429e16eda74b866e40a27973091f6fc6bd661091f248a3a8586a7bda6aae72"

URI_x86_64_v2_rust-parking_lot+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+default-devel-0.12.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+default-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+default-devel.sha256sum] = "25030f59695f878a01c422b18fda2571fa82e6dba4ae778c7ac452b40f3aed99"

URI_x86_64_v2_rust-parking_lot+hardware-lock-elision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+hardware-lock-elision-devel-0.12.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+hardware-lock-elision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+hardware-lock-elision-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+hardware-lock-elision-devel.sha256sum] = "3478851bb428fe11d710756dea33b757a94f40e199f9c92f18d4739e4e519ad8"

URI_x86_64_v2_rust-parking_lot+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+nightly-devel-0.12.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+nightly-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+nightly-devel.sha256sum] = "43ff3924a0c301fc5fb88b7a44066712202b28ca7bf3a16e1fafc3d5a0d5e4a6"

URI_x86_64_v2_rust-parking_lot+owning_ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+owning_ref-devel-0.12.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+owning_ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+owning_ref-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+owning_ref-devel.sha256sum] = "c6f9913c46a3fac3540fe6847fd3ec0d461beac789493bd350fc3ff499dbe416"

URI_x86_64_v2_rust-parking_lot+send_guard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+send_guard-devel-0.12.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+send_guard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+send_guard-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+send_guard-devel.sha256sum] = "c484476e8092e1b3e7013f75e59597a5d3dff90da7154e70133c7c1491a405f9"

URI_x86_64_v2_rust-parking_lot+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot+serde-devel-0.12.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot+serde-devel}"
SRC_URI[x86_64_v2_rust-parking_lot+serde-devel.sha256sum] = "8a88211ab42279735c8cda8cfebc5552c4519daac7b53486b530878958c3cbff"

URI_x86_64_v2_rust-parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot-devel-0.12.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot-devel}"
SRC_URI[x86_64_v2_rust-parking_lot-devel.sha256sum] = "affbbbb53c96edb72424ee5e5c6c100f375004fb31d525c6fe8537034c15be85"

URI_aarch64_rust-parking_lot+arc_lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+arc_lock-devel-0.12.5-1.el10_2.noarch.rpm;name=aarch64_rust-parking_lot+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+arc_lock-devel}"
SRC_URI[aarch64_rust-parking_lot+arc_lock-devel.sha256sum] = "4a0fc51ec1717791ac5c0f0de8924ee4598d1e10c2451d2c5ea07fdd5ac993b1"

URI_aarch64_rust-parking_lot+deadlock_detection-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+deadlock_detection-devel-0.12.5-1.el10_2.noarch.rpm;name=aarch64_rust-parking_lot+deadlock_detection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+deadlock_detection-devel}"
SRC_URI[aarch64_rust-parking_lot+deadlock_detection-devel.sha256sum] = "4208dc11e773bbfcde03214790945620958d93695b9d3014a5ab9fa9617c40b9"

URI_aarch64_rust-parking_lot+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+default-devel-0.12.5-1.el10_2.noarch.rpm;name=aarch64_rust-parking_lot+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+default-devel}"
SRC_URI[aarch64_rust-parking_lot+default-devel.sha256sum] = "ecd09a77e451adf6bf27b307b36ad13a7dd49c408a67033c0a5d74e47e2d5311"

URI_aarch64_rust-parking_lot+hardware-lock-elision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+hardware-lock-elision-devel-0.12.5-1.el10_2.noarch.rpm;name=aarch64_rust-parking_lot+hardware-lock-elision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+hardware-lock-elision-devel}"
SRC_URI[aarch64_rust-parking_lot+hardware-lock-elision-devel.sha256sum] = "b14fdbaa6e609700b89cfda007198ccc4faa3edd894b36ab57adda958a53f54a"

URI_aarch64_rust-parking_lot+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+nightly-devel-0.12.5-1.el10_2.noarch.rpm;name=aarch64_rust-parking_lot+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+nightly-devel}"
SRC_URI[aarch64_rust-parking_lot+nightly-devel.sha256sum] = "bb4dbd2ef7156d4de03a760583c5f9e41ba2118457bd052a1c476b15e8058e23"

URI_aarch64_rust-parking_lot+owning_ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+owning_ref-devel-0.12.5-1.el10_2.noarch.rpm;name=aarch64_rust-parking_lot+owning_ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+owning_ref-devel}"
SRC_URI[aarch64_rust-parking_lot+owning_ref-devel.sha256sum] = "4614e11813107cf5a1b5c8557dc33eb7fa0b7ce1f61e778a24a883e53e8fad29"

URI_aarch64_rust-parking_lot+send_guard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+send_guard-devel-0.12.5-1.el10_2.noarch.rpm;name=aarch64_rust-parking_lot+send_guard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+send_guard-devel}"
SRC_URI[aarch64_rust-parking_lot+send_guard-devel.sha256sum] = "61c22c5d5eef44ddf67c481c0dfe986999f2345549f53610c570927c9f1c72d7"

URI_aarch64_rust-parking_lot+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot+serde-devel-0.12.5-1.el10_2.noarch.rpm;name=aarch64_rust-parking_lot+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot+serde-devel}"
SRC_URI[aarch64_rust-parking_lot+serde-devel.sha256sum] = "d5471d6f491d885aeb5a3ab659f0e368cb1d6f4f7e200fd0477a9c8c5dd41f07"

URI_aarch64_rust-parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot-devel-0.12.5-1.el10_2.noarch.rpm;name=aarch64_rust-parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot-devel}"
SRC_URI[aarch64_rust-parking_lot-devel.sha256sum] = "80ab6d96a0cb9a5b27f79ca43513c31ce245fbbe114c18991cf0421b797a1d62"

RDEPENDS:rust-parking_lot+arc_lock-devel = " \
 cargo \
 rust-lock_api+arc_lock-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot+deadlock_detection-devel = " \
 cargo \
 rust-parking_lot-devel \
 rust-parking_lot_core+deadlock_detection-devel \
 "
RDEPENDS:rust-parking_lot+default-devel = " \
 cargo \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot+hardware-lock-elision-devel = " \
 cargo \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot+nightly-devel = " \
 cargo \
 rust-lock_api+nightly-devel \
 rust-parking_lot-devel \
 rust-parking_lot_core+nightly-devel \
 "
RDEPENDS:rust-parking_lot+owning_ref-devel = " \
 cargo \
 rust-lock_api+owning_ref-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot+send_guard-devel = " \
 cargo \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot+serde-devel = " \
 cargo \
 rust-lock_api+serde-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-parking_lot-devel = " \
 cargo \
 rust \
 rust-lock_api+default-devel \
 rust-parking_lot_core+default-devel \
 "
