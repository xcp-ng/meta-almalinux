# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "HepMC3"
PV = "3.3.1"
PR = "12.el10_3"
PACKAGES = " \
 HepMC3 \
 HepMC3-devel \
 HepMC3-doc \
 HepMC3-interfaces-devel \
 HepMC3-protobufIO \
 HepMC3-protobufIO-devel \
 HepMC3-rootIO \
 HepMC3-rootIO-devel \
 HepMC3-search \
 HepMC3-search-devel \
 python3-HepMC3 \
 python3-HepMC3-protobufIO \
 python3-HepMC3-rootIO \
 python3-HepMC3-search \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/HepMC3-3.3.1-12.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d43ce535b871c7eb13f215c915a1e94986242792ad020f632a883c8fb71b397"

URI_x86_64_v2_HepMC3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-3.3.1-12.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3}"
SRC_URI[x86_64_v2_HepMC3.sha256sum] = "ead4b209a8aa314dfcfbee6638c218ef65263f8612d728edd02744dfaee230b1"

URI_x86_64_v2_HepMC3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-devel-3.3.1-12.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-devel}"
SRC_URI[x86_64_v2_HepMC3-devel.sha256sum] = "2a4c52f292ef8d4df5fe27aab3a4d5bc04e5de1014baadbe95e4973568f4bf1b"

URI_x86_64_v2_HepMC3-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-doc-3.3.1-12.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_HepMC3-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-doc}"
SRC_URI[x86_64_v2_HepMC3-doc.sha256sum] = "94e42ccaeaa926c8f8633853eddcdf9434844200d606c83da8874e6baa96fc3f"

URI_x86_64_v2_HepMC3-interfaces-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-interfaces-devel-3.3.1-12.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_HepMC3-interfaces-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-interfaces-devel}"
SRC_URI[x86_64_v2_HepMC3-interfaces-devel.sha256sum] = "03d55a1b760c615ba9f9f08faefbdc8fa9c4300faa900829c8cb7436328f3b70"

URI_x86_64_v2_HepMC3-protobufIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-protobufIO-3.3.1-12.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-protobufIO}"
SRC_URI[x86_64_v2_HepMC3-protobufIO.sha256sum] = "9e16488e0f341e2cf94cd0da1599f5403764217b0089917d10dcd5db0ea9ed07"

URI_x86_64_v2_HepMC3-protobufIO-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-protobufIO-devel-3.3.1-12.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-protobufIO-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-protobufIO-devel}"
SRC_URI[x86_64_v2_HepMC3-protobufIO-devel.sha256sum] = "38168bf554c689afa49c1b49493c790ca2a49f8a85dd09dd256c8da4f55f2502"

URI_x86_64_v2_HepMC3-rootIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-rootIO-3.3.1-12.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-rootIO}"
SRC_URI[x86_64_v2_HepMC3-rootIO.sha256sum] = "287bae2ea02e7c328bd929958c4a1d160094bfab74630c87e464afa44540cb18"

URI_x86_64_v2_HepMC3-rootIO-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-rootIO-devel-3.3.1-12.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-rootIO-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-rootIO-devel}"
SRC_URI[x86_64_v2_HepMC3-rootIO-devel.sha256sum] = "1802bf7f7ab1b7239a53a7714d0b5cadb36ecfbe3c7b6a4f9441a3d8d5a51338"

URI_x86_64_v2_HepMC3-search = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-search-3.3.1-12.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-search}"
SRC_URI[x86_64_v2_HepMC3-search.sha256sum] = "442bd275487330b92f6edba3084cfe711670d3e326a20e87d68bc5b290054670"

URI_x86_64_v2_HepMC3-search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-search-devel-3.3.1-12.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-search-devel}"
SRC_URI[x86_64_v2_HepMC3-search-devel.sha256sum] = "4bcf7f241cea994fc574d5cd9b077c47b9a58dbb90699b08a807405fb7b3e0a9"

URI_x86_64_v2_python3-HepMC3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-3.3.1-12.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3}"
SRC_URI[x86_64_v2_python3-HepMC3.sha256sum] = "561024bf69dde3db73a0f2ad1b712501c37dcb0b29bcc1a9502b69976ffe5f67"

URI_x86_64_v2_python3-HepMC3-protobufIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-protobufIO-3.3.1-12.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3-protobufIO}"
SRC_URI[x86_64_v2_python3-HepMC3-protobufIO.sha256sum] = "b6995bef3f174bf2d1481bbea5463f4f42f9200253cb3f0e708bb8a4680cf0f6"

URI_x86_64_v2_python3-HepMC3-rootIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-rootIO-3.3.1-12.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3-rootIO}"
SRC_URI[x86_64_v2_python3-HepMC3-rootIO.sha256sum] = "7ebe979068fe1925d7c091b76bba766153b8901655e9b645ae67520f6fe9c83a"

URI_x86_64_v2_python3-HepMC3-search = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-search-3.3.1-12.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3-search}"
SRC_URI[x86_64_v2_python3-HepMC3-search.sha256sum] = "7a5c1e0105ad4a2394dbe588a2cb144a51110692ccc6cf6f5ac2249f89f9cdc6"

URI_aarch64_HepMC3 = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-3.3.1-12.el10_3.aarch64.rpm;name=aarch64_HepMC3;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3}"
SRC_URI[aarch64_HepMC3.sha256sum] = "51bda04f78d09149c992abedc284a1a5c807cd0b14ce7c79062cf52edc2bc80d"

URI_aarch64_HepMC3-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-devel-3.3.1-12.el10_3.aarch64.rpm;name=aarch64_HepMC3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-devel}"
SRC_URI[aarch64_HepMC3-devel.sha256sum] = "41784f398e11d88ae043b034d7fdc4ad67077e0d3ecbfbb1c7a9af2f1d666559"

URI_aarch64_HepMC3-doc = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-doc-3.3.1-12.el10_3.noarch.rpm;name=aarch64_HepMC3-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-doc}"
SRC_URI[aarch64_HepMC3-doc.sha256sum] = "f3ddd354eb73ed0749613cef6b3560f5db886b541701cad64d2331bcc9fc2bd0"

URI_aarch64_HepMC3-interfaces-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-interfaces-devel-3.3.1-12.el10_3.noarch.rpm;name=aarch64_HepMC3-interfaces-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-interfaces-devel}"
SRC_URI[aarch64_HepMC3-interfaces-devel.sha256sum] = "e0195db5221eb30e29c7e9311c578a7eb73aa47060de440d2b14e184ee87dd3e"

URI_aarch64_HepMC3-protobufIO = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-protobufIO-3.3.1-12.el10_3.aarch64.rpm;name=aarch64_HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-protobufIO}"
SRC_URI[aarch64_HepMC3-protobufIO.sha256sum] = "e99e20490810b617d17c7594477a59e40234fcbafd6df3b50185cce1d91c7298"

URI_aarch64_HepMC3-protobufIO-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-protobufIO-devel-3.3.1-12.el10_3.aarch64.rpm;name=aarch64_HepMC3-protobufIO-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-protobufIO-devel}"
SRC_URI[aarch64_HepMC3-protobufIO-devel.sha256sum] = "a7a97e7f9e93599bb6dc1a866aa94935243ba414e7d9c7af24cce70d68a33c8f"

URI_aarch64_HepMC3-rootIO = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-rootIO-3.3.1-12.el10_3.aarch64.rpm;name=aarch64_HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-rootIO}"
SRC_URI[aarch64_HepMC3-rootIO.sha256sum] = "eb4ed0dbfc0d51b8704a4650dd9dba2f46c1bada5c7a4647b8056594e2669034"

URI_aarch64_HepMC3-rootIO-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-rootIO-devel-3.3.1-12.el10_3.aarch64.rpm;name=aarch64_HepMC3-rootIO-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-rootIO-devel}"
SRC_URI[aarch64_HepMC3-rootIO-devel.sha256sum] = "18d69e01863873fbb4e6fb3c61a1e3ecfa3bbbfff3f08b30e9d2bb55273a2ea3"

URI_aarch64_HepMC3-search = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-search-3.3.1-12.el10_3.aarch64.rpm;name=aarch64_HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-search}"
SRC_URI[aarch64_HepMC3-search.sha256sum] = "08eaa13523b1d14e2db48a2d57dd0628f58a14abc258087ee447bcc8b3468431"

URI_aarch64_HepMC3-search-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-search-devel-3.3.1-12.el10_3.aarch64.rpm;name=aarch64_HepMC3-search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-search-devel}"
SRC_URI[aarch64_HepMC3-search-devel.sha256sum] = "3e896ce7e4eb31c3d4ef6f6db9058f1dae1e95d6728e7e07ce07bf6a672c9168"

URI_aarch64_python3-HepMC3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-3.3.1-12.el10_3.aarch64.rpm;name=aarch64_python3-HepMC3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3}"
SRC_URI[aarch64_python3-HepMC3.sha256sum] = "a46cc89a42e466fc5042373df08e87bb4e75a95293187ecf728bfe15086ae030"

URI_aarch64_python3-HepMC3-protobufIO = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-protobufIO-3.3.1-12.el10_3.aarch64.rpm;name=aarch64_python3-HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3-protobufIO}"
SRC_URI[aarch64_python3-HepMC3-protobufIO.sha256sum] = "b1000a2e7862c5b99dd74e58656e8866621c5c8caf9b8f0b7b0485cbffeda1dc"

URI_aarch64_python3-HepMC3-rootIO = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-rootIO-3.3.1-12.el10_3.aarch64.rpm;name=aarch64_python3-HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3-rootIO}"
SRC_URI[aarch64_python3-HepMC3-rootIO.sha256sum] = "df06315d75c8d6194d3717cd815b813daafaf1d804eeb8996f6b169350bf07e4"

URI_aarch64_python3-HepMC3-search = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-search-3.3.1-12.el10_3.aarch64.rpm;name=aarch64_python3-HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3-search}"
SRC_URI[aarch64_python3-HepMC3-search.sha256sum] = "87b82da105043e2d15a296931406729ffbee5b8658b7cb8f3eaf750609ad3ad1"

RDEPENDS:HepMC3 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:HepMC3-devel = " \
 HepMC3 \
 bash \
 "
RDEPENDS:HepMC3-doc = " \
 "
RDEPENDS:HepMC3-interfaces-devel = " \
 HepMC3-devel \
 "
RDEPENDS:HepMC3-protobufIO = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 "
RDEPENDS:HepMC3-protobufIO-devel = " \
 HepMC3-devel \
 HepMC3-protobufIO \
 "
RDEPENDS:HepMC3-rootIO = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-tree \
 "
RDEPENDS:HepMC3-rootIO-devel = " \
 HepMC3-devel \
 HepMC3-rootIO \
 "
RDEPENDS:HepMC3-search = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:HepMC3-search-devel = " \
 HepMC3-devel \
 HepMC3-search \
 "
RDEPENDS:python3-HepMC3 = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:python3-HepMC3-protobufIO = " \
 HepMC3 \
 HepMC3-protobufIO \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 python3 \
 python3-HepMC3 \
 "
RDEPENDS:python3-HepMC3-rootIO = " \
 HepMC3 \
 HepMC3-rootIO \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-HepMC3 \
 root-core \
 "
RDEPENDS:python3-HepMC3-search = " \
 HepMC3 \
 HepMC3-search \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-HepMC3 \
 "
