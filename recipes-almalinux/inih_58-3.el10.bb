# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "inih"
PV = "58"
PR = "3.el10"
PACKAGES = " \
 inih \
 inih-cpp \
 inih-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/inih-58-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac8c3c57ee29fa85f6960e7d55eba94020e9da86ece563bade0a7d07afe30ef6"

URI_x86_64_v2_inih = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/inih-58-3.el10.x86_64_v2.rpm;name=x86_64_v2_inih;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_inih}"
SRC_URI[x86_64_v2_inih.sha256sum] = "3610dddeac847924b93d9ddc38b65f30604b569c5cd5ad8f6780d4b593d7ae94"

URI_x86_64_v2_inih-cpp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/inih-cpp-58-3.el10.x86_64_v2.rpm;name=x86_64_v2_inih-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_inih-cpp}"
SRC_URI[x86_64_v2_inih-cpp.sha256sum] = "3c522134b8259b5092514f232f6fa8107dfba83ddf106f867ac5b8ff62bcbbf4"

URI_x86_64_v2_inih-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/inih-devel-58-3.el10.x86_64_v2.rpm;name=x86_64_v2_inih-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_inih-devel}"
SRC_URI[x86_64_v2_inih-devel.sha256sum] = "4f95aaf76b0f0b6546135f74fe829fadd20f6c5cf74e3ffcef085c10492cfa11"

URI_aarch64_inih = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/inih-58-3.el10.aarch64.rpm;name=aarch64_inih;unpack=0"
SRC_URI:append = " ${URI_aarch64_inih}"
SRC_URI[aarch64_inih.sha256sum] = "1848dd8d83bb4d7f1caa221d1bd387a291636bd719ff9ee313090d349d71cd9e"

URI_aarch64_inih-cpp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/inih-cpp-58-3.el10.aarch64.rpm;name=aarch64_inih-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_inih-cpp}"
SRC_URI[aarch64_inih-cpp.sha256sum] = "672830959aef25fb7ed94792826e5bb707b296f66f16fcec51cc29446ea45ee5"

URI_aarch64_inih-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/inih-devel-58-3.el10.aarch64.rpm;name=aarch64_inih-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_inih-devel}"
SRC_URI[aarch64_inih-devel.sha256sum] = "85c8444fd71c55ca544b7d96265552c60fa3d679494622b0e8f215a04574adb1"

RDEPENDS:inih = " \
 glibc \
 "
RDEPENDS:inih-cpp = " \
 glibc \
 inih \
 libgcc \
 libstdc++ \
 "
RDEPENDS:inih-devel = " \
 inih \
 inih-cpp \
 inih-devel \
 pkgconf-pkg-config \
 "
