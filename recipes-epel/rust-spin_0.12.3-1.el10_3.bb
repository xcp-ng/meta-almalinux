# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-spin"
PV = "0.12.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-spin+barrier-devel \
 rust-spin+default-devel \
 rust-spin+fair_mutex-devel \
 rust-spin+lazy-devel \
 rust-spin+lazylock-devel \
 rust-spin+lock_api-devel \
 rust-spin+mutex-devel \
 rust-spin+once-devel \
 rust-spin+portable-atomic-devel \
 rust-spin+portable_atomic-devel \
 rust-spin+rwlock-devel \
 rust-spin+spin_mutex-devel \
 rust-spin+std-devel \
 rust-spin+ticket_mutex-devel \
 rust-spin+use_ticket_mutex-devel \
 rust-spin-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-spin-0.12.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7a0f82be44a0593a55adec326e8c31150c5928f6e24584549f8f51f84ceca4e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+barrier-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+barrier-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin+barrier-devel.sha256sum] = "78197034d17e8999d469dd1e52022ac36e1e3a5312399b0cba1a6531a439a61e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+default-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin+default-devel.sha256sum] = "2d42af6d7e3a9bc6492b60c20e8cbc07b7102a29f0a80faadd7238b207855be2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+fair_mutex-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+fair_mutex-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin+fair_mutex-devel.sha256sum] = "49e7d960b14e3340ed235aedbbca2cfe0d87c9a85fe14a7b6292993d8fd4a6f6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+lazy-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+lazy-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin+lazy-devel.sha256sum] = "16255d5705efecf478df43d58628e4329cf97ae6db0b591dd749cb39ede8025f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+lazylock-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+lazylock-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin+lazylock-devel.sha256sum] = "d890e9184a8bc9bcac41021fc649f270f7221b5007a91bd1f6a1482052533340"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+lock_api-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+lock_api-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin+lock_api-devel.sha256sum] = "be1881ba287388991574e26a008308f7094a8f7e1aaddb11b93515a18610a46c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+mutex-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+mutex-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin+mutex-devel.sha256sum] = "d1173b7112a8d1fe99d66c622f526e7cae4629dc9e9bb3809772356a1f75e430"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+once-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+once-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin+once-devel.sha256sum] = "f1b7f02b96412a583bfd7437de426a6d5f7ff84e6508ea8b3669f17db6e1e363"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+portable-atomic-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+portable-atomic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin+portable-atomic-devel.sha256sum] = "a34e537cb0fc0c69862bca3a364afead4fa1b6b8a76d9b02ad47f6cac0fdc961"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+portable_atomic-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+portable_atomic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin+portable_atomic-devel.sha256sum] = "8930fae36d2d084b2f097b05d12bcd9df40a96f572caa653c0821aa77ed5eac7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+rwlock-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+rwlock-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin+rwlock-devel.sha256sum] = "60ed92ad5ad19945e6c490c8b41b6454bb5a40d04b1fb41e9ebdfeb981e3158c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+spin_mutex-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+spin_mutex-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin+spin_mutex-devel.sha256sum] = "5cdeae5d1cdcbccd3310fcc437235c78e0cee525c269f46396465552d6190991"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+std-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin+std-devel.sha256sum] = "1e3f061d45b68652b324ff46ebb92dbf5c34f22a7d6f4b5218e3e09225698e9c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+ticket_mutex-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+ticket_mutex-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin+ticket_mutex-devel.sha256sum] = "a6321b2929840e372509c01361d3af0c300a5a33ba74a3b7ce792c40576e59f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+use_ticket_mutex-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+use_ticket_mutex-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin+use_ticket_mutex-devel.sha256sum] = "7d6690e2b49c032f8ab89254d0d4d7aa8d14bef692c611ae4f6823012a7fa6dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin-devel-0.12.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin-devel;unpack=0"
SRC_URI[x86_64_v2_rust-spin-devel.sha256sum] = "7e36074acbbca56c0bcddd767854dedfa594d102ca8c4dad4222ed7a29119dce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+barrier-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin+barrier-devel;unpack=0"
SRC_URI[aarch64_rust-spin+barrier-devel.sha256sum] = "9e0a432815236edaa1dab74449da8bc16dbe0fba57644722f26030be2407090a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+default-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin+default-devel;unpack=0"
SRC_URI[aarch64_rust-spin+default-devel.sha256sum] = "2e074f7211cf83fbfa9e76e7a7b4fc2e47f01fa376eccb5ca0392e93ee5b6c5f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+fair_mutex-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin+fair_mutex-devel;unpack=0"
SRC_URI[aarch64_rust-spin+fair_mutex-devel.sha256sum] = "e4903bdc61eace73078baf9c3470a1043374ff95562553ac6dece31c56a9836b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+lazy-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin+lazy-devel;unpack=0"
SRC_URI[aarch64_rust-spin+lazy-devel.sha256sum] = "e77763ba7a44df6fc437001b64e935eb950e12072bbc326dee06cbc44397e56d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+lazylock-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin+lazylock-devel;unpack=0"
SRC_URI[aarch64_rust-spin+lazylock-devel.sha256sum] = "add5b5c850ba1e8999d724aef63bc7172768f40e8140f46c82726ad7f8f43f21"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+lock_api-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin+lock_api-devel;unpack=0"
SRC_URI[aarch64_rust-spin+lock_api-devel.sha256sum] = "ea7ed58238845360784e0c9e1bf607c19634ecaa4aca6be8c858983494e370ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+mutex-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin+mutex-devel;unpack=0"
SRC_URI[aarch64_rust-spin+mutex-devel.sha256sum] = "9abf1fa93fd47d2fd7c9efa99626717bd4c18b7cac13fa1c4c366af18829aaca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+once-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin+once-devel;unpack=0"
SRC_URI[aarch64_rust-spin+once-devel.sha256sum] = "0e3c7a74f89afe28d2688e0767ef0fc06cd1b1bcf77d327a55748d2ed98f8629"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+portable-atomic-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin+portable-atomic-devel;unpack=0"
SRC_URI[aarch64_rust-spin+portable-atomic-devel.sha256sum] = "f2ff07791174267b7f56d468de7134e08e96597970cd4d33971df674e6d13953"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+portable_atomic-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin+portable_atomic-devel;unpack=0"
SRC_URI[aarch64_rust-spin+portable_atomic-devel.sha256sum] = "9ff43b90f7bd165e5470e6d8eede250710eb83148b1b254d58f4a4ebcac9c068"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+rwlock-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin+rwlock-devel;unpack=0"
SRC_URI[aarch64_rust-spin+rwlock-devel.sha256sum] = "67a979d73eb6a305e4ae71969eb4159926f37d83876bdc9ca7bc78352fcec6cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+spin_mutex-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin+spin_mutex-devel;unpack=0"
SRC_URI[aarch64_rust-spin+spin_mutex-devel.sha256sum] = "83d7bd12f9f19a81be834e1f00781717f314c3dfd43f70b9bbc49554958113f2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+std-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin+std-devel;unpack=0"
SRC_URI[aarch64_rust-spin+std-devel.sha256sum] = "58281a2eb7ae319fa3a21fe5652519cf6f60f961166a95002609de40e178838a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+ticket_mutex-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin+ticket_mutex-devel;unpack=0"
SRC_URI[aarch64_rust-spin+ticket_mutex-devel.sha256sum] = "575dfdc86094821d548f208336fcc38024532fb6dfb67b6ba9509f0e9ebf5621"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+use_ticket_mutex-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin+use_ticket_mutex-devel;unpack=0"
SRC_URI[aarch64_rust-spin+use_ticket_mutex-devel.sha256sum] = "49a730724e5f686c717d0bbaf7609715bb8da113c4edf981c26869256552a2ea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-spin-devel-0.12.3-1.el10_3.noarch.rpm;name=aarch64_rust-spin-devel;unpack=0"
SRC_URI[aarch64_rust-spin-devel.sha256sum] = "37af58403dae27eba989855ca0b03ce0af493c3f07cfd914772b799bd8263386"

RDEPENDS:rust-spin+barrier-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+default-devel = " \
 cargo \
 rust-spin+barrier-devel \
 rust-spin+lazylock-devel \
 rust-spin+lock_api-devel \
 rust-spin+mutex-devel \
 rust-spin+once-devel \
 rust-spin+rwlock-devel \
 rust-spin+spin_mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+fair_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+lazy-devel = " \
 cargo \
 rust-spin+lazylock-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+lazylock-devel = " \
 cargo \
 rust-spin+once-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+lock_api-devel = " \
 cargo \
 rust-lock_api+default-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+mutex-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+once-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+portable-atomic-devel = " \
 cargo \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+portable_atomic-devel = " \
 cargo \
 rust-spin+portable-atomic-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+rwlock-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+spin_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+std-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+ticket_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+use_ticket_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin+ticket_mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin-devel = " \
 cargo \
 rust \
 "
