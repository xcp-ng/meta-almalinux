# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-collectd_cvmfs"
PV = "1.4.0"
PR = "2.el10_2"
PACKAGES = " \
 python3-collectd_cvmfs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-collectd_cvmfs-1.4.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a872c8f4bb06defaa385c3aec1f7b174013f5ba3a7706c7a080b2c593d9a60b"

URI_x86_64_v2_python3-collectd_cvmfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-collectd_cvmfs-1.4.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-collectd_cvmfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-collectd_cvmfs}"
SRC_URI[x86_64_v2_python3-collectd_cvmfs.sha256sum] = "e4d39c3c37c784d841ec1f71ca1f8fbb4b4dae35e6f3e70f1d7cf9ec9209e425"

URI_aarch64_python3-collectd_cvmfs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-collectd_cvmfs-1.4.0-2.el10_2.noarch.rpm;name=aarch64_python3-collectd_cvmfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-collectd_cvmfs}"
SRC_URI[aarch64_python3-collectd_cvmfs.sha256sum] = "d19371ff5b10759b0238290c1506897ccdb92312d11109773a144a9ff9b3cec6"

RDEPENDS:python3-collectd_cvmfs = " \
 python3 \
 python3-psutil \
 python3-pyxattr \
 "
