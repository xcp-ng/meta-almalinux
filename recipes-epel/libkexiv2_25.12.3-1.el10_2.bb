# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkexiv2"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 libkexiv2-qt6 \
 libkexiv2-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkexiv2-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7c7461860529de99962509a0d15dcc93df627f4e379d35433b1a37ed1ac70e1"

URI_x86_64_v2_libkexiv2-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkexiv2-qt6-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkexiv2-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkexiv2-qt6}"
SRC_URI[x86_64_v2_libkexiv2-qt6.sha256sum] = "662f00782a3d407474e7ce2328383995f2f809961f6404ad7f0d4ad8b2da325e"

URI_x86_64_v2_libkexiv2-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkexiv2-qt6-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkexiv2-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkexiv2-qt6-devel}"
SRC_URI[x86_64_v2_libkexiv2-qt6-devel.sha256sum] = "7575cb816917d7905168e7d9edba6cfabdf79f367e2fd29e1f0493359503bd77"

URI_aarch64_libkexiv2-qt6 = "${EPEL_MIRROR}/aarch64/Packages/l/libkexiv2-qt6-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkexiv2-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkexiv2-qt6}"
SRC_URI[aarch64_libkexiv2-qt6.sha256sum] = "959a3d9c5d290558c06a87934b53694c00c56d9a56f725e7deeffabe09d31487"

URI_aarch64_libkexiv2-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkexiv2-qt6-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkexiv2-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkexiv2-qt6-devel}"
SRC_URI[aarch64_libkexiv2-qt6-devel.sha256sum] = "e3fdc52ad6fa6cdeb5343251f839f4d71f4cbd6d60c67e77c335b4675bf9d8e9"

RDEPENDS:libkexiv2-qt6 = " \
 exiv2-libs \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkexiv2-qt6-devel = " \
 cmake-filesystem \
 libkexiv2-qt6 \
 qt6-qtbase-devel \
 "
