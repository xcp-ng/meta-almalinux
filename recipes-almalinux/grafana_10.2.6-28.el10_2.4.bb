# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grafana"
PV = "10.2.6"
PR = "28.el10_2.4"
PACKAGES = " \
 grafana \
 grafana-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/grafana-10.2.6-28.el10_2.4.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e428be9e9a91bc8b7e71d65296e2ffc92510a75e19b8a9ab1beddd8d526a4128"

URI_x86_64_v2_grafana = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-10.2.6-28.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_grafana;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grafana}"
SRC_URI[x86_64_v2_grafana.sha256sum] = "b9da239f5dc112745aff9268951b326f91012d3bef3dc28e79681abfb2a84020"

URI_x86_64_v2_grafana-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-selinux-10.2.6-28.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_grafana-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grafana-selinux}"
SRC_URI[x86_64_v2_grafana-selinux.sha256sum] = "2f61bfaf645239532e18a1c8b4bf0f520bce9a38364a3078cced4f3e9336afc4"

URI_aarch64_grafana = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-10.2.6-28.el10_2.4.aarch64.rpm;name=aarch64_grafana;unpack=0"
SRC_URI:append = " ${URI_aarch64_grafana}"
SRC_URI[aarch64_grafana.sha256sum] = "d44f8d15930e000611dccfed81a9580dabdcbbeb6e8eb8c50328855aeb0eceb2"

URI_aarch64_grafana-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-selinux-10.2.6-28.el10_2.4.aarch64.rpm;name=aarch64_grafana-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_grafana-selinux}"
SRC_URI[aarch64_grafana-selinux.sha256sum] = "dfc4bd4882a03737d050aebce457aa23f5e2baf2dac1756a99c4e70b707c275c"

RDEPENDS:grafana = " \
 bash \
 glibc \
 grafana-selinux \
 shadow-utils \
 shared-mime-info \
 systemd \
 "
RDEPENDS:grafana-selinux = " \
 bash \
 policycoreutils-python-utils \
 virtual/selinux-policy-any \
 "
