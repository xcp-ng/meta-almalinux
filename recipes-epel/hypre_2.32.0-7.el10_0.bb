# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hypre"
PV = "2.32.0"
PR = "7.el10_0"
PACKAGES = " \
 hypre \
 hypre-devel \
 hypre-doc \
 hypre-mpich \
 hypre-mpich-devel \
 hypre-openmpi \
 hypre-openmpi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hypre-2.32.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f01b61757faf88f12e0c64dfb0e47ab85d63f866b9e90a956955ac74a82a1a14"

URI_x86_64_v2_hypre = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-2.32.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre}"
SRC_URI[x86_64_v2_hypre.sha256sum] = "ab4416e6cba1da9ece822a748cf7fdf926c8609d780434627c86c9b0dcecaf8e"

URI_x86_64_v2_hypre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-devel-2.32.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-devel}"
SRC_URI[x86_64_v2_hypre-devel.sha256sum] = "0191268c4b7ff7eb5ea4167d954ed70d5d0690dba312fb0a819f01b955e1e616"

URI_x86_64_v2_hypre-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-doc-2.32.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_hypre-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-doc}"
SRC_URI[x86_64_v2_hypre-doc.sha256sum] = "04461e77a063e1ff362828470eacdbe49ebaa935b441e57e1a9b8514bd1e22a7"

URI_x86_64_v2_hypre-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-mpich-2.32.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-mpich}"
SRC_URI[x86_64_v2_hypre-mpich.sha256sum] = "2b01fb01514c124698083ea89cbf3ef3d73d2bb0b2419b873e9b7703450772d9"

URI_x86_64_v2_hypre-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-mpich-devel-2.32.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-mpich-devel}"
SRC_URI[x86_64_v2_hypre-mpich-devel.sha256sum] = "88966c9672064e263a6819b456ff64f7ebe2453de15e73d2671e49059d887b26"

URI_x86_64_v2_hypre-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-openmpi-2.32.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-openmpi}"
SRC_URI[x86_64_v2_hypre-openmpi.sha256sum] = "c9c84649b6fb56217194a3eb08ec90d9ce89ef61913650587af9d04f9dbd93cc"

URI_x86_64_v2_hypre-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-openmpi-devel-2.32.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-openmpi-devel}"
SRC_URI[x86_64_v2_hypre-openmpi-devel.sha256sum] = "490e872776a31d75ba26ab910d64b78367782c25640c1ea2199802bc44b665d3"

URI_aarch64_hypre = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-2.32.0-7.el10_0.aarch64.rpm;name=aarch64_hypre;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre}"
SRC_URI[aarch64_hypre.sha256sum] = "e78c791f7f324cadb3ac5eec06c4f77dea3505a376dabc132fee0881a0658d0c"

URI_aarch64_hypre-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-devel-2.32.0-7.el10_0.aarch64.rpm;name=aarch64_hypre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-devel}"
SRC_URI[aarch64_hypre-devel.sha256sum] = "59fcde74e0910e3a939284eb236743f25669e131d6a9fc7f1f2071d0076e1b36"

URI_aarch64_hypre-doc = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-doc-2.32.0-7.el10_0.noarch.rpm;name=aarch64_hypre-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-doc}"
SRC_URI[aarch64_hypre-doc.sha256sum] = "c78b4c87492ef1d9e6cab38c1952a2301b0b9b239a0a1203683b6b5538399c2a"

URI_aarch64_hypre-mpich = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-mpich-2.32.0-7.el10_0.aarch64.rpm;name=aarch64_hypre-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-mpich}"
SRC_URI[aarch64_hypre-mpich.sha256sum] = "bbdbcebcd3fbb76d61969b8cccaf6a01e0474a357be386ccc748a229c15c1183"

URI_aarch64_hypre-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-mpich-devel-2.32.0-7.el10_0.aarch64.rpm;name=aarch64_hypre-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-mpich-devel}"
SRC_URI[aarch64_hypre-mpich-devel.sha256sum] = "f787a11c7350ed64a71dfc31c46c168cd4afff8477333d7e3d34e62d3fd6c241"

URI_aarch64_hypre-openmpi = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-openmpi-2.32.0-7.el10_0.aarch64.rpm;name=aarch64_hypre-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-openmpi}"
SRC_URI[aarch64_hypre-openmpi.sha256sum] = "fa6d9ad4878de51177042be1abacf06ef624b8eb99361b21be14669355804369"

URI_aarch64_hypre-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-openmpi-devel-2.32.0-7.el10_0.aarch64.rpm;name=aarch64_hypre-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-openmpi-devel}"
SRC_URI[aarch64_hypre-openmpi-devel.sha256sum] = "3a5eea95ffde3ffc2bd2f666361b1a9a74bb5681577c7b209729ea725b4f5027"

RDEPENDS:hypre = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:hypre-devel = " \
 SuperLU-devel \
 cmake-filesystem \
 flexiblas-devel \
 hypre \
 "
RDEPENDS:hypre-doc = " \
 "
RDEPENDS:hypre-mpich = " \
 glibc \
 libgcc \
 libgomp \
 mpich \
 "
RDEPENDS:hypre-mpich-devel = " \
 flexiblas-devel \
 hypre-mpich \
 mpich-devel \
 ptscotch-mpich-devel \
 superlu_dist-mpich-devel \
 "
RDEPENDS:hypre-openmpi = " \
 glibc \
 libgcc \
 libgomp \
 openmpi \
 "
RDEPENDS:hypre-openmpi-devel = " \
 flexiblas-devel \
 hypre-openmpi \
 openmpi-devel \
 ptscotch-openmpi-devel \
 superlu_dist-openmpi-devel \
 "
