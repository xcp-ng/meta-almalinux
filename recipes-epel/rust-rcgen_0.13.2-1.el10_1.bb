# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rcgen"
PV = "0.13.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-rcgen+crypto-devel \
 rust-rcgen+default-devel \
 rust-rcgen+pem-devel \
 rust-rcgen+ring-devel \
 rust-rcgen+x509-parser-devel \
 rust-rcgen+zeroize-devel \
 rust-rcgen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rcgen-0.13.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2028911f4ffe3fcb5dd31cb93c74f6ce66bdacf118c4e56845701cc091d51dc"

URI_x86_64_v2_rust-rcgen+crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+crypto-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+crypto-devel}"
SRC_URI[x86_64_v2_rust-rcgen+crypto-devel.sha256sum] = "27150b57f20a78771dd14fcc1ccfd9668089976e4d756027344e15a4dcefcd6f"

URI_x86_64_v2_rust-rcgen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+default-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+default-devel}"
SRC_URI[x86_64_v2_rust-rcgen+default-devel.sha256sum] = "f95337d3f8fc539e514a91cb6d4e90686005eff14525bc344e8a696e96822be2"

URI_x86_64_v2_rust-rcgen+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+pem-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+pem-devel}"
SRC_URI[x86_64_v2_rust-rcgen+pem-devel.sha256sum] = "eeb905d730493e642dce2103535453e0f7ba8e7acc362e53f33863e4d7a6c4dc"

URI_x86_64_v2_rust-rcgen+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+ring-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+ring-devel}"
SRC_URI[x86_64_v2_rust-rcgen+ring-devel.sha256sum] = "023dcfa484a8799e16cb6707c6abfd0b6a60a81134b34bc28be618aa4dd3cfdd"

URI_x86_64_v2_rust-rcgen+x509-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+x509-parser-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+x509-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+x509-parser-devel}"
SRC_URI[x86_64_v2_rust-rcgen+x509-parser-devel.sha256sum] = "f96c462289f42b93f1a6a1cb4a91a14ce006862afce8c32330ad4784632447b2"

URI_x86_64_v2_rust-rcgen+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+zeroize-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+zeroize-devel}"
SRC_URI[x86_64_v2_rust-rcgen+zeroize-devel.sha256sum] = "806bb2990ff39712b43787bd570a4e8223edbdd73951a7ebed0dd4a16d5bf2c5"

URI_x86_64_v2_rust-rcgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen-devel}"
SRC_URI[x86_64_v2_rust-rcgen-devel.sha256sum] = "f717b7c315e10760cd54d78368bbb90d6f409b850dbfa827ad2e76a373c27672"

URI_aarch64_rust-rcgen+crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+crypto-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-rcgen+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+crypto-devel}"
SRC_URI[aarch64_rust-rcgen+crypto-devel.sha256sum] = "780e6ea292f4a1c29af81fc8368d4fdc061c2f7cae523892f54f87d328ba99b9"

URI_aarch64_rust-rcgen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+default-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-rcgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+default-devel}"
SRC_URI[aarch64_rust-rcgen+default-devel.sha256sum] = "3ff8d60d36ffcf58720114959bd80728107200ef76dff583e4f255626b243278"

URI_aarch64_rust-rcgen+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+pem-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-rcgen+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+pem-devel}"
SRC_URI[aarch64_rust-rcgen+pem-devel.sha256sum] = "75c9f2458c247193bdcbc2cdb1f535f7fd2247225cbaa147d2e355dc81ec19c4"

URI_aarch64_rust-rcgen+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+ring-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-rcgen+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+ring-devel}"
SRC_URI[aarch64_rust-rcgen+ring-devel.sha256sum] = "b57e8a3f0e466ecc024a7d6be03af81782917159e8579d650cc36294b844b6fb"

URI_aarch64_rust-rcgen+x509-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+x509-parser-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-rcgen+x509-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+x509-parser-devel}"
SRC_URI[aarch64_rust-rcgen+x509-parser-devel.sha256sum] = "5cbf3e908001c7035592753bbfc2579036f381e72ef9313889f8cc68b7ac42c8"

URI_aarch64_rust-rcgen+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+zeroize-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-rcgen+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+zeroize-devel}"
SRC_URI[aarch64_rust-rcgen+zeroize-devel.sha256sum] = "d64e754c6756f4edf0d0a9d80ed16917495b7a0d2ca49750485eef7fb434313d"

URI_aarch64_rust-rcgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-rcgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen-devel}"
SRC_URI[aarch64_rust-rcgen-devel.sha256sum] = "1fe6ae476ae3ebe669802038fee61c63c1f3085332f2116e7130038d60564ba3"

RDEPENDS:rust-rcgen+crypto-devel = " \
 cargo \
 rust-rcgen-devel \
 "
RDEPENDS:rust-rcgen+default-devel = " \
 cargo \
 rust-rcgen+crypto-devel \
 rust-rcgen+pem-devel \
 rust-rcgen+ring-devel \
 rust-rcgen-devel \
 "
RDEPENDS:rust-rcgen+pem-devel = " \
 cargo \
 rust-pem+default-devel \
 rust-rcgen-devel \
 "
RDEPENDS:rust-rcgen+ring-devel = " \
 cargo \
 rust-rcgen+crypto-devel \
 rust-rcgen-devel \
 rust-ring+default-devel \
 "
RDEPENDS:rust-rcgen+x509-parser-devel = " \
 cargo \
 rust-rcgen-devel \
 rust-x509-parser+default-devel \
 rust-x509-parser+verify-devel \
 "
RDEPENDS:rust-rcgen+zeroize-devel = " \
 cargo \
 rust-rcgen-devel \
 rust-zeroize+default-devel \
 "
RDEPENDS:rust-rcgen-devel = " \
 cargo \
 rust-rustls-pki-types+default-devel \
 rust-time-devel \
 rust-yasna+default-devel \
 rust-yasna+std-devel \
 rust-yasna+time-devel \
 "
