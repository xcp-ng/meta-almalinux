# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ecdsa"
PV = "0.16.9"
PR = "3.el10_0"
PACKAGES = " \
 rust-ecdsa+alloc-devel \
 rust-ecdsa+arithmetic-devel \
 rust-ecdsa+default-devel \
 rust-ecdsa+der-devel \
 rust-ecdsa+dev-devel \
 rust-ecdsa+digest-devel \
 rust-ecdsa+hazmat-devel \
 rust-ecdsa+pem-devel \
 rust-ecdsa+pkcs8-devel \
 rust-ecdsa+rfc6979-devel \
 rust-ecdsa+serde-devel \
 rust-ecdsa+serdect-devel \
 rust-ecdsa+sha2-devel \
 rust-ecdsa+signing-devel \
 rust-ecdsa+spki-devel \
 rust-ecdsa+std-devel \
 rust-ecdsa+verifying-devel \
 rust-ecdsa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ecdsa-0.16.9-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b24f85799d0233aa4398a1b5be32d1f75ac076eb7e1c8d3afc08e114cb500f4"

URI_x86_64_v2_rust-ecdsa+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+alloc-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+alloc-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+alloc-devel.sha256sum] = "21a86bd84aee852c7bab5610d0d571a71e747955797b53357e6fdc4d319f9eb2"

URI_x86_64_v2_rust-ecdsa+arithmetic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+arithmetic-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+arithmetic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+arithmetic-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+arithmetic-devel.sha256sum] = "e3962c83edab9c1ab35d204e8654b9bb717d22df7909d54e93f3116593aed1e5"

URI_x86_64_v2_rust-ecdsa+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+default-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+default-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+default-devel.sha256sum] = "e9684466a151e8dfe32d6dfb5306e86fb909c1e105539c67b9900159c2205fba"

URI_x86_64_v2_rust-ecdsa+der-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+der-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+der-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+der-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+der-devel.sha256sum] = "2508e06e0fa07315a63eb92115340701f9f328702faabaac05f79cb1274abf47"

URI_x86_64_v2_rust-ecdsa+dev-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+dev-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+dev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+dev-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+dev-devel.sha256sum] = "b4c362f3043084b49ca632200bcd39318f995909aaa1115c0c8dc514f00a433b"

URI_x86_64_v2_rust-ecdsa+digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+digest-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+digest-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+digest-devel.sha256sum] = "9242090826cec17bed18363606db185d756a242febf8a9f3169ed315f9fa06fe"

URI_x86_64_v2_rust-ecdsa+hazmat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+hazmat-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+hazmat-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+hazmat-devel.sha256sum] = "b85a0eb7255e893007fb3e055e5de290df9eec455e69efcea032e13a8bdae19c"

URI_x86_64_v2_rust-ecdsa+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+pem-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+pem-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+pem-devel.sha256sum] = "7856d974d2e2ec455fad2a47b2c23bed309f824b314ac83f1d373d79ea6df5c0"

URI_x86_64_v2_rust-ecdsa+pkcs8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+pkcs8-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+pkcs8-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+pkcs8-devel.sha256sum] = "ece1bf33254ef3f35295c20171e2cc344a7c1dda721eb8df8d8f0261fa1f896f"

URI_x86_64_v2_rust-ecdsa+rfc6979-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+rfc6979-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+rfc6979-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+rfc6979-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+rfc6979-devel.sha256sum] = "b140805a675178eb8b75cea652c4665669b05ac10ef9cad72eb1d5c9ccd13083"

URI_x86_64_v2_rust-ecdsa+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+serde-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+serde-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+serde-devel.sha256sum] = "c7268f1c8ee830de1e4736cc8f5e7c1682944039e0151f0679872f59f9be11e1"

URI_x86_64_v2_rust-ecdsa+serdect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+serdect-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+serdect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+serdect-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+serdect-devel.sha256sum] = "5dcb44d98decdc57f9180a4d832086df71ae1d217d16fda27fce238051d7e4fb"

URI_x86_64_v2_rust-ecdsa+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+sha2-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+sha2-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+sha2-devel.sha256sum] = "65b5f5632893c2170b97c1b73aeebfd039fa8864ffec0d55569a23476d73655c"

URI_x86_64_v2_rust-ecdsa+signing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+signing-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+signing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+signing-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+signing-devel.sha256sum] = "b6f433fe6a3522d79061b0b558fbbd732aa7484ce7152766dce7304062729817"

URI_x86_64_v2_rust-ecdsa+spki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+spki-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+spki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+spki-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+spki-devel.sha256sum] = "f27ebad42305a037525fd0b68a65c1887292252c2c580598b1603bd7ea3cb9b9"

URI_x86_64_v2_rust-ecdsa+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+std-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+std-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+std-devel.sha256sum] = "0db8f69f5382ff402b723034af8b1feab92147eee26457b5aeb216a5f072c072"

URI_x86_64_v2_rust-ecdsa+verifying-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+verifying-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+verifying-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+verifying-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+verifying-devel.sha256sum] = "2f501b3befb93f63f31f5213fa70f288338595487e4369a454c19ef916f3f4ba"

URI_x86_64_v2_rust-ecdsa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa-devel-0.16.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa-devel}"
SRC_URI[x86_64_v2_rust-ecdsa-devel.sha256sum] = "984c5b0ccb0427409a91c66608d3277ec70f4f507c0722dae775b24375f75308"

URI_aarch64_rust-ecdsa+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+alloc-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+alloc-devel}"
SRC_URI[aarch64_rust-ecdsa+alloc-devel.sha256sum] = "882b1004b0def63044c9b22fa2c3affef2912db988209fbd5af0cbf9f0713838"

URI_aarch64_rust-ecdsa+arithmetic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+arithmetic-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+arithmetic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+arithmetic-devel}"
SRC_URI[aarch64_rust-ecdsa+arithmetic-devel.sha256sum] = "3afe7e163e153f32c5201109610b735f2d09530c4a8e5c32ca5674e5379b7e76"

URI_aarch64_rust-ecdsa+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+default-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+default-devel}"
SRC_URI[aarch64_rust-ecdsa+default-devel.sha256sum] = "55e877cecab500bd90f549df885fccf40cf9e220a05531d6a86cff572ba35287"

URI_aarch64_rust-ecdsa+der-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+der-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+der-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+der-devel}"
SRC_URI[aarch64_rust-ecdsa+der-devel.sha256sum] = "12b37de5abd61634134d6d57f442b4bb610a084ffd26ca0468984f897fac9142"

URI_aarch64_rust-ecdsa+dev-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+dev-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+dev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+dev-devel}"
SRC_URI[aarch64_rust-ecdsa+dev-devel.sha256sum] = "0ce925316abf9687f8be407d19788c6ca35355b8f8972dd159561351e489b6d0"

URI_aarch64_rust-ecdsa+digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+digest-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+digest-devel}"
SRC_URI[aarch64_rust-ecdsa+digest-devel.sha256sum] = "ca7b2ae6afd264945a6e911fe2d64cb093bdca4539fcc9ca98461577260a5f1f"

URI_aarch64_rust-ecdsa+hazmat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+hazmat-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+hazmat-devel}"
SRC_URI[aarch64_rust-ecdsa+hazmat-devel.sha256sum] = "7845540b8e4cdd75f1b9a13bf8adc10ed05a2a5a4a34835aab2378a056519ee9"

URI_aarch64_rust-ecdsa+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+pem-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+pem-devel}"
SRC_URI[aarch64_rust-ecdsa+pem-devel.sha256sum] = "992db3fa79d027e1586ac0dd15b7f31dfde4ee71490b4192082328ada0e3dcd7"

URI_aarch64_rust-ecdsa+pkcs8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+pkcs8-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+pkcs8-devel}"
SRC_URI[aarch64_rust-ecdsa+pkcs8-devel.sha256sum] = "3864cb1dcdd4f9dd3e72c644f0ddb86fa7920a50e785e87dffa5f47eebed38c9"

URI_aarch64_rust-ecdsa+rfc6979-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+rfc6979-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+rfc6979-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+rfc6979-devel}"
SRC_URI[aarch64_rust-ecdsa+rfc6979-devel.sha256sum] = "88f993e42449e82a5af9a0827c2a006ce83dc30f7cb69c0fcb264172f3cddfbc"

URI_aarch64_rust-ecdsa+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+serde-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+serde-devel}"
SRC_URI[aarch64_rust-ecdsa+serde-devel.sha256sum] = "e92f9fe540f61eedd809036f9ea3fe8f4a0afc6df011e354799aa70f714cfce8"

URI_aarch64_rust-ecdsa+serdect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+serdect-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+serdect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+serdect-devel}"
SRC_URI[aarch64_rust-ecdsa+serdect-devel.sha256sum] = "50169afbcd4478573df82f84778202f84c19ce3e1233977ca646f54231be35bc"

URI_aarch64_rust-ecdsa+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+sha2-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+sha2-devel}"
SRC_URI[aarch64_rust-ecdsa+sha2-devel.sha256sum] = "8dff9e10a816b4def691b211c5921210ba853fb9eb4fcd0196155514a75395b0"

URI_aarch64_rust-ecdsa+signing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+signing-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+signing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+signing-devel}"
SRC_URI[aarch64_rust-ecdsa+signing-devel.sha256sum] = "9356255abcca4ab1a3ba9cef027279e718aeb76c78a0eb00e610765f1c5f8ee7"

URI_aarch64_rust-ecdsa+spki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+spki-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+spki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+spki-devel}"
SRC_URI[aarch64_rust-ecdsa+spki-devel.sha256sum] = "5bb56c8bfae30996d06ecda2542bbe26987d43c74c6a70e3852b352d43a9a372"

URI_aarch64_rust-ecdsa+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+std-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+std-devel}"
SRC_URI[aarch64_rust-ecdsa+std-devel.sha256sum] = "7e9d829a26494645f6431f4630a0e29e94633f8302931edb408da5f7b5c872f3"

URI_aarch64_rust-ecdsa+verifying-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+verifying-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa+verifying-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+verifying-devel}"
SRC_URI[aarch64_rust-ecdsa+verifying-devel.sha256sum] = "3da3f54bed5f9c3b0a77a5009490425d49fd3bc85d5263faab0d02eec46d5822"

URI_aarch64_rust-ecdsa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa-devel-0.16.9-3.el10_0.noarch.rpm;name=aarch64_rust-ecdsa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa-devel}"
SRC_URI[aarch64_rust-ecdsa-devel.sha256sum] = "f415181d0c740a0d08093e2df27e61342a4a2ad50e3951e56ad1f0f3b47a57f3"

RDEPENDS:rust-ecdsa+alloc-devel = " \
 cargo \
 rust-ecdsa-devel \
 rust-elliptic-curve+alloc-devel \
 rust-signature+alloc-devel \
 rust-spki+alloc-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-ecdsa+arithmetic-devel = " \
 cargo \
 rust-ecdsa-devel \
 rust-elliptic-curve+arithmetic-devel \
 "
RDEPENDS:rust-ecdsa+default-devel = " \
 cargo \
 rust-ecdsa+digest-devel \
 rust-ecdsa-devel \
 "
RDEPENDS:rust-ecdsa+der-devel = " \
 cargo \
 rust-der+default-devel \
 rust-ecdsa-devel \
 "
RDEPENDS:rust-ecdsa+dev-devel = " \
 cargo \
 rust-ecdsa+arithmetic-devel \
 rust-ecdsa+digest-devel \
 rust-ecdsa+hazmat-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+dev-devel \
 "
RDEPENDS:rust-ecdsa+digest-devel = " \
 cargo \
 rust-digest+oid-devel \
 rust-digest-devel \
 rust-ecdsa-devel \
 rust-signature+digest-devel \
 "
RDEPENDS:rust-ecdsa+hazmat-devel = " \
 cargo \
 rust-ecdsa-devel \
 "
RDEPENDS:rust-ecdsa+pem-devel = " \
 cargo \
 rust-ecdsa+pkcs8-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+pem-devel \
 "
RDEPENDS:rust-ecdsa+pkcs8-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+digest-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+pkcs8-devel \
 "
RDEPENDS:rust-ecdsa+rfc6979-devel = " \
 cargo \
 rust-ecdsa-devel \
 rust-rfc6979+default-devel \
 "
RDEPENDS:rust-ecdsa+serde-devel = " \
 cargo \
 rust-ecdsa+serdect-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+serde-devel \
 "
RDEPENDS:rust-ecdsa+serdect-devel = " \
 cargo \
 rust-ecdsa-devel \
 rust-serdect+alloc-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-ecdsa+sha2-devel = " \
 cargo \
 rust-ecdsa-devel \
 rust-sha2+oid-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-ecdsa+signing-devel = " \
 cargo \
 rust-ecdsa+arithmetic-devel \
 rust-ecdsa+digest-devel \
 rust-ecdsa+hazmat-devel \
 rust-ecdsa+rfc6979-devel \
 rust-ecdsa-devel \
 "
RDEPENDS:rust-ecdsa+spki-devel = " \
 cargo \
 rust-ecdsa-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-ecdsa+std-devel = " \
 cargo \
 rust-ecdsa+alloc-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+std-devel \
 rust-signature+std-devel \
 "
RDEPENDS:rust-ecdsa+verifying-devel = " \
 cargo \
 rust-ecdsa+arithmetic-devel \
 rust-ecdsa+digest-devel \
 rust-ecdsa+hazmat-devel \
 rust-ecdsa-devel \
 "
RDEPENDS:rust-ecdsa-devel = " \
 cargo \
 rust \
 rust-elliptic-curve+digest-devel \
 rust-elliptic-curve+sec1-devel \
 rust-elliptic-curve-devel \
 rust-signature+rand_core-devel \
 rust-signature-devel \
 "
