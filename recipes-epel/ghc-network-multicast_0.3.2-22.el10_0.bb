# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-network-multicast"
PV = "0.3.2"
PR = "22.el10_0"
PACKAGES = " \
 ghc-network-multicast \
 ghc-network-multicast-devel \
 ghc-network-multicast-doc \
 ghc-network-multicast-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-network-multicast-0.3.2-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db8e5e3c0725d9d07fad889c660e21dab9b585bf09b0b7f2605a269844e3d9a1"

URI_x86_64_v2_ghc-network-multicast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-multicast-0.3.2-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-multicast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-multicast}"
SRC_URI[x86_64_v2_ghc-network-multicast.sha256sum] = "f63de49296c3dae62809f83737c4067e95b270b6afc48e91ba562420031a5bb1"

URI_x86_64_v2_ghc-network-multicast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-multicast-devel-0.3.2-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-multicast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-multicast-devel}"
SRC_URI[x86_64_v2_ghc-network-multicast-devel.sha256sum] = "8dbdce600f3520e63c8dc3f06475438a3fc2553d7e66bdf6b5adc0d5968ce5f0"

URI_x86_64_v2_ghc-network-multicast-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-multicast-doc-0.3.2-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-network-multicast-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-multicast-doc}"
SRC_URI[x86_64_v2_ghc-network-multicast-doc.sha256sum] = "2d34adb39f0469c7760bfb9f590bc12734da63ad97b56fdb4905950abe9a890c"

URI_x86_64_v2_ghc-network-multicast-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-multicast-prof-0.3.2-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-multicast-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-multicast-prof}"
SRC_URI[x86_64_v2_ghc-network-multicast-prof.sha256sum] = "10202e49848c93f08d8be3d3ec3e152eb674f8cca9ff2e25ffb9c5c208317473"

URI_aarch64_ghc-network-multicast = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-multicast-0.3.2-22.el10_0.aarch64.rpm;name=aarch64_ghc-network-multicast;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-multicast}"
SRC_URI[aarch64_ghc-network-multicast.sha256sum] = "70a60afeeb9b5166a8c272d5015c2ac532a787c1436872f43adc339155c43387"

URI_aarch64_ghc-network-multicast-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-multicast-devel-0.3.2-22.el10_0.aarch64.rpm;name=aarch64_ghc-network-multicast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-multicast-devel}"
SRC_URI[aarch64_ghc-network-multicast-devel.sha256sum] = "1fefc4c40ee8d6023145979449855abcf1b5a32abc3996dd437809358a0ac963"

URI_aarch64_ghc-network-multicast-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-multicast-doc-0.3.2-22.el10_0.noarch.rpm;name=aarch64_ghc-network-multicast-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-multicast-doc}"
SRC_URI[aarch64_ghc-network-multicast-doc.sha256sum] = "7c902bd86867a550e10f50dc9e55e1b8b38cb14959fb0af69a34559d43872c9f"

URI_aarch64_ghc-network-multicast-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-multicast-prof-0.3.2-22.el10_0.aarch64.rpm;name=aarch64_ghc-network-multicast-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-multicast-prof}"
SRC_URI[aarch64_ghc-network-multicast-prof.sha256sum] = "e69b168fa59cd065033dbcc7a9369a59dfe89741f078288e9ea12894bc5aa08b"

RDEPENDS:ghc-network-multicast = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-network \
 ghc-network-bsd \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-network-multicast-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-network-bsd-devel \
 ghc-network-devel \
 ghc-network-multicast \
 "
RDEPENDS:ghc-network-multicast-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-network-multicast-prof = " \
 ghc-base-prof \
 ghc-network-bsd-prof \
 ghc-network-multicast-devel \
 ghc-network-prof \
 "
