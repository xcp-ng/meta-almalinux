# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-der_derive0.7"
PV = "0.7.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-der_derive0.7+default-devel \
 rust-der_derive0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-der_derive0.7-0.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78fddbaa543d2a7beb0fd1b7b1d5f7b894ddc1509519ae5bf16127773f079205"

URI_x86_64_v2_rust-der_derive0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der_derive0.7+default-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der_derive0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der_derive0.7+default-devel}"
SRC_URI[x86_64_v2_rust-der_derive0.7+default-devel.sha256sum] = "70cdf10ca6423b7951929c44dbaf82580a522f98858112be93431cd251762c48"

URI_x86_64_v2_rust-der_derive0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der_derive0.7-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der_derive0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der_derive0.7-devel}"
SRC_URI[x86_64_v2_rust-der_derive0.7-devel.sha256sum] = "456cdb87d0a30f5a46b290e20cc2c989459a21efd8ab36f8cda0162bc8bc1b10"

URI_aarch64_rust-der_derive0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der_derive0.7+default-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-der_derive0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der_derive0.7+default-devel}"
SRC_URI[aarch64_rust-der_derive0.7+default-devel.sha256sum] = "1c5b3699c9f4614895368c396b1aa8e2944aa860f608b18d69dcac71ed8ecd79"

URI_aarch64_rust-der_derive0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der_derive0.7-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-der_derive0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der_derive0.7-devel}"
SRC_URI[aarch64_rust-der_derive0.7-devel.sha256sum] = "023d89ab68f871fee9c58706fb99e866c3d1f96a9b0d617f1f24d00ef0c5b429"

RDEPENDS:rust-der_derive0.7+default-devel = " \
 cargo \
 rust-der_derive0.7-devel \
 "
RDEPENDS:rust-der_derive0.7-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 "
