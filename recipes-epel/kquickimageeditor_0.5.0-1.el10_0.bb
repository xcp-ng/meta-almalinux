# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kquickimageeditor"
PV = "0.5.0"
PR = "1.el10_0"
PACKAGES = " \
 kquickimageeditor-qt6 \
 kquickimageeditor-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kquickimageeditor-0.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33f9b4de50a0c5efa25000c7b802737ccfa6608fa8fc0c638cd54a9dc6e3c73e"

URI_x86_64_v2_kquickimageeditor-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kquickimageeditor-qt6-0.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kquickimageeditor-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kquickimageeditor-qt6}"
SRC_URI[x86_64_v2_kquickimageeditor-qt6.sha256sum] = "4ee3aad64e684d358d8c6371fffb42f9cc8f555e575b76ff921e8fc6407e1cfb"

URI_x86_64_v2_kquickimageeditor-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kquickimageeditor-qt6-devel-0.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kquickimageeditor-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kquickimageeditor-qt6-devel}"
SRC_URI[x86_64_v2_kquickimageeditor-qt6-devel.sha256sum] = "aac4d34b44c392d2f8eed76509a39e436f8df6c9d3b87939c592e7425acaf4bd"

URI_aarch64_kquickimageeditor-qt6 = "${EPEL_MIRROR}/aarch64/Packages/k/kquickimageeditor-qt6-0.5.0-1.el10_0.aarch64.rpm;name=aarch64_kquickimageeditor-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_kquickimageeditor-qt6}"
SRC_URI[aarch64_kquickimageeditor-qt6.sha256sum] = "128f9acca1c7369eb5bd65c152342e523accc1044fc349867add84e548a15b0a"

URI_aarch64_kquickimageeditor-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kquickimageeditor-qt6-devel-0.5.0-1.el10_0.aarch64.rpm;name=aarch64_kquickimageeditor-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kquickimageeditor-qt6-devel}"
SRC_URI[aarch64_kquickimageeditor-qt6-devel.sha256sum] = "9965e7abe911790361cfba52b32addb460b4e087fb427c409fb3a3d069a2a48c"

RDEPENDS:kquickimageeditor-qt6 = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kquickimageeditor-qt6-devel = " \
 cmake-filesystem \
 kquickimageeditor-qt6 \
 "
