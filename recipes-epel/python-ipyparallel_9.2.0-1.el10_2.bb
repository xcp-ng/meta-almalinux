# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ipyparallel"
PV = "9.2.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-ipyparallel \
 python3-ipyparallel+test \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ipyparallel-9.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e5c5991861338933c831216e536b98aa61e55c85767366912151323cbca3c2a"

URI_x86_64_v2_python3-ipyparallel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipyparallel-9.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipyparallel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipyparallel}"
SRC_URI[x86_64_v2_python3-ipyparallel.sha256sum] = "5b64adc6e679cfe3b300ef815a99e125a4d887295f21882802f691122310395e"

URI_x86_64_v2_python3-ipyparallel+test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipyparallel+test-9.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipyparallel+test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipyparallel+test}"
SRC_URI[x86_64_v2_python3-ipyparallel+test.sha256sum] = "97573e9a96c9f9710c40ef38a3d4094fbf8f06aa5df0d428b62298247ea641dc"

URI_aarch64_python3-ipyparallel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipyparallel-9.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-ipyparallel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipyparallel}"
SRC_URI[aarch64_python3-ipyparallel.sha256sum] = "cbc38d1a368746a4becbf5ed44dbf115bc035be49f4fb47f719717da03d8896f"

URI_aarch64_python3-ipyparallel+test = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipyparallel+test-9.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-ipyparallel+test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipyparallel+test}"
SRC_URI[aarch64_python3-ipyparallel+test.sha256sum] = "2d29819f4d965258d8ceb117959620e6d208f321fbb50900c91afe202cc419fd"

RDEPENDS:python3-ipyparallel = " \
 python-jupyter-filesystem \
 python3 \
 python3-dateutil \
 python3-decorator \
 python3-ipykernel \
 python3-ipython \
 python3-jupyter-client \
 python3-psutil \
 python3-pyzmq \
 python3-tornado \
 python3-tqdm \
 python3-traitlets \
 "
RDEPENDS:python3-ipyparallel+test = " \
 python3 \
 python3-ipyparallel \
 python3-ipython \
 python3-ipython+test \
 python3-pytest \
 python3-pytest-asyncio \
 python3-pytest-cov \
 python3-testpath \
 "
