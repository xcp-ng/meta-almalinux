# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-PPIx-Utils"
PV = "0.003"
PR = "4.el10_0"
PACKAGES = " \
 perl-PPIx-Utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-PPIx-Utils-0.003-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4730aa85058debe302c36368d92558aa3ea2dd0542ca97d8af490e0b4f98fe2d"

URI_x86_64_v2_perl-PPIx-Utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-PPIx-Utils-0.003-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-PPIx-Utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PPIx-Utils}"
SRC_URI[x86_64_v2_perl-PPIx-Utils.sha256sum] = "f8cc302f5fadd56ec1a4690d2f425eae30bd08b2c983a42571d7db822b8bfca0"

URI_aarch64_perl-PPIx-Utils = "${EPEL_MIRROR}/aarch64/Packages/p/perl-PPIx-Utils-0.003-4.el10_0.noarch.rpm;name=aarch64_perl-PPIx-Utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PPIx-Utils}"
SRC_URI[aarch64_perl-PPIx-Utils.sha256sum] = "bde84af1d6c748e19d15d0bd87aa388fc03d7165171cb3c37cb09bb887b45664"

RDEPENDS:perl-PPIx-Utils = " \
 perl-B-Keywords \
 perl-Exporter \
 perl-PPI \
 perl-PPIx-Utils \
 perl-Scalar-List-Utils \
 perl-libs \
 "
