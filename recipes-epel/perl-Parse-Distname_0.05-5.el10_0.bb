# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Parse-Distname"
PV = "0.05"
PR = "5.el10_0"
PACKAGES = " \
 perl-Parse-Distname \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Parse-Distname-0.05-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0242756208ae33b7f7a67d0e41a9406da02daaab3ae30cf5bb7b022dd28d4041"

URI_x86_64_v2_perl-Parse-Distname = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Parse-Distname-0.05-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Parse-Distname;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Parse-Distname}"
SRC_URI[x86_64_v2_perl-Parse-Distname.sha256sum] = "a7066617645804a96155930777fc8064720d007bca41c6c8cc281b07251dd7a4"

URI_aarch64_perl-Parse-Distname = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Parse-Distname-0.05-5.el10_0.noarch.rpm;name=aarch64_perl-Parse-Distname;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Parse-Distname}"
SRC_URI[aarch64_perl-Parse-Distname.sha256sum] = "f5591647f34cb11471c9bfa9f502c4ea27a52347109ec1ebeed1410467d35b92"

RDEPENDS:perl-Parse-Distname = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
