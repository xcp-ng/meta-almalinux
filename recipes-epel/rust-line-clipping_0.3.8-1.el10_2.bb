# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-line-clipping"
PV = "0.3.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-line-clipping+default-devel \
 rust-line-clipping-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-line-clipping-0.3.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86c2fd6faea6abbc452fc35bb9515aee70f5ab092dd7c76bd9ba75eb60f85931"

URI_x86_64_v2_rust-line-clipping+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-line-clipping+default-devel-0.3.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-line-clipping+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-line-clipping+default-devel}"
SRC_URI[x86_64_v2_rust-line-clipping+default-devel.sha256sum] = "03378d9e8138ce1fe48d8570f5aa9f7a16d5fbbdaf76093b9679500121c5cedd"

URI_x86_64_v2_rust-line-clipping-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-line-clipping-devel-0.3.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-line-clipping-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-line-clipping-devel}"
SRC_URI[x86_64_v2_rust-line-clipping-devel.sha256sum] = "048237028d60ad001a24fa625ce9652c1dd2ed68f825864ee235e63d3b8ac00b"

URI_aarch64_rust-line-clipping+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-line-clipping+default-devel-0.3.8-1.el10_2.noarch.rpm;name=aarch64_rust-line-clipping+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-line-clipping+default-devel}"
SRC_URI[aarch64_rust-line-clipping+default-devel.sha256sum] = "f72abc64935290333f9acf1a6dc63b0bad46f535755a6395a99a369308eb87fc"

URI_aarch64_rust-line-clipping-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-line-clipping-devel-0.3.8-1.el10_2.noarch.rpm;name=aarch64_rust-line-clipping-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-line-clipping-devel}"
SRC_URI[aarch64_rust-line-clipping-devel.sha256sum] = "e1a3225cb03f773963b99be1113cfa95bafe985ac34ec5bf08e9f6b09eab7e2c"

RDEPENDS:rust-line-clipping+default-devel = " \
 cargo \
 rust-line-clipping-devel \
 "
RDEPENDS:rust-line-clipping-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 "
