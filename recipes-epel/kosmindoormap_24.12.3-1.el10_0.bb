# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kosmindoormap"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kosmindoormap \
 kosmindoormap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kosmindoormap-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a62401e23acdd62d7721e9583d47ad3e3f9da666b19338bdf300b04d93ef591"

URI_x86_64_v2_kosmindoormap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kosmindoormap-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kosmindoormap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kosmindoormap}"
SRC_URI[x86_64_v2_kosmindoormap.sha256sum] = "e41bc97012653294ca39b0fdbaea83c79153e22714ac06d459e442fbcfde7971"

URI_x86_64_v2_kosmindoormap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kosmindoormap-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kosmindoormap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kosmindoormap-devel}"
SRC_URI[x86_64_v2_kosmindoormap-devel.sha256sum] = "e1b496e9f159c16f36323a56a2efd40dbe4154175587586d04766cdba2706bdd"

URI_aarch64_kosmindoormap = "${EPEL_MIRROR}/aarch64/Packages/k/kosmindoormap-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kosmindoormap;unpack=0"
SRC_URI:append = " ${URI_aarch64_kosmindoormap}"
SRC_URI[aarch64_kosmindoormap.sha256sum] = "4085d562f5933b2ce5ae70ee451024086f7d4acd13d905811195e1e07378a536"

URI_aarch64_kosmindoormap-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kosmindoormap-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kosmindoormap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kosmindoormap-devel}"
SRC_URI[aarch64_kosmindoormap-devel.sha256sum] = "caf4d3b0c218be5559e120c425bc4a51fc88b112f46c1ae7de0dde7edba27168"

RDEPENDS:kosmindoormap = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kservice \
 kopeninghours \
 kpublictransport \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kosmindoormap-devel = " \
 cmake-filesystem \
 kosmindoormap \
 "
