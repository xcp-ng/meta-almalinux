# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "udisks2"
PV = "2.11.1"
PR = "2.el10.alma.1"
PACKAGES = " \
 libudisks2 \
 libudisks2-devel \
 udisks2 \
 udisks2-btrfs \
 udisks2-iscsi \
 udisks2-lsm \
 udisks2-lvm2 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/udisks2-2.11.1-2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b4f2c8d0bbd0869777ce0e91592903560cf3ad4858c7d40dc04e637228d38cdb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libudisks2-2.11.1-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libudisks2;unpack=0"
SRC_URI[x86_64_v2_libudisks2.sha256sum] = "a0635cac0dbc3ac3ec23c6a15448e7cc36e28bc99bdcc5205bb24239bb08483a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libudisks2-devel-2.11.1-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libudisks2-devel;unpack=0"
SRC_URI[x86_64_v2_libudisks2-devel.sha256sum] = "227126022634678f5bb7e3654d8ceeabc9750795261c99e69efc7e120c45a853"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-2.11.1-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_udisks2;unpack=0"
SRC_URI[x86_64_v2_udisks2.sha256sum] = "7351bbcaf26a8aae16ced05fdfc56bab6ec7eaad0f6b02ac59dcbfd58993b035"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-btrfs-2.11.1-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_udisks2-btrfs;unpack=0"
SRC_URI[x86_64_v2_udisks2-btrfs.sha256sum] = "e67b6dfccf8967a6bd6dbe8cbd4931200981e677e626112eb8632f4cccec85ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-iscsi-2.11.1-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_udisks2-iscsi;unpack=0"
SRC_URI[x86_64_v2_udisks2-iscsi.sha256sum] = "1f5c11d6c37493b8c0dfc52245065533249a7a0121b26e591f1c7b08a2cf9795"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-lsm-2.11.1-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_udisks2-lsm;unpack=0"
SRC_URI[x86_64_v2_udisks2-lsm.sha256sum] = "94f049013ea43ed4d7f6a6b4b67f5838ef3c09aec6ec9c62cd55f2ed47f5f7bf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-lvm2-2.11.1-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_udisks2-lvm2;unpack=0"
SRC_URI[x86_64_v2_udisks2-lvm2.sha256sum] = "855549d82ef906ba8bd2733b7141dc1c484a98d607b7a7b3370fa7a910a232a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libudisks2-2.11.1-2.el10.alma.1.aarch64.rpm;name=aarch64_libudisks2;unpack=0"
SRC_URI[aarch64_libudisks2.sha256sum] = "1c597354b4792b4b1621f163f435ce84b59ade84cd1edbd6d5c9c99cbde48237"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libudisks2-devel-2.11.1-2.el10.alma.1.aarch64.rpm;name=aarch64_libudisks2-devel;unpack=0"
SRC_URI[aarch64_libudisks2-devel.sha256sum] = "aa02def15ce4aba9a1ce76386afb5c6874958288fc8f5cf7ff75e11616d9abd0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-2.11.1-2.el10.alma.1.aarch64.rpm;name=aarch64_udisks2;unpack=0"
SRC_URI[aarch64_udisks2.sha256sum] = "ff925354d71e21609bb8dbef3d3f380cc7b3d8c84d383044e2e770ddc1e530f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-btrfs-2.11.1-2.el10.alma.1.aarch64.rpm;name=aarch64_udisks2-btrfs;unpack=0"
SRC_URI[aarch64_udisks2-btrfs.sha256sum] = "2219732f4e1c6bbb1e22aed1670edbfa6a809be00bb3d931ba23ca528adab37c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-iscsi-2.11.1-2.el10.alma.1.aarch64.rpm;name=aarch64_udisks2-iscsi;unpack=0"
SRC_URI[aarch64_udisks2-iscsi.sha256sum] = "eb4960ea1204c32b43f21985ee331f285693d2dcff86e21a4d772efe6269261c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-lsm-2.11.1-2.el10.alma.1.aarch64.rpm;name=aarch64_udisks2-lsm;unpack=0"
SRC_URI[aarch64_udisks2-lsm.sha256sum] = "2305ae8817c6f619d079789c56f7d05f4c833264a1a137f047327e0c2d9fbab8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-lvm2-2.11.1-2.el10.alma.1.aarch64.rpm;name=aarch64_udisks2-lvm2;unpack=0"
SRC_URI[aarch64_udisks2-lvm2.sha256sum] = "e916d05becae240bdc7ccdd823af169acb30bd922c247f92606285e9635f4e46"

RDEPENDS:libudisks2 = " \
 glib2 \
 glibc \
 "
RDEPENDS:libudisks2-devel = " \
 glib2-devel \
 libudisks2 \
 libudisks2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:udisks2 = " \
 bash \
 dbus \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-crypto \
 libblockdev-fs \
 libblockdev-loop \
 libblockdev-mdraid \
 libblockdev-nvme \
 libblockdev-part \
 libblockdev-smart \
 libblockdev-swap \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 polkit \
 polkit-libs \
 systemd-libs \
 systemd-udev \
 util-linux \
 "
RDEPENDS:udisks2-btrfs = " \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-btrfs \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:udisks2-iscsi = " \
 glib2 \
 glibc \
 iscsi-initiator-utils \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:udisks2-lsm = " \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-utils \
 libconfig \
 libgcc \
 libgudev \
 libmount \
 libstoragemgmt \
 libudisks2 \
 libuuid \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:udisks2-lvm2 = " \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-lvm \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 lvm2 \
 polkit-libs \
 systemd-libs \
 "
