# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-productmd"
PV = "1.38"
PR = "5.el10.alma.2"
PACKAGES = " \
 python3-productmd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-productmd-1.38-5.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a54b6e3229528650588d76a3ee2aa87ae031bff002f43dce2bca629a726d73e"

URI_x86_64_v2_python3-productmd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-productmd-1.38-5.el10.alma.2.noarch.rpm;name=x86_64_v2_python3-productmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-productmd}"
SRC_URI[x86_64_v2_python3-productmd.sha256sum] = "6f84a181aee3562efe4a4a47f07e960c762a9725b29ae17cb73f2a1baad5f1d6"

URI_aarch64_python3-productmd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-productmd-1.38-5.el10.alma.2.noarch.rpm;name=aarch64_python3-productmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-productmd}"
SRC_URI[aarch64_python3-productmd.sha256sum] = "6f84a181aee3562efe4a4a47f07e960c762a9725b29ae17cb73f2a1baad5f1d6"

RDEPENDS:python3-productmd = " \
 python3 \
 python3-six \
 "
