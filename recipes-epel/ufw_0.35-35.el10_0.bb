# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ufw"
PV = "0.35"
PR = "35.el10_0"
PACKAGES = " \
 ufw \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/ufw-0.35-35.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "062c6a61e048a50bbb540cd072bb714f7f6b7b87c33ce878363543a7aa9cdf52"

URI_x86_64_v2_ufw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ufw-0.35-35.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ufw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ufw}"
SRC_URI[x86_64_v2_ufw.sha256sum] = "7843b3e1ee765850b8c3ed5b8d5a1614976543a2335d943cab7248ef162eea0e"

URI_aarch64_ufw = "${EPEL_MIRROR}/aarch64/Packages/u/ufw-0.35-35.el10_0.noarch.rpm;name=aarch64_ufw;unpack=0"
SRC_URI:append = " ${URI_aarch64_ufw}"
SRC_URI[aarch64_ufw.sha256sum] = "d7dc7d625b4b1ca1b3818edaa63364c5def4424327804470c493e1ca92329034"

RDEPENDS:ufw = " \
 bash \
 iptables-nft \
 python3 \
 systemd \
 "
