# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-qqc2-desktop-style"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-qqc2-desktop-style \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-qqc2-desktop-style-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d61b2476c8bf60769642f36299dce19953c230aae6769d2efde28148891a3d4c"

URI_x86_64_v2_kf6-qqc2-desktop-style = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-qqc2-desktop-style-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-qqc2-desktop-style;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-qqc2-desktop-style}"
SRC_URI[x86_64_v2_kf6-qqc2-desktop-style.sha256sum] = "e6f2f665acb92048ce7ea869a07a73782813c9c9eb10fe3a6dc96bdfd2475d1a"

URI_aarch64_kf6-qqc2-desktop-style = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-qqc2-desktop-style-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-qqc2-desktop-style;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-qqc2-desktop-style}"
SRC_URI[aarch64_kf6-qqc2-desktop-style.sha256sum] = "00e6b5392b5e13adcf5644491ad6e1f2fcb64f162ae3feb19ccf809805c8cb3b"

RDEPENDS:kf6-qqc2-desktop-style = " \
 cmake-filesystem \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
