# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-WrapI18N"
PV = "0.06"
PR = "51.el10"
PACKAGES = " \
 perl-Text-WrapI18N \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Text-WrapI18N-0.06-51.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bf33ccf02a585e5bee039f4691b782aec0d61787f8fbed4b2ec1b8631ed78da"

URI_x86_64_v2_perl-Text-WrapI18N = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Text-WrapI18N-0.06-51.el10.noarch.rpm;name=x86_64_v2_perl-Text-WrapI18N;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-WrapI18N}"
SRC_URI[x86_64_v2_perl-Text-WrapI18N.sha256sum] = "0567dba138a66896f11bd724507f05589e8887a48f33f769480383b79dcb40bb"

URI_aarch64_perl-Text-WrapI18N = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Text-WrapI18N-0.06-51.el10.noarch.rpm;name=aarch64_perl-Text-WrapI18N;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-WrapI18N}"
SRC_URI[aarch64_perl-Text-WrapI18N.sha256sum] = "0567dba138a66896f11bd724507f05589e8887a48f33f769480383b79dcb40bb"

RDEPENDS:perl-Text-WrapI18N = " \
 perl-Exporter \
 perl-Text-CharWidth \
 perl-libs \
 perl-vars \
 "
