# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-safe-exceptions"
PV = "0.1.7.4"
PR = "1.el10_0"
PACKAGES = " \
 ghc-safe-exceptions \
 ghc-safe-exceptions-devel \
 ghc-safe-exceptions-doc \
 ghc-safe-exceptions-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-safe-exceptions-0.1.7.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ab948e5ec5c61f8ef69720842636e47e7974811647d9aafaef547483544edda"

URI_x86_64_v2_ghc-safe-exceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-safe-exceptions-0.1.7.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-safe-exceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-safe-exceptions}"
SRC_URI[x86_64_v2_ghc-safe-exceptions.sha256sum] = "1dafbadefe668ca7deaeb6da78d3645ff06d60c7cb93ef175e98af746509c240"

URI_x86_64_v2_ghc-safe-exceptions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-safe-exceptions-devel-0.1.7.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-safe-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-safe-exceptions-devel}"
SRC_URI[x86_64_v2_ghc-safe-exceptions-devel.sha256sum] = "3eed7c81fc5a49e63e90345fd9bbaffc12f56b2439500c2c8c027f8949c3ef3a"

URI_x86_64_v2_ghc-safe-exceptions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-safe-exceptions-doc-0.1.7.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-safe-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-safe-exceptions-doc}"
SRC_URI[x86_64_v2_ghc-safe-exceptions-doc.sha256sum] = "5975a944b360041e7f4994b54ee3129d5fadfa89e987fae10076e7ea7a9b1637"

URI_x86_64_v2_ghc-safe-exceptions-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-safe-exceptions-prof-0.1.7.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-safe-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-safe-exceptions-prof}"
SRC_URI[x86_64_v2_ghc-safe-exceptions-prof.sha256sum] = "8313e23c4bdc0d0c629262c305a4ff8da7bc8a00b72f5ce3cb2f6d814207d879"

URI_aarch64_ghc-safe-exceptions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-safe-exceptions-0.1.7.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-safe-exceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-safe-exceptions}"
SRC_URI[aarch64_ghc-safe-exceptions.sha256sum] = "3e1f1c363953ebddd065683ec7b9adda0355f2b1b16883859616bdf15415225e"

URI_aarch64_ghc-safe-exceptions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-safe-exceptions-devel-0.1.7.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-safe-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-safe-exceptions-devel}"
SRC_URI[aarch64_ghc-safe-exceptions-devel.sha256sum] = "395ed019079a1df29345dd5a82131e9208b942b488510705aa29df4317df8c0e"

URI_aarch64_ghc-safe-exceptions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-safe-exceptions-doc-0.1.7.4-1.el10_0.noarch.rpm;name=aarch64_ghc-safe-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-safe-exceptions-doc}"
SRC_URI[aarch64_ghc-safe-exceptions-doc.sha256sum] = "b6fc9710f08f823e37565458afa7059719a822735e3a03776c78a381a0eebdf5"

URI_aarch64_ghc-safe-exceptions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-safe-exceptions-prof-0.1.7.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-safe-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-safe-exceptions-prof}"
SRC_URI[aarch64_ghc-safe-exceptions-prof.sha256sum] = "e6ba546e8984680cd0f51e3fa4c72bc3cc589226f361030fc3e6b69de80a0b76"

RDEPENDS:ghc-safe-exceptions = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-exceptions \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-safe-exceptions-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-exceptions-devel \
 ghc-safe-exceptions \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-safe-exceptions-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-safe-exceptions-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-exceptions-prof \
 ghc-safe-exceptions-devel \
 ghc-transformers-prof \
 "
