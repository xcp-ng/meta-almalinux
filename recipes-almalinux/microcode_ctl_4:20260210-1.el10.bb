# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "microcode_ctl"
PE = "4"
PV = "20260210"
PR = "1.el10"
PACKAGES = " \
 microcode_ctl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/microcode_ctl-20260210-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60a196e1178b7196a488d7d17f83061f0016b6caafa58fc491f42b1949d8042b"

URI_x86_64_v2_microcode_ctl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/microcode_ctl-20260210-1.el10.noarch.rpm;name=x86_64_v2_microcode_ctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_microcode_ctl}"
SRC_URI[x86_64_v2_microcode_ctl.sha256sum] = "15d4a67ec660211869e53ba2a682f7494d8245c2fc1003747db0ce82f0bf486c"

URI_aarch64_microcode_ctl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/microcode_ctl-20260210-1.el10.noarch.rpm;name=aarch64_microcode_ctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_microcode_ctl}"
SRC_URI[aarch64_microcode_ctl.sha256sum] = "15d4a67ec660211869e53ba2a682f7494d8245c2fc1003747db0ce82f0bf486c"

RDEPENDS:microcode_ctl = " \
 bash \
 dracut \
 systemd \
 virtual/coreutils \
 "
