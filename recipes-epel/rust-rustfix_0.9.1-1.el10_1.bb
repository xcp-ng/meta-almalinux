# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustfix"
PV = "0.9.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-rustfix+default-devel \
 rust-rustfix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustfix-0.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14f540893eb8380786e03e49872a7cda1d1c6ced41f167575d9373bc4f5b52fc"

URI_x86_64_v2_rust-rustfix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustfix+default-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustfix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustfix+default-devel}"
SRC_URI[x86_64_v2_rust-rustfix+default-devel.sha256sum] = "9fdbbe713213a62e03cacbf4cf179d8611c22ef3d5efc90c0ea0841ae41c3f7a"

URI_x86_64_v2_rust-rustfix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustfix-devel-0.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustfix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustfix-devel}"
SRC_URI[x86_64_v2_rust-rustfix-devel.sha256sum] = "b24c47c64ac1aa64cc901232cd9598e7338c093452702ad917bd60ec9246d0b2"

URI_aarch64_rust-rustfix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustfix+default-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-rustfix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustfix+default-devel}"
SRC_URI[aarch64_rust-rustfix+default-devel.sha256sum] = "4a7f04599802a7afcffb5c88d991c8ffa452e3448650a13467bdb609558a30ed"

URI_aarch64_rust-rustfix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustfix-devel-0.9.1-1.el10_1.noarch.rpm;name=aarch64_rust-rustfix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustfix-devel}"
SRC_URI[aarch64_rust-rustfix-devel.sha256sum] = "b0d816f24fa4a076e3036aa64376492898fc45ffb2c934aadc3f6586e9983d27"

RDEPENDS:rust-rustfix+default-devel = " \
 cargo \
 rust-rustfix-devel \
 "
RDEPENDS:rust-rustfix-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
