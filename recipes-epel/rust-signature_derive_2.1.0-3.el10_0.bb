# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-signature_derive"
PV = "2.1.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-signature_derive+default-devel \
 rust-signature_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-signature_derive-2.1.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e252dd71c6f81b33be50b51d710b33756a87b8727bf28a985b88c82a62ac6fd2"

URI_x86_64_v2_rust-signature_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature_derive+default-devel-2.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature_derive+default-devel}"
SRC_URI[x86_64_v2_rust-signature_derive+default-devel.sha256sum] = "f70a2ed03fef9c67e4abf7c5f92fc9ca35e5b99f6041b924faff9a14df1d0d57"

URI_x86_64_v2_rust-signature_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature_derive-devel-2.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature_derive-devel}"
SRC_URI[x86_64_v2_rust-signature_derive-devel.sha256sum] = "badca2e3514a2be1a7b85fbcb5717c549c86f6df83b57cb01d70fb157406ff71"

URI_aarch64_rust-signature_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature_derive+default-devel-2.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-signature_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature_derive+default-devel}"
SRC_URI[aarch64_rust-signature_derive+default-devel.sha256sum] = "abe5047cd261e988be7ea7091e20a97b2ad08309e6ac51dbfef4002447c8296c"

URI_aarch64_rust-signature_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature_derive-devel-2.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-signature_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature_derive-devel}"
SRC_URI[aarch64_rust-signature_derive-devel.sha256sum] = "99ad5dad028f3091c2b32bedf905914bcf6159a44f53ba5370212a163b1be8f4"

RDEPENDS:rust-signature_derive+default-devel = " \
 cargo \
 rust-signature_derive-devel \
 "
RDEPENDS:rust-signature_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
