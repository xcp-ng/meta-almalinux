# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcsc-cyberjack"
PV = "3.99.5final.SP16"
PR = "1.el10_1"
PACKAGES = " \
 pcsc-cyberjack \
 pcsc-cyberjack-cjflash \
 pcsc-cyberjack-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pcsc-cyberjack-3.99.5final.SP16-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdca21d2bc397e99527b4c3183488eb1bfb33d9aaa1c3a8fe3e3d52daa84ff00"

URI_x86_64_v2_pcsc-cyberjack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcsc-cyberjack-3.99.5final.SP16-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pcsc-cyberjack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcsc-cyberjack}"
SRC_URI[x86_64_v2_pcsc-cyberjack.sha256sum] = "c011df2b16f7ed6aec25a53b54a3e9714fa48841d741afd47f3648605201452e"

URI_x86_64_v2_pcsc-cyberjack-cjflash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcsc-cyberjack-cjflash-3.99.5final.SP16-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pcsc-cyberjack-cjflash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcsc-cyberjack-cjflash}"
SRC_URI[x86_64_v2_pcsc-cyberjack-cjflash.sha256sum] = "8a24ee62112411fa50ad1cdbf809ff2ea254f940f0a36a3e22d991b003e3f437"

URI_x86_64_v2_pcsc-cyberjack-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcsc-cyberjack-examples-3.99.5final.SP16-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pcsc-cyberjack-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcsc-cyberjack-examples}"
SRC_URI[x86_64_v2_pcsc-cyberjack-examples.sha256sum] = "9000ddc0be4c61fbf89a1f32d2902f7508b4dadaeedb1ae8aa5c14bd86713a98"

URI_aarch64_pcsc-cyberjack = "${EPEL_MIRROR}/aarch64/Packages/p/pcsc-cyberjack-3.99.5final.SP16-1.el10_1.aarch64.rpm;name=aarch64_pcsc-cyberjack;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcsc-cyberjack}"
SRC_URI[aarch64_pcsc-cyberjack.sha256sum] = "927a22be547f9d67adc57d96b8e418ed8c8b0d78a7447895d4a6903cc0e1648b"

URI_aarch64_pcsc-cyberjack-cjflash = "${EPEL_MIRROR}/aarch64/Packages/p/pcsc-cyberjack-cjflash-3.99.5final.SP16-1.el10_1.aarch64.rpm;name=aarch64_pcsc-cyberjack-cjflash;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcsc-cyberjack-cjflash}"
SRC_URI[aarch64_pcsc-cyberjack-cjflash.sha256sum] = "048d4d9f4096b1a173e03c31b52b79c6bcdfc814b0b114b50f96240145207ddf"

URI_aarch64_pcsc-cyberjack-examples = "${EPEL_MIRROR}/aarch64/Packages/p/pcsc-cyberjack-examples-3.99.5final.SP16-1.el10_1.noarch.rpm;name=aarch64_pcsc-cyberjack-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcsc-cyberjack-examples}"
SRC_URI[aarch64_pcsc-cyberjack-examples.sha256sum] = "f4eeeec12b2d7438d8b8ffbaa07e408f63099e364fa98126e5d6e95dac4fe9b3"

RDEPENDS:pcsc-cyberjack = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 libusb1 \
 pcsc-lite \
 systemd \
 systemd-udev \
 "
RDEPENDS:pcsc-cyberjack-cjflash = " \
 glibc \
 libgcc \
 libstdc++ \
 libusb1 \
 pcsc-cyberjack \
 "
RDEPENDS:pcsc-cyberjack-examples = " \
 pcsc-cyberjack \
 "
