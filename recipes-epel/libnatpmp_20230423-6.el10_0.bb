# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnatpmp"
PV = "20230423"
PR = "6.el10_0"
PACKAGES = " \
 libnatpmp \
 libnatpmp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libnatpmp-20230423-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60d6373344a224f8b2823b3ea2287205b3dbe076b023fe326a753ca6208c4ae4"

URI_x86_64_v2_libnatpmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnatpmp-20230423-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnatpmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnatpmp}"
SRC_URI[x86_64_v2_libnatpmp.sha256sum] = "2466560dff656a4697b664e35ab9229f728575185e868e38247735759c030f46"

URI_x86_64_v2_libnatpmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnatpmp-devel-20230423-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnatpmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnatpmp-devel}"
SRC_URI[x86_64_v2_libnatpmp-devel.sha256sum] = "b9d1df51afcb8765b6a675fa2d9806c37c7576e6b7b080912e7cae80d2c91dab"

URI_aarch64_libnatpmp = "${EPEL_MIRROR}/aarch64/Packages/l/libnatpmp-20230423-6.el10_0.aarch64.rpm;name=aarch64_libnatpmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnatpmp}"
SRC_URI[aarch64_libnatpmp.sha256sum] = "781b712b4c3eb126237eb06b5a70d922b5718e5377868c28916dea016d8db8ba"

URI_aarch64_libnatpmp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libnatpmp-devel-20230423-6.el10_0.aarch64.rpm;name=aarch64_libnatpmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnatpmp-devel}"
SRC_URI[aarch64_libnatpmp-devel.sha256sum] = "f3616845b95b0d7deb7d7f2900dfcfefab2d9aa4288ad4497d6096bccefcb73d"

RDEPENDS:libnatpmp = " \
 glibc \
 "
RDEPENDS:libnatpmp-devel = " \
 libnatpmp \
 "
