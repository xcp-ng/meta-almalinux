# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ansiterm"
PV = "0.12.2"
PR = "5.el10_1"
PACKAGES = " \
 rust-ansiterm+ansi_colours-devel \
 rust-ansiterm+default-devel \
 rust-ansiterm+derive_serde_style-devel \
 rust-ansiterm+serde-devel \
 rust-ansiterm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ansiterm-0.12.2-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34f8e8cc2ad7d17241ee2823a292e46993c40430321c79610d7851a1368293fe"

URI_x86_64_v2_rust-ansiterm+ansi_colours-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansiterm+ansi_colours-devel-0.12.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansiterm+ansi_colours-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansiterm+ansi_colours-devel}"
SRC_URI[x86_64_v2_rust-ansiterm+ansi_colours-devel.sha256sum] = "9eef60380899092f545c93600710ed5dcb5b427862137474548e5ce35662e4f7"

URI_x86_64_v2_rust-ansiterm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansiterm+default-devel-0.12.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansiterm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansiterm+default-devel}"
SRC_URI[x86_64_v2_rust-ansiterm+default-devel.sha256sum] = "f127cf451e033009beeafc1e098d78b5cb83b0f03656e22ea370996656d31d62"

URI_x86_64_v2_rust-ansiterm+derive_serde_style-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansiterm+derive_serde_style-devel-0.12.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansiterm+derive_serde_style-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansiterm+derive_serde_style-devel}"
SRC_URI[x86_64_v2_rust-ansiterm+derive_serde_style-devel.sha256sum] = "b8fb300ba54df433e9f6efa90694695da39b0ae868ea57880362e1e26c979fd5"

URI_x86_64_v2_rust-ansiterm+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansiterm+serde-devel-0.12.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansiterm+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansiterm+serde-devel}"
SRC_URI[x86_64_v2_rust-ansiterm+serde-devel.sha256sum] = "f1fa47de2b32b1d48880f9a977b1284beb1fd2280ea5f6920d7eadde80439586"

URI_x86_64_v2_rust-ansiterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansiterm-devel-0.12.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansiterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansiterm-devel}"
SRC_URI[x86_64_v2_rust-ansiterm-devel.sha256sum] = "c1a85ecee746d4e9f23e5ae85896f5adc5b39cd0011d198aa148bb85dded4f74"

URI_aarch64_rust-ansiterm+ansi_colours-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansiterm+ansi_colours-devel-0.12.2-5.el10_1.noarch.rpm;name=aarch64_rust-ansiterm+ansi_colours-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansiterm+ansi_colours-devel}"
SRC_URI[aarch64_rust-ansiterm+ansi_colours-devel.sha256sum] = "57fe975ef79b987fcc52e71f1cc31365196f2ae4b82e618a74673a75b0b30a2d"

URI_aarch64_rust-ansiterm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansiterm+default-devel-0.12.2-5.el10_1.noarch.rpm;name=aarch64_rust-ansiterm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansiterm+default-devel}"
SRC_URI[aarch64_rust-ansiterm+default-devel.sha256sum] = "966c7940d544ae0019d8f4e7c00ba268b05b0ec77a3b4372782cc4f11ae1a52f"

URI_aarch64_rust-ansiterm+derive_serde_style-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansiterm+derive_serde_style-devel-0.12.2-5.el10_1.noarch.rpm;name=aarch64_rust-ansiterm+derive_serde_style-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansiterm+derive_serde_style-devel}"
SRC_URI[aarch64_rust-ansiterm+derive_serde_style-devel.sha256sum] = "f958ea8aebca03751c2500cc75f76444f40395fda6abf53861a90fd60bcc4efa"

URI_aarch64_rust-ansiterm+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansiterm+serde-devel-0.12.2-5.el10_1.noarch.rpm;name=aarch64_rust-ansiterm+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansiterm+serde-devel}"
SRC_URI[aarch64_rust-ansiterm+serde-devel.sha256sum] = "56154a6eeab71686ef043067ce7087b1ff8f91dd647154a2a896c4d924d8e55d"

URI_aarch64_rust-ansiterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansiterm-devel-0.12.2-5.el10_1.noarch.rpm;name=aarch64_rust-ansiterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansiterm-devel}"
SRC_URI[aarch64_rust-ansiterm-devel.sha256sum] = "6fbfd7e584d91e2e3394cfb941a840820ff22a1225157192cab94abfc1b151ce"

RDEPENDS:rust-ansiterm+ansi_colours-devel = " \
 cargo \
 rust-ansi_colours-devel \
 rust-ansiterm-devel \
 "
RDEPENDS:rust-ansiterm+default-devel = " \
 cargo \
 rust-ansiterm-devel \
 "
RDEPENDS:rust-ansiterm+derive_serde_style-devel = " \
 cargo \
 rust-ansiterm+serde-devel \
 rust-ansiterm-devel \
 "
RDEPENDS:rust-ansiterm+serde-devel = " \
 cargo \
 rust-ansiterm-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-ansiterm-devel = " \
 cargo \
 "
