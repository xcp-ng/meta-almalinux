# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gum"
PV = "0.16.1"
PR = "1.el10_1"
PACKAGES = " \
 gum \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gum-0.16.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d13b141234beac6bd377c4f4b5a4989de75f012e130f03c76762c270c390829"

URI_x86_64_v2_gum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gum-0.16.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gum}"
SRC_URI[x86_64_v2_gum.sha256sum] = "2c28c45c0044e8a63c978f943c4685af4d9ecc0133a978c17ac286ee7e8d85d6"

URI_aarch64_gum = "${EPEL_MIRROR}/aarch64/Packages/g/gum-0.16.1-1.el10_1.aarch64.rpm;name=aarch64_gum;unpack=0"
SRC_URI:append = " ${URI_aarch64_gum}"
SRC_URI[aarch64_gum.sha256sum] = "8f808b78c167bf14a5978cde77e79fb9076be00778956a7a0351f145d74ef1cf"

RDEPENDS:gum = " \
 glibc \
 "
