# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "orocos-kdl"
PV = "1.5.1"
PR = "7.el10_1"
PACKAGES = " \
 orocos-kdl \
 orocos-kdl-devel \
 orocos-kdl-doc \
 python3-pykdl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/orocos-kdl-1.5.1-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4622d87a6da40023e83ab39199b0b608664dcfabf628234a0d3c11b655f01cb"

URI_x86_64_v2_orocos-kdl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/orocos-kdl-1.5.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_orocos-kdl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_orocos-kdl}"
SRC_URI[x86_64_v2_orocos-kdl.sha256sum] = "0ae8cf838e2f5f6cadc66db027b93c44a77e23a66c5fa38647541c982b32f3a5"

URI_x86_64_v2_orocos-kdl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/orocos-kdl-devel-1.5.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_orocos-kdl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_orocos-kdl-devel}"
SRC_URI[x86_64_v2_orocos-kdl-devel.sha256sum] = "4d27dbdd24d8b9dcdfc7dd1a304f8d801acbe5b7e682cb6bd3aa3e7612b79791"

URI_x86_64_v2_orocos-kdl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/orocos-kdl-doc-1.5.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_orocos-kdl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_orocos-kdl-doc}"
SRC_URI[x86_64_v2_orocos-kdl-doc.sha256sum] = "d3dd720c34e228a2e7f9b6f97ebd639cb1546c2a0874bed27ae2e57f03b94afa"

URI_x86_64_v2_python3-pykdl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pykdl-1.5.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pykdl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pykdl}"
SRC_URI[x86_64_v2_python3-pykdl.sha256sum] = "67aae3483747eacc04bafd65b553a8b5021cf03eb08f5b528206b31df389d514"

URI_aarch64_orocos-kdl = "${EPEL_MIRROR}/aarch64/Packages/o/orocos-kdl-1.5.1-7.el10_1.aarch64.rpm;name=aarch64_orocos-kdl;unpack=0"
SRC_URI:append = " ${URI_aarch64_orocos-kdl}"
SRC_URI[aarch64_orocos-kdl.sha256sum] = "36bc53680b8e3fd8d51ff82ff096a18ec48d460a508defcd590b4c02122eea3e"

URI_aarch64_orocos-kdl-devel = "${EPEL_MIRROR}/aarch64/Packages/o/orocos-kdl-devel-1.5.1-7.el10_1.aarch64.rpm;name=aarch64_orocos-kdl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_orocos-kdl-devel}"
SRC_URI[aarch64_orocos-kdl-devel.sha256sum] = "83146db258f19f445afd800abfcb65ccf05b1e4e7ce04cfe361533c971c7b0e1"

URI_aarch64_orocos-kdl-doc = "${EPEL_MIRROR}/aarch64/Packages/o/orocos-kdl-doc-1.5.1-7.el10_1.noarch.rpm;name=aarch64_orocos-kdl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_orocos-kdl-doc}"
SRC_URI[aarch64_orocos-kdl-doc.sha256sum] = "bb0c8ed97121a25f5173094601b187470079163501352a4b27fe3101a53fe03e"

URI_aarch64_python3-pykdl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pykdl-1.5.1-7.el10_1.aarch64.rpm;name=aarch64_python3-pykdl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pykdl}"
SRC_URI[aarch64_python3-pykdl.sha256sum] = "c5aa28497eb04e1103994d93ca118fbb452f44521ec20c08cc675810c67ca401"

RDEPENDS:orocos-kdl = " \
 eigen3-devel \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:orocos-kdl-devel = " \
 orocos-kdl \
 pkgconf-pkg-config \
 "
RDEPENDS:orocos-kdl-doc = " \
 "
RDEPENDS:python3-pykdl = " \
 glibc \
 libgcc \
 libstdc++ \
 orocos-kdl \
 python3 \
 "
