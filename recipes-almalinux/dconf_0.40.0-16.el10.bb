# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dconf"
PV = "0.40.0"
PR = "16.el10"
PACKAGES = " \
 dconf \
 dconf-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dconf-0.40.0-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f76ba4b81c5d3cd5bfb3fd8936e5248bcf168fd54c7cba221dc918ab73294dea"

URI_x86_64_v2_dconf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dconf-0.40.0-16.el10.x86_64_v2.rpm;name=x86_64_v2_dconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dconf}"
SRC_URI[x86_64_v2_dconf.sha256sum] = "5a99f6bd9ab89b9d07bd3e027b29a4287d971b43794798aba8585f94e95f2dc6"

URI_x86_64_v2_dconf-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dconf-devel-0.40.0-16.el10.x86_64_v2.rpm;name=x86_64_v2_dconf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dconf-devel}"
SRC_URI[x86_64_v2_dconf-devel.sha256sum] = "a26c8ed098577fa35b764016b31275c132405c56e20473d236117fc789338e0d"

URI_aarch64_dconf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dconf-0.40.0-16.el10.aarch64.rpm;name=aarch64_dconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_dconf}"
SRC_URI[aarch64_dconf.sha256sum] = "86534d6db23361b65d9c35fdb299d07d2391d6a6280f15081ef6dd7221885d33"

URI_aarch64_dconf-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dconf-devel-0.40.0-16.el10.aarch64.rpm;name=aarch64_dconf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dconf-devel}"
SRC_URI[aarch64_dconf-devel.sha256sum] = "0bd4d9e5b1c0a908c8a91f269925f0eeebcec21bdff4903c68cc0010d59f2b56"

RDEPENDS:dconf = " \
 bash \
 dbus \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:dconf-devel = " \
 dconf \
 glib2-devel \
 pkgconf-pkg-config \
 "
