# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "frr"
PV = "10.6.1"
PR = "3.el10"
PACKAGES = " \
 frr \
 frr-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/frr-10.6.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "212c9c6f84dbb0e5813ababb87b8b4763b15da0c6c534dab788982599b35cf9b"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - frr: libcap.so.2()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/frr-10.6.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_frr;unpack=0"
SRC_URI[x86_64_v2_frr.sha256sum] = "b512bdf08966e915f7a4a981ed5be2e552e6fd0f69b5f699eeef348ad9ec4274"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/frr-selinux-10.6.1-3.el10.noarch.rpm;name=x86_64_v2_frr-selinux;unpack=0"
SRC_URI[x86_64_v2_frr-selinux.sha256sum] = "68c7ccd926cb05442fb1c5b88ee9dc285f61c64d30af8dad1cc03d0ab93d8308"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/frr-10.6.1-3.el10.aarch64.rpm;name=aarch64_frr;unpack=0"
SRC_URI[aarch64_frr.sha256sum] = "b53c5c01c9c9b5fbe881d025204c764bee21917ed538eca2db0ff4e8f6e139fb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/frr-selinux-10.6.1-3.el10.noarch.rpm;name=aarch64_frr-selinux;unpack=0"
SRC_URI[aarch64_frr-selinux.sha256sum] = "68c7ccd926cb05442fb1c5b88ee9dc285f61c64d30af8dad1cc03d0ab93d8308"

RDEPENDS:frr:x86_64_v2 = " \
 bash \
 c-ares \
 frr-selinux \
 glibc \
 hostname \
 json-c \
 libcap \
 libgcc \
 libxcrypt \
 libyang \
 ncurses \
 net-snmp \
 net-snmp-agent-libs \
 net-snmp-libs \
 openssl-libs \
 protobuf-c \
 python3 \
 readline \
 shadow-utils \
 systemd \
"
RDEPENDS:frr:aarch64 = " \
 bash \
 c-ares \
 frr-selinux \
 glibc \
 hostname \
 json-c \
 libatomic \
 libgcc \
 libxcrypt \
 libyang \
 ncurses \
 net-snmp \
 net-snmp-agent-libs \
 net-snmp-libs \
 openssl-libs \
 protobuf-c \
 python3 \
 readline \
 shadow-utils \
 systemd \
"
RDEPENDS:frr-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
