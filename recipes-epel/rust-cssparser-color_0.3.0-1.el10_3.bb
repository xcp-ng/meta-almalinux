# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cssparser-color"
PV = "0.3.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-cssparser-color+default-devel \
 rust-cssparser-color+serde-devel \
 rust-cssparser-color-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cssparser-color-0.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27edd795bb70209310e7b2132168b6f7c9bb0f3bc06d59e2ef1ddd05ebb0378a"

URI_x86_64_v2_rust-cssparser-color+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cssparser-color+default-devel-0.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cssparser-color+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cssparser-color+default-devel}"
SRC_URI[x86_64_v2_rust-cssparser-color+default-devel.sha256sum] = "f93061f73eb20b555e0d4538f7ced9afa9b92f827312a40188a9daafc8e37c6d"

URI_x86_64_v2_rust-cssparser-color+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cssparser-color+serde-devel-0.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cssparser-color+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cssparser-color+serde-devel}"
SRC_URI[x86_64_v2_rust-cssparser-color+serde-devel.sha256sum] = "821acab2ee7d57c3bb55058f0e5be9859a092282fbe7d7cdae0f9c2a08b209ff"

URI_x86_64_v2_rust-cssparser-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cssparser-color-devel-0.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cssparser-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cssparser-color-devel}"
SRC_URI[x86_64_v2_rust-cssparser-color-devel.sha256sum] = "764f6bc1b75823edb6637d7ec4cb166c6a74af856d0fbe723994ac3d20a1a586"

URI_aarch64_rust-cssparser-color+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cssparser-color+default-devel-0.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-cssparser-color+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cssparser-color+default-devel}"
SRC_URI[aarch64_rust-cssparser-color+default-devel.sha256sum] = "579a314bb2d83d113b36fb5869ffbd303df9694b8a6ab160b2507c190260f980"

URI_aarch64_rust-cssparser-color+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cssparser-color+serde-devel-0.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-cssparser-color+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cssparser-color+serde-devel}"
SRC_URI[aarch64_rust-cssparser-color+serde-devel.sha256sum] = "3dee1eac958f50c9c155f0c44b893c86b3766748b2adc2c8ed3209855d4bb53a"

URI_aarch64_rust-cssparser-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cssparser-color-devel-0.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-cssparser-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cssparser-color-devel}"
SRC_URI[aarch64_rust-cssparser-color-devel.sha256sum] = "82290d5f86958cda528a0642a83fb1e35221c3ccbd2ee498c85efeb41907d441"

RDEPENDS:rust-cssparser-color+default-devel = " \
 cargo \
 rust-cssparser-color-devel \
 "
RDEPENDS:rust-cssparser-color+serde-devel = " \
 cargo \
 rust-cssparser+serde-devel \
 rust-cssparser-color-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-cssparser-color-devel = " \
 cargo \
 rust-cssparser+default-devel \
 "
