# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "simdjson"
PV = "3.12.3"
PR = "1.el10_0"
PACKAGES = " \
 simdjson \
 simdjson-devel \
 simdjson-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/simdjson-3.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62dc4c5388ca04e3a53e35746d577f9d54a03c34c6a50d6310f16660243d2cf4"

URI_x86_64_v2_simdjson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simdjson-3.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_simdjson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_simdjson}"
SRC_URI[x86_64_v2_simdjson.sha256sum] = "09303288607eb3d8640a00122f66515b0075257ca2a1427b46ba19f29926bd75"

URI_x86_64_v2_simdjson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simdjson-devel-3.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_simdjson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_simdjson-devel}"
SRC_URI[x86_64_v2_simdjson-devel.sha256sum] = "b8d8ba0f9e331388b792365760de9ea99ab6ecfa0afe002e62efeb54359e8c95"

URI_x86_64_v2_simdjson-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simdjson-doc-3.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_simdjson-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_simdjson-doc}"
SRC_URI[x86_64_v2_simdjson-doc.sha256sum] = "af43e53666ca1ec803b450a3ec478314dfcde6366dd1a4e4a53d4ddaee657b46"

URI_aarch64_simdjson = "${EPEL_MIRROR}/aarch64/Packages/s/simdjson-3.12.3-1.el10_0.aarch64.rpm;name=aarch64_simdjson;unpack=0"
SRC_URI:append = " ${URI_aarch64_simdjson}"
SRC_URI[aarch64_simdjson.sha256sum] = "7c90359972ea8c52e5528c888ec8208550f36bfeac22bc401dadd10df598b619"

URI_aarch64_simdjson-devel = "${EPEL_MIRROR}/aarch64/Packages/s/simdjson-devel-3.12.3-1.el10_0.aarch64.rpm;name=aarch64_simdjson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_simdjson-devel}"
SRC_URI[aarch64_simdjson-devel.sha256sum] = "e635d94cd8c7ace591ada7495717090719325d809cb68a0c98de4704d2367968"

URI_aarch64_simdjson-doc = "${EPEL_MIRROR}/aarch64/Packages/s/simdjson-doc-3.12.3-1.el10_0.aarch64.rpm;name=aarch64_simdjson-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_simdjson-doc}"
SRC_URI[aarch64_simdjson-doc.sha256sum] = "0c192380e51a8af5ae99fd87b5019395ff6c2fee109da6a99acc808d7e636085"

RDEPENDS:simdjson = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:simdjson-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 simdjson \
 "
RDEPENDS:simdjson-doc = " \
 "
