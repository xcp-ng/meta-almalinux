# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "webkitgtk"
PV = "2.48.3"
PR = "1.el10_1"
PACKAGES = " \
 javascriptcoregtk4.1 \
 javascriptcoregtk4.1-devel \
 javascriptcoregtk6.0 \
 javascriptcoregtk6.0-devel \
 webkit2gtk4.1 \
 webkit2gtk4.1-devel \
 webkit2gtk4.1-doc \
 webkitgtk6.0 \
 webkitgtk6.0-devel \
 webkitgtk6.0-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/webkitgtk-2.48.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b967bf12d7b093122e4831d959b5769d118c4433cc903e6af00c1e13d2ddc04"

URI_x86_64_v2_javascriptcoregtk4.1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk4.1-2.48.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk4.1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk4.1}"
SRC_URI[x86_64_v2_javascriptcoregtk4.1.sha256sum] = "b9bf800f95eef25e006b347e634f939ce8c18e36414db7210a6cef4c76f5fd9b"

URI_x86_64_v2_javascriptcoregtk4.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk4.1-devel-2.48.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk4.1-devel}"
SRC_URI[x86_64_v2_javascriptcoregtk4.1-devel.sha256sum] = "ec84d100eeb66ebc6fd694f72eab65f12f64a53f1862af132addace713c44de7"

URI_x86_64_v2_javascriptcoregtk6.0 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk6.0-2.48.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk6.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk6.0}"
SRC_URI[x86_64_v2_javascriptcoregtk6.0.sha256sum] = "6744069d5a415b212d0b625ac31e709fa39e529b30b3de5d89dae2ece440db5b"

URI_x86_64_v2_javascriptcoregtk6.0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk6.0-devel-2.48.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk6.0-devel}"
SRC_URI[x86_64_v2_javascriptcoregtk6.0-devel.sha256sum] = "a941cdc096222a39c62f544727996d367749471ac95b5c17edbdca3c134bad0c"

URI_x86_64_v2_webkit2gtk4.1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkit2gtk4.1-2.48.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkit2gtk4.1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkit2gtk4.1}"
SRC_URI[x86_64_v2_webkit2gtk4.1.sha256sum] = "20bade81cd3b6a53555acb8cf45c7022f01da9c962ae17e746374841184768a1"

URI_x86_64_v2_webkit2gtk4.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkit2gtk4.1-devel-2.48.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkit2gtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkit2gtk4.1-devel}"
SRC_URI[x86_64_v2_webkit2gtk4.1-devel.sha256sum] = "923776e494ea4ff3a4b9408a05488fecd63069fae1895c0bb362e788734313cc"

URI_x86_64_v2_webkit2gtk4.1-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkit2gtk4.1-doc-2.48.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_webkit2gtk4.1-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkit2gtk4.1-doc}"
SRC_URI[x86_64_v2_webkit2gtk4.1-doc.sha256sum] = "4164a52b83881a583235677e0c2686fa7c5f41df457f61e523c6da0edf1515d7"

URI_x86_64_v2_webkitgtk6.0 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkitgtk6.0-2.48.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkitgtk6.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkitgtk6.0}"
SRC_URI[x86_64_v2_webkitgtk6.0.sha256sum] = "c4734056a11b2eb997e7e4c46919725ae2fab01b11fd343d22f8a3a1c0295154"

URI_x86_64_v2_webkitgtk6.0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkitgtk6.0-devel-2.48.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkitgtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkitgtk6.0-devel}"
SRC_URI[x86_64_v2_webkitgtk6.0-devel.sha256sum] = "76ed0b409506f766ad7b4836404408d7d67baac1c11b216256fbf21c94947ee2"

URI_x86_64_v2_webkitgtk6.0-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkitgtk6.0-doc-2.48.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_webkitgtk6.0-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkitgtk6.0-doc}"
SRC_URI[x86_64_v2_webkitgtk6.0-doc.sha256sum] = "5196b0ce4a141dc3dac72cc18ab6d76fe3a8af301ec98bb83b4059a97a9c2e1f"

URI_aarch64_javascriptcoregtk4.1 = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk4.1-2.48.3-1.el10_1.aarch64.rpm;name=aarch64_javascriptcoregtk4.1;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk4.1}"
SRC_URI[aarch64_javascriptcoregtk4.1.sha256sum] = "b71ca8ba00eaedc33eb03e66b1d4e58ade279df3a8a56a351414f5c70c84c789"

URI_aarch64_javascriptcoregtk4.1-devel = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk4.1-devel-2.48.3-1.el10_1.aarch64.rpm;name=aarch64_javascriptcoregtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk4.1-devel}"
SRC_URI[aarch64_javascriptcoregtk4.1-devel.sha256sum] = "5f7ed4c1ff2594b36e4d918f43ee6e9bf62a677680560861cf198442d29982a1"

URI_aarch64_javascriptcoregtk6.0 = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk6.0-2.48.3-1.el10_1.aarch64.rpm;name=aarch64_javascriptcoregtk6.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk6.0}"
SRC_URI[aarch64_javascriptcoregtk6.0.sha256sum] = "48c71d53473fb61cbc364fce3ec44fa9939254378bd7614af96fe724547b8878"

URI_aarch64_javascriptcoregtk6.0-devel = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk6.0-devel-2.48.3-1.el10_1.aarch64.rpm;name=aarch64_javascriptcoregtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk6.0-devel}"
SRC_URI[aarch64_javascriptcoregtk6.0-devel.sha256sum] = "e01bc1b993ee08214e037f38b3ee9a1723c4b5c37df8e729de379d04a734d64c"

URI_aarch64_webkit2gtk4.1 = "${EPEL_MIRROR}/aarch64/Packages/w/webkit2gtk4.1-2.48.3-1.el10_1.aarch64.rpm;name=aarch64_webkit2gtk4.1;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkit2gtk4.1}"
SRC_URI[aarch64_webkit2gtk4.1.sha256sum] = "bee6130920f2ef8c0ca3eefa24001d560de8c1018af1d32dcdee824935eacb36"

URI_aarch64_webkit2gtk4.1-devel = "${EPEL_MIRROR}/aarch64/Packages/w/webkit2gtk4.1-devel-2.48.3-1.el10_1.aarch64.rpm;name=aarch64_webkit2gtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkit2gtk4.1-devel}"
SRC_URI[aarch64_webkit2gtk4.1-devel.sha256sum] = "13aff0380393e4ab72e33cdc816d09d70b400934865a1e3c79beb7499f957f6d"

URI_aarch64_webkit2gtk4.1-doc = "${EPEL_MIRROR}/aarch64/Packages/w/webkit2gtk4.1-doc-2.48.3-1.el10_1.noarch.rpm;name=aarch64_webkit2gtk4.1-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkit2gtk4.1-doc}"
SRC_URI[aarch64_webkit2gtk4.1-doc.sha256sum] = "aa50e893e51b851f5d0358a3a367b05c46905e669fa9cfd5f3dc23a1db310218"

URI_aarch64_webkitgtk6.0 = "${EPEL_MIRROR}/aarch64/Packages/w/webkitgtk6.0-2.48.3-1.el10_1.aarch64.rpm;name=aarch64_webkitgtk6.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkitgtk6.0}"
SRC_URI[aarch64_webkitgtk6.0.sha256sum] = "78e5c52ee90b650447b0faee42f165e3fa5886a0a3f4231c07fe6198180843dc"

URI_aarch64_webkitgtk6.0-devel = "${EPEL_MIRROR}/aarch64/Packages/w/webkitgtk6.0-devel-2.48.3-1.el10_1.aarch64.rpm;name=aarch64_webkitgtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkitgtk6.0-devel}"
SRC_URI[aarch64_webkitgtk6.0-devel.sha256sum] = "51d6018d0936aaaed2b05baf1445fe08e5f3838b114f09e813de20d3559933f5"

URI_aarch64_webkitgtk6.0-doc = "${EPEL_MIRROR}/aarch64/Packages/w/webkitgtk6.0-doc-2.48.3-1.el10_1.noarch.rpm;name=aarch64_webkitgtk6.0-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkitgtk6.0-doc}"
SRC_URI[aarch64_webkitgtk6.0-doc.sha256sum] = "18d3a405d40b5520b38951ba54072f3378ee5ff4fdb84142e1791dfa1cb93a68"

RDEPENDS:javascriptcoregtk4.1 = " \
 glib2 \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 systemd-libs \
 "
RDEPENDS:javascriptcoregtk4.1-devel = " \
 glib2-devel \
 glibc \
 javascriptcoregtk4.1 \
 libstdc++ \
 pkgconf-pkg-config \
 "
RDEPENDS:javascriptcoregtk6.0 = " \
 glib2 \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 systemd-libs \
 "
RDEPENDS:javascriptcoregtk6.0-devel = " \
 glib2-devel \
 glibc \
 javascriptcoregtk6.0 \
 libstdc++ \
 pkgconf-pkg-config \
 "
RDEPENDS:webkit2gtk4.1:x86_64_v2 = " \
 atk \
 bubblewrap \
 cairo \
 enchant2 \
 expat \
 flite \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk3 \
 harfbuzz \
 harfbuzz-icu \
 hyphen \
 javascriptcoregtk4.1 \
 lcms2 \
 libX11 \
 libavif \
 libdrm \
 libepoxy \
 libgcrypt \
 libglvnd-gles \
 libicu \
 libjpeg-turbo \
 libjxl \
 libmanette \
 libpng \
 libseccomp \
 libsecret \
 libsoup3 \
 libstdc++ \
 libtasn1 \
 libwayland-client \
 libwayland-server \
 libwebp \
 libxml2 \
 libxslt \
 mesa-libgbm \
 pango \
 sqlite-libs \
 systemd-libs \
 woff2 \
 xdg-dbus-proxy \
 zlib-ng-compat \
"
RDEPENDS:webkit2gtk4.1:aarch64 = " \
 atk \
 bubblewrap \
 cairo \
 enchant2 \
 expat \
 flite \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk3 \
 harfbuzz \
 harfbuzz-icu \
 hyphen \
 javascriptcoregtk4.1 \
 lcms2 \
 libX11 \
 libavif \
 libdrm \
 libepoxy \
 libgcc \
 libgcrypt \
 libglvnd-gles \
 libicu \
 libjpeg-turbo \
 libjxl \
 libmanette \
 libpng \
 libseccomp \
 libsecret \
 libsoup3 \
 libstdc++ \
 libtasn1 \
 libwayland-client \
 libwayland-server \
 libwebp \
 libxml2 \
 libxslt \
 mesa-libgbm \
 pango \
 sqlite-libs \
 systemd-libs \
 woff2 \
 xdg-dbus-proxy \
 zlib-ng-compat \
"
RDEPENDS:webkit2gtk4.1-devel = " \
 cairo \
 glib2 \
 glib2-devel \
 glibc \
 gstreamer1 \
 gtk3 \
 gtk3-devel \
 javascriptcoregtk4.1 \
 javascriptcoregtk4.1-devel \
 libsoup3-devel \
 pkgconf-pkg-config \
 webkit2gtk4.1 \
 "
RDEPENDS:webkit2gtk4.1-doc = " \
 webkit2gtk4.1 \
 "
RDEPENDS:webkitgtk6.0:x86_64_v2 = " \
 bubblewrap \
 cairo \
 enchant2 \
 expat \
 flite \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk4 \
 harfbuzz \
 harfbuzz-icu \
 hyphen \
 javascriptcoregtk6.0 \
 lcms2 \
 libX11 \
 libavif \
 libdrm \
 libepoxy \
 libgcrypt \
 libglvnd-gles \
 libicu \
 libjpeg-turbo \
 libjxl \
 libmanette \
 libpng \
 libseccomp \
 libsecret \
 libsoup3 \
 libstdc++ \
 libtasn1 \
 libwayland-client \
 libwayland-server \
 libwebp \
 libxml2 \
 libxslt \
 mesa-libgbm \
 pango \
 sqlite-libs \
 systemd-libs \
 woff2 \
 xdg-dbus-proxy \
 zlib-ng-compat \
"
RDEPENDS:webkitgtk6.0:aarch64 = " \
 bubblewrap \
 cairo \
 enchant2 \
 expat \
 flite \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk4 \
 harfbuzz \
 harfbuzz-icu \
 hyphen \
 javascriptcoregtk6.0 \
 lcms2 \
 libX11 \
 libavif \
 libdrm \
 libepoxy \
 libgcc \
 libgcrypt \
 libglvnd-gles \
 libicu \
 libjpeg-turbo \
 libjxl \
 libmanette \
 libpng \
 libseccomp \
 libsecret \
 libsoup3 \
 libstdc++ \
 libtasn1 \
 libwayland-client \
 libwayland-server \
 libwebp \
 libxml2 \
 libxslt \
 mesa-libgbm \
 pango \
 sqlite-libs \
 systemd-libs \
 woff2 \
 xdg-dbus-proxy \
 zlib-ng-compat \
"
RDEPENDS:webkitgtk6.0-devel = " \
 glib2 \
 glib2-devel \
 glibc \
 gstreamer1 \
 gtk4 \
 gtk4-devel \
 javascriptcoregtk6.0 \
 javascriptcoregtk6.0-devel \
 libsoup3-devel \
 pkgconf-pkg-config \
 webkitgtk6.0 \
 "
RDEPENDS:webkitgtk6.0-doc = " \
 webkitgtk6.0 \
 "
