# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fence-agents"
PV = "4.16.0"
PR = "13.el10_1.4"
PACKAGES:x86_64_v2 = " \
 fence-agents-aliyun \
 fence-agents-all \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-aws \
 fence-agents-azure-arm \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-common \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-gce \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibm-powervs \
 fence-agents-ibm-vpc \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-kubevirt \
 fence-agents-lpar \
 fence-agents-mpath \
 fence-agents-nutanix-ahv \
 fence-agents-openstack \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-virsh \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
 fence-virt \
 fence-virtd \
 fence-virtd-cpg \
 fence-virtd-libvirt \
 fence-virtd-multicast \
 fence-virtd-serial \
 fence-virtd-tcp \
 ha-cloud-support \
"
PACKAGES:aarch64 = " \
 fence-agents-all \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-common \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibm-powervs \
 fence-agents-ibm-vpc \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-kubevirt \
 fence-agents-lpar \
 fence-agents-mpath \
 fence-agents-nutanix-ahv \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-virsh \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fence-agents-4.16.0-13.el10_1.4.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9471faa0bf436ab155160c0059046fbae06d75e990407413831e09d122d46768"

URI_x86_64_v2_fence-agents-aliyun = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-aliyun-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-agents-aliyun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-aliyun}"
SRC_URI[x86_64_v2_fence-agents-aliyun.sha256sum] = "54c6f470faf95e690fb1f1c5c0f5697518159858e34a353c47cb6dd759941069"

URI_x86_64_v2_fence-agents-all = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-all-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-agents-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-all}"
SRC_URI[x86_64_v2_fence-agents-all.sha256sum] = "70062f24771479677b6d47ace24a5cb5518ddcf3b7d957d1f68a0de3e107d133"

URI_x86_64_v2_fence-agents-amt-ws = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-amt-ws-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-amt-ws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-amt-ws}"
SRC_URI[x86_64_v2_fence-agents-amt-ws.sha256sum] = "50d72f9cd4bfd7fc65eda01bf150a90be24a153c30f99417eafef8877077ef4f"

URI_x86_64_v2_fence-agents-apc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-apc-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-apc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-apc}"
SRC_URI[x86_64_v2_fence-agents-apc.sha256sum] = "40c0afa796c637960ff90f2cfa52b86d0cacb83953ec58ab14345b545c796177"

URI_x86_64_v2_fence-agents-apc-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-apc-snmp-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-apc-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-apc-snmp}"
SRC_URI[x86_64_v2_fence-agents-apc-snmp.sha256sum] = "09586142e4db307e44af085e6d66ca117ddb082e918e1309383706cd2066a5fb"

URI_x86_64_v2_fence-agents-aws = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-aws-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-agents-aws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-aws}"
SRC_URI[x86_64_v2_fence-agents-aws.sha256sum] = "2926b19b232cbf814140146d3b6ffd5c1f9ebda88a254d5cd0538a23e4351291"

URI_x86_64_v2_fence-agents-azure-arm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-azure-arm-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-agents-azure-arm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-azure-arm}"
SRC_URI[x86_64_v2_fence-agents-azure-arm.sha256sum] = "aaf369d040756b845d35c4e7ef2f59c2e5623c8615b6f2dea9691e133176dcd2"

URI_x86_64_v2_fence-agents-bladecenter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-bladecenter-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-bladecenter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-bladecenter}"
SRC_URI[x86_64_v2_fence-agents-bladecenter.sha256sum] = "7cf03088b1ac60084af803034abc88eee26cda8c5dc406e92919eb9b828815d1"

URI_x86_64_v2_fence-agents-brocade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-brocade-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-brocade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-brocade}"
SRC_URI[x86_64_v2_fence-agents-brocade.sha256sum] = "cabe63c7a87f4e060900aacf939c987a516b2cc485369cf76c1b74b3952f84a5"

URI_x86_64_v2_fence-agents-cisco-mds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-cisco-mds-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-cisco-mds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-cisco-mds}"
SRC_URI[x86_64_v2_fence-agents-cisco-mds.sha256sum] = "5ae3ab516c0776437ae1e4e1df064d5dafe0016b631e2e4939329b809f783d1c"

URI_x86_64_v2_fence-agents-cisco-ucs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-cisco-ucs-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-cisco-ucs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-cisco-ucs}"
SRC_URI[x86_64_v2_fence-agents-cisco-ucs.sha256sum] = "0b3ac254ae6065db9f3fd8a0c18b3424ef60815dc8bb7f87d8eb11362937ec5a"

URI_x86_64_v2_fence-agents-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-common-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-agents-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-common}"
SRC_URI[x86_64_v2_fence-agents-common.sha256sum] = "e4ed752e65b62fd8aed3b75446a6d43aef4b72ab46e6dbdf9001f11421131d53"

URI_x86_64_v2_fence-agents-drac5 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-drac5-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-drac5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-drac5}"
SRC_URI[x86_64_v2_fence-agents-drac5.sha256sum] = "44c48ba2985bbd6100acb5c3a1e64b8abb8016a8f37a003f818be1dbb1cd7be1"

URI_x86_64_v2_fence-agents-eaton-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-eaton-snmp-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-eaton-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-eaton-snmp}"
SRC_URI[x86_64_v2_fence-agents-eaton-snmp.sha256sum] = "5bbf406dfcb2db87c03f2e1476b6f4bc929ba44acfb45465741d4d61fc492f16"

URI_x86_64_v2_fence-agents-emerson = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-emerson-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-emerson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-emerson}"
SRC_URI[x86_64_v2_fence-agents-emerson.sha256sum] = "5c59da8d7daed25a631ae45abc16a7f5d047cb0cf850d686b5846e1f7bffcd04"

URI_x86_64_v2_fence-agents-eps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-eps-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-eps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-eps}"
SRC_URI[x86_64_v2_fence-agents-eps.sha256sum] = "9e75484bc74cfb7036a82ffa29ba58bc70d67e8076f54e44aeae4ffd1ba6000a"

URI_x86_64_v2_fence-agents-gce = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-gce-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-agents-gce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-gce}"
SRC_URI[x86_64_v2_fence-agents-gce.sha256sum] = "c225734037de3bbb1c665140caf6d9c7724d71920ff217f0de88f2ac0e06c638"

URI_x86_64_v2_fence-agents-heuristics-ping = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-heuristics-ping-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-heuristics-ping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-heuristics-ping}"
SRC_URI[x86_64_v2_fence-agents-heuristics-ping.sha256sum] = "bc8d9c8343a67f6a7dcbf1e4f3bc8e4d99d8d9e5a09b9148da2c2788de117719"

URI_x86_64_v2_fence-agents-hpblade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-hpblade-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-hpblade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-hpblade}"
SRC_URI[x86_64_v2_fence-agents-hpblade.sha256sum] = "67dcec47ae4e519a1254f1d0d4447a97229f4d8236f69bbabc49ec054e90b7c3"

URI_x86_64_v2_fence-agents-ibm-powervs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibm-powervs-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-ibm-powervs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ibm-powervs}"
SRC_URI[x86_64_v2_fence-agents-ibm-powervs.sha256sum] = "38d9040e1f453db74c8e54ba21913fdfb555b66517d459944484715a2ba2580b"

URI_x86_64_v2_fence-agents-ibm-vpc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibm-vpc-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-ibm-vpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ibm-vpc}"
SRC_URI[x86_64_v2_fence-agents-ibm-vpc.sha256sum] = "6417b2cb1571024cbdd6477e43dd1aef148a7586627d30ed79b36c7e004257c4"

URI_x86_64_v2_fence-agents-ibmblade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibmblade-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-ibmblade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ibmblade}"
SRC_URI[x86_64_v2_fence-agents-ibmblade.sha256sum] = "19e840c25ceadfce471169e2ef7ebb31beefab58c7b698de272228a8fac31f95"

URI_x86_64_v2_fence-agents-ifmib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ifmib-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-ifmib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ifmib}"
SRC_URI[x86_64_v2_fence-agents-ifmib.sha256sum] = "f7e882281033fac4fdebd0fc3fee4c4d0b17d9d72ddb8c2bd68fb27b52ee4415"

URI_x86_64_v2_fence-agents-ilo-moonshot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-moonshot-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-ilo-moonshot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo-moonshot}"
SRC_URI[x86_64_v2_fence-agents-ilo-moonshot.sha256sum] = "08ad9c154bff120cd30dd79d5edebee89b06ccf3c9a3b9a3887b9002d2a2563a"

URI_x86_64_v2_fence-agents-ilo-mp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-mp-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-ilo-mp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo-mp}"
SRC_URI[x86_64_v2_fence-agents-ilo-mp.sha256sum] = "7e4ae4eb44f25cade6f76ff2e2bc0877f8d862923348598643bceded08a51f9f"

URI_x86_64_v2_fence-agents-ilo-ssh = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-ssh-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-ilo-ssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo-ssh}"
SRC_URI[x86_64_v2_fence-agents-ilo-ssh.sha256sum] = "1da76611feaa508e56b3c5492319c66464d86fc378d78132b629b7fbcca5efce"

URI_x86_64_v2_fence-agents-ilo2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo2-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-ilo2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo2}"
SRC_URI[x86_64_v2_fence-agents-ilo2.sha256sum] = "4429f1c854aa2512515e7262f7cbedd9f1085cc4cf92dc85717b4a2bd73b8c4e"

URI_x86_64_v2_fence-agents-intelmodular = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-intelmodular-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-intelmodular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-intelmodular}"
SRC_URI[x86_64_v2_fence-agents-intelmodular.sha256sum] = "0bbfb1e37e90d4e1432c9cec542413d6cf6451bd90df505848818795123be95e"

URI_x86_64_v2_fence-agents-ipdu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ipdu-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-ipdu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ipdu}"
SRC_URI[x86_64_v2_fence-agents-ipdu.sha256sum] = "e912eb61d4955627962a2623da6f10773cbb01d18ef74d72d0f9cbf4fd99a549"

URI_x86_64_v2_fence-agents-ipmilan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ipmilan-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-ipmilan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ipmilan}"
SRC_URI[x86_64_v2_fence-agents-ipmilan.sha256sum] = "b64c8fe552f889c877f9e42378e9281f99de9ac1b476314f740de35a37e2b078"

URI_x86_64_v2_fence-agents-kdump = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-kdump-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-agents-kdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-kdump}"
SRC_URI[x86_64_v2_fence-agents-kdump.sha256sum] = "2da5b1688c609747cc0da786c7faced6dd83f5fe841e4c7e3a23f8a9efd8c546"

URI_x86_64_v2_fence-agents-kubevirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-kubevirt-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-agents-kubevirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-kubevirt}"
SRC_URI[x86_64_v2_fence-agents-kubevirt.sha256sum] = "b7282d619f098b03eb7a5e760534144343975413825e7418ea8e1bd130848c84"

URI_x86_64_v2_fence-agents-lpar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-lpar-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-lpar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-lpar}"
SRC_URI[x86_64_v2_fence-agents-lpar.sha256sum] = "a8fbaee61f5ddaf0cf9bffcc118db4826a5a05bc25b785eb579b59dcf34ee783"

URI_x86_64_v2_fence-agents-mpath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-mpath-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-mpath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-mpath}"
SRC_URI[x86_64_v2_fence-agents-mpath.sha256sum] = "55121c91124b5b1ab8ae428a71153fca48830cb2377a66133299e49d476f8579"

URI_x86_64_v2_fence-agents-nutanix-ahv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-nutanix-ahv-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-nutanix-ahv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-nutanix-ahv}"
SRC_URI[x86_64_v2_fence-agents-nutanix-ahv.sha256sum] = "1bb21e363c275364c5569b7c6ab8587207b8c3d19c8a54beebef3fe9f16ebfe9"

URI_x86_64_v2_fence-agents-openstack = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-openstack-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-agents-openstack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-openstack}"
SRC_URI[x86_64_v2_fence-agents-openstack.sha256sum] = "753a41a8108a1926b2f2038deca7a468600234b8b9b3b67dbe9980bc9db94f43"

URI_x86_64_v2_fence-agents-redfish = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-redfish-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-agents-redfish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-redfish}"
SRC_URI[x86_64_v2_fence-agents-redfish.sha256sum] = "af592f77eef13c20319e1ea56f22cb99593ba397c12fc8591ba7e392e0d3dc81"

URI_x86_64_v2_fence-agents-rhevm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rhevm-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-rhevm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-rhevm}"
SRC_URI[x86_64_v2_fence-agents-rhevm.sha256sum] = "12eaddf2375f0d9463b22053a12d88184a4685b6ed97827b4d00e3f540d35a77"

URI_x86_64_v2_fence-agents-rsa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rsa-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-rsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-rsa}"
SRC_URI[x86_64_v2_fence-agents-rsa.sha256sum] = "92db5ae9375388dc8ae94376db9a39eade8ddb2f154910d70382f8b189d5f241"

URI_x86_64_v2_fence-agents-rsb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rsb-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-rsb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-rsb}"
SRC_URI[x86_64_v2_fence-agents-rsb.sha256sum] = "64c1a70a480fd7389814260dec8d49a3eac09cdd66420169a15598b084a38f76"

URI_x86_64_v2_fence-agents-sbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-sbd-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-sbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-sbd}"
SRC_URI[x86_64_v2_fence-agents-sbd.sha256sum] = "ea7f7f484c5264cd4132020c87ce81e1045b4f7d5db9ab98b0f9fe552b84fe71"

URI_x86_64_v2_fence-agents-scsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-scsi-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-scsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-scsi}"
SRC_URI[x86_64_v2_fence-agents-scsi.sha256sum] = "370e2496ac9153f56c6558113029a023615e055784a7b9902882374acd5a7629"

URI_x86_64_v2_fence-agents-virsh = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-virsh-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-virsh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-virsh}"
SRC_URI[x86_64_v2_fence-agents-virsh.sha256sum] = "2c902ac3068ddd98e7defae5577838c602f6c8fb732e8f1d0b4563f431378765"

URI_x86_64_v2_fence-agents-vmware-rest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-vmware-rest-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-vmware-rest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-vmware-rest}"
SRC_URI[x86_64_v2_fence-agents-vmware-rest.sha256sum] = "ce0ea98c5bd6f588d435203a29125e138b51a6b0455cb7bd4ee31c2ae79b8436"

URI_x86_64_v2_fence-agents-vmware-soap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-vmware-soap-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-vmware-soap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-vmware-soap}"
SRC_URI[x86_64_v2_fence-agents-vmware-soap.sha256sum] = "136fdc84f90af4bcf5ed80ad8ca0c1c577d6d6fc735674c0497db5fabf4695d6"

URI_x86_64_v2_fence-agents-wti = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-wti-4.16.0-13.el10_1.4.noarch.rpm;name=x86_64_v2_fence-agents-wti;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-wti}"
SRC_URI[x86_64_v2_fence-agents-wti.sha256sum] = "0da1dba7aef97589de709563d61f44907f921295c07340ebef9c639c32fae497"

URI_x86_64_v2_fence-virt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virt-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virt}"
SRC_URI[x86_64_v2_fence-virt.sha256sum] = "8fc7bb42aa7eb35d8065059492188fbdc5c62b9a84ae7a23e341e42c65445f1b"

URI_x86_64_v2_fence-virtd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-virtd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd}"
SRC_URI[x86_64_v2_fence-virtd.sha256sum] = "2caa52ea7fc638e03d457034e5179aff6be71f7b9541f9da2d6151460cd4b17c"

URI_x86_64_v2_fence-virtd-cpg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-cpg-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-cpg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-cpg}"
SRC_URI[x86_64_v2_fence-virtd-cpg.sha256sum] = "9dd9e2ed11103fd77e45256a376e07f3b59785229826b385eb6de4690675d78d"

URI_x86_64_v2_fence-virtd-libvirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-libvirt-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-libvirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-libvirt}"
SRC_URI[x86_64_v2_fence-virtd-libvirt.sha256sum] = "1cef948582df8367af340148f14f7490536e31ed689b17c27087bfe34635f275"

URI_x86_64_v2_fence-virtd-multicast = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-multicast-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-multicast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-multicast}"
SRC_URI[x86_64_v2_fence-virtd-multicast.sha256sum] = "4fa570cd3a0f6134ce7e5f1a8d30d6423228fd8c94cec5fc079f7a51801c02f7"

URI_x86_64_v2_fence-virtd-serial = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-serial-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-serial;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-serial}"
SRC_URI[x86_64_v2_fence-virtd-serial.sha256sum] = "124427a82a13a73d7160ab5636fc22839cb3212fa5c126909b929813ceef85c8"

URI_x86_64_v2_fence-virtd-tcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-tcp-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-tcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-tcp}"
SRC_URI[x86_64_v2_fence-virtd-tcp.sha256sum] = "b81ad26b97e88ab5ad59ac38c3c487ee407a664348aa19fe052f781eef04eae4"

URI_x86_64_v2_ha-cloud-support = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ha-cloud-support-4.16.0-13.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_ha-cloud-support;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ha-cloud-support}"
SRC_URI[x86_64_v2_ha-cloud-support.sha256sum] = "ec5be2b7d9d9cf7d590c46b0a58030dea0ff6dc30e5292c4d364c9f2bc307a58"

URI_aarch64_fence-agents-all = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-all-4.16.0-13.el10_1.4.aarch64.rpm;name=aarch64_fence-agents-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-all}"
SRC_URI[aarch64_fence-agents-all.sha256sum] = "cd385c9c19527bca346d4bae6b0edaadbfe92a1e6e94d35c984a02f25df72b4c"

URI_aarch64_fence-agents-amt-ws = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-amt-ws-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-amt-ws;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-amt-ws}"
SRC_URI[aarch64_fence-agents-amt-ws.sha256sum] = "50d72f9cd4bfd7fc65eda01bf150a90be24a153c30f99417eafef8877077ef4f"

URI_aarch64_fence-agents-apc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-apc-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-apc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-apc}"
SRC_URI[aarch64_fence-agents-apc.sha256sum] = "40c0afa796c637960ff90f2cfa52b86d0cacb83953ec58ab14345b545c796177"

URI_aarch64_fence-agents-apc-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-apc-snmp-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-apc-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-apc-snmp}"
SRC_URI[aarch64_fence-agents-apc-snmp.sha256sum] = "09586142e4db307e44af085e6d66ca117ddb082e918e1309383706cd2066a5fb"

URI_aarch64_fence-agents-bladecenter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-bladecenter-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-bladecenter;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-bladecenter}"
SRC_URI[aarch64_fence-agents-bladecenter.sha256sum] = "7cf03088b1ac60084af803034abc88eee26cda8c5dc406e92919eb9b828815d1"

URI_aarch64_fence-agents-brocade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-brocade-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-brocade;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-brocade}"
SRC_URI[aarch64_fence-agents-brocade.sha256sum] = "cabe63c7a87f4e060900aacf939c987a516b2cc485369cf76c1b74b3952f84a5"

URI_aarch64_fence-agents-cisco-mds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-cisco-mds-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-cisco-mds;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-cisco-mds}"
SRC_URI[aarch64_fence-agents-cisco-mds.sha256sum] = "5ae3ab516c0776437ae1e4e1df064d5dafe0016b631e2e4939329b809f783d1c"

URI_aarch64_fence-agents-cisco-ucs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-cisco-ucs-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-cisco-ucs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-cisco-ucs}"
SRC_URI[aarch64_fence-agents-cisco-ucs.sha256sum] = "0b3ac254ae6065db9f3fd8a0c18b3424ef60815dc8bb7f87d8eb11362937ec5a"

URI_aarch64_fence-agents-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-common-4.16.0-13.el10_1.4.aarch64.rpm;name=aarch64_fence-agents-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-common}"
SRC_URI[aarch64_fence-agents-common.sha256sum] = "033e718edca5ddde3d40904d7bf3a186d2204c98f4a61bf701ba6d38ecb9e142"

URI_aarch64_fence-agents-drac5 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-drac5-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-drac5;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-drac5}"
SRC_URI[aarch64_fence-agents-drac5.sha256sum] = "44c48ba2985bbd6100acb5c3a1e64b8abb8016a8f37a003f818be1dbb1cd7be1"

URI_aarch64_fence-agents-eaton-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-eaton-snmp-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-eaton-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-eaton-snmp}"
SRC_URI[aarch64_fence-agents-eaton-snmp.sha256sum] = "5bbf406dfcb2db87c03f2e1476b6f4bc929ba44acfb45465741d4d61fc492f16"

URI_aarch64_fence-agents-emerson = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-emerson-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-emerson;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-emerson}"
SRC_URI[aarch64_fence-agents-emerson.sha256sum] = "5c59da8d7daed25a631ae45abc16a7f5d047cb0cf850d686b5846e1f7bffcd04"

URI_aarch64_fence-agents-eps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-eps-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-eps;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-eps}"
SRC_URI[aarch64_fence-agents-eps.sha256sum] = "9e75484bc74cfb7036a82ffa29ba58bc70d67e8076f54e44aeae4ffd1ba6000a"

URI_aarch64_fence-agents-heuristics-ping = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-heuristics-ping-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-heuristics-ping;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-heuristics-ping}"
SRC_URI[aarch64_fence-agents-heuristics-ping.sha256sum] = "bc8d9c8343a67f6a7dcbf1e4f3bc8e4d99d8d9e5a09b9148da2c2788de117719"

URI_aarch64_fence-agents-hpblade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-hpblade-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-hpblade;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-hpblade}"
SRC_URI[aarch64_fence-agents-hpblade.sha256sum] = "67dcec47ae4e519a1254f1d0d4447a97229f4d8236f69bbabc49ec054e90b7c3"

URI_aarch64_fence-agents-ibm-powervs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibm-powervs-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-ibm-powervs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ibm-powervs}"
SRC_URI[aarch64_fence-agents-ibm-powervs.sha256sum] = "38d9040e1f453db74c8e54ba21913fdfb555b66517d459944484715a2ba2580b"

URI_aarch64_fence-agents-ibm-vpc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibm-vpc-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-ibm-vpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ibm-vpc}"
SRC_URI[aarch64_fence-agents-ibm-vpc.sha256sum] = "6417b2cb1571024cbdd6477e43dd1aef148a7586627d30ed79b36c7e004257c4"

URI_aarch64_fence-agents-ibmblade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibmblade-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-ibmblade;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ibmblade}"
SRC_URI[aarch64_fence-agents-ibmblade.sha256sum] = "19e840c25ceadfce471169e2ef7ebb31beefab58c7b698de272228a8fac31f95"

URI_aarch64_fence-agents-ifmib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ifmib-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-ifmib;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ifmib}"
SRC_URI[aarch64_fence-agents-ifmib.sha256sum] = "f7e882281033fac4fdebd0fc3fee4c4d0b17d9d72ddb8c2bd68fb27b52ee4415"

URI_aarch64_fence-agents-ilo-moonshot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-moonshot-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-ilo-moonshot;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo-moonshot}"
SRC_URI[aarch64_fence-agents-ilo-moonshot.sha256sum] = "08ad9c154bff120cd30dd79d5edebee89b06ccf3c9a3b9a3887b9002d2a2563a"

URI_aarch64_fence-agents-ilo-mp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-mp-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-ilo-mp;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo-mp}"
SRC_URI[aarch64_fence-agents-ilo-mp.sha256sum] = "7e4ae4eb44f25cade6f76ff2e2bc0877f8d862923348598643bceded08a51f9f"

URI_aarch64_fence-agents-ilo-ssh = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-ssh-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-ilo-ssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo-ssh}"
SRC_URI[aarch64_fence-agents-ilo-ssh.sha256sum] = "1da76611feaa508e56b3c5492319c66464d86fc378d78132b629b7fbcca5efce"

URI_aarch64_fence-agents-ilo2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo2-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-ilo2;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo2}"
SRC_URI[aarch64_fence-agents-ilo2.sha256sum] = "4429f1c854aa2512515e7262f7cbedd9f1085cc4cf92dc85717b4a2bd73b8c4e"

URI_aarch64_fence-agents-intelmodular = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-intelmodular-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-intelmodular;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-intelmodular}"
SRC_URI[aarch64_fence-agents-intelmodular.sha256sum] = "0bbfb1e37e90d4e1432c9cec542413d6cf6451bd90df505848818795123be95e"

URI_aarch64_fence-agents-ipdu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ipdu-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-ipdu;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ipdu}"
SRC_URI[aarch64_fence-agents-ipdu.sha256sum] = "e912eb61d4955627962a2623da6f10773cbb01d18ef74d72d0f9cbf4fd99a549"

URI_aarch64_fence-agents-ipmilan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ipmilan-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-ipmilan;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ipmilan}"
SRC_URI[aarch64_fence-agents-ipmilan.sha256sum] = "b64c8fe552f889c877f9e42378e9281f99de9ac1b476314f740de35a37e2b078"

URI_aarch64_fence-agents-kdump = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-kdump-4.16.0-13.el10_1.4.aarch64.rpm;name=aarch64_fence-agents-kdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-kdump}"
SRC_URI[aarch64_fence-agents-kdump.sha256sum] = "4e758b871754466b18021b45ea42e1a74814a2ab18d02a1aec652797fdb909c2"

URI_aarch64_fence-agents-kubevirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-kubevirt-4.16.0-13.el10_1.4.aarch64.rpm;name=aarch64_fence-agents-kubevirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-kubevirt}"
SRC_URI[aarch64_fence-agents-kubevirt.sha256sum] = "f9142a88e20c215a5d1542221e19109e401bf89eb163899a44e7be6efda51dec"

URI_aarch64_fence-agents-lpar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-lpar-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-lpar;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-lpar}"
SRC_URI[aarch64_fence-agents-lpar.sha256sum] = "a8fbaee61f5ddaf0cf9bffcc118db4826a5a05bc25b785eb579b59dcf34ee783"

URI_aarch64_fence-agents-mpath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-mpath-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-mpath;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-mpath}"
SRC_URI[aarch64_fence-agents-mpath.sha256sum] = "55121c91124b5b1ab8ae428a71153fca48830cb2377a66133299e49d476f8579"

URI_aarch64_fence-agents-nutanix-ahv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-nutanix-ahv-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-nutanix-ahv;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-nutanix-ahv}"
SRC_URI[aarch64_fence-agents-nutanix-ahv.sha256sum] = "1bb21e363c275364c5569b7c6ab8587207b8c3d19c8a54beebef3fe9f16ebfe9"

URI_aarch64_fence-agents-redfish = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-redfish-4.16.0-13.el10_1.4.aarch64.rpm;name=aarch64_fence-agents-redfish;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-redfish}"
SRC_URI[aarch64_fence-agents-redfish.sha256sum] = "e28dbcd2775ac6354d1fdbf0cf964aeccf78747f7dbd296c9e41fab7f7ebf818"

URI_aarch64_fence-agents-rhevm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rhevm-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-rhevm;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-rhevm}"
SRC_URI[aarch64_fence-agents-rhevm.sha256sum] = "12eaddf2375f0d9463b22053a12d88184a4685b6ed97827b4d00e3f540d35a77"

URI_aarch64_fence-agents-rsa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rsa-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-rsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-rsa}"
SRC_URI[aarch64_fence-agents-rsa.sha256sum] = "92db5ae9375388dc8ae94376db9a39eade8ddb2f154910d70382f8b189d5f241"

URI_aarch64_fence-agents-rsb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rsb-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-rsb;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-rsb}"
SRC_URI[aarch64_fence-agents-rsb.sha256sum] = "64c1a70a480fd7389814260dec8d49a3eac09cdd66420169a15598b084a38f76"

URI_aarch64_fence-agents-sbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-sbd-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-sbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-sbd}"
SRC_URI[aarch64_fence-agents-sbd.sha256sum] = "ea7f7f484c5264cd4132020c87ce81e1045b4f7d5db9ab98b0f9fe552b84fe71"

URI_aarch64_fence-agents-scsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-scsi-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-scsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-scsi}"
SRC_URI[aarch64_fence-agents-scsi.sha256sum] = "370e2496ac9153f56c6558113029a023615e055784a7b9902882374acd5a7629"

URI_aarch64_fence-agents-virsh = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-virsh-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-virsh;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-virsh}"
SRC_URI[aarch64_fence-agents-virsh.sha256sum] = "2c902ac3068ddd98e7defae5577838c602f6c8fb732e8f1d0b4563f431378765"

URI_aarch64_fence-agents-vmware-rest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-vmware-rest-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-vmware-rest;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-vmware-rest}"
SRC_URI[aarch64_fence-agents-vmware-rest.sha256sum] = "ce0ea98c5bd6f588d435203a29125e138b51a6b0455cb7bd4ee31c2ae79b8436"

URI_aarch64_fence-agents-vmware-soap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-vmware-soap-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-vmware-soap;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-vmware-soap}"
SRC_URI[aarch64_fence-agents-vmware-soap.sha256sum] = "136fdc84f90af4bcf5ed80ad8ca0c1c577d6d6fc735674c0497db5fabf4695d6"

URI_aarch64_fence-agents-wti = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-wti-4.16.0-13.el10_1.4.noarch.rpm;name=aarch64_fence-agents-wti;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-wti}"
SRC_URI[aarch64_fence-agents-wti.sha256sum] = "0da1dba7aef97589de709563d61f44907f921295c07340ebef9c639c32fae497"

RDEPENDS:fence-agents-aliyun = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 python3-jmespath \
 "
RDEPENDS:fence-agents-all:x86_64_v2 = " \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-mpath \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
 fence-virt \
"
RDEPENDS:fence-agents-all:aarch64 = " \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-mpath \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
"
RDEPENDS:fence-agents-amt-ws = " \
 fence-agents-common \
 openwsman-python3 \
 python3 \
 "
RDEPENDS:fence-agents-apc = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-apc-snmp = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-aws = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-azure-arm = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-bladecenter = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-brocade = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-cisco-mds = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-cisco-ucs = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-common = " \
 glibc \
 openssl-libs \
 pkgconf-pkg-config \
 python3 \
 python3-pexpect \
 python3-ptyprocess \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:fence-agents-drac5 = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-eaton-snmp = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-emerson = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-eps = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-gce = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-heuristics-ping = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-hpblade = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ibm-powervs = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-ibm-vpc = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-ibmblade = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ifmib = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ilo-moonshot = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo-mp = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo-ssh = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo2 = " \
 fence-agents-common \
 gnutls-utils \
 python3 \
 "
RDEPENDS:fence-agents-intelmodular = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ipdu = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ipmilan = " \
 fence-agents-common \
 ipmitool \
 python3 \
 "
RDEPENDS:fence-agents-kdump = " \
 fence-agents-common \
 glibc \
 "
RDEPENDS:fence-agents-kubevirt = " \
 fence-agents-common \
 python3 \
 python3-charset-normalizer \
 python3-dateutil \
 python3-oauthlib \
 python3-pyasn1 \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-six \
 python3-urllib3 \
 "
RDEPENDS:fence-agents-lpar = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-mpath = " \
 device-mapper-multipath \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-nutanix-ahv = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-openstack = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-redfish = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-rhevm = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-rsa = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-rsb = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-sbd = " \
 fence-agents-common \
 python3 \
 sbd \
 "
RDEPENDS:fence-agents-scsi = " \
 fence-agents-common \
 python3 \
 sg3_utils \
 "
RDEPENDS:fence-agents-virsh = " \
 fence-agents-common \
 libvirt-client \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-vmware-rest = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-vmware-soap = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-wti = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-virt = " \
 glibc \
 nss \
 systemd \
 "
RDEPENDS:fence-virtd = " \
 glibc \
 libuuid \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-cpg = " \
 corosynclib \
 fence-virtd \
 glibc \
 libqb \
 libvirt-libs \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-libvirt = " \
 fence-virtd \
 glibc \
 libvirt \
 libvirt-libs \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-multicast = " \
 fence-virtd \
 glibc \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-serial = " \
 fence-virtd \
 glibc \
 libvirt \
 libvirt-libs \
 libxml2 \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-tcp = " \
 fence-virtd \
 glibc \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:ha-cloud-support = " \
 awscli2 \
 glibc \
 python3-cffi \
 python3-charset-normalizer \
 python3-colorama \
 python3-cryptography \
 python3-dateutil \
 python3-docutils \
 python3-idna \
 python3-jmespath \
 python3-oauthlib \
 python3-packaging \
 python3-protobuf \
 python3-pyasn1 \
 python3-pycparser \
 python3-pyparsing \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-six \
 python3-typing-extensions \
 python3-urllib3 \
 "
