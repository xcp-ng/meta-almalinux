# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-urllib3"
PV = "1.26.19"
PR = "4.el10"
PACKAGES = " \
 python3-urllib3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-urllib3-1.26.19-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcbb13ea3706fe4ced4cc0959f19a45fc1a3dfffbf26de69a52b2a569c77ab7c"

URI_x86_64_v2_python3-urllib3 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-urllib3-1.26.19-4.el10.noarch.rpm;name=x86_64_v2_python3-urllib3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-urllib3}"
SRC_URI[x86_64_v2_python3-urllib3.sha256sum] = "fb024b16c3f2a5e18b48bb2cda388d9e020773dc395ee4ae1ea312c7ec7ca502"

URI_aarch64_python3-urllib3 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-urllib3-1.26.19-4.el10.noarch.rpm;name=aarch64_python3-urllib3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-urllib3}"
SRC_URI[aarch64_python3-urllib3.sha256sum] = "fb024b16c3f2a5e18b48bb2cda388d9e020773dc395ee4ae1ea312c7ec7ca502"

RDEPENDS:python3-urllib3 = " \
 ca-certificates \
 python3 \
 python3-idna \
 "
