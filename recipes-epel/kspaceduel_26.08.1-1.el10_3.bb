# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kspaceduel"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kspaceduel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kspaceduel-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0b54a0d595074ff91cb8cc317e86980b9d335f9f643f6634a66097a9c746a99f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kspaceduel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kspaceduel;unpack=0"
SRC_URI[x86_64_v2_kspaceduel.sha256sum] = "fa1316db94de90f46d50a8fe4237ce8c0cf13355a67f0a7f0db6865ea1d84d4f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kspaceduel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kspaceduel;unpack=0"
SRC_URI[aarch64_kspaceduel.sha256sum] = "5ac2547d5cc9e886e8a49bed351a5cf80838cabff4875ca0e44fb8634e0d7fc4"

RDEPENDS:kspaceduel = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
