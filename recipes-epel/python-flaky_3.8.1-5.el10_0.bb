# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flaky"
PV = "3.8.1"
PR = "5.el10_0"
PACKAGES = " \
 python3-flaky \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-flaky-3.8.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "23a547b35f6c5a27b068b7e22c71b7e7890f0ac1439141d06a7e78d757fbaf0a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flaky-3.8.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flaky;unpack=0"
SRC_URI[x86_64_v2_python3-flaky.sha256sum] = "9899468fdf18e571126c371a244beace01680311c47f9ffaf49e5bbed25804ec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-flaky-3.8.1-5.el10_0.noarch.rpm;name=aarch64_python3-flaky;unpack=0"
SRC_URI[aarch64_python3-flaky.sha256sum] = "e994d5e0011539b57222d7c86b2ab2d78bb1a65c649f728fe021ccee9c874cd3"

RDEPENDS:python3-flaky = " \
 python3 \
 "
