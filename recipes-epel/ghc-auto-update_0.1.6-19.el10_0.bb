# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-auto-update"
PV = "0.1.6"
PR = "19.el10_0"
PACKAGES = " \
 ghc-auto-update \
 ghc-auto-update-devel \
 ghc-auto-update-doc \
 ghc-auto-update-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-auto-update-0.1.6-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ab3b38a82a1d367be85936db4c9ea61f484aa414ffd009e6f265a2c1b9677f6"

URI_x86_64_v2_ghc-auto-update = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-auto-update-0.1.6-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-auto-update;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-auto-update}"
SRC_URI[x86_64_v2_ghc-auto-update.sha256sum] = "1fbd886ac7db36e5f4cc49af0bcc54251c733d5a95d964647ae4e1d40d1e82ed"

URI_x86_64_v2_ghc-auto-update-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-auto-update-devel-0.1.6-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-auto-update-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-auto-update-devel}"
SRC_URI[x86_64_v2_ghc-auto-update-devel.sha256sum] = "719979cae54626d9b351c64b9c23574c59dd7f6fccc1b0a9ab83e026ed54ef1b"

URI_x86_64_v2_ghc-auto-update-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-auto-update-doc-0.1.6-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-auto-update-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-auto-update-doc}"
SRC_URI[x86_64_v2_ghc-auto-update-doc.sha256sum] = "962b898858a8075596cd12d4ed2d76fa50689d5edd1ab938ac05f3e9368b2f22"

URI_x86_64_v2_ghc-auto-update-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-auto-update-prof-0.1.6-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-auto-update-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-auto-update-prof}"
SRC_URI[x86_64_v2_ghc-auto-update-prof.sha256sum] = "860980847f3ec2c4691464179daa82731aa5724a16fb4b38e69e8d39fe3f5c31"

URI_aarch64_ghc-auto-update = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-auto-update-0.1.6-19.el10_0.aarch64.rpm;name=aarch64_ghc-auto-update;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-auto-update}"
SRC_URI[aarch64_ghc-auto-update.sha256sum] = "d90cfc189f38e5e0c5ea6766a299986c5510510641211dc1b3c320423f40fabc"

URI_aarch64_ghc-auto-update-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-auto-update-devel-0.1.6-19.el10_0.aarch64.rpm;name=aarch64_ghc-auto-update-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-auto-update-devel}"
SRC_URI[aarch64_ghc-auto-update-devel.sha256sum] = "6bc97abf1e59e5fd97316bfa7709c8043db603b37328a990e2fa5f43c60a6b99"

URI_aarch64_ghc-auto-update-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-auto-update-doc-0.1.6-19.el10_0.noarch.rpm;name=aarch64_ghc-auto-update-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-auto-update-doc}"
SRC_URI[aarch64_ghc-auto-update-doc.sha256sum] = "38ed4f9f43cacbc6d51bbf956bc1248ab6aa6e6dd88445ad08edd5925aaf9f91"

URI_aarch64_ghc-auto-update-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-auto-update-prof-0.1.6-19.el10_0.aarch64.rpm;name=aarch64_ghc-auto-update-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-auto-update-prof}"
SRC_URI[aarch64_ghc-auto-update-prof.sha256sum] = "66abf2fd46a7f80ebbe7ed0b187d3494ff5f6f48d9e533ef7afc63bbd48a0e15"

RDEPENDS:ghc-auto-update = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-auto-update-devel = " \
 ghc-auto-update \
 ghc-base-devel \
 ghc-compiler \
 "
RDEPENDS:ghc-auto-update-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-auto-update-prof = " \
 ghc-auto-update-devel \
 ghc-base-prof \
 "
