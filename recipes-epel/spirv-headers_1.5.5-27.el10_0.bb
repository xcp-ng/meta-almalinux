# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spirv-headers"
PV = "1.5.5"
PR = "27.el10_0"
PACKAGES = " \
 spirv-headers-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spirv-headers-1.5.5-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76dbdf6194b31db95a7411a6acde61e591a9429b3406ecb037c13bed182725aa"

URI_x86_64_v2_spirv-headers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spirv-headers-devel-1.5.5-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_spirv-headers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spirv-headers-devel}"
SRC_URI[x86_64_v2_spirv-headers-devel.sha256sum] = "3fd6f1c2d5f009bd37db0507abad4dbb3dfc3c5b6c91a22cf2a9a77aabb270a9"

URI_aarch64_spirv-headers-devel = "${EPEL_MIRROR}/aarch64/Packages/s/spirv-headers-devel-1.5.5-27.el10_0.noarch.rpm;name=aarch64_spirv-headers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_spirv-headers-devel}"
SRC_URI[aarch64_spirv-headers-devel.sha256sum] = "1698f74ab6c10e79637fa2afa3698e984491af7bcdae0b59f671ed2c5e7b3267"

RDEPENDS:spirv-headers-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
