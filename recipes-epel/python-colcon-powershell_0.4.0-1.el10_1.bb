# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-powershell"
PV = "0.4.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-powershell \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-powershell-0.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9572cbfcfd7ced17a35817ee9e7ba0697150bf758fedbf1015a1dc1cfa53fc10"

URI_x86_64_v2_python3-colcon-powershell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-powershell-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-powershell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-powershell}"
SRC_URI[x86_64_v2_python3-colcon-powershell.sha256sum] = "ca1f529b089974d85ec0723eca971296db17ebfdc29b128c03ecfaa13fdf2629"

URI_aarch64_python3-colcon-powershell = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-powershell-0.4.0-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-powershell;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-powershell}"
SRC_URI[aarch64_python3-colcon-powershell.sha256sum] = "f5ea0c4a90e2f3f0e183886c151653935f3463de1fbfb9a4b68c45e40c14c73b"

RDEPENDS:python3-colcon-powershell = " \
 python3 \
 python3-colcon-core \
 "
