# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mongo-c-driver"
PV = "1.30.11"
PR = "1.el10_2"
PACKAGES = " \
 libbson \
 libbson-devel \
 mongo-c-driver \
 mongo-c-driver-devel \
 mongo-c-driver-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/mongo-c-driver-1.30.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c7cdffb26514685f388419fa9115eb62c9d6358c5ce29b23bb53fc99d99853a3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbson-1.30.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbson;unpack=0"
SRC_URI[x86_64_v2_libbson.sha256sum] = "a3790371f731a1c7a3431d633d55abdb87b8e0feb790e2a7f78020eb255d5d4a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbson-devel-1.30.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbson-devel;unpack=0"
SRC_URI[x86_64_v2_libbson-devel.sha256sum] = "1ab90e0db0ceafa9cb1ea379a43d9be1f0cad57f64bbb7f56b384bd82e12d89c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mongo-c-driver-1.30.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mongo-c-driver;unpack=0"
SRC_URI[x86_64_v2_mongo-c-driver.sha256sum] = "d245ff6a82df4793d0a6fdab1a03d1f96d8cbe438137ea41583e78985db1c8e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mongo-c-driver-devel-1.30.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mongo-c-driver-devel;unpack=0"
SRC_URI[x86_64_v2_mongo-c-driver-devel.sha256sum] = "2f7b024ddaccef04222118ad171098e6b6ee69116ad0ac91da690ed1e359873d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mongo-c-driver-libs-1.30.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mongo-c-driver-libs;unpack=0"
SRC_URI[x86_64_v2_mongo-c-driver-libs.sha256sum] = "33a5c5c933b6d4fe675b30a649eefd75fd8405f0fba6572b86ddfb6d4c6e5149"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libbson-1.30.11-1.el10_2.aarch64.rpm;name=aarch64_libbson;unpack=0"
SRC_URI[aarch64_libbson.sha256sum] = "0263f2253eff2ca69fd060af729ac486e9df9564021a886d142e21924da8f375"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libbson-devel-1.30.11-1.el10_2.aarch64.rpm;name=aarch64_libbson-devel;unpack=0"
SRC_URI[aarch64_libbson-devel.sha256sum] = "e5d317881a7ebb466b59d05e8cbcc899ff91d30eb66c2ea796fefb1189930143"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-1.30.11-1.el10_2.aarch64.rpm;name=aarch64_mongo-c-driver;unpack=0"
SRC_URI[aarch64_mongo-c-driver.sha256sum] = "400a27050a9b9ca5c0b6946bdb5ab0bd5c9f5ba8f3b5ce96f76a1411ab3c768e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-devel-1.30.11-1.el10_2.aarch64.rpm;name=aarch64_mongo-c-driver-devel;unpack=0"
SRC_URI[aarch64_mongo-c-driver-devel.sha256sum] = "d947dca2125171c72bc67fb32442927e488e1b25ff5f34055c3c9bda6e5d0ef3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-libs-1.30.11-1.el10_2.aarch64.rpm;name=aarch64_mongo-c-driver-libs;unpack=0"
SRC_URI[aarch64_mongo-c-driver-libs.sha256sum] = "9cb8c857a7d21406a44462d051438406e62a6d39fc1c8d2739be5c3334c8408b"

RDEPENDS:libbson = " \
 glibc \
 "
RDEPENDS:libbson-devel = " \
 cmake-filesystem \
 libbson \
 pkgconf-pkg-config \
 "
RDEPENDS:mongo-c-driver = " \
 glibc \
 mongo-c-driver-libs \
 "
RDEPENDS:mongo-c-driver-devel = " \
 cmake-filesystem \
 libbson-devel \
 libmongocrypt-devel \
 libzstd-devel \
 mongo-c-driver \
 mongo-c-driver-devel \
 mongo-c-driver-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:mongo-c-driver-libs = " \
 cyrus-sasl-lib \
 glibc \
 libbson \
 libmongocrypt \
 libzstd \
 openssl-libs \
 snappy \
 utf8proc \
 zlib-ng-compat \
 "
