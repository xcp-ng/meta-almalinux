# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jwcrypto"
PV = "1.5.6"
PR = "5.el10_2"
PACKAGES = " \
 python3-jwcrypto \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-jwcrypto-1.5.6-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fd73201bfe7f8832f19ae6d225fda350d5b54b2be46aaeefbd08c33f667fc8c"

URI_x86_64_v2_python3-jwcrypto = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-jwcrypto-1.5.6-5.el10_2.noarch.rpm;name=x86_64_v2_python3-jwcrypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jwcrypto}"
SRC_URI[x86_64_v2_python3-jwcrypto.sha256sum] = "db89aecbcd378aa983e05761a6b2cbca01c3a05e38a708730a9029e277498a12"

URI_aarch64_python3-jwcrypto = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-jwcrypto-1.5.6-5.el10_2.noarch.rpm;name=aarch64_python3-jwcrypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jwcrypto}"
SRC_URI[aarch64_python3-jwcrypto.sha256sum] = "db89aecbcd378aa983e05761a6b2cbca01c3a05e38a708730a9029e277498a12"

RDEPENDS:python3-jwcrypto = " \
 python3 \
 python3-cryptography \
 python3-typing-extensions \
 "
