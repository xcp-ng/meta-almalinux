# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-frozendict"
PV = "2.4.6"
PR = "6.el10_2"
PACKAGES = " \
 python3-frozendict \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-frozendict-2.4.6-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9cad9c86268a625c475c5a544144c37ba048a7ea7a188d8b5597af9bec661ac"

URI_x86_64_v2_python3-frozendict = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-frozendict-2.4.6-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-frozendict;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-frozendict}"
SRC_URI[x86_64_v2_python3-frozendict.sha256sum] = "2784349973fe069b09dd4292c87586224411a93a73f7ca35468dcbe45ec0fcbe"

URI_aarch64_python3-frozendict = "${EPEL_MIRROR}/aarch64/Packages/p/python3-frozendict-2.4.6-6.el10_2.noarch.rpm;name=aarch64_python3-frozendict;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-frozendict}"
SRC_URI[aarch64_python3-frozendict.sha256sum] = "ffc82bf41d86254782cd2f1d417f84d0e8747a159b7c1fe520df21d1e2f1c08b"

RDEPENDS:python3-frozendict = " \
 python3 \
 "
