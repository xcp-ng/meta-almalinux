# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deadpool-runtime"
PV = "0.3.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-deadpool-runtime+default-devel \
 rust-deadpool-runtime+smol_2-devel \
 rust-deadpool-runtime+tokio_1-devel \
 rust-deadpool-runtime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deadpool-runtime-0.3.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c815173cbe2be3c6a6a3325c5fe3d2d6caa1be014f531ec0a731a82492a6d032"

URI_x86_64_v2_rust-deadpool-runtime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool-runtime+default-devel-0.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool-runtime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool-runtime+default-devel}"
SRC_URI[x86_64_v2_rust-deadpool-runtime+default-devel.sha256sum] = "732cc67f1f1f13cfcc6f044370e9100d666986b48f5ce8ed5af31edd20d28256"

URI_x86_64_v2_rust-deadpool-runtime+smol_2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool-runtime+smol_2-devel-0.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool-runtime+smol_2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool-runtime+smol_2-devel}"
SRC_URI[x86_64_v2_rust-deadpool-runtime+smol_2-devel.sha256sum] = "e103d6e933995b0d1730db86f895ecc50b7eb5b1d0edead9e27453361eff0296"

URI_x86_64_v2_rust-deadpool-runtime+tokio_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool-runtime+tokio_1-devel-0.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool-runtime+tokio_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool-runtime+tokio_1-devel}"
SRC_URI[x86_64_v2_rust-deadpool-runtime+tokio_1-devel.sha256sum] = "fd012e139d22b4242cdb0c0681827cc081ef19abb9980ae26536e98455b7d91f"

URI_x86_64_v2_rust-deadpool-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool-runtime-devel-0.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool-runtime-devel}"
SRC_URI[x86_64_v2_rust-deadpool-runtime-devel.sha256sum] = "cf46ef1de32ce0eed86dda2efb1ebcdf6550e65986f580ec9ba097e11f5d5035"

URI_aarch64_rust-deadpool-runtime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool-runtime+default-devel-0.3.1-2.el10_2.noarch.rpm;name=aarch64_rust-deadpool-runtime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool-runtime+default-devel}"
SRC_URI[aarch64_rust-deadpool-runtime+default-devel.sha256sum] = "d1486e441c2f5f5d1770fd7e2ef90df4e7db5b76a349593eba41198e718a31ea"

URI_aarch64_rust-deadpool-runtime+smol_2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool-runtime+smol_2-devel-0.3.1-2.el10_2.noarch.rpm;name=aarch64_rust-deadpool-runtime+smol_2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool-runtime+smol_2-devel}"
SRC_URI[aarch64_rust-deadpool-runtime+smol_2-devel.sha256sum] = "21be9ac17c518fc3dedc47069c2af697733e45ad041085bc9d1b67b1af68293b"

URI_aarch64_rust-deadpool-runtime+tokio_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool-runtime+tokio_1-devel-0.3.1-2.el10_2.noarch.rpm;name=aarch64_rust-deadpool-runtime+tokio_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool-runtime+tokio_1-devel}"
SRC_URI[aarch64_rust-deadpool-runtime+tokio_1-devel.sha256sum] = "e2e4008690426d57d1a84eb2207a17b56548102ed44c00ee1a157357257e6ee5"

URI_aarch64_rust-deadpool-runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool-runtime-devel-0.3.1-2.el10_2.noarch.rpm;name=aarch64_rust-deadpool-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool-runtime-devel}"
SRC_URI[aarch64_rust-deadpool-runtime-devel.sha256sum] = "5c03082db8ce79c3266aec8812bd8aaf651d5b904a5b9f3cc87ff82c29be32b4"

RDEPENDS:rust-deadpool-runtime+default-devel = " \
 cargo \
 rust-deadpool-runtime-devel \
 "
RDEPENDS:rust-deadpool-runtime+smol_2-devel = " \
 cargo \
 rust-async-io+default-devel \
 rust-blocking+default-devel \
 rust-deadpool-runtime-devel \
 rust-futures-lite+default-devel \
 "
RDEPENDS:rust-deadpool-runtime+tokio_1-devel = " \
 cargo \
 rust-deadpool-runtime-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-deadpool-runtime-devel = " \
 cargo \
 rust \
 "
