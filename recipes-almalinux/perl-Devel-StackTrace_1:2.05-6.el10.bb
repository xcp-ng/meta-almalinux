# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-StackTrace"
PE = "1"
PV = "2.05"
PR = "6.el10"
PACKAGES = " \
 perl-Devel-StackTrace \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Devel-StackTrace-2.05-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18ab7663655ca9c51714d63ed3fa294c0ed57132921310f19e0005343f291875"

URI_x86_64_v2_perl-Devel-StackTrace = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Devel-StackTrace-2.05-6.el10.noarch.rpm;name=x86_64_v2_perl-Devel-StackTrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-StackTrace}"
SRC_URI[x86_64_v2_perl-Devel-StackTrace.sha256sum] = "4090588db2038c9173c4b8f48b52a3b7d89a4b5c8291710f89831677eb698542"

URI_aarch64_perl-Devel-StackTrace = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Devel-StackTrace-2.05-6.el10.noarch.rpm;name=aarch64_perl-Devel-StackTrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-StackTrace}"
SRC_URI[aarch64_perl-Devel-StackTrace.sha256sum] = "4090588db2038c9173c4b8f48b52a3b7d89a4b5c8291710f89831677eb698542"

RDEPENDS:perl-Devel-StackTrace = " \
 perl-Devel-StackTrace \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 "
