# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-settings"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-settings \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-settings-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f827e46fe7d1eccaec02a7189bfd7a6b72470f0ceefa66628e536701372fd06e"

URI_x86_64_v2_plasma-settings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-settings-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-settings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-settings}"
SRC_URI[x86_64_v2_plasma-settings.sha256sum] = "a669ee0a158ffac86e70b2adda22c24dec3210a0d0126eb9089b4ec4325b6ae1"

URI_aarch64_plasma-settings = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-settings-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-settings;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-settings}"
SRC_URI[aarch64_plasma-settings.sha256sum] = "48114625e94b25d4d20d72286e689d125e4140c762d686c018eb67bf44665377"

RDEPENDS:plasma-settings = " \
 accountsservice \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kservice \
 libstdc++ \
 polkit-kde \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 sound-theme-freedesktop \
 "
