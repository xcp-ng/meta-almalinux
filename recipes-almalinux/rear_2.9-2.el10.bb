# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rear"
PV = "2.9"
PR = "2.el10"
PACKAGES:x86_64_v2 = " \
 rear \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rear-2.9-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e61b7ba510954d5cb1c2e8de2a056c63a4f48c55ac8d9c77611999fcda84dbf"

URI_x86_64_v2_rear = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rear-2.9-2.el10.x86_64_v2.rpm;name=x86_64_v2_rear;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rear}"
SRC_URI[x86_64_v2_rear.sha256sum] = "017039d3cfd0804d8917407e194673db96927ea78b63fcd0b77ff2121c9184f3"

RDEPENDS:rear = " \
 attr \
 bash \
 bc \
 binutils \
 dhcpcd \
 dosfstools \
 ethtool \
 file \
 gawk \
 grub2-efi-x64-modules \
 gzip \
 iproute \
 iputils \
 openssl \
 parted \
 syslinux-extlinux \
 tar \
 util-linux \
 xorriso \
 "
