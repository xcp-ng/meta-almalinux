# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ansi-parser"
PV = "0.9.1"
PR = "3.el10_1"
PACKAGES = " \
 rust-ansi-parser+default-devel \
 rust-ansi-parser+std-devel \
 rust-ansi-parser-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ansi-parser-0.9.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6770c55f3586469b718d3d95837e5f60949c6fe120eb8a6868a69269408256c4"

URI_x86_64_v2_rust-ansi-parser+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi-parser+default-devel-0.9.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi-parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi-parser+default-devel}"
SRC_URI[x86_64_v2_rust-ansi-parser+default-devel.sha256sum] = "6d283d72d22d966b8cc51ccd5e9e6a96e9093645b941416cf3e46d283e606966"

URI_x86_64_v2_rust-ansi-parser+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi-parser+std-devel-0.9.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi-parser+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi-parser+std-devel}"
SRC_URI[x86_64_v2_rust-ansi-parser+std-devel.sha256sum] = "24a2fcb9097182000f2be04ef705522c171d6799ae5c7642ffe6030f23406411"

URI_x86_64_v2_rust-ansi-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi-parser-devel-0.9.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi-parser-devel}"
SRC_URI[x86_64_v2_rust-ansi-parser-devel.sha256sum] = "acdf7dde64d25452fed7d7498609e48c09d62d41185cc0238d85d8c379f14659"

URI_aarch64_rust-ansi-parser+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi-parser+default-devel-0.9.1-3.el10_1.noarch.rpm;name=aarch64_rust-ansi-parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi-parser+default-devel}"
SRC_URI[aarch64_rust-ansi-parser+default-devel.sha256sum] = "db197f860901bbca01305e24c9ee274763f07b761785e7af9733c5cc114d82ed"

URI_aarch64_rust-ansi-parser+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi-parser+std-devel-0.9.1-3.el10_1.noarch.rpm;name=aarch64_rust-ansi-parser+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi-parser+std-devel}"
SRC_URI[aarch64_rust-ansi-parser+std-devel.sha256sum] = "49669cd39effb65353aeeecb9f3c364ac01fd667c936dd14a774589374a2090a"

URI_aarch64_rust-ansi-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi-parser-devel-0.9.1-3.el10_1.noarch.rpm;name=aarch64_rust-ansi-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi-parser-devel}"
SRC_URI[aarch64_rust-ansi-parser-devel.sha256sum] = "4bc85a52bd46e2be747a9388a4cc1ef8f81db19594b083427fcea818aefdc634"

RDEPENDS:rust-ansi-parser+default-devel = " \
 cargo \
 rust-ansi-parser+std-devel \
 rust-ansi-parser-devel \
 "
RDEPENDS:rust-ansi-parser+std-devel = " \
 cargo \
 rust-ansi-parser-devel \
 rust-nom7+std-devel \
 "
RDEPENDS:rust-ansi-parser-devel = " \
 cargo \
 rust-heapless+default-devel \
 rust-nom7-devel \
 "
