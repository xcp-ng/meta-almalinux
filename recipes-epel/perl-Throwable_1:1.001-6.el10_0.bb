# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Throwable"
PE = "1"
PV = "1.001"
PR = "6.el10_0"
PACKAGES = " \
 perl-Throwable \
 perl-Throwable-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Throwable-1.001-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f4147b9270a94adbc9062dc56313d8959371d24de8e96fd13b12bca618b4d45b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Throwable-1.001-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Throwable;unpack=0"
SRC_URI[x86_64_v2_perl-Throwable.sha256sum] = "b1ba5eaa5524b6a8f238a7b92970f7032725eb287beede4b72179921d93ab02d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Throwable-tests-1.001-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Throwable-tests;unpack=0"
SRC_URI[x86_64_v2_perl-Throwable-tests.sha256sum] = "f386fbf86ca8d20a5d4a5555671b33fe352abde565481fe9b79933713778b148"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Throwable-1.001-6.el10_0.noarch.rpm;name=aarch64_perl-Throwable;unpack=0"
SRC_URI[aarch64_perl-Throwable.sha256sum] = "7766e2df6573798d057f3ee4db9ec23ed28daf8ac8300029d6b898d898853bb2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Throwable-tests-1.001-6.el10_0.noarch.rpm;name=aarch64_perl-Throwable-tests;unpack=0"
SRC_URI[aarch64_perl-Throwable-tests.sha256sum] = "63c1543dd28e95cc958ad86f8a5ca775896b44abfa5046e38c9120b251590930"

RDEPENDS:perl-Throwable = " \
 perl-Carp \
 perl-Devel-StackTrace \
 perl-Module-Runtime \
 perl-Moo \
 perl-Scalar-List-Utils \
 perl-Sub-Quote \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Throwable-tests = " \
 bash \
 perl-Devel-StackTrace \
 perl-ExtUtils-MakeMaker \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Throwable \
 perl-base \
 perl-interpreter \
 perl-libs \
 "
