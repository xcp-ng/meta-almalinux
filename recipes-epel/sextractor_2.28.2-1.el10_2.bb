# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sextractor"
PV = "2.28.2"
PR = "1.el10_2"
PACKAGES = " \
 sextractor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sextractor-2.28.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "071ccbbfece77dc8202fbc20d1f4fcc1303245e436791ec9af281aaa97a90cc0"

URI_x86_64_v2_sextractor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sextractor-2.28.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sextractor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sextractor}"
SRC_URI[x86_64_v2_sextractor.sha256sum] = "19d8a613219debe5f5dc1a7c8afa99b92dcceff0e97b8c893a88c9f56263a572"

URI_aarch64_sextractor = "${EPEL_MIRROR}/aarch64/Packages/s/sextractor-2.28.2-1.el10_2.aarch64.rpm;name=aarch64_sextractor;unpack=0"
SRC_URI:append = " ${URI_aarch64_sextractor}"
SRC_URI[aarch64_sextractor.sha256sum] = "980500b386d1a33aab5c63630dbdc56102df15107e7ab9cc9ecce3d19259eaa0"

RDEPENDS:sextractor = " \
 cfitsio \
 fftw-libs-single \
 glibc \
 openblas-threads \
 "
