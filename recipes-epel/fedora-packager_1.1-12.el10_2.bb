# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-packager"
PV = "1.1"
PR = "12.el10_2"
PACKAGES = " \
 fedora-packager \
 fedora-packager-kerberos \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-packager-1.1-12.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f253a38ef253cf06f4ab4f672748f9e66f2b76c24672cc7a9fb11658d7e55183"

URI_x86_64_v2_fedora-packager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-packager-1.1-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-packager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-packager}"
SRC_URI[x86_64_v2_fedora-packager.sha256sum] = "8883f73caa1f20e94cb14514258710f26fdf71231dc9b8cdfba79e94a8492a14"

URI_x86_64_v2_fedora-packager-kerberos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-packager-kerberos-1.1-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-packager-kerberos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-packager-kerberos}"
SRC_URI[x86_64_v2_fedora-packager-kerberos.sha256sum] = "cbcf6a4d3ef407aa013771b4cee86f23de973d693ef82205fcc2b3335e608280"

URI_aarch64_fedora-packager = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-packager-1.1-12.el10_2.noarch.rpm;name=aarch64_fedora-packager;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-packager}"
SRC_URI[aarch64_fedora-packager.sha256sum] = "da9627c832df6c0f49ae676c873dc62130ae9a0f336760a0a63b3c7ede96d1ac"

URI_aarch64_fedora-packager-kerberos = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-packager-kerberos-1.1-12.el10_2.noarch.rpm;name=aarch64_fedora-packager-kerberos;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-packager-kerberos}"
SRC_URI[aarch64_fedora-packager-kerberos.sha256sum] = "4b9eb1e5055020fd2d48bbcee011244009f9e81c21eaace69ecb9f5519d739ac"

RDEPENDS:fedora-packager = " \
 bash \
 bodhi-client \
 curl \
 fedora-packager-kerberos \
 fedpkg \
 koji \
 mock \
 openssh-clients \
 python3 \
 python3-koji-cli-plugins \
 redhat-rpm-config \
 rpm-build \
 rpmautospec \
 rpmdevtools \
 rpmlint \
 systemd \
 "
RDEPENDS:fedora-packager-kerberos = " \
 bash \
 fedora-packager \
 krb5-pkinit \
 krb5-workstation \
 "
