# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Warnings"
PV = "0.033"
PR = "3.el10"
PACKAGES = " \
 perl-Test-Warnings \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Test-Warnings-0.033-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1da935abd357d9846b950d0d7dd8bf5d0de19a1601c71ad125a6f191d51ce8ee"

URI_x86_64_v2_perl-Test-Warnings = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Test-Warnings-0.033-3.el10.noarch.rpm;name=x86_64_v2_perl-Test-Warnings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Warnings}"
SRC_URI[x86_64_v2_perl-Test-Warnings.sha256sum] = "20220a911ad95a86082703811118cdaafc83aea8c30601140fbfe47743250fda"

URI_aarch64_perl-Test-Warnings = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Test-Warnings-0.033-3.el10.noarch.rpm;name=aarch64_perl-Test-Warnings;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Warnings}"
SRC_URI[aarch64_perl-Test-Warnings.sha256sum] = "20220a911ad95a86082703811118cdaafc83aea8c30601140fbfe47743250fda"

RDEPENDS:perl-Test-Warnings = " \
 perl-Carp \
 perl-Exporter \
 perl-Test-Simple \
 perl-libs \
 perl-parent \
 "
