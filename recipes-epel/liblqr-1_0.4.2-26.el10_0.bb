# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liblqr-1"
PV = "0.4.2"
PR = "26.el10_0"
PACKAGES = " \
 liblqr-1 \
 liblqr-1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/liblqr-1-0.4.2-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe72cf71f93f6c8adb8cb0c8ba4677bfaed34db179bf3d571f6fceb87cf8113b"

URI_x86_64_v2_liblqr-1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblqr-1-0.4.2-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblqr-1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblqr-1}"
SRC_URI[x86_64_v2_liblqr-1.sha256sum] = "7176472c717a11c74a9fa987b06cc20c52c9aed446a1128c1171069b55915c9b"

URI_x86_64_v2_liblqr-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblqr-1-devel-0.4.2-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblqr-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblqr-1-devel}"
SRC_URI[x86_64_v2_liblqr-1-devel.sha256sum] = "04f79ee844fba215f7ec11ade79ad42b0439264e894c764bb30be9a8996fa9d6"

URI_aarch64_liblqr-1 = "${EPEL_MIRROR}/aarch64/Packages/l/liblqr-1-0.4.2-26.el10_0.aarch64.rpm;name=aarch64_liblqr-1;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblqr-1}"
SRC_URI[aarch64_liblqr-1.sha256sum] = "53d31d5e9ea735c9f82fb5f5db9f3a270862c413444be80644d6b4f3ea3bd22b"

URI_aarch64_liblqr-1-devel = "${EPEL_MIRROR}/aarch64/Packages/l/liblqr-1-devel-0.4.2-26.el10_0.aarch64.rpm;name=aarch64_liblqr-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblqr-1-devel}"
SRC_URI[aarch64_liblqr-1-devel.sha256sum] = "20d555d79c5a7ca0c83d213e8241d5d32f4fe1b62fec31704fefb4cc4f06667c"

RDEPENDS:liblqr-1 = " \
 glib2 \
 glibc \
 "
RDEPENDS:liblqr-1-devel = " \
 glib2-devel \
 liblqr-1 \
 pkgconf-pkg-config \
 "
