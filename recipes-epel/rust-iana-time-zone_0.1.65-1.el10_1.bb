# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-iana-time-zone"
PV = "0.1.65"
PR = "1.el10_1"
PACKAGES = " \
 rust-iana-time-zone+default-devel \
 rust-iana-time-zone+fallback-devel \
 rust-iana-time-zone-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-iana-time-zone-0.1.65-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70931f8496a2ba7f8c8862f39cfadb1af554021c8858b393bb92999508cb16a0"

URI_x86_64_v2_rust-iana-time-zone+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iana-time-zone+default-devel-0.1.65-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iana-time-zone+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iana-time-zone+default-devel}"
SRC_URI[x86_64_v2_rust-iana-time-zone+default-devel.sha256sum] = "52495a2b86ed928c565548b4ec762717bd6a5262f5e6cdc421b183378bf11744"

URI_x86_64_v2_rust-iana-time-zone+fallback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iana-time-zone+fallback-devel-0.1.65-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iana-time-zone+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iana-time-zone+fallback-devel}"
SRC_URI[x86_64_v2_rust-iana-time-zone+fallback-devel.sha256sum] = "d0ac12ca0c88ee994fda701a754c74b25653c24ececfc9d3cb4917fe4779e343"

URI_x86_64_v2_rust-iana-time-zone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iana-time-zone-devel-0.1.65-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iana-time-zone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iana-time-zone-devel}"
SRC_URI[x86_64_v2_rust-iana-time-zone-devel.sha256sum] = "0506f46b5f452cb667839ab89750f6562738499df756bc67da66fb37d8de17bf"

URI_aarch64_rust-iana-time-zone+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iana-time-zone+default-devel-0.1.65-1.el10_1.noarch.rpm;name=aarch64_rust-iana-time-zone+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iana-time-zone+default-devel}"
SRC_URI[aarch64_rust-iana-time-zone+default-devel.sha256sum] = "f9811b790f3dd94a550dae3604c828a17ad6b48b7c5c2244abe020ba96863f32"

URI_aarch64_rust-iana-time-zone+fallback-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iana-time-zone+fallback-devel-0.1.65-1.el10_1.noarch.rpm;name=aarch64_rust-iana-time-zone+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iana-time-zone+fallback-devel}"
SRC_URI[aarch64_rust-iana-time-zone+fallback-devel.sha256sum] = "937dd93eaa0190850330a697a0fee97e83fb6297d1392b1e30e46743b35f1a60"

URI_aarch64_rust-iana-time-zone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iana-time-zone-devel-0.1.65-1.el10_1.noarch.rpm;name=aarch64_rust-iana-time-zone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iana-time-zone-devel}"
SRC_URI[aarch64_rust-iana-time-zone-devel.sha256sum] = "c1ade30f21b796c88a43499c63a5ac8cff4c6baebe956969b8bd28678a8c4b75"

RDEPENDS:rust-iana-time-zone+default-devel = " \
 cargo \
 rust-iana-time-zone-devel \
 "
RDEPENDS:rust-iana-time-zone+fallback-devel = " \
 cargo \
 rust-iana-time-zone-devel \
 "
RDEPENDS:rust-iana-time-zone-devel = " \
 cargo \
 rust \
 "
