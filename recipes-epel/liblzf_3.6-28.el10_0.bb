# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liblzf"
PV = "3.6"
PR = "28.el10_0"
PACKAGES = " \
 liblzf \
 liblzf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/liblzf-3.6-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "faeebd5aca1f5cd1a9c9e05bdc4f937f49af5e77120f42e1c666de931718e765"

URI_x86_64_v2_liblzf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblzf-3.6-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblzf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblzf}"
SRC_URI[x86_64_v2_liblzf.sha256sum] = "ad45c03fe339fbdae4e161e165430593e84ff1dde1a18ab422d162356c4d7cbf"

URI_x86_64_v2_liblzf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblzf-devel-3.6-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblzf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblzf-devel}"
SRC_URI[x86_64_v2_liblzf-devel.sha256sum] = "12c0160611275087d02cfcf0fec1b99e0d6b6ea3cd89c7b151c9b5b3b876a5a1"

URI_aarch64_liblzf = "${EPEL_MIRROR}/aarch64/Packages/l/liblzf-3.6-28.el10_0.aarch64.rpm;name=aarch64_liblzf;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblzf}"
SRC_URI[aarch64_liblzf.sha256sum] = "af58a9327fdba9a71b7c620b85f96ddcb34e4678ed9252da5472d35311db6cb7"

URI_aarch64_liblzf-devel = "${EPEL_MIRROR}/aarch64/Packages/l/liblzf-devel-3.6-28.el10_0.aarch64.rpm;name=aarch64_liblzf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblzf-devel}"
SRC_URI[aarch64_liblzf-devel.sha256sum] = "9d9ab1920f1fc625cc8d10fa0b39dc28c0b3c9291d3a25873a61d755d829d4e8"

RDEPENDS:liblzf = " \
 glibc \
 "
RDEPENDS:liblzf-devel = " \
 liblzf \
 pkgconf-pkg-config \
 "
