# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtpositioning"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtpositioning \
 qt6-qtpositioning-devel \
 qt6-qtpositioning-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtpositioning-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "147f7b25bdc2cfa5888f113f6c3c1e61c7473420f9c99de1458b77cbf8cf5c97"

URI_x86_64_v2_qt6-qtpositioning = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtpositioning-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtpositioning;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtpositioning}"
SRC_URI[x86_64_v2_qt6-qtpositioning.sha256sum] = "ee8d24ee10816013965bb1e679f0f03e3980f7e2ff6c74c11765ea8a10261435"

URI_x86_64_v2_qt6-qtpositioning-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtpositioning-devel-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtpositioning-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtpositioning-devel}"
SRC_URI[x86_64_v2_qt6-qtpositioning-devel.sha256sum] = "721df75205f0762b1113815fe6918088552d83f0b2347758a7ce8af76d6ad919"

URI_x86_64_v2_qt6-qtpositioning-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtpositioning-examples-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtpositioning-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtpositioning-examples}"
SRC_URI[x86_64_v2_qt6-qtpositioning-examples.sha256sum] = "a526201208bb08e6e7d5c018fd18df7e0dc3486b51ed81a28c0b0998463ff829"

URI_aarch64_qt6-qtpositioning = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtpositioning-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtpositioning;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtpositioning}"
SRC_URI[aarch64_qt6-qtpositioning.sha256sum] = "68b9e2514ba245cf454686abd62543397694aee8b35716f262f5e7a63060bd97"

URI_aarch64_qt6-qtpositioning-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtpositioning-devel-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtpositioning-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtpositioning-devel}"
SRC_URI[aarch64_qt6-qtpositioning-devel.sha256sum] = "bdaf4ee75751f009badd1af89d3ce71eebea0bad4aeeac13f3b95945ce6cb89f"

URI_aarch64_qt6-qtpositioning-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtpositioning-examples-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtpositioning-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtpositioning-examples}"
SRC_URI[aarch64_qt6-qtpositioning-examples.sha256sum] = "0de9b87b15a32717db38b29e75c1bf215fc497ed6143b8b3d29a1d53a7bd363b"

RDEPENDS:qt6-qtpositioning = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 qt6-qtserialport \
 "
RDEPENDS:qt6-qtpositioning-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtpositioning \
 qt6-qtpositioning-devel \
 "
RDEPENDS:qt6-qtpositioning-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 "
