# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-echo"
PV = "0.1.4"
PR = "11.el10_0"
PACKAGES = " \
 ghc-echo \
 ghc-echo-devel \
 ghc-echo-doc \
 ghc-echo-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-echo-0.1.4-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7f95866588f75b11f3bffdc15aee2d59783bc6f6d9cfbcac2f6c7cecdf2d511"

URI_x86_64_v2_ghc-echo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-echo-0.1.4-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-echo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-echo}"
SRC_URI[x86_64_v2_ghc-echo.sha256sum] = "6c2aeb3904ceab65a3ec866089fc08d5b8e998852c9cea1451b68ca9f0516524"

URI_x86_64_v2_ghc-echo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-echo-devel-0.1.4-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-echo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-echo-devel}"
SRC_URI[x86_64_v2_ghc-echo-devel.sha256sum] = "420568083c770032a3db057c34095b9bbd7c59e3b817391a8b45e56c01457b54"

URI_x86_64_v2_ghc-echo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-echo-doc-0.1.4-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-echo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-echo-doc}"
SRC_URI[x86_64_v2_ghc-echo-doc.sha256sum] = "6858ae0c9a16af02075d22ab1532e12b27189d1c99cacd32625664e3a4cf45d5"

URI_x86_64_v2_ghc-echo-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-echo-prof-0.1.4-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-echo-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-echo-prof}"
SRC_URI[x86_64_v2_ghc-echo-prof.sha256sum] = "b60d605f903db99be386e2109d7db40b535a7f1a03bb5cf88c5a2d585d4cc8c2"

URI_aarch64_ghc-echo = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-echo-0.1.4-11.el10_0.aarch64.rpm;name=aarch64_ghc-echo;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-echo}"
SRC_URI[aarch64_ghc-echo.sha256sum] = "46a0e595bd8e07108e626ab2369065d7e51f6389cc51d25534c18418a9975c0c"

URI_aarch64_ghc-echo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-echo-devel-0.1.4-11.el10_0.aarch64.rpm;name=aarch64_ghc-echo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-echo-devel}"
SRC_URI[aarch64_ghc-echo-devel.sha256sum] = "5f1bc61ede4c3d2ee200949894b82b9fb521c82fd0ec7f96540b6e53aa925e18"

URI_aarch64_ghc-echo-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-echo-doc-0.1.4-11.el10_0.noarch.rpm;name=aarch64_ghc-echo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-echo-doc}"
SRC_URI[aarch64_ghc-echo-doc.sha256sum] = "17029e90d1f4c1a61fb4f9c1fbdc9522c7fda3ac4e603576c383181d28d91334"

URI_aarch64_ghc-echo-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-echo-prof-0.1.4-11.el10_0.aarch64.rpm;name=aarch64_ghc-echo-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-echo-prof}"
SRC_URI[aarch64_ghc-echo-prof.sha256sum] = "6b3b8d938ba6fdf6a92c6d0e237f66fe62c24e850b4661c0cc54e212eeb98697"

RDEPENDS:ghc-echo = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-echo-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-echo \
 ghc-process-devel \
 "
RDEPENDS:ghc-echo-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-echo-prof = " \
 ghc-base-prof \
 ghc-echo-devel \
 ghc-process-prof \
 "
