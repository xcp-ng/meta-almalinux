# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-menuinst"
PV = "2.4.2"
PR = "2.el10_3~bootstrap"
PACKAGES = " \
 python3-menuinst \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-menuinst-2.4.2-2.el10_3~bootstrap.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4c0630b69940813edf9d5c7dd42241fb4d6bb8d207d7a79abfaf3650dff1dee"

URI_aarch64_python3-menuinst = "${EPEL_MIRROR}/aarch64/Packages/p/python3-menuinst-2.4.2-2.el10_3~bootstrap.noarch.rpm;name=aarch64_python3-menuinst;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-menuinst}"
SRC_URI[aarch64_python3-menuinst.sha256sum] = "70c0350753b03258b32caee37b07a3393ae1f9b5d028d1e08382b88f4db74875"

RDEPENDS:python3-menuinst = " \
 python3 \
 "
