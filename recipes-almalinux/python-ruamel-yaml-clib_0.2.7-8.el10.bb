# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ruamel-yaml-clib"
PV = "0.2.7"
PR = "8.el10"
PACKAGES = " \
 python3-ruamel-yaml-clib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-ruamel-yaml-clib-0.2.7-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10e0554f1b44fde1efea60bd27169c4950a043cbbba5a0487d4df7c2cfd6d924"

URI_x86_64_v2_python3-ruamel-yaml-clib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ruamel-yaml-clib-0.2.7-8.el10.x86_64_v2.rpm;name=x86_64_v2_python3-ruamel-yaml-clib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ruamel-yaml-clib}"
SRC_URI[x86_64_v2_python3-ruamel-yaml-clib.sha256sum] = "de8a038437e6201b4c1e32b212264d9427e62cde8b200b69faa585c39469b987"

URI_aarch64_python3-ruamel-yaml-clib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ruamel-yaml-clib-0.2.7-8.el10.aarch64.rpm;name=aarch64_python3-ruamel-yaml-clib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ruamel-yaml-clib}"
SRC_URI[aarch64_python3-ruamel-yaml-clib.sha256sum] = "0373133ae8414e8d8df29fbb45e110eca2bef4de945bf37b9fff1a837e2c2c72"

RDEPENDS:python3-ruamel-yaml-clib = " \
 glibc \
 python3 \
 python3-ruamel-yaml \
 "
