# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-io-streams"
PV = "1.5.2.2"
PR = "9.el10_0"
PACKAGES = " \
 ghc-io-streams \
 ghc-io-streams-devel \
 ghc-io-streams-doc \
 ghc-io-streams-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-io-streams-1.5.2.2-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79622be7435225272217268cd728751163c6eca285d0b7d64fdd342bbaf02205"

URI_x86_64_v2_ghc-io-streams = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-io-streams-1.5.2.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-io-streams;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-io-streams}"
SRC_URI[x86_64_v2_ghc-io-streams.sha256sum] = "68bec8dc19ce87e77261e3a312f1cf0592eb72fa7f175e7a982bd7a8f7fa24d0"

URI_x86_64_v2_ghc-io-streams-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-io-streams-devel-1.5.2.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-io-streams-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-io-streams-devel}"
SRC_URI[x86_64_v2_ghc-io-streams-devel.sha256sum] = "42ca7ce295bbf0f23515ec89ad068b20b96fa8b0d1a617b72eb9280ca1928719"

URI_x86_64_v2_ghc-io-streams-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-io-streams-doc-1.5.2.2-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-io-streams-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-io-streams-doc}"
SRC_URI[x86_64_v2_ghc-io-streams-doc.sha256sum] = "828a6fab30e8ea6bb38fe4989a84055adc058538797c02a8b4d8915afaa94333"

URI_x86_64_v2_ghc-io-streams-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-io-streams-prof-1.5.2.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-io-streams-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-io-streams-prof}"
SRC_URI[x86_64_v2_ghc-io-streams-prof.sha256sum] = "dc57b079553925e1a3a53d1421b37ea9230c27418a20d35e3b916159cb63f563"

URI_aarch64_ghc-io-streams = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-io-streams-1.5.2.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-io-streams;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-io-streams}"
SRC_URI[aarch64_ghc-io-streams.sha256sum] = "293e717e06fc1b00ebdb394da5c905e8e9ad1a1302cce04a73e17337ae185d78"

URI_aarch64_ghc-io-streams-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-io-streams-devel-1.5.2.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-io-streams-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-io-streams-devel}"
SRC_URI[aarch64_ghc-io-streams-devel.sha256sum] = "555214e3cb9dace1c88edb956612e204c54482d113d6d5ed8d29dce2ac797fd7"

URI_aarch64_ghc-io-streams-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-io-streams-doc-1.5.2.2-9.el10_0.noarch.rpm;name=aarch64_ghc-io-streams-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-io-streams-doc}"
SRC_URI[aarch64_ghc-io-streams-doc.sha256sum] = "ebdf146a1ab7efaf61395a90374ea5942d141c25b04e94c9da9664faf14e1f78"

URI_aarch64_ghc-io-streams-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-io-streams-prof-1.5.2.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-io-streams-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-io-streams-prof}"
SRC_URI[aarch64_ghc-io-streams-prof.sha256sum] = "c97dadfcf404365bbdb7c7874ca23244882a5ef3fe70ed10571ea688094a3f92"

RDEPENDS:ghc-io-streams = " \
 ghc-array \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-scientific \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-vector \
 ghc-vector-stream \
 ghc-zlib \
 ghc-zlib-bindings \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-io-streams-devel = " \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-io-streams \
 ghc-network-devel \
 ghc-primitive-devel \
 ghc-process-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-vector-devel \
 ghc-zlib-bindings-devel \
 "
RDEPENDS:ghc-io-streams-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-io-streams-prof = " \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-io-streams-devel \
 ghc-network-prof \
 ghc-primitive-prof \
 ghc-process-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-vector-prof \
 ghc-zlib-bindings-prof \
 "
