# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtsensors"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtsensors \
 qt6-qtsensors-devel \
 qt6-qtsensors-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtsensors-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfad9f0ddae98039a76710cb8c453315772498a5cc91485120b2ed7131fd2a46"

URI_x86_64_v2_qt6-qtsensors = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtsensors-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtsensors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtsensors}"
SRC_URI[x86_64_v2_qt6-qtsensors.sha256sum] = "e1877c4e8008fd54cf60bf0e89cb549ffc57e232f495d33c50b8fba1bc13b915"

URI_x86_64_v2_qt6-qtsensors-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtsensors-devel-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtsensors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtsensors-devel}"
SRC_URI[x86_64_v2_qt6-qtsensors-devel.sha256sum] = "3bd6e14070d4ae4687afdb936b0dd39c9b4f4de1fc50c77807840711c4ae8b03"

URI_x86_64_v2_qt6-qtsensors-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtsensors-examples-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtsensors-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtsensors-examples}"
SRC_URI[x86_64_v2_qt6-qtsensors-examples.sha256sum] = "eef1642874d245bc0d76d5b70b47a35e3975770b6ab0ae8e371927a61138af38"

URI_aarch64_qt6-qtsensors = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtsensors-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtsensors;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtsensors}"
SRC_URI[aarch64_qt6-qtsensors.sha256sum] = "648c017eba30f25e3ed2e5ec15e53aed9cbe9a6f88075a81198f768bfbd5969e"

URI_aarch64_qt6-qtsensors-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtsensors-devel-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtsensors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtsensors-devel}"
SRC_URI[aarch64_qt6-qtsensors-devel.sha256sum] = "166193f5f7ea86caabb22fccaaff7af150a521e5f3700f9fa82800d5890e63f3"

URI_aarch64_qt6-qtsensors-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtsensors-examples-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtsensors-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtsensors-examples}"
SRC_URI[aarch64_qt6-qtsensors-examples.sha256sum] = "3f742ca7eebdc36f08bddee70133d497b0fb3746ae0e9a891250ec9d60705852"

RDEPENDS:qt6-qtsensors = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtsensors-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtsensors \
 qt6-qtsensors-devel \
 "
RDEPENDS:qt6-qtsensors-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsensors \
 "
