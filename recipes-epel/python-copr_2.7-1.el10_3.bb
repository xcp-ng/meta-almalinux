# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-copr"
PV = "2.7"
PR = "1.el10_3"
PACKAGES = " \
 python-copr-doc \
 python3-copr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-copr-2.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a3a3700b3b00d044acae16109939ba18d0547e5f458bb5998da443b4a8e2646"

URI_x86_64_v2_python-copr-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-copr-doc-2.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-copr-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-copr-doc}"
SRC_URI[x86_64_v2_python-copr-doc.sha256sum] = "8c8b53ca40f5b300d0e828bccf3a7410b7455d2e40891ee1a13e6f508f03b9c3"

URI_x86_64_v2_python3-copr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-copr-2.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-copr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-copr}"
SRC_URI[x86_64_v2_python3-copr.sha256sum] = "31f9f786f5206851c648d836bc977c61a585656390818a6ab0052d755730d570"

URI_aarch64_python-copr-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-copr-doc-2.7-1.el10_3.noarch.rpm;name=aarch64_python-copr-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-copr-doc}"
SRC_URI[aarch64_python-copr-doc.sha256sum] = "44554421af9110010604de4e0bcc36d2d95dfd3947c887e33d39c5b15ed5bbd9"

URI_aarch64_python3-copr = "${EPEL_MIRROR}/aarch64/Packages/p/python3-copr-2.7-1.el10_3.noarch.rpm;name=aarch64_python3-copr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-copr}"
SRC_URI[aarch64_python3-copr.sha256sum] = "e970a94798089017b920073a9f0141c32fc58da4a22d8f8585af51c5c3bdd116"

RDEPENDS:python-copr-doc = " \
 "
RDEPENDS:python3-copr = " \
 python3 \
 python3-filelock \
 python3-munch \
 python3-requests \
 python3-requests-gssapi \
 python3-requests-toolbelt \
 python3-setuptools \
 "
