# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sandogasa"
PV = "0.11.0"
PR = "1.el10_2"
PACKAGES = " \
 sandogasa \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sandogasa-0.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dfbbc3c1151aab8699baff88089993e97b5ee12e4c5881a064d7818112377752"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sandogasa-0.11.0-1.el10_2.aarch64.rpm;name=aarch64_sandogasa;unpack=0"
SRC_URI[aarch64_sandogasa.sha256sum] = "cbbea618870e034a29e74a96e57de8424bf6473ab3993285b9563606597f97c2"

RDEPENDS:sandogasa = " \
 glibc \
 koji \
 libgcc \
 "
