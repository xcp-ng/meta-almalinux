# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ark"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 ark \
 ark-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ark-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "303bac2ce086608f65e6c1d17c2baaa694d2439c1eef10f0ca3c1939f4ecab19"

URI_x86_64_v2_ark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ark-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ark}"
SRC_URI[x86_64_v2_ark.sha256sum] = "898a428fe6a9ba50ff72a275236658e16117ecb81d08d1e0d11a2529d0882faa"

URI_x86_64_v2_ark-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ark-libs-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ark-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ark-libs}"
SRC_URI[x86_64_v2_ark-libs.sha256sum] = "fbd2cfaf6e5e3a60bb02bd62a38562d1640ae6139ccf3a390abceaa42b09e9b3"

URI_aarch64_ark = "${EPEL_MIRROR}/aarch64/Packages/a/ark-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_ark;unpack=0"
SRC_URI:append = " ${URI_aarch64_ark}"
SRC_URI[aarch64_ark.sha256sum] = "772a1ff8a7e452c3af805c28ee9fa6eb96fa4779895ef12a104e66e706931b0d"

URI_aarch64_ark-libs = "${EPEL_MIRROR}/aarch64/Packages/a/ark-libs-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_ark-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ark-libs}"
SRC_URI[aarch64_ark-libs.sha256sum] = "0bb4918b1480ae2a18f9b880b72f9b0b738e9787a5f5af226a8a0dd654290a30"

RDEPENDS:ark = " \
 ark-libs \
 bzip2 \
 glibc \
 gzip \
 kf6-breeze-icons \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 unzip \
 "
RDEPENDS:ark-libs = " \
 ark \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kpty \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libarchive \
 libgcc \
 libstdc++ \
 libzip \
 qt6-qtbase \
 qt6-qtbase-gui \
 zlib-ng-compat \
 "
