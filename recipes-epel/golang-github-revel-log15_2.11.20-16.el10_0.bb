# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-revel-log15"
PV = "2.11.20"
PR = "16.el10_0"
PACKAGES = " \
 golang-github-revel-log15-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-revel-log15-2.11.20-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53a3c2c6bc4e8ef968dfd58407370813a6e0237ba9139a59cc4e2bbce6ef558f"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-github-revel-log15-devel: golang(gopkg.in/stack.v0)

URI_x86_64_v2_golang-github-revel-log15-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-revel-log15-devel-2.11.20-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-revel-log15-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-revel-log15-devel}"
SRC_URI[x86_64_v2_golang-github-revel-log15-devel.sha256sum] = "afe03f13e688c8b0474d2e0f3dd63db73a9cf04f05697c6ea2998e36dc193099"

URI_aarch64_golang-github-revel-log15-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-revel-log15-devel-2.11.20-16.el10_0.noarch.rpm;name=aarch64_golang-github-revel-log15-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-revel-log15-devel}"
SRC_URI[aarch64_golang-github-revel-log15-devel.sha256sum] = "62337692c05895847ce47fec43317d87ad830235c379c1d2d32145bb63ebc949"

RDEPENDS:golang-github-revel-log15-devel:x86_64_v2 = " \
 go-filesystem \
 golang-github-inconshreveable-log15-devel \
 golang-github-mattn-colorable-devel \
"
RDEPENDS:golang-github-revel-log15-devel:aarch64 = " \
 go-filesystem \
 golang-github-inconshreveable-log15-devel \
 golang-github-mattn-colorable-devel \
 golang-gopkg-stack-0-devel \
"
