# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xmlrpc-c"
PV = "1.60.04"
PR = "2.el10_0"
PACKAGES = " \
 xmlrpc-c \
 xmlrpc-c-apps \
 xmlrpc-c-c++ \
 xmlrpc-c-client \
 xmlrpc-c-client++ \
 xmlrpc-c-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xmlrpc-c-1.60.04-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a29b2938d560f49902094c70063e1de43d9354f8b48beffa38b3b1604cc06071"

URI_x86_64_v2_xmlrpc-c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xmlrpc-c-1.60.04-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xmlrpc-c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlrpc-c}"
SRC_URI[x86_64_v2_xmlrpc-c.sha256sum] = "2f9cd4667d490d1996beec1cd21f71288bf97b4318c62e6c7b4d1adb13b1d451"

URI_x86_64_v2_xmlrpc-c-apps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xmlrpc-c-apps-1.60.04-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xmlrpc-c-apps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlrpc-c-apps}"
SRC_URI[x86_64_v2_xmlrpc-c-apps.sha256sum] = "4f8b4dc7c104a9f098c995f0aaaf149dc095d9a2f404687480a261eada3eec8e"

URI_x86_64_v2_xmlrpc-c-c++ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xmlrpc-c-c++-1.60.04-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xmlrpc-c-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlrpc-c-c++}"
SRC_URI[x86_64_v2_xmlrpc-c-c++.sha256sum] = "8edb706ec708da059110a6560c10fcb74025ebe16472418f793066b8d85bffd4"

URI_x86_64_v2_xmlrpc-c-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xmlrpc-c-client-1.60.04-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xmlrpc-c-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlrpc-c-client}"
SRC_URI[x86_64_v2_xmlrpc-c-client.sha256sum] = "701c606abaa9b14e26c123eb0af719f82251dd1ae03572d4916c82f6a649931b"

URI_x86_64_v2_xmlrpc-c-client++ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xmlrpc-c-client++-1.60.04-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xmlrpc-c-client++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlrpc-c-client++}"
SRC_URI[x86_64_v2_xmlrpc-c-client++.sha256sum] = "f12e492da8dd0c6efae725b88eba7bed3ca3e897924e2e7618385380eb1e63c7"

URI_x86_64_v2_xmlrpc-c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xmlrpc-c-devel-1.60.04-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xmlrpc-c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlrpc-c-devel}"
SRC_URI[x86_64_v2_xmlrpc-c-devel.sha256sum] = "85b19dbec9c0bdf16f86a06407f707d4c7bd5b37d2e7bd82c79e54268e5acddf"

URI_aarch64_xmlrpc-c = "${EPEL_MIRROR}/aarch64/Packages/x/xmlrpc-c-1.60.04-2.el10_0.aarch64.rpm;name=aarch64_xmlrpc-c;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlrpc-c}"
SRC_URI[aarch64_xmlrpc-c.sha256sum] = "2ee17cb278726dee0e4658c481b7f210fcf78a36262fc6cb66ca875fbba166d0"

URI_aarch64_xmlrpc-c-apps = "${EPEL_MIRROR}/aarch64/Packages/x/xmlrpc-c-apps-1.60.04-2.el10_0.aarch64.rpm;name=aarch64_xmlrpc-c-apps;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlrpc-c-apps}"
SRC_URI[aarch64_xmlrpc-c-apps.sha256sum] = "595b5096ee02e0258e82a1e950a5d131a408c62e689f98356e50ecd7dc1b816f"

URI_aarch64_xmlrpc-c-c++ = "${EPEL_MIRROR}/aarch64/Packages/x/xmlrpc-c-c++-1.60.04-2.el10_0.aarch64.rpm;name=aarch64_xmlrpc-c-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlrpc-c-c++}"
SRC_URI[aarch64_xmlrpc-c-c++.sha256sum] = "6979cb4ffb8687e00c53d667dbaba1dd9dab3b8e5299c7149294be824a659c5a"

URI_aarch64_xmlrpc-c-client = "${EPEL_MIRROR}/aarch64/Packages/x/xmlrpc-c-client-1.60.04-2.el10_0.aarch64.rpm;name=aarch64_xmlrpc-c-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlrpc-c-client}"
SRC_URI[aarch64_xmlrpc-c-client.sha256sum] = "08814c895123b07a26c8f757cd45a0c7edcbb53b8996c3c588137df14e5cb74c"

URI_aarch64_xmlrpc-c-client++ = "${EPEL_MIRROR}/aarch64/Packages/x/xmlrpc-c-client++-1.60.04-2.el10_0.aarch64.rpm;name=aarch64_xmlrpc-c-client++;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlrpc-c-client++}"
SRC_URI[aarch64_xmlrpc-c-client++.sha256sum] = "a744105391ddb1f9e55dca977061b4d43218bc1d78d562225b13dbd654b12bca"

URI_aarch64_xmlrpc-c-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xmlrpc-c-devel-1.60.04-2.el10_0.aarch64.rpm;name=aarch64_xmlrpc-c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlrpc-c-devel}"
SRC_URI[aarch64_xmlrpc-c-devel.sha256sum] = "1a7dce889d1fb45df14a993a17b53e6b5c0d34a48b897cd707a58368145adc37"

RDEPENDS:xmlrpc-c = " \
 glibc \
 libgcc \
 openssl-libs \
 "
RDEPENDS:xmlrpc-c-apps = " \
 glibc \
 libgcc \
 libstdc++ \
 perl-interpreter \
 readline \
 xmlrpc-c \
 xmlrpc-c-c++ \
 xmlrpc-c-client \
 xmlrpc-c-client++ \
 "
RDEPENDS:xmlrpc-c-c++ = " \
 glibc \
 libgcc \
 libstdc++ \
 xmlrpc-c \
 "
RDEPENDS:xmlrpc-c-client = " \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 xmlrpc-c \
 "
RDEPENDS:xmlrpc-c-client++ = " \
 glibc \
 libgcc \
 libstdc++ \
 xmlrpc-c \
 xmlrpc-c-c++ \
 xmlrpc-c-client \
 "
RDEPENDS:xmlrpc-c-devel = " \
 bash \
 pkgconf-pkg-config \
 xmlrpc-c \
 xmlrpc-c-c++ \
 xmlrpc-c-client \
 xmlrpc-c-client++ \
 xmlrpc-c-devel \
 "
