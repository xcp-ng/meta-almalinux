# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knetwalk"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 knetwalk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/knetwalk-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65ede394f05268b6d29c9d8a248f2e0aa5d366b2a5834f6cab13c980a285c430"

URI_x86_64_v2_knetwalk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knetwalk-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knetwalk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knetwalk}"
SRC_URI[x86_64_v2_knetwalk.sha256sum] = "fb3e6814e9356c5a2d9afa74c40f8f9c9f5af5eb4483932c9b39b4c5573aaa87"

URI_aarch64_knetwalk = "${EPEL_MIRROR}/aarch64/Packages/k/knetwalk-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_knetwalk;unpack=0"
SRC_URI:append = " ${URI_aarch64_knetwalk}"
SRC_URI[aarch64_knetwalk.sha256sum] = "bdc1751f4c1bdcda5bef02287478fccf5a6172be0ec546bd213ccd998ffd585d"

RDEPENDS:knetwalk = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
