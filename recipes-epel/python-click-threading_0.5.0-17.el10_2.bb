# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-click-threading"
PV = "0.5.0"
PR = "17.el10_2"
PACKAGES = " \
 python3-click-threading \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-click-threading-0.5.0-17.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a073419e583e0321dd9932ae6db6f91d4d1ae93aed7d7136833ee21aee14053"

URI_x86_64_v2_python3-click-threading = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-click-threading-0.5.0-17.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-click-threading;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-click-threading}"
SRC_URI[x86_64_v2_python3-click-threading.sha256sum] = "5031975a7d39171f7ec656a4dd54b734ac4dae3f5d9b74b8e2e423bdc68b8590"

URI_aarch64_python3-click-threading = "${EPEL_MIRROR}/aarch64/Packages/p/python3-click-threading-0.5.0-17.el10_2.noarch.rpm;name=aarch64_python3-click-threading;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-click-threading}"
SRC_URI[aarch64_python3-click-threading.sha256sum] = "1401269e6ca4fd77e08a491ad1680aefa1a6156b5535d38c8253a719bc15e231"

RDEPENDS:python3-click-threading = " \
 python3 \
 python3-click \
 "
