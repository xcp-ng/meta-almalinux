# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pinentry"
PV = "1.3.1"
PR = "1.el10"
PACKAGES = " \
 pinentry \
 pinentry-gnome3 \
 pinentry-tty \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pinentry-1.3.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d774330730a8fc034729917ce9ebbcce335807b259982272ee2cdc316d0ae3d6"

URI_x86_64_v2_pinentry = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pinentry-1.3.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_pinentry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pinentry}"
SRC_URI[x86_64_v2_pinentry.sha256sum] = "a645264ddd36d3ea37965fa0e5edde473d945116a44ea1cf810b14b9b3e57e8e"

URI_x86_64_v2_pinentry-gnome3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pinentry-gnome3-1.3.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_pinentry-gnome3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pinentry-gnome3}"
SRC_URI[x86_64_v2_pinentry-gnome3.sha256sum] = "8547e109464ad46b3b4b172d98abab0598433b002832a1804fdc9a276f9771cb"

URI_x86_64_v2_pinentry-tty = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pinentry-tty-1.3.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_pinentry-tty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pinentry-tty}"
SRC_URI[x86_64_v2_pinentry-tty.sha256sum] = "e53d9968c63783361a5ef87466c109dfdaaf083e5b7e3869d1094df68fb2eea2"

URI_aarch64_pinentry = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pinentry-1.3.1-1.el10.aarch64.rpm;name=aarch64_pinentry;unpack=0"
SRC_URI:append = " ${URI_aarch64_pinentry}"
SRC_URI[aarch64_pinentry.sha256sum] = "d8fcf3fad1df1b42567611203c98a6c697cd79a68bbbb365c40ac08be1503b8c"

URI_aarch64_pinentry-gnome3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pinentry-gnome3-1.3.1-1.el10.aarch64.rpm;name=aarch64_pinentry-gnome3;unpack=0"
SRC_URI:append = " ${URI_aarch64_pinentry-gnome3}"
SRC_URI[aarch64_pinentry-gnome3.sha256sum] = "c845cbe56843494aa7f3ba31d4bc513efa243c150dee8f8409f8ac615230b699"

URI_aarch64_pinentry-tty = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pinentry-tty-1.3.1-1.el10.aarch64.rpm;name=aarch64_pinentry-tty;unpack=0"
SRC_URI:append = " ${URI_aarch64_pinentry-tty}"
SRC_URI[aarch64_pinentry-tty.sha256sum] = "ce50d58b8727bacef58979f25e664321914a78e68209a32b541b1d3cedbe0a7c"

RDEPENDS:pinentry = " \
 bash \
 glib2 \
 glibc \
 libassuan \
 libgpg-error \
 libsecret \
 ncurses-libs \
 "
RDEPENDS:pinentry-gnome3 = " \
 gcr-libs \
 glib2 \
 glibc \
 libassuan \
 libgpg-error \
 libsecret \
 ncurses-libs \
 pinentry \
 "
RDEPENDS:pinentry-tty = " \
 glib2 \
 glibc \
 libassuan \
 libgpg-error \
 libsecret \
 pinentry \
 "
