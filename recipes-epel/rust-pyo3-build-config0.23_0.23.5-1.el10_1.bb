# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-build-config0.23"
PV = "0.23.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-pyo3-build-config0.23+abi3-devel \
 rust-pyo3-build-config0.23+abi3-py310-devel \
 rust-pyo3-build-config0.23+abi3-py311-devel \
 rust-pyo3-build-config0.23+abi3-py312-devel \
 rust-pyo3-build-config0.23+abi3-py37-devel \
 rust-pyo3-build-config0.23+abi3-py38-devel \
 rust-pyo3-build-config0.23+abi3-py39-devel \
 rust-pyo3-build-config0.23+default-devel \
 rust-pyo3-build-config0.23+extension-module-devel \
 rust-pyo3-build-config0.23+resolve-config-devel \
 rust-pyo3-build-config0.23-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-build-config0.23-0.23.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "803b822dd58932474b9ae83798c0f866f746193f692a40f8782702326bd8a7ac"

URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+abi3-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+abi3-devel.sha256sum] = "15f7d18763287f12c5f82688d2a7e6b4e3b814d1b4809d3b8e4b693c18d61164"

URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+abi3-py310-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+abi3-py310-devel.sha256sum] = "e6e1e037cf96ddd6154a9872271d9bc780ae5a4cc59f95f5d17e931a22bd9443"

URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+abi3-py311-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+abi3-py311-devel.sha256sum] = "3a3f341e36c89993c9f016045170cf284c401a1ee6fdfdf87e3f35ee6a284693"

URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+abi3-py312-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+abi3-py312-devel.sha256sum] = "7f1ad5c09eaa63466415a7bb8b2e556a3456b2a3b56c879aed4dba6d20381f8d"

URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+abi3-py37-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+abi3-py37-devel.sha256sum] = "001aaa6dce12bbd06e73134ed2d5c0e4d2bfbe5596d5f502dcc801b53ea06aa6"

URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+abi3-py38-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+abi3-py38-devel.sha256sum] = "b9fb5b3fb83fa5c0458d506b5eac6c457b23fa407367a4e2ae9fca619718a158"

URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+abi3-py39-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+abi3-py39-devel.sha256sum] = "a08e2f48f6e43c849705e1ceae4c1ee3ee8099485dd17e4071be5a928df64ad9"

URI_x86_64_v2_rust-pyo3-build-config0.23+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+default-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+default-devel.sha256sum] = "ab442fed520ab38a53f28b0f78d23f86888a8aa9f5c2f5f9550c91bf333f68cb"

URI_x86_64_v2_rust-pyo3-build-config0.23+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+extension-module-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+extension-module-devel.sha256sum] = "d33a7c9f06901b1cf704576b1bd156f3f8fb458f9322dbd3ce56cb6d1bd3f840"

URI_x86_64_v2_rust-pyo3-build-config0.23+resolve-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23+resolve-config-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23+resolve-config-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23+resolve-config-devel.sha256sum] = "a4fddd0fa65994a2dc2e480810ca2ece2e3fb85276996e5a471243a9c31d883f"

URI_x86_64_v2_rust-pyo3-build-config0.23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.23-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.23-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.23-devel.sha256sum] = "f0c0f50ac28ccb8ce3ae8cba5b7fd788f6dcd15d20d788029e7bca3ff988d067"

URI_aarch64_rust-pyo3-build-config0.23+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+abi3-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+abi3-devel.sha256sum] = "5cffb90a81025e35d433d9b5be971f3e4f00f133a187fd7bb9ef35e6b95b20bb"

URI_aarch64_rust-pyo3-build-config0.23+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+abi3-py310-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+abi3-py310-devel.sha256sum] = "dad482c8b69920911adc6da80b9f30009569076a41bae64cc57c2deaf617b1cf"

URI_aarch64_rust-pyo3-build-config0.23+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+abi3-py311-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+abi3-py311-devel.sha256sum] = "8c925936df607fa2ac15fc9c8a42b5c4c13082c5649f62775409682f8fb33be4"

URI_aarch64_rust-pyo3-build-config0.23+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+abi3-py312-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+abi3-py312-devel.sha256sum] = "0c1a4f252efc110aa741bddcbdbba3d09d8fb2d5d444ea6f594135d7343e7257"

URI_aarch64_rust-pyo3-build-config0.23+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+abi3-py37-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+abi3-py37-devel.sha256sum] = "38491b37770805f0c89fc062eee543a9593fea713bc3d8afef2fb548e3d04c11"

URI_aarch64_rust-pyo3-build-config0.23+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+abi3-py38-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+abi3-py38-devel.sha256sum] = "be65f4630d465b2914327b17b374d6c5148f6ce0ed0cd50d466c48667ff69897"

URI_aarch64_rust-pyo3-build-config0.23+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+abi3-py39-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+abi3-py39-devel.sha256sum] = "d55be068086e7280f5263732e356a933cca5c427376bf8b962d014e53d596d82"

URI_aarch64_rust-pyo3-build-config0.23+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+default-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+default-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+default-devel.sha256sum] = "c3063ce746d949af642a58d69ff897acedcbf362301c3897345c751ca9e56335"

URI_aarch64_rust-pyo3-build-config0.23+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+extension-module-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+extension-module-devel.sha256sum] = "122bc0af095d3dc0cefb9687ddac454b95f645f4324cc6a2a66d35734a15fa91"

URI_aarch64_rust-pyo3-build-config0.23+resolve-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23+resolve-config-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23+resolve-config-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23+resolve-config-devel.sha256sum] = "be8d58981b2eb611e524ca6a45dba3a0dc9938857e6516b8f7e1f2023fcb3542"

URI_aarch64_rust-pyo3-build-config0.23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.23-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.23-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.23-devel.sha256sum] = "1ea3cd109e5c1fbbb259fc331d1e999e6ef498f040e17f6eb9e3008917ed5d16"

RDEPENDS:rust-pyo3-build-config0.23+abi3-devel = " \
 cargo \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+abi3-py310-devel = " \
 cargo \
 rust-pyo3-build-config0.23+abi3-py311-devel \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+abi3-py311-devel = " \
 cargo \
 rust-pyo3-build-config0.23+abi3-py312-devel \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+abi3-py312-devel = " \
 cargo \
 rust-pyo3-build-config0.23+abi3-devel \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+abi3-py37-devel = " \
 cargo \
 rust-pyo3-build-config0.23+abi3-py38-devel \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+abi3-py38-devel = " \
 cargo \
 rust-pyo3-build-config0.23+abi3-py39-devel \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+abi3-py39-devel = " \
 cargo \
 rust-pyo3-build-config0.23+abi3-py310-devel \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+default-devel = " \
 cargo \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+extension-module-devel = " \
 cargo \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23+resolve-config-devel = " \
 cargo \
 rust-pyo3-build-config0.23-devel \
 "
RDEPENDS:rust-pyo3-build-config0.23-devel = " \
 cargo \
 python3 \
 rust \
 rust-once_cell+default-devel \
 rust-target-lexicon0.12+default-devel \
 "
