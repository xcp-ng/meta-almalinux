# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tcl"
PE = "1"
PV = "8.6.13"
PR = "4.el10"
PACKAGES = " \
 tcl \
 tcl-devel \
 tcl-doc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tcl-8.6.13-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d98978fed0de47e2058d187e8993f07cf95875f34eb20c9b71a79166c9bb66ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tcl-8.6.13-4.el10.x86_64_v2.rpm;name=x86_64_v2_tcl;unpack=0"
SRC_URI[x86_64_v2_tcl.sha256sum] = "2a0c99d5685d505ea16e47038197f0752c8a7c484f0f05e83f871a096ae6b2c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tcl-devel-8.6.13-4.el10.x86_64_v2.rpm;name=x86_64_v2_tcl-devel;unpack=0"
SRC_URI[x86_64_v2_tcl-devel.sha256sum] = "f1340fa2254fad36051504ef08caf04faa7e703a6eb2924d47f369fe851f7eb5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tcl-doc-8.6.13-4.el10.noarch.rpm;name=x86_64_v2_tcl-doc;unpack=0"
SRC_URI[x86_64_v2_tcl-doc.sha256sum] = "6be9be7383bf4c7a2f0907cc59da5c02c2c7e160787653cbe3e9655327148e5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tcl-8.6.13-4.el10.aarch64.rpm;name=aarch64_tcl;unpack=0"
SRC_URI[aarch64_tcl.sha256sum] = "94248d54a78d5a1fe916daccba8c193b160f87e08def3264e1b4b5cd09bac020"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tcl-devel-8.6.13-4.el10.aarch64.rpm;name=aarch64_tcl-devel;unpack=0"
SRC_URI[aarch64_tcl-devel.sha256sum] = "284a3238585d9cf2166c11d492884908e4a2fa77995febed05e12265e256f757"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tcl-doc-8.6.13-4.el10.noarch.rpm;name=aarch64_tcl-doc;unpack=0"
SRC_URI[aarch64_tcl-doc.sha256sum] = "6be9be7383bf4c7a2f0907cc59da5c02c2c7e160787653cbe3e9655327148e5b"

RDEPENDS:tcl = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:tcl-devel = " \
 pkgconf-pkg-config \
 tcl \
 zlib-ng-compat-devel \
 "
RDEPENDS:tcl-doc = " \
 tcl \
 "
