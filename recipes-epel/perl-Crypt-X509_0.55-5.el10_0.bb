# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-X509"
PV = "0.55"
PR = "5.el10_0"
PACKAGES = " \
 perl-Crypt-X509 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-X509-0.55-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e350a96e36c69c7eb3d41385eb06c14b0523094459acbb3356898c395425dc19"

URI_x86_64_v2_perl-Crypt-X509 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-X509-0.55-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-X509;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-X509}"
SRC_URI[x86_64_v2_perl-Crypt-X509.sha256sum] = "c3866e26658f1394f050812686ff0c1c71bacf99ea26757b13574d1ce74f56ae"

URI_aarch64_perl-Crypt-X509 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-X509-0.55-5.el10_0.noarch.rpm;name=aarch64_perl-Crypt-X509;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-X509}"
SRC_URI[aarch64_perl-Crypt-X509.sha256sum] = "d47747bec18ab424831d9ae4696c0217f8dd44cd2c8c77b87592b295ad707d75"

RDEPENDS:perl-Crypt-X509 = " \
 perl-Carp \
 perl-Convert-ASN1 \
 perl-Exporter \
 perl-libs \
 "
