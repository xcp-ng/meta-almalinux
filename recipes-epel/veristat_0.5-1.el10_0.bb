# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "veristat"
PV = "0.5"
PR = "1.el10_0"
PACKAGES = " \
 veristat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/veristat-0.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42c388299ed9145d254dbf8adc57595929e1af5599280118064f5990ee2b9010"

URI_x86_64_v2_veristat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/veristat-0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_veristat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_veristat}"
SRC_URI[x86_64_v2_veristat.sha256sum] = "eef8724ceab98c5b73c30ed0af45aa22c9430b2076630cb028777905371eac99"

URI_aarch64_veristat = "${EPEL_MIRROR}/aarch64/Packages/v/veristat-0.5-1.el10_0.aarch64.rpm;name=aarch64_veristat;unpack=0"
SRC_URI:append = " ${URI_aarch64_veristat}"
SRC_URI[aarch64_veristat.sha256sum] = "499e33ce880546e2b8edb9dac8dc76565ab12eff566991448d3a098c1eda9ef1"

RDEPENDS:veristat = " \
 elfutils-libelf \
 glibc \
 zlib-ng-compat \
 "
