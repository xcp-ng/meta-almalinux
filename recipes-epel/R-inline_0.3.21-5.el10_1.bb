# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-inline"
PV = "0.3.21"
PR = "5.el10_1"
PACKAGES = " \
 R-inline \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-inline-0.3.21-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a175586a6215865ac29a91a64606b092b2234d54a7594291687b59cbe959de91"

URI_x86_64_v2_R-inline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-inline-0.3.21-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_R-inline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-inline}"
SRC_URI[x86_64_v2_R-inline.sha256sum] = "a25298ed23bb7ace3b36c758f841d9d8f6d418fee66c1af1367b5c03c0fa43ce"

URI_aarch64_R-inline = "${EPEL_MIRROR}/aarch64/Packages/r/R-inline-0.3.21-5.el10_1.noarch.rpm;name=aarch64_R-inline;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-inline}"
SRC_URI[aarch64_R-inline.sha256sum] = "8910827ce2ee4dbc5a6280dc20718c24d1968db1c56416a377f34ddf1b89bd4c"

RDEPENDS:R-inline = " \
 R-core \
 "
