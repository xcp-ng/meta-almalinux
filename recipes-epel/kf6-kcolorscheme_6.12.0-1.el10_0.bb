# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcolorscheme"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kcolorscheme \
 kf6-kcolorscheme-devel \
 kf6-kcolorscheme-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcolorscheme-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "923f1c3a1ee0d9befdecce3c31387be10d0cc8b03552be2384c4c06a9f72535c"

URI_x86_64_v2_kf6-kcolorscheme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcolorscheme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcolorscheme}"
SRC_URI[x86_64_v2_kf6-kcolorscheme.sha256sum] = "029244c62d2ab5a35799b901dc8b254b22c224e1fa9f78b67ee1283fefc93285"

URI_x86_64_v2_kf6-kcolorscheme-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcolorscheme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcolorscheme-devel}"
SRC_URI[x86_64_v2_kf6-kcolorscheme-devel.sha256sum] = "e8c131f63e080f59d979944658fa4f04079c456201ab5dde47687f812f0962f7"

URI_x86_64_v2_kf6-kcolorscheme-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcolorscheme-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcolorscheme-doc}"
SRC_URI[x86_64_v2_kf6-kcolorscheme-doc.sha256sum] = "7221b56ee56186005eba80ffed0f1288c16cbb36a7a2e1e9517143e6d6bae151"

URI_aarch64_kf6-kcolorscheme = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcolorscheme;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcolorscheme}"
SRC_URI[aarch64_kf6-kcolorscheme.sha256sum] = "5617cf35892caccc9f8d7cad0019b7d2f67120ae5fd99c96ad40ae2d96e25f51"

URI_aarch64_kf6-kcolorscheme-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcolorscheme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcolorscheme-devel}"
SRC_URI[aarch64_kf6-kcolorscheme-devel.sha256sum] = "887a222e2fb849798c04ce928711f6864e01518eace95561151b21b4786258c0"

URI_aarch64_kf6-kcolorscheme-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kcolorscheme-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcolorscheme-doc}"
SRC_URI[aarch64_kf6-kcolorscheme-doc.sha256sum] = "a63d52817b2b6118d6aad510ac252da36f98576634e21cb7261dd59466b1e201"

RDEPENDS:kf6-kcolorscheme = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcolorscheme-devel = " \
 cmake-filesystem \
 kf6-kcolorscheme \
 "
RDEPENDS:kf6-kcolorscheme-doc = " \
 "
