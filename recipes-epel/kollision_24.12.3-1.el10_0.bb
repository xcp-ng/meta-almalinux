# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kollision"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kollision \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kollision-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7ef2b2716e0c13e620f27fd37b68e51bf77208be335d9a339141daefbc601f4"

URI_x86_64_v2_kollision = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kollision-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kollision;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kollision}"
SRC_URI[x86_64_v2_kollision.sha256sum] = "947ee0c1ad3978e94e73ab8bb3995ce3bafa87e0a037702dfebb628ff9638cea"

URI_aarch64_kollision = "${EPEL_MIRROR}/aarch64/Packages/k/kollision-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kollision;unpack=0"
SRC_URI:append = " ${URI_aarch64_kollision}"
SRC_URI[aarch64_kollision.sha256sum] = "d9b827276fe6d2f338954d335339cf1bf116b4105d806ea9522baad8ca15349a"

RDEPENDS:kollision = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
