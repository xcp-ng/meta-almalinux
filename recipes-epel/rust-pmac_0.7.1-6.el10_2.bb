# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pmac"
PV = "0.7.1"
PR = "6.el10_2"
PACKAGES = " \
 rust-pmac+default-devel \
 rust-pmac+std-devel \
 rust-pmac+zeroize-devel \
 rust-pmac-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pmac-0.7.1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4071ad8c5e5a3f9a5f22d0005deb8c65ced6c9a8286eb2a6a2ba124bae3496a"

URI_x86_64_v2_rust-pmac+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pmac+default-devel-0.7.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pmac+default-devel}"
SRC_URI[x86_64_v2_rust-pmac+default-devel.sha256sum] = "f9260b5af6a183e903edf475b5d1e6d2c06aab70d0bb5aa580566b9e8f3bafda"

URI_x86_64_v2_rust-pmac+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pmac+std-devel-0.7.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pmac+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pmac+std-devel}"
SRC_URI[x86_64_v2_rust-pmac+std-devel.sha256sum] = "035a56e7304d0675cb1b63bbd6516e9811eee9d534824d4b06375395fd25ec6a"

URI_x86_64_v2_rust-pmac+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pmac+zeroize-devel-0.7.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pmac+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pmac+zeroize-devel}"
SRC_URI[x86_64_v2_rust-pmac+zeroize-devel.sha256sum] = "b8bcc3be49cfe01417ebfee83dec50b61feba1ee7deefb4b1f1df677095f4563"

URI_x86_64_v2_rust-pmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pmac-devel-0.7.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pmac-devel}"
SRC_URI[x86_64_v2_rust-pmac-devel.sha256sum] = "941390ad258fe7c22c29fdda790d666e7be4574a4e55bfeb59f394c0356a9100"

URI_aarch64_rust-pmac+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pmac+default-devel-0.7.1-6.el10_2.noarch.rpm;name=aarch64_rust-pmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pmac+default-devel}"
SRC_URI[aarch64_rust-pmac+default-devel.sha256sum] = "c053b37a73de4e9d22d25a3dbebdb161a546b285af172c1f29d3928cb7515a1d"

URI_aarch64_rust-pmac+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pmac+std-devel-0.7.1-6.el10_2.noarch.rpm;name=aarch64_rust-pmac+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pmac+std-devel}"
SRC_URI[aarch64_rust-pmac+std-devel.sha256sum] = "fb1d8921608de7add3b79ca85958999928d1a4e4366941051a4373ef1074bcf0"

URI_aarch64_rust-pmac+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pmac+zeroize-devel-0.7.1-6.el10_2.noarch.rpm;name=aarch64_rust-pmac+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pmac+zeroize-devel}"
SRC_URI[aarch64_rust-pmac+zeroize-devel.sha256sum] = "8fac2aeda1d2a24678d3ccb2410051f909102d63d38469bf23d671077776b1e1"

URI_aarch64_rust-pmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pmac-devel-0.7.1-6.el10_2.noarch.rpm;name=aarch64_rust-pmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pmac-devel}"
SRC_URI[aarch64_rust-pmac-devel.sha256sum] = "3d7529195c346791dc08a75b351c6fb51dfab2dc2a9882fbfd29c169e285a2de"

RDEPENDS:rust-pmac+default-devel = " \
 cargo \
 rust-pmac-devel \
 "
RDEPENDS:rust-pmac+std-devel = " \
 cargo \
 rust-digest+std-devel \
 rust-pmac-devel \
 "
RDEPENDS:rust-pmac+zeroize-devel = " \
 cargo \
 rust-cipher0.4+zeroize-devel \
 rust-pmac-devel \
 "
RDEPENDS:rust-pmac-devel = " \
 cargo \
 rust \
 rust-cipher0.4+default-devel \
 rust-dbl+default-devel \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 "
