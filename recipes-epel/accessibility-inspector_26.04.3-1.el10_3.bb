# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "accessibility-inspector"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 accessibility-inspector \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/accessibility-inspector-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bc9f1cb6513efc1d9741f97bd64d9aac5410b9b1fbe45c064847a872cc32402"

URI_x86_64_v2_accessibility-inspector = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/accessibility-inspector-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_accessibility-inspector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accessibility-inspector}"
SRC_URI[x86_64_v2_accessibility-inspector.sha256sum] = "b848db3124b34ab557a3bffc1fa953a01b2eec5bf6fee0a693a566a2b85f3cc9"

URI_aarch64_accessibility-inspector = "${EPEL_MIRROR}/aarch64/Packages/a/accessibility-inspector-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_accessibility-inspector;unpack=0"
SRC_URI:append = " ${URI_aarch64_accessibility-inspector}"
SRC_URI[aarch64_accessibility-inspector.sha256sum] = "564730ede3c8ca8a0d81e5adec8242f05e837d90c12944a5754d22caff720450"

RDEPENDS:accessibility-inspector = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qaccessibilityclient-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
