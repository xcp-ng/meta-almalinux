# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-kstring"
PV = "2.0.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-kstring+arc-devel \
 rust-kstring+default-devel \
 rust-kstring+document-features-devel \
 rust-kstring+max_inline-devel \
 rust-kstring+serde-devel \
 rust-kstring+std-devel \
 rust-kstring+unsafe-devel \
 rust-kstring+unstable_bench_subset-devel \
 rust-kstring-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-kstring-2.0.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "078a203e46b392b4337fc7d6579b3bb9d9779695e930be05c29771776eaea1a9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+arc-devel-2.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+arc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-kstring+arc-devel.sha256sum] = "13f0a46e9d004cd994b184025be17313496535e763c1428165b447e48d379881"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+default-devel-2.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-kstring+default-devel.sha256sum] = "97c0365b9600199d73d13882c91947a77725745822a00feb4903fe2701790c93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+document-features-devel-2.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+document-features-devel;unpack=0"
SRC_URI[x86_64_v2_rust-kstring+document-features-devel.sha256sum] = "94a385845516f71a83f24ac91ca8ccf03dc6eb615c0aac502a349f1dc51218db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+max_inline-devel-2.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+max_inline-devel;unpack=0"
SRC_URI[x86_64_v2_rust-kstring+max_inline-devel.sha256sum] = "c7027f95561434ae2b87196099770f09aa64dc03178607c42d815ec9d978fd7c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+serde-devel-2.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-kstring+serde-devel.sha256sum] = "e33878bfbee97809f651af9ed46478803b8b4e1d8899d5184aa61321094c6784"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+std-devel-2.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-kstring+std-devel.sha256sum] = "0dc0bd5936c1a96155da7d7a5cf1fae27edd85b7b1e15ff6a16ec4b0a7b791c0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+unsafe-devel-2.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+unsafe-devel;unpack=0"
SRC_URI[x86_64_v2_rust-kstring+unsafe-devel.sha256sum] = "3f57ebb505f653f3ae125f157b5262a9b3ad7f743e40b172375f9454bbd00cc4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+unstable_bench_subset-devel-2.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+unstable_bench_subset-devel;unpack=0"
SRC_URI[x86_64_v2_rust-kstring+unstable_bench_subset-devel.sha256sum] = "abcf2eba7b669abce3864e147c2a1bced0679d834ffc2ad4f7461b6718ae7d81"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring-devel-2.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring-devel;unpack=0"
SRC_URI[x86_64_v2_rust-kstring-devel.sha256sum] = "0bb49b2279751ea7ada3f05b0cdcb35652df759a9ca67bdad182e1ece96cb25b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+arc-devel-2.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-kstring+arc-devel;unpack=0"
SRC_URI[aarch64_rust-kstring+arc-devel.sha256sum] = "d75fdbcbf10fac728d41df0d53268ebfa67407ee5c541801719785b560f83341"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+default-devel-2.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-kstring+default-devel;unpack=0"
SRC_URI[aarch64_rust-kstring+default-devel.sha256sum] = "6a2022e32ac70a7b8c63414e0d0189604d27bc3f9029e3043e7b60ea7d51696a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+document-features-devel-2.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-kstring+document-features-devel;unpack=0"
SRC_URI[aarch64_rust-kstring+document-features-devel.sha256sum] = "25fad8dd434633e0dc0c58245484369c16a46aa8a9118874f846cc1f24983548"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+max_inline-devel-2.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-kstring+max_inline-devel;unpack=0"
SRC_URI[aarch64_rust-kstring+max_inline-devel.sha256sum] = "1fcc6cd895c9c6d455d29e6b01851530c10d98d72f69af092680ed78c377911e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+serde-devel-2.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-kstring+serde-devel;unpack=0"
SRC_URI[aarch64_rust-kstring+serde-devel.sha256sum] = "351943cafd881f78700ae1d29e6d1f7c198607b58c98de7753356d09add63908"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+std-devel-2.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-kstring+std-devel;unpack=0"
SRC_URI[aarch64_rust-kstring+std-devel.sha256sum] = "d403bd901d8a04912c7d2a6eb962559643b10c62bec5c7a95f533e67e9262442"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+unsafe-devel-2.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-kstring+unsafe-devel;unpack=0"
SRC_URI[aarch64_rust-kstring+unsafe-devel.sha256sum] = "6b3ac8529abb04172d2da18340dd66ea9f6f5b431efbc195632a49b56a7aba7d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+unstable_bench_subset-devel-2.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-kstring+unstable_bench_subset-devel;unpack=0"
SRC_URI[aarch64_rust-kstring+unstable_bench_subset-devel.sha256sum] = "7c2f94f4a8599294fdd52cfec0b480f85a5b99beb11285ea06b5ddcc765d4c03"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring-devel-2.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-kstring-devel;unpack=0"
SRC_URI[aarch64_rust-kstring-devel.sha256sum] = "480d690a7f0b1ac58efefaa6920a523e7bd9c4b848fbf2b854de0d30961d6a50"

RDEPENDS:rust-kstring+arc-devel = " \
 cargo \
 rust-kstring-devel \
 "
RDEPENDS:rust-kstring+default-devel = " \
 cargo \
 rust-kstring+std-devel \
 rust-kstring+unsafe-devel \
 rust-kstring-devel \
 "
RDEPENDS:rust-kstring+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-kstring-devel \
 "
RDEPENDS:rust-kstring+max_inline-devel = " \
 cargo \
 rust-kstring-devel \
 "
RDEPENDS:rust-kstring+serde-devel = " \
 cargo \
 rust-kstring-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-kstring+std-devel = " \
 cargo \
 rust-kstring-devel \
 "
RDEPENDS:rust-kstring+unsafe-devel = " \
 cargo \
 rust-kstring-devel \
 "
RDEPENDS:rust-kstring+unstable_bench_subset-devel = " \
 cargo \
 rust-kstring-devel \
 "
RDEPENDS:rust-kstring-devel = " \
 cargo \
 rust \
 rust-static_assertions+default-devel \
 "
