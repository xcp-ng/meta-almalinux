# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "accel-config"
PV = "4.1.8"
PR = "3.el10"
PACKAGES:x86_64_v2 = " \
 accel-config \
 accel-config-devel \
 accel-config-libs \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/accel-config-4.1.8-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74792054e0c135752fd4298ac907ae2b347b8060e7f8055dba94f70972a97085"

URI_x86_64_v2_accel-config = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/accel-config-4.1.8-3.el10.x86_64_v2.rpm;name=x86_64_v2_accel-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accel-config}"
SRC_URI[x86_64_v2_accel-config.sha256sum] = "19e0dc1b39eba06eb58bbdf42748daf6dc893482da19e24b461526f97bd89c53"

URI_x86_64_v2_accel-config-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/accel-config-devel-4.1.8-3.el10.x86_64_v2.rpm;name=x86_64_v2_accel-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accel-config-devel}"
SRC_URI[x86_64_v2_accel-config-devel.sha256sum] = "fae17cfbd729e453401830b9750f8e8668c40c01537b6e69c9b21453ccf9cb58"

URI_x86_64_v2_accel-config-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/accel-config-libs-4.1.8-3.el10.x86_64_v2.rpm;name=x86_64_v2_accel-config-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accel-config-libs}"
SRC_URI[x86_64_v2_accel-config-libs.sha256sum] = "f0ea2c964a8f8750fe230659f158bd1b4d97c86836a316adef970c34a9154a44"

RDEPENDS:accel-config = " \
 accel-config-libs \
 glibc \
 json-c \
 "
RDEPENDS:accel-config-devel = " \
 accel-config-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:accel-config-libs = " \
 accel-config \
 glibc \
 libuuid \
 "
