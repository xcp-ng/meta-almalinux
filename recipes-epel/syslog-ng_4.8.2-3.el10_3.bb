# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "syslog-ng"
PV = "4.8.2"
PR = "3.el10_3"
PACKAGES = " \
 syslog-ng \
 syslog-ng-amqp \
 syslog-ng-bigquery \
 syslog-ng-bpf \
 syslog-ng-devel \
 syslog-ng-geoip \
 syslog-ng-grpc \
 syslog-ng-http \
 syslog-ng-kafka \
 syslog-ng-loki \
 syslog-ng-mongodb \
 syslog-ng-opentelemetry \
 syslog-ng-python \
 syslog-ng-python-modules \
 syslog-ng-redis \
 syslog-ng-riemann \
 syslog-ng-slog \
 syslog-ng-snmp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/syslog-ng-4.8.2-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ac85afa62531b8e1316f0686d127587ab056c996193c2354ba15b5b92b55fd9"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - syslog-ng-amqp: libcap.so.2()(64bit)
# - syslog-ng-bigquery: libcap.so.2()(64bit)
# - syslog-ng-bpf: libcap.so.2()(64bit)
# - syslog-ng-geoip: libcap.so.2()(64bit)
# - syslog-ng-grpc: libcap.so.2()(64bit)
# - syslog-ng-http: libcap.so.2()(64bit)
# - syslog-ng-kafka: libcap.so.2()(64bit)
# - syslog-ng-loki: libcap.so.2()(64bit)
# - syslog-ng-mongodb: libcap.so.2()(64bit)
# - syslog-ng-opentelemetry: libcap.so.2()(64bit)
# - syslog-ng-python: libcap.so.2()(64bit)
# - syslog-ng-redis: libcap.so.2()(64bit)
# - syslog-ng-riemann: libcap.so.2()(64bit)
# - syslog-ng-slog: libcap.so.2()(64bit)
# - syslog-ng-snmp: libcap.so.2()(64bit)
# - syslog-ng: libcap.so.2()(64bit)

URI_x86_64_v2_syslog-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng}"
SRC_URI[x86_64_v2_syslog-ng.sha256sum] = "bd0328a68c5d42c2565f57e1afdb2c59bc74387bc41fa15a75191e97414c56b2"
RPROVIDES:syslog-ng:x86_64_v2 = "virtual/syslog"

URI_x86_64_v2_syslog-ng-amqp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-amqp-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-amqp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-amqp}"
SRC_URI[x86_64_v2_syslog-ng-amqp.sha256sum] = "0c1297118722aa1606d5fc31aeaaef6cbe2a30c260ac463bfb61cff58377d313"

URI_x86_64_v2_syslog-ng-bigquery = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-bigquery-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-bigquery;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-bigquery}"
SRC_URI[x86_64_v2_syslog-ng-bigquery.sha256sum] = "ad25a3dd463ffcc5248aeee16427b654ca4a0281a2f385e87f08cef983f362de"

URI_x86_64_v2_syslog-ng-bpf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-bpf-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-bpf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-bpf}"
SRC_URI[x86_64_v2_syslog-ng-bpf.sha256sum] = "70a20061af6f7addb6894643088bdffd54d175ff7b0068fbd4d621b66aa0a9c5"

URI_x86_64_v2_syslog-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-devel-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-devel}"
SRC_URI[x86_64_v2_syslog-ng-devel.sha256sum] = "a1aabeb22e6388445515575cc8db57d41d7858a78c49b0d91cf44eb4fb1c599c"

URI_x86_64_v2_syslog-ng-geoip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-geoip-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-geoip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-geoip}"
SRC_URI[x86_64_v2_syslog-ng-geoip.sha256sum] = "efe5eea7933637eaf179edc3231516b2c89e778f316070430b74ff20f8dcf688"

URI_x86_64_v2_syslog-ng-grpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-grpc-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-grpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-grpc}"
SRC_URI[x86_64_v2_syslog-ng-grpc.sha256sum] = "f7fe5debe4db63bd00741676601d2dcad0d0bd7a10fcff9a85f52424c46959f6"

URI_x86_64_v2_syslog-ng-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-http-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-http}"
SRC_URI[x86_64_v2_syslog-ng-http.sha256sum] = "58a46fde727294c93a89307d4b7da83cf78fbbc478da837198101c789c8a2d3c"

URI_x86_64_v2_syslog-ng-kafka = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-kafka-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-kafka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-kafka}"
SRC_URI[x86_64_v2_syslog-ng-kafka.sha256sum] = "6b907f669aaa49d8a7556c916aa330a1e5877f360dfbe1e4ecd60effb5edefd9"

URI_x86_64_v2_syslog-ng-loki = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-loki-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-loki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-loki}"
SRC_URI[x86_64_v2_syslog-ng-loki.sha256sum] = "48337f911a557baf828c42738f9be3329517de4bf0aac610566d46cbf6796eef"

URI_x86_64_v2_syslog-ng-mongodb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-mongodb-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-mongodb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-mongodb}"
SRC_URI[x86_64_v2_syslog-ng-mongodb.sha256sum] = "c416fb13b3fd354acac2659b185623708947b33d14318cc6dc99d55c9551737d"

URI_x86_64_v2_syslog-ng-opentelemetry = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-opentelemetry-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-opentelemetry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-opentelemetry}"
SRC_URI[x86_64_v2_syslog-ng-opentelemetry.sha256sum] = "63add7a2a56c0e59bd627fea9284c5211304d679c2961ea14ef0e66e9c33c58c"

URI_x86_64_v2_syslog-ng-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-python-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-python}"
SRC_URI[x86_64_v2_syslog-ng-python.sha256sum] = "7a55b3f5d7a1f52d3f991fb28a89fe327e8e7505cab48b246fc2fe07d9ecd77b"

URI_x86_64_v2_syslog-ng-python-modules = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-python-modules-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-python-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-python-modules}"
SRC_URI[x86_64_v2_syslog-ng-python-modules.sha256sum] = "2604c12187cf0159c0d4151894252c50379ac61e6dcc7390539d2753dc7bf93b"

URI_x86_64_v2_syslog-ng-redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-redis-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-redis}"
SRC_URI[x86_64_v2_syslog-ng-redis.sha256sum] = "57f701e305a24fcff87acb527534e802b513170c51b412b2b3d9cb24bb1d98ac"

URI_x86_64_v2_syslog-ng-riemann = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-riemann-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-riemann;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-riemann}"
SRC_URI[x86_64_v2_syslog-ng-riemann.sha256sum] = "d194a97b44c9908148b5412ae4c585dd975f18d316f41738cab884f62a777ea1"

URI_x86_64_v2_syslog-ng-slog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-slog-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-slog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-slog}"
SRC_URI[x86_64_v2_syslog-ng-slog.sha256sum] = "9d5d03e0e88e3a482cefbe08486383535588c01f2d320d679ee07f0938fb5481"

URI_x86_64_v2_syslog-ng-snmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-snmp-4.8.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-snmp}"
SRC_URI[x86_64_v2_syslog-ng-snmp.sha256sum] = "cf7e8e9b761f6528f45cfd6e8dfd51a57f0894492b6033c141239289b9b54ba7"

URI_aarch64_syslog-ng = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng}"
SRC_URI[aarch64_syslog-ng.sha256sum] = "b5f7ba156a5106417425f806f501f93cf0103b183e47f2807ece5d7ca18a6b09"
RPROVIDES:syslog-ng:aarch64 = "virtual/syslog"

URI_aarch64_syslog-ng-amqp = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-amqp-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-amqp;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-amqp}"
SRC_URI[aarch64_syslog-ng-amqp.sha256sum] = "826880cb2e1c79eb9af11032c61deb890fd1bb10ebe41cc8ddbeaeafc4347d27"

URI_aarch64_syslog-ng-bigquery = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-bigquery-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-bigquery;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-bigquery}"
SRC_URI[aarch64_syslog-ng-bigquery.sha256sum] = "a776f4dd30b7d6b83b0a4fbba38a8bed77d93b4b69f1b5804acbb087c08cd4f0"

URI_aarch64_syslog-ng-bpf = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-bpf-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-bpf;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-bpf}"
SRC_URI[aarch64_syslog-ng-bpf.sha256sum] = "07d96286b7e1d22171d569846d633b65ca1f45741399449360fca2013be00d45"

URI_aarch64_syslog-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-devel-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-devel}"
SRC_URI[aarch64_syslog-ng-devel.sha256sum] = "7a77feb5153447bae61418cae40b564ce56d31b8579a36d450e2eacc421ee203"

URI_aarch64_syslog-ng-geoip = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-geoip-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-geoip;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-geoip}"
SRC_URI[aarch64_syslog-ng-geoip.sha256sum] = "42eac8165ac7cd3115dab7deba79312e275a6627e45bd4672aca1af4fa8a156c"

URI_aarch64_syslog-ng-grpc = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-grpc-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-grpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-grpc}"
SRC_URI[aarch64_syslog-ng-grpc.sha256sum] = "8e7c35d48d8ed3a59c0fff2bbbc01c808ed5f749736498eebd39969470f8ef3e"

URI_aarch64_syslog-ng-http = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-http-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-http}"
SRC_URI[aarch64_syslog-ng-http.sha256sum] = "564e5adc85b5604306ac55b978cd9a94ea883d88323feaa9bfcf6614abd9b247"

URI_aarch64_syslog-ng-kafka = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-kafka-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-kafka;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-kafka}"
SRC_URI[aarch64_syslog-ng-kafka.sha256sum] = "76bc196df6d36f6b6d203d9997b16a4bbe423900f3e891ccbf7e7d16e9d1f0fe"

URI_aarch64_syslog-ng-loki = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-loki-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-loki;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-loki}"
SRC_URI[aarch64_syslog-ng-loki.sha256sum] = "20e047e4c074b52c8bc7c02def4b671cf2dac82c83fec2dc48fa0e81ca062f7c"

URI_aarch64_syslog-ng-mongodb = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-mongodb-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-mongodb;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-mongodb}"
SRC_URI[aarch64_syslog-ng-mongodb.sha256sum] = "d365a70d95643df3282e89e1465d886687b3f51f1fdfcc528702a815cde78f89"

URI_aarch64_syslog-ng-opentelemetry = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-opentelemetry-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-opentelemetry;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-opentelemetry}"
SRC_URI[aarch64_syslog-ng-opentelemetry.sha256sum] = "a4cb7df19fada2adde7daafba2d636253f9f3200cebb2b9f1de1ac2b65152bad"

URI_aarch64_syslog-ng-python = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-python-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-python}"
SRC_URI[aarch64_syslog-ng-python.sha256sum] = "e67ab9ae55bf6bb6548fadf7591f6322aea85c5249629e62aa9a6ba1c6afae6c"

URI_aarch64_syslog-ng-python-modules = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-python-modules-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-python-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-python-modules}"
SRC_URI[aarch64_syslog-ng-python-modules.sha256sum] = "8470c2b1ac306fb25ad15bcf68ba829bbc18ca91c9d160c1bdf4b18333fdd32c"

URI_aarch64_syslog-ng-redis = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-redis-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-redis}"
SRC_URI[aarch64_syslog-ng-redis.sha256sum] = "19bd91dd78ab2b0e1a14bafd92e75d9bd82eed5322d347aefed1e43f4650d40e"

URI_aarch64_syslog-ng-riemann = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-riemann-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-riemann;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-riemann}"
SRC_URI[aarch64_syslog-ng-riemann.sha256sum] = "671d3c6ea68ec2084a522443ee4347b687d6c1e598eea50bc697b499e3e4ab72"

URI_aarch64_syslog-ng-slog = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-slog-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-slog;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-slog}"
SRC_URI[aarch64_syslog-ng-slog.sha256sum] = "97876165b084c413d22326766c6d31e6ef5ea2da293069cbb04aef524dc3edb3"

URI_aarch64_syslog-ng-snmp = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-snmp-4.8.2-3.el10_3.aarch64.rpm;name=aarch64_syslog-ng-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-snmp}"
SRC_URI[aarch64_syslog-ng-snmp.sha256sum] = "cb411f3f26b9a8d6f4604ff9e7893c1555fa5800ecefc6a874c27d927f87bc59"

RDEPENDS:syslog-ng:x86_64_v2 = " \
 bash \
 gawk \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libcap \
 libgcc \
 libnet \
 libstdc++ \
 logrotate \
 openssl-libs \
 pcre2 \
 systemd \
 systemd-libs \
"
RDEPENDS:syslog-ng:aarch64 = " \
 bash \
 gawk \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libgcc \
 libnet \
 libstdc++ \
 logrotate \
 openssl-libs \
 pcre2 \
 systemd \
 systemd-libs \
"
RDEPENDS:syslog-ng-amqp:x86_64_v2 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libcap \
 librabbitmq \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-amqp:aarch64 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 librabbitmq \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-bigquery:x86_64_v2 = " \
 abseil-cpp \
 c-ares \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 ivykis \
 json-c \
 libcap \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcre2 \
 protobuf \
 re2 \
 syslog-ng \
 syslog-ng-grpc \
 systemd-libs \
 zlib-ng-compat \
"
RDEPENDS:syslog-ng-bigquery:aarch64 = " \
 abseil-cpp \
 c-ares \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 ivykis \
 json-c \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcre2 \
 protobuf \
 re2 \
 syslog-ng \
 syslog-ng-grpc \
 systemd-libs \
 zlib-ng-compat \
"
RDEPENDS:syslog-ng-bpf:x86_64_v2 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libbpf \
 libcap \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-bpf:aarch64 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libbpf \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-devel = " \
 bash \
 glib2-devel \
 pkgconf-pkg-config \
 python3 \
 syslog-ng \
 "
RDEPENDS:syslog-ng-geoip:x86_64_v2 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libcap \
 libmaxminddb \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-geoip:aarch64 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libmaxminddb \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-grpc:x86_64_v2 = " \
 abseil-cpp \
 c-ares \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 ivykis \
 json-c \
 libcap \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcre2 \
 protobuf \
 re2 \
 syslog-ng \
 systemd-libs \
 zlib-ng-compat \
"
RDEPENDS:syslog-ng-grpc:aarch64 = " \
 abseil-cpp \
 c-ares \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 ivykis \
 json-c \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcre2 \
 protobuf \
 re2 \
 syslog-ng \
 systemd-libs \
 zlib-ng-compat \
"
RDEPENDS:syslog-ng-http:x86_64_v2 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libcap \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:syslog-ng-http:aarch64 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:syslog-ng-kafka:x86_64_v2 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libcap \
 librdkafka \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-kafka:aarch64 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 librdkafka \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-loki:x86_64_v2 = " \
 abseil-cpp \
 c-ares \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 ivykis \
 json-c \
 libcap \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcre2 \
 protobuf \
 re2 \
 syslog-ng \
 syslog-ng-grpc \
 systemd-libs \
 zlib-ng-compat \
"
RDEPENDS:syslog-ng-loki:aarch64 = " \
 abseil-cpp \
 c-ares \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 ivykis \
 json-c \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcre2 \
 protobuf \
 re2 \
 syslog-ng \
 syslog-ng-grpc \
 systemd-libs \
 zlib-ng-compat \
"
RDEPENDS:syslog-ng-mongodb:x86_64_v2 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libbson \
 libcap \
 mongo-c-driver-libs \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-mongodb:aarch64 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libbson \
 mongo-c-driver-libs \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-opentelemetry:x86_64_v2 = " \
 abseil-cpp \
 c-ares \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 ivykis \
 json-c \
 libcap \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcre2 \
 protobuf \
 re2 \
 syslog-ng \
 syslog-ng-grpc \
 systemd-libs \
 zlib-ng-compat \
"
RDEPENDS:syslog-ng-opentelemetry:aarch64 = " \
 abseil-cpp \
 c-ares \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 ivykis \
 json-c \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcre2 \
 protobuf \
 re2 \
 syslog-ng \
 syslog-ng-grpc \
 systemd-libs \
 zlib-ng-compat \
"
RDEPENDS:syslog-ng-python:x86_64_v2 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libcap \
 openssl-libs \
 pcre2 \
 python3-libs \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-python:aarch64 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 openssl-libs \
 pcre2 \
 python3-libs \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-python-modules = " \
 python3-cachetools \
 python3-certifi \
 python3-charset-normalizer \
 python3-dateutil \
 python3-google-auth \
 python3-idna \
 python3-kubernetes \
 python3-oauthlib \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-rsa \
 python3-six \
 python3-urllib3 \
 python3-websocket-client \
 syslog-ng \
 syslog-ng-python \
 "
RDEPENDS:syslog-ng-redis:x86_64_v2 = " \
 glib2 \
 glibc \
 hiredis \
 ivykis \
 json-c \
 libcap \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-redis:aarch64 = " \
 glib2 \
 glibc \
 hiredis \
 ivykis \
 json-c \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-riemann:x86_64_v2 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libcap \
 openssl-libs \
 pcre2 \
 riemann-c-client \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-riemann:aarch64 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 openssl-libs \
 pcre2 \
 riemann-c-client \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-slog:x86_64_v2 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libcap \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-slog:aarch64 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-snmp:x86_64_v2 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libcap \
 net-snmp-libs \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"
RDEPENDS:syslog-ng-snmp:aarch64 = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 net-snmp-libs \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
"

PROVIDES:append:x86_64_v2 = " rpm/virtual/syslog"

PROVIDES:append:aarch64 = " rpm/virtual/syslog"
