# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tower-http"
PV = "0.6.6"
PR = "2.el10_0"
PACKAGES = " \
 rust-tower-http+add-extension-devel \
 rust-tower-http+async-compression-devel \
 rust-tower-http+auth-devel \
 rust-tower-http+base64-devel \
 rust-tower-http+catch-panic-devel \
 rust-tower-http+compression-br-devel \
 rust-tower-http+compression-deflate-devel \
 rust-tower-http+compression-full-devel \
 rust-tower-http+compression-gzip-devel \
 rust-tower-http+compression-zstd-devel \
 rust-tower-http+cors-devel \
 rust-tower-http+decompression-br-devel \
 rust-tower-http+decompression-deflate-devel \
 rust-tower-http+decompression-full-devel \
 rust-tower-http+decompression-gzip-devel \
 rust-tower-http+decompression-zstd-devel \
 rust-tower-http+default-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http+fs-devel \
 rust-tower-http+full-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+futures-util-devel \
 rust-tower-http+httpdate-devel \
 rust-tower-http+iri-string-devel \
 rust-tower-http+limit-devel \
 rust-tower-http+map-request-body-devel \
 rust-tower-http+map-response-body-devel \
 rust-tower-http+metrics-devel \
 rust-tower-http+mime-devel \
 rust-tower-http+mime_guess-devel \
 rust-tower-http+normalize-path-devel \
 rust-tower-http+percent-encoding-devel \
 rust-tower-http+propagate-header-devel \
 rust-tower-http+redirect-devel \
 rust-tower-http+request-id-devel \
 rust-tower-http+sensitive-headers-devel \
 rust-tower-http+set-header-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+timeout-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http+tower-devel \
 rust-tower-http+trace-devel \
 rust-tower-http+tracing-devel \
 rust-tower-http+util-devel \
 rust-tower-http+uuid-devel \
 rust-tower-http+validate-request-devel \
 rust-tower-http-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tower-http-0.6.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07cdaef57060840fc12ec4c525e2e4b86dae18210a35c1de01ea7d70a0222909"

URI_x86_64_v2_rust-tower-http+add-extension-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+add-extension-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+add-extension-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+add-extension-devel}"
SRC_URI[x86_64_v2_rust-tower-http+add-extension-devel.sha256sum] = "87cde4344638b2169cb5e806ed716d3e5d071f9af68ee3eb7a3d858b95e44923"

URI_x86_64_v2_rust-tower-http+async-compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+async-compression-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+async-compression-devel}"
SRC_URI[x86_64_v2_rust-tower-http+async-compression-devel.sha256sum] = "7f8ae23153aaaa573bb0d7f6d74f373f66ec7017d6242e6e8fbc0daf0a982bae"

URI_x86_64_v2_rust-tower-http+auth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+auth-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+auth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+auth-devel}"
SRC_URI[x86_64_v2_rust-tower-http+auth-devel.sha256sum] = "0bd7667f78de2932f439416f79af2c996c4f6eb593ea0ae6303e6ff84a2bcdaa"

URI_x86_64_v2_rust-tower-http+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+base64-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+base64-devel}"
SRC_URI[x86_64_v2_rust-tower-http+base64-devel.sha256sum] = "f686d657f2547e6ca61ea893e832f8d4b58838372aa8c6a65ed3052c3b005c64"

URI_x86_64_v2_rust-tower-http+catch-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+catch-panic-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+catch-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+catch-panic-devel}"
SRC_URI[x86_64_v2_rust-tower-http+catch-panic-devel.sha256sum] = "0e63ceca057fe903905a797212612270be6c74335c7af5b994c613b203830b13"

URI_x86_64_v2_rust-tower-http+compression-br-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-br-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-br-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+compression-br-devel}"
SRC_URI[x86_64_v2_rust-tower-http+compression-br-devel.sha256sum] = "ff7f8b66123d8660dfde4920fcd6e346f233feaa44ac234f03aa812aaa595574"

URI_x86_64_v2_rust-tower-http+compression-deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-deflate-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+compression-deflate-devel}"
SRC_URI[x86_64_v2_rust-tower-http+compression-deflate-devel.sha256sum] = "17639b194dd4dffe7ce175400b4904044f296c4166ed8b917c97d2e8ce4fa737"

URI_x86_64_v2_rust-tower-http+compression-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-full-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+compression-full-devel}"
SRC_URI[x86_64_v2_rust-tower-http+compression-full-devel.sha256sum] = "a8d0fb80fddfc0c1be7caf4cf9179d0855902066570c58d1bc7ec75ff52231ad"

URI_x86_64_v2_rust-tower-http+compression-gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-gzip-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+compression-gzip-devel}"
SRC_URI[x86_64_v2_rust-tower-http+compression-gzip-devel.sha256sum] = "27314e8be87a2a6c336176605f2720852d24fed598e22b756c685e80eb7039d4"

URI_x86_64_v2_rust-tower-http+compression-zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-zstd-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+compression-zstd-devel}"
SRC_URI[x86_64_v2_rust-tower-http+compression-zstd-devel.sha256sum] = "f118c8f821591654429bc560d494b88bb647b90b64a876c289740315249fbb3f"

URI_x86_64_v2_rust-tower-http+cors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+cors-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+cors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+cors-devel}"
SRC_URI[x86_64_v2_rust-tower-http+cors-devel.sha256sum] = "2bb9490f87267e2c19be3be804d776db9d174562c219a3b49101e0a77433f4f5"

URI_x86_64_v2_rust-tower-http+decompression-br-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-br-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-br-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+decompression-br-devel}"
SRC_URI[x86_64_v2_rust-tower-http+decompression-br-devel.sha256sum] = "5a0254e7567eeab748b631dd19b81e9ff029aae74720ea0f4012ae397dd08f45"

URI_x86_64_v2_rust-tower-http+decompression-deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-deflate-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+decompression-deflate-devel}"
SRC_URI[x86_64_v2_rust-tower-http+decompression-deflate-devel.sha256sum] = "ea6d4ab273c90cd0e64a1c52b5028925da8cfd5bc3d47f7f331436719ed7fa2a"

URI_x86_64_v2_rust-tower-http+decompression-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-full-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+decompression-full-devel}"
SRC_URI[x86_64_v2_rust-tower-http+decompression-full-devel.sha256sum] = "8b0bd2be16e85db5d5f6b5d290c9972ded263b13abffa8ed5b08ced426c9839f"

URI_x86_64_v2_rust-tower-http+decompression-gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-gzip-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+decompression-gzip-devel}"
SRC_URI[x86_64_v2_rust-tower-http+decompression-gzip-devel.sha256sum] = "ddf95cbac8cb263da6e652da5fc244a3c1593dd73abc419087a21142175bdf7a"

URI_x86_64_v2_rust-tower-http+decompression-zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-zstd-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+decompression-zstd-devel}"
SRC_URI[x86_64_v2_rust-tower-http+decompression-zstd-devel.sha256sum] = "27e1744800bc8ce3f0b4fda20f25434b578d5bf3220d7098510e39297391e39a"

URI_x86_64_v2_rust-tower-http+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+default-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+default-devel}"
SRC_URI[x86_64_v2_rust-tower-http+default-devel.sha256sum] = "76ec21af755f8d795b0df9c544fbd98693a28c6667c34e62432646ddca235ba4"

URI_x86_64_v2_rust-tower-http+follow-redirect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+follow-redirect-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+follow-redirect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+follow-redirect-devel}"
SRC_URI[x86_64_v2_rust-tower-http+follow-redirect-devel.sha256sum] = "ec9f5b34b14ccc24ac2eb3c81885cdca46d8b744f9131d69380ff1341d03018e"

URI_x86_64_v2_rust-tower-http+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+fs-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+fs-devel}"
SRC_URI[x86_64_v2_rust-tower-http+fs-devel.sha256sum] = "b1f03633502b1d1f4a55a325774da02f8000d52e9f3c746156c5803549cf4781"

URI_x86_64_v2_rust-tower-http+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+full-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+full-devel}"
SRC_URI[x86_64_v2_rust-tower-http+full-devel.sha256sum] = "df3c317c9b8b68987e4f33e92dce75979bb22ccb4d4f83e9517e5fb446951f1b"

URI_x86_64_v2_rust-tower-http+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+futures-core-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+futures-core-devel}"
SRC_URI[x86_64_v2_rust-tower-http+futures-core-devel.sha256sum] = "385b8245de07d8437c072cb5d79cdf0310f0af8a00e84de95aa083ea8aff5776"

URI_x86_64_v2_rust-tower-http+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+futures-util-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+futures-util-devel}"
SRC_URI[x86_64_v2_rust-tower-http+futures-util-devel.sha256sum] = "86e51779ff5b472e0a383809d5085bd00878d468151bc2256fea496c17171dc9"

URI_x86_64_v2_rust-tower-http+httpdate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+httpdate-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+httpdate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+httpdate-devel}"
SRC_URI[x86_64_v2_rust-tower-http+httpdate-devel.sha256sum] = "ae0438183b04a21dff34ecb7c0aa179b2dde066b3ffc9a4be902f66691cae422"

URI_x86_64_v2_rust-tower-http+iri-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+iri-string-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+iri-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+iri-string-devel}"
SRC_URI[x86_64_v2_rust-tower-http+iri-string-devel.sha256sum] = "f5fec35435e8477693656b1acd1f482ed6b363f2b7c404b5f3455f0573769d72"

URI_x86_64_v2_rust-tower-http+limit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+limit-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+limit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+limit-devel}"
SRC_URI[x86_64_v2_rust-tower-http+limit-devel.sha256sum] = "b1116d7dea0d2d6e34645160cbdefa40a4ddd811da61b5ebf6aefc0f6b9b8037"

URI_x86_64_v2_rust-tower-http+map-request-body-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+map-request-body-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+map-request-body-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+map-request-body-devel}"
SRC_URI[x86_64_v2_rust-tower-http+map-request-body-devel.sha256sum] = "6c8b119acd91dd0997a99242e9c3e2d37eaed0bd61ee0e080abe95f3c060ae26"

URI_x86_64_v2_rust-tower-http+map-response-body-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+map-response-body-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+map-response-body-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+map-response-body-devel}"
SRC_URI[x86_64_v2_rust-tower-http+map-response-body-devel.sha256sum] = "68414f59c13f1812d7a24b00c2063c47e779d7a99d454c363d8a7a153d647924"

URI_x86_64_v2_rust-tower-http+metrics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+metrics-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+metrics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+metrics-devel}"
SRC_URI[x86_64_v2_rust-tower-http+metrics-devel.sha256sum] = "7cf61fcfe05aeae7dc4ac668df43511d2b970e588b1dc058051c0919f78a18de"

URI_x86_64_v2_rust-tower-http+mime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+mime-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+mime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+mime-devel}"
SRC_URI[x86_64_v2_rust-tower-http+mime-devel.sha256sum] = "98a5a41056425e54331b1b7afabcd77d0cb29fbf1bf9c1846f71f3988d7ebc63"

URI_x86_64_v2_rust-tower-http+mime_guess-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+mime_guess-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+mime_guess-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+mime_guess-devel}"
SRC_URI[x86_64_v2_rust-tower-http+mime_guess-devel.sha256sum] = "0d4668ccbc298afbf09e209f730a942572dd2c7f6215abecdb1590aba8394e3d"

URI_x86_64_v2_rust-tower-http+normalize-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+normalize-path-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+normalize-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+normalize-path-devel}"
SRC_URI[x86_64_v2_rust-tower-http+normalize-path-devel.sha256sum] = "0a893b2aaca50e15bd24d3a0acf7f0b46c35c8a5f73b58394108677bc31891f7"

URI_x86_64_v2_rust-tower-http+percent-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+percent-encoding-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+percent-encoding-devel}"
SRC_URI[x86_64_v2_rust-tower-http+percent-encoding-devel.sha256sum] = "e5fa6c6edc575df1c04ef50f39002330d330b53e615df6fefe7ad45c6e977218"

URI_x86_64_v2_rust-tower-http+propagate-header-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+propagate-header-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+propagate-header-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+propagate-header-devel}"
SRC_URI[x86_64_v2_rust-tower-http+propagate-header-devel.sha256sum] = "4492868aa96269c4a51fe53365b29fb0c4acbff324d2c66c30b86b7ea973bd8b"

URI_x86_64_v2_rust-tower-http+redirect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+redirect-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+redirect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+redirect-devel}"
SRC_URI[x86_64_v2_rust-tower-http+redirect-devel.sha256sum] = "93003d1b06b3dbc957cb9cad5782ef89fffa6bc6b8220a085f6a7f73ffaf5f0b"

URI_x86_64_v2_rust-tower-http+request-id-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+request-id-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+request-id-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+request-id-devel}"
SRC_URI[x86_64_v2_rust-tower-http+request-id-devel.sha256sum] = "c94cd5614b1b7668dbc77a5ae65180cc46bdf763ce6cb26b5e7ec2609f2728e8"

URI_x86_64_v2_rust-tower-http+sensitive-headers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+sensitive-headers-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+sensitive-headers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+sensitive-headers-devel}"
SRC_URI[x86_64_v2_rust-tower-http+sensitive-headers-devel.sha256sum] = "707e99d02497db97b0397210ddf7a86c5ad9fcca9aba0ba74310eb2f1c3f84c6"

URI_x86_64_v2_rust-tower-http+set-header-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+set-header-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+set-header-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+set-header-devel}"
SRC_URI[x86_64_v2_rust-tower-http+set-header-devel.sha256sum] = "9c09f8189fd586187a7374968e331df886a84636343718204a835b8d0d06bb04"

URI_x86_64_v2_rust-tower-http+set-status-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+set-status-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+set-status-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+set-status-devel}"
SRC_URI[x86_64_v2_rust-tower-http+set-status-devel.sha256sum] = "82c9c14a87ba6c1ba044b978c44ef96bb6b952bc6813358606303c6ee376749e"

URI_x86_64_v2_rust-tower-http+timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+timeout-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+timeout-devel}"
SRC_URI[x86_64_v2_rust-tower-http+timeout-devel.sha256sum] = "2963d0f3af63c86748f52b70cb60330abcb37368a607884ba98877f178e9a36a"

URI_x86_64_v2_rust-tower-http+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tokio-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+tokio-devel}"
SRC_URI[x86_64_v2_rust-tower-http+tokio-devel.sha256sum] = "ea49c95ddb0a1196cb5223bb7916e944586b14c59ffd0a05e1b39f4c18f53757"

URI_x86_64_v2_rust-tower-http+tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tokio-util-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+tokio-util-devel}"
SRC_URI[x86_64_v2_rust-tower-http+tokio-util-devel.sha256sum] = "daecf874b15ca9e946c0eab42011614bdcc780c8bdfe5de989f646611005310f"

URI_x86_64_v2_rust-tower-http+tower-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tower-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tower-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+tower-devel}"
SRC_URI[x86_64_v2_rust-tower-http+tower-devel.sha256sum] = "798ffc22568fd69fc2b4fe235773bc4f982e728c01e1378f5e3cf299c0db6957"

URI_x86_64_v2_rust-tower-http+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+trace-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+trace-devel}"
SRC_URI[x86_64_v2_rust-tower-http+trace-devel.sha256sum] = "1a551eefa80685f8c03047daf085178d3e287b002b7b0ab90a6227b914c8b326"

URI_x86_64_v2_rust-tower-http+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tracing-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+tracing-devel}"
SRC_URI[x86_64_v2_rust-tower-http+tracing-devel.sha256sum] = "462c037cdd10daff7725ae643a9680fd82456ea483920e71b7c85c8ab3edfad8"

URI_x86_64_v2_rust-tower-http+util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+util-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+util-devel}"
SRC_URI[x86_64_v2_rust-tower-http+util-devel.sha256sum] = "62fb3c0e78dc628908f9e67e39bf7ebdc69557164e3adeb4343a1c6f5caa11a1"

URI_x86_64_v2_rust-tower-http+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+uuid-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+uuid-devel}"
SRC_URI[x86_64_v2_rust-tower-http+uuid-devel.sha256sum] = "33e14700629babed34c8d8b11dbb4ff74a4e1eaa477e3665e3a2f8c80b084785"

URI_x86_64_v2_rust-tower-http+validate-request-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+validate-request-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+validate-request-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+validate-request-devel}"
SRC_URI[x86_64_v2_rust-tower-http+validate-request-devel.sha256sum] = "c512d39a066d90412f887fb3a2bc9868aad5631c355231757364f42688236c7f"

URI_x86_64_v2_rust-tower-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http-devel-0.6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http-devel}"
SRC_URI[x86_64_v2_rust-tower-http-devel.sha256sum] = "a1748fa770225bf9072f4bba4d6f7ae9f8a7fb7cde111ecf834e649c4052b807"

URI_aarch64_rust-tower-http+add-extension-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+add-extension-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+add-extension-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+add-extension-devel}"
SRC_URI[aarch64_rust-tower-http+add-extension-devel.sha256sum] = "34008d3d19784dbe1bf11e4c09f6161ff95f68870ec1d2cbcb1f1b0ff32733b7"

URI_aarch64_rust-tower-http+async-compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+async-compression-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+async-compression-devel}"
SRC_URI[aarch64_rust-tower-http+async-compression-devel.sha256sum] = "9cba3eaccdae4f90918e42e83ce448588335e81d05cf9890596cef776b8aab2c"

URI_aarch64_rust-tower-http+auth-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+auth-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+auth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+auth-devel}"
SRC_URI[aarch64_rust-tower-http+auth-devel.sha256sum] = "5fabc77bf17be38ee2144ae4b40f2afb9a2e1856ae8d05f4423415f8a297b1c7"

URI_aarch64_rust-tower-http+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+base64-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+base64-devel}"
SRC_URI[aarch64_rust-tower-http+base64-devel.sha256sum] = "3633a732483009b9cc83d874109aadafe137e6f9a45fc48e9d6c7bf65fc46342"

URI_aarch64_rust-tower-http+catch-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+catch-panic-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+catch-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+catch-panic-devel}"
SRC_URI[aarch64_rust-tower-http+catch-panic-devel.sha256sum] = "9d681981c44631dc38b56b19c3158fced5522e1e43d9544edbf9310466b45bac"

URI_aarch64_rust-tower-http+compression-br-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-br-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+compression-br-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+compression-br-devel}"
SRC_URI[aarch64_rust-tower-http+compression-br-devel.sha256sum] = "493e98565311f820ec331fb8bf756a4a486c7d0b75d8406dd037876b32c72592"

URI_aarch64_rust-tower-http+compression-deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-deflate-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+compression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+compression-deflate-devel}"
SRC_URI[aarch64_rust-tower-http+compression-deflate-devel.sha256sum] = "414a0da8b5ec47b53031c5da33009081e448b92f951b0c594d66f663411c03a0"

URI_aarch64_rust-tower-http+compression-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-full-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+compression-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+compression-full-devel}"
SRC_URI[aarch64_rust-tower-http+compression-full-devel.sha256sum] = "204d0671d9a412c72060daffba005a1604efad8b1353d880cc1e26b715aaa477"

URI_aarch64_rust-tower-http+compression-gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-gzip-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+compression-gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+compression-gzip-devel}"
SRC_URI[aarch64_rust-tower-http+compression-gzip-devel.sha256sum] = "8cfa1f56006083371d8711fac2575d5d43ebff8bff10a2a264f783082f760e2b"

URI_aarch64_rust-tower-http+compression-zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-zstd-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+compression-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+compression-zstd-devel}"
SRC_URI[aarch64_rust-tower-http+compression-zstd-devel.sha256sum] = "f9b99a1285b082c33b5373bcdf31ad6f24dd7a66d0a7786731d7a69e51062977"

URI_aarch64_rust-tower-http+cors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+cors-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+cors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+cors-devel}"
SRC_URI[aarch64_rust-tower-http+cors-devel.sha256sum] = "b552e0160d3cd734790f7fd9a937748068f0eda82bc8921932d48313da7f6dbe"

URI_aarch64_rust-tower-http+decompression-br-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-br-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+decompression-br-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+decompression-br-devel}"
SRC_URI[aarch64_rust-tower-http+decompression-br-devel.sha256sum] = "2926936ce43fb9c39d17c9e92b06b4fd6dd2ab69e7b27e7e7c78685143edd0c7"

URI_aarch64_rust-tower-http+decompression-deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-deflate-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+decompression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+decompression-deflate-devel}"
SRC_URI[aarch64_rust-tower-http+decompression-deflate-devel.sha256sum] = "5ae3dc86c9b4f1d9df67f9f9d27ff33a2aba042d3d4e2be962a6329e649b705a"

URI_aarch64_rust-tower-http+decompression-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-full-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+decompression-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+decompression-full-devel}"
SRC_URI[aarch64_rust-tower-http+decompression-full-devel.sha256sum] = "853ab78e1aafecfa0601466cf9161bf2dfc6ade1b49bfc960cd21b66d63b87a2"

URI_aarch64_rust-tower-http+decompression-gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-gzip-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+decompression-gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+decompression-gzip-devel}"
SRC_URI[aarch64_rust-tower-http+decompression-gzip-devel.sha256sum] = "ab784291e4e3d8a9535efc3e34bc6b383ae1f5bdb9d3d39b4d9d9c37cc225183"

URI_aarch64_rust-tower-http+decompression-zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-zstd-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+decompression-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+decompression-zstd-devel}"
SRC_URI[aarch64_rust-tower-http+decompression-zstd-devel.sha256sum] = "7c92d6e03745da79b1d08c59b540009f8fe6372ff13a6b7664a3bbef7e127427"

URI_aarch64_rust-tower-http+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+default-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+default-devel}"
SRC_URI[aarch64_rust-tower-http+default-devel.sha256sum] = "7a115a109a42b9a849fa9ebcc018979e142f3a6b75d0f653b66516d3976e5f97"

URI_aarch64_rust-tower-http+follow-redirect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+follow-redirect-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+follow-redirect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+follow-redirect-devel}"
SRC_URI[aarch64_rust-tower-http+follow-redirect-devel.sha256sum] = "2e523a8178216c82a1f309272cd18818f08a395c64facb0f7fd98624fa8f6524"

URI_aarch64_rust-tower-http+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+fs-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+fs-devel}"
SRC_URI[aarch64_rust-tower-http+fs-devel.sha256sum] = "8ec371c0914926216c724394e8afbe6731360ac5b14c33764693edc41d04edaa"

URI_aarch64_rust-tower-http+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+full-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+full-devel}"
SRC_URI[aarch64_rust-tower-http+full-devel.sha256sum] = "226e2dac522b2b3dd6de9f8e8e37db16d857612d9290fa8b45f04d5a842ca239"

URI_aarch64_rust-tower-http+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+futures-core-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+futures-core-devel}"
SRC_URI[aarch64_rust-tower-http+futures-core-devel.sha256sum] = "b1ea822d52883c8ae1b0339bd3d57c959e97db736d1316580f59204f311ceaf3"

URI_aarch64_rust-tower-http+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+futures-util-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+futures-util-devel}"
SRC_URI[aarch64_rust-tower-http+futures-util-devel.sha256sum] = "d1265fbe9633b86908ea8d703bee78f5576f92946c53ed8f0314b8e413d986ed"

URI_aarch64_rust-tower-http+httpdate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+httpdate-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+httpdate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+httpdate-devel}"
SRC_URI[aarch64_rust-tower-http+httpdate-devel.sha256sum] = "1c2f37b0c8db454dad5358e399bb849dca029ba630fae4d3e99b63b633f3a49b"

URI_aarch64_rust-tower-http+iri-string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+iri-string-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+iri-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+iri-string-devel}"
SRC_URI[aarch64_rust-tower-http+iri-string-devel.sha256sum] = "d2c1eb66e76d13a2bc38336e2b7f6c1ff91f5aba2cfaa706b084045b17333cdc"

URI_aarch64_rust-tower-http+limit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+limit-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+limit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+limit-devel}"
SRC_URI[aarch64_rust-tower-http+limit-devel.sha256sum] = "18933b4841faf4e6ae279eed1d4cc31526577f715ba476f3111bb9fc0ef36d14"

URI_aarch64_rust-tower-http+map-request-body-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+map-request-body-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+map-request-body-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+map-request-body-devel}"
SRC_URI[aarch64_rust-tower-http+map-request-body-devel.sha256sum] = "6a7fcffd963d8d72650183c3d8c03159915cf8bb6791fbe6451806455c682530"

URI_aarch64_rust-tower-http+map-response-body-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+map-response-body-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+map-response-body-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+map-response-body-devel}"
SRC_URI[aarch64_rust-tower-http+map-response-body-devel.sha256sum] = "dfbf93aea6f390184e034d271c49ae6b1b69739fe5b85449895af4595e6e4c42"

URI_aarch64_rust-tower-http+metrics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+metrics-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+metrics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+metrics-devel}"
SRC_URI[aarch64_rust-tower-http+metrics-devel.sha256sum] = "1b805f6adb611e77171461c832bf4db558435cf5ccd21189eafd36ca709d0e41"

URI_aarch64_rust-tower-http+mime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+mime-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+mime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+mime-devel}"
SRC_URI[aarch64_rust-tower-http+mime-devel.sha256sum] = "2c362680b45aab08fcdfe7e883b0cf6a61143611c890184830ff4dc8932abe54"

URI_aarch64_rust-tower-http+mime_guess-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+mime_guess-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+mime_guess-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+mime_guess-devel}"
SRC_URI[aarch64_rust-tower-http+mime_guess-devel.sha256sum] = "6db5d4ad9522395b4fb1a8108342b336c23c79bdec2e8c5a36c5bbaeb3034494"

URI_aarch64_rust-tower-http+normalize-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+normalize-path-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+normalize-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+normalize-path-devel}"
SRC_URI[aarch64_rust-tower-http+normalize-path-devel.sha256sum] = "19a4b689c83cc2c34714953bbb3bbeb85a4eb4366786a6d8be51e1c5490533bb"

URI_aarch64_rust-tower-http+percent-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+percent-encoding-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+percent-encoding-devel}"
SRC_URI[aarch64_rust-tower-http+percent-encoding-devel.sha256sum] = "9a726d0dba7cf36f48d31ba459ca1e413f592bbc7de7ccb6314d16c6c23ad5b2"

URI_aarch64_rust-tower-http+propagate-header-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+propagate-header-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+propagate-header-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+propagate-header-devel}"
SRC_URI[aarch64_rust-tower-http+propagate-header-devel.sha256sum] = "977fc02e8d575a5b8764945abca89dccdd77a35279173c7db920aea14a4c5551"

URI_aarch64_rust-tower-http+redirect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+redirect-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+redirect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+redirect-devel}"
SRC_URI[aarch64_rust-tower-http+redirect-devel.sha256sum] = "9312aac48c8d8c597a76f28b5c13e58d4a936c27a7484a20199556dc5ed22f42"

URI_aarch64_rust-tower-http+request-id-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+request-id-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+request-id-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+request-id-devel}"
SRC_URI[aarch64_rust-tower-http+request-id-devel.sha256sum] = "bd64a95d4461ef69a12f09cb231728ae878b711fe97e33304899d456023f00f9"

URI_aarch64_rust-tower-http+sensitive-headers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+sensitive-headers-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+sensitive-headers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+sensitive-headers-devel}"
SRC_URI[aarch64_rust-tower-http+sensitive-headers-devel.sha256sum] = "d849bc38d28f3039758c46c59c6e1218992a291b5ec709a3c8cd70bc456cbacb"

URI_aarch64_rust-tower-http+set-header-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+set-header-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+set-header-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+set-header-devel}"
SRC_URI[aarch64_rust-tower-http+set-header-devel.sha256sum] = "2094425e9e8f337cb97eaa596d56c840d50cb230122459576c3cbf742c50f65f"

URI_aarch64_rust-tower-http+set-status-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+set-status-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+set-status-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+set-status-devel}"
SRC_URI[aarch64_rust-tower-http+set-status-devel.sha256sum] = "b042bc81a0dab02610b0366ff6e66e6434d0cde2e30f7f35bea03f76abf2a6c8"

URI_aarch64_rust-tower-http+timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+timeout-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+timeout-devel}"
SRC_URI[aarch64_rust-tower-http+timeout-devel.sha256sum] = "debdbcaf8d77336fc4f5228811f2204f146239d7f87a5df259ea77dd7e90a3b6"

URI_aarch64_rust-tower-http+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tokio-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+tokio-devel}"
SRC_URI[aarch64_rust-tower-http+tokio-devel.sha256sum] = "f151844749290a896f548dfa977b5a813d79a75b624374eddef78daa87b53561"

URI_aarch64_rust-tower-http+tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tokio-util-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+tokio-util-devel}"
SRC_URI[aarch64_rust-tower-http+tokio-util-devel.sha256sum] = "df5b7e48a56311cb3c133d8973843fde7730a5c9d6260d499ed0f64ebac3ea8b"

URI_aarch64_rust-tower-http+tower-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tower-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+tower-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+tower-devel}"
SRC_URI[aarch64_rust-tower-http+tower-devel.sha256sum] = "f4f9980883c973af47aedc45c5e4e658f9758f978e4889c64b93e2509b492240"

URI_aarch64_rust-tower-http+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+trace-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+trace-devel}"
SRC_URI[aarch64_rust-tower-http+trace-devel.sha256sum] = "94079dd60bc8dc47a822787bc88f73d2405f5428041a4b23ae631da29b22a555"

URI_aarch64_rust-tower-http+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tracing-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+tracing-devel}"
SRC_URI[aarch64_rust-tower-http+tracing-devel.sha256sum] = "75f8ff20611d14132bfe74615c2b8feb2c12eb36017b67ff2b3e24701cb5c56b"

URI_aarch64_rust-tower-http+util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+util-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+util-devel}"
SRC_URI[aarch64_rust-tower-http+util-devel.sha256sum] = "c22dfab4ff228122ebadb250dcc2374d84478df459c5ecef881ba24b66d4ea4b"

URI_aarch64_rust-tower-http+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+uuid-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+uuid-devel}"
SRC_URI[aarch64_rust-tower-http+uuid-devel.sha256sum] = "ec16bfecdb69834654c651b83c7dd1cdc6fa6585e1ed2bb50ac95e530162126a"

URI_aarch64_rust-tower-http+validate-request-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+validate-request-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http+validate-request-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+validate-request-devel}"
SRC_URI[aarch64_rust-tower-http+validate-request-devel.sha256sum] = "ffdfedefbdb77809ddc11ce70529527853c6dc9becad4c41074624a40ccfbba8"

URI_aarch64_rust-tower-http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http-devel-0.6.6-2.el10_0.noarch.rpm;name=aarch64_rust-tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http-devel}"
SRC_URI[aarch64_rust-tower-http-devel.sha256sum] = "4ba489468ae5334f04314be31b86dbc214a8ad0b0c8a7b8021a51199d8a77f03"

RDEPENDS:rust-tower-http+add-extension-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+async-compression-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+auth-devel = " \
 cargo \
 rust-tower-http+base64-devel \
 rust-tower-http+validate-request-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+base64-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+catch-panic-devel = " \
 cargo \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+tracing-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-br-devel = " \
 cargo \
 rust-async-compression+brotli-devel \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-deflate-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zlib-devel \
 rust-http-body+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-full-devel = " \
 cargo \
 rust-tower-http+compression-br-devel \
 rust-tower-http+compression-deflate-devel \
 rust-tower-http+compression-gzip-devel \
 rust-tower-http+compression-zstd-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-gzip-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+gzip-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-zstd-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zstd-devel \
 rust-http-body+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+cors-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-br-devel = " \
 cargo \
 rust-async-compression+brotli-devel \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-deflate-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zlib-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-full-devel = " \
 cargo \
 rust-tower-http+decompression-br-devel \
 rust-tower-http+decompression-deflate-devel \
 rust-tower-http+decompression-gzip-devel \
 rust-tower-http+decompression-zstd-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-gzip-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+gzip-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-zstd-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zstd-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+default-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+follow-redirect-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tower+default-devel \
 rust-tower+util-devel \
 rust-tower-http+futures-util-devel \
 rust-tower-http+iri-string-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+fs-devel = " \
 cargo \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-http-range-header+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+futures-util-devel \
 rust-tower-http+httpdate-devel \
 rust-tower-http+mime-devel \
 rust-tower-http+mime_guess-devel \
 rust-tower-http+percent-encoding-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+tracing-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+full-devel = " \
 cargo \
 rust-tower-http+add-extension-devel \
 rust-tower-http+auth-devel \
 rust-tower-http+catch-panic-devel \
 rust-tower-http+compression-full-devel \
 rust-tower-http+cors-devel \
 rust-tower-http+decompression-full-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http+fs-devel \
 rust-tower-http+limit-devel \
 rust-tower-http+map-request-body-devel \
 rust-tower-http+map-response-body-devel \
 rust-tower-http+metrics-devel \
 rust-tower-http+normalize-path-devel \
 rust-tower-http+propagate-header-devel \
 rust-tower-http+redirect-devel \
 rust-tower-http+request-id-devel \
 rust-tower-http+sensitive-headers-devel \
 rust-tower-http+set-header-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+timeout-devel \
 rust-tower-http+trace-devel \
 rust-tower-http+util-devel \
 rust-tower-http+validate-request-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+futures-core-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+futures-util-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+httpdate-devel = " \
 cargo \
 rust-httpdate+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+iri-string-devel = " \
 cargo \
 rust-iri-string+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+limit-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+map-request-body-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+map-response-body-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+metrics-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+mime-devel = " \
 cargo \
 rust-mime-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+mime_guess-devel = " \
 cargo \
 rust-mime_guess-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+normalize-path-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+percent-encoding-devel = " \
 cargo \
 rust-percent-encoding+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+propagate-header-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+redirect-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+request-id-devel = " \
 cargo \
 rust-tower-http+uuid-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+sensitive-headers-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+set-header-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+set-status-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+timeout-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tokio-devel = " \
 cargo \
 rust-tokio-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tokio-util-devel = " \
 cargo \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tower-devel = " \
 cargo \
 rust-tower+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+trace-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tower-http+tracing-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tracing-devel = " \
 cargo \
 rust-tower-http-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tower-http+util-devel = " \
 cargo \
 rust-tower-http+tower-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+uuid-devel = " \
 cargo \
 rust-tower-http-devel \
 rust-uuid+default-devel \
 rust-uuid+v4-devel \
 "
RDEPENDS:rust-tower-http+validate-request-devel = " \
 cargo \
 rust-tower-http+mime-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-pin-project-lite+default-devel \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
