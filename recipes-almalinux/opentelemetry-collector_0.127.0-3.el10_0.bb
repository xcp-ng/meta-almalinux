# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opentelemetry-collector"
PV = "0.127.0"
PR = "3.el10_0"
PACKAGES = " \
 opentelemetry-collector \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/opentelemetry-collector-0.127.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfc071fb4c4d21d68503c6414613c80791389d971db63589974b6c8f5f2d0955"

URI_x86_64_v2_opentelemetry-collector = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/opentelemetry-collector-0.127.0-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_opentelemetry-collector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opentelemetry-collector}"
SRC_URI[x86_64_v2_opentelemetry-collector.sha256sum] = "c20e669a6cbad58ccb45d55edcf96d99bdb373ab2b7527a3e4da974965f67920"

URI_aarch64_opentelemetry-collector = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/opentelemetry-collector-0.127.0-3.el10_0.aarch64.rpm;name=aarch64_opentelemetry-collector;unpack=0"
SRC_URI:append = " ${URI_aarch64_opentelemetry-collector}"
SRC_URI[aarch64_opentelemetry-collector.sha256sum] = "405722e5fa1624cd28c7ad7f7574ce08159ea2fd8130feeb77f488804905f875"

RDEPENDS:opentelemetry-collector = " \
 bash \
 glibc \
 glibc-common \
 shadow-utils \
 util-linux \
 "
