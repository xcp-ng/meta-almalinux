# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rnp"
PV = "0.18.0"
PR = "1.el10_0"
PACKAGES = " \
 librnp \
 librnp-devel \
 rnp \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rnp-0.18.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ec0b4a1849eef221159808925e674deb238ed9c8d691544646e382dd1e3833a4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librnp-0.18.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librnp;unpack=0"
SRC_URI[x86_64_v2_librnp.sha256sum] = "5299ab797ec6d02d6746a30a8bae195085d499d63a8c2bcf87b270649e542e90"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librnp-devel-0.18.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librnp-devel;unpack=0"
SRC_URI[x86_64_v2_librnp-devel.sha256sum] = "ca4f45304096d9139584d44f522252695bd8f0da93b46d7cccbeb601b0d2aef6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rnp-0.18.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rnp;unpack=0"
SRC_URI[x86_64_v2_rnp.sha256sum] = "6f075ccfe8a3c50ff9b098d692467eed2549df1c237a029eb769b906b73ecd0f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/librnp-0.18.0-1.el10_0.aarch64.rpm;name=aarch64_librnp;unpack=0"
SRC_URI[aarch64_librnp.sha256sum] = "41fc43c90f99b7afc163ccc414306daee4d32d0d86382c9e2f2ce4d6264f33ff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/librnp-devel-0.18.0-1.el10_0.aarch64.rpm;name=aarch64_librnp-devel;unpack=0"
SRC_URI[aarch64_librnp-devel.sha256sum] = "5bfa6b7e15b6ae033b5e654e18e18f64d8a4ab100f9902a8bf1bf7b17e316b2a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rnp-0.18.0-1.el10_0.aarch64.rpm;name=aarch64_rnp;unpack=0"
SRC_URI[aarch64_rnp.sha256sum] = "46a7d81283741f0e3a48a791fe74e3f187eef21251fba5bfb827801d2aacc5c8"

RDEPENDS:librnp = " \
 botan2 \
 bzip2-libs \
 glibc \
 json-c \
 libgcc \
 libsexpp \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:librnp-devel = " \
 cmake-filesystem \
 librnp \
 pkgconf-pkg-config \
 "
RDEPENDS:rnp = " \
 glibc \
 json-c \
 libgcc \
 librnp \
 libstdc++ \
 "
