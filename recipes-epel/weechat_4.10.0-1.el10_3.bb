# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "weechat"
PV = "4.10.0"
PR = "1.el10_3"
PACKAGES = " \
 weechat \
 weechat-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/weechat-4.10.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "886eb94be28570b62500468260fb52e8dca752e34d7d5d738d93fe060aa6f563"

URI_x86_64_v2_weechat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weechat-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weechat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_weechat}"
SRC_URI[x86_64_v2_weechat.sha256sum] = "55c3b2f0965a0480d72815745ead6d96986f3d2473a50feb46c4a1bfd247028b"

URI_x86_64_v2_weechat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weechat-devel-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weechat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_weechat-devel}"
SRC_URI[x86_64_v2_weechat-devel.sha256sum] = "7c49e45ad6d1affb71d7d48cf809376d9e223f0e6b8cd5cac4cb5b36081adcc0"

URI_aarch64_weechat = "${EPEL_MIRROR}/aarch64/Packages/w/weechat-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_weechat;unpack=0"
SRC_URI:append = " ${URI_aarch64_weechat}"
SRC_URI[aarch64_weechat.sha256sum] = "8dc2337bde4cfd02583f9e16768075705246275acf08e4a1f75de21e84942b4e"

URI_aarch64_weechat-devel = "${EPEL_MIRROR}/aarch64/Packages/w/weechat-devel-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_weechat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_weechat-devel}"
SRC_URI[aarch64_weechat-devel.sha256sum] = "46caeb6656f31859f11e1b1aa7cad9950c163dc3dc409b3dd48d1bc0a4a0a569"

RDEPENDS:weechat = " \
 cjson \
 enchant2 \
 glibc \
 gnutls \
 guile30 \
 hicolor-icon-theme \
 libgcc \
 libgcrypt \
 libzstd \
 lua-libs \
 ncurses-libs \
 perl-libs \
 python3-libs \
 ruby-libs \
 tcl \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:weechat-devel = " \
 pkgconf-pkg-config \
 weechat \
 "
