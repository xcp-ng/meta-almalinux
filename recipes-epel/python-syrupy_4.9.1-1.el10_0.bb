# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-syrupy"
PV = "4.9.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-syrupy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-syrupy-4.9.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b905471e3a98d48917bb91f13bd33f8d72e9fbe17b0cdbbec44e023bd2b9c02b"

URI_x86_64_v2_python3-syrupy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-syrupy-4.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-syrupy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-syrupy}"
SRC_URI[x86_64_v2_python3-syrupy.sha256sum] = "f8bd7bace70d389f4c1cd39219461ad93c85d37061cef586bad0cff6ef38175c"

URI_aarch64_python3-syrupy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-syrupy-4.9.1-1.el10_0.noarch.rpm;name=aarch64_python3-syrupy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-syrupy}"
SRC_URI[aarch64_python3-syrupy.sha256sum] = "50a2c5ecf098195f7e7b4e984e418be4eeedc4bbaa4c360192b5909265245b13"

RDEPENDS:python3-syrupy = " \
 python3 \
 python3-pytest \
 "
