# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "picosat"
PV = "965"
PR = "30.el10_3"
PACKAGES = " \
 picosat \
 picosat-R \
 picosat-devel \
 picosat-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/picosat-965-30.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95421157a636bffc263341e71bb45d0eb7fa47c2b066884656b333937c3bf934"

URI_x86_64_v2_picosat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/picosat-965-30.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_picosat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_picosat}"
SRC_URI[x86_64_v2_picosat.sha256sum] = "7de68beed8da271b484eb7b71366930778f4d218fb1433a63227b639d950c8e8"

URI_x86_64_v2_picosat-R = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/picosat-R-965-30.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_picosat-R;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_picosat-R}"
SRC_URI[x86_64_v2_picosat-R.sha256sum] = "5b6f5cfd68288572b8fce67390a651abc46d2b55c3d60da3a959ed168afe6a5c"

URI_x86_64_v2_picosat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/picosat-devel-965-30.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_picosat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_picosat-devel}"
SRC_URI[x86_64_v2_picosat-devel.sha256sum] = "6dd575bb8fa59023ff3fc7b3f47c8d2e0c132e5529b66cea4f21cc85c40c57a5"

URI_x86_64_v2_picosat-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/picosat-libs-965-30.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_picosat-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_picosat-libs}"
SRC_URI[x86_64_v2_picosat-libs.sha256sum] = "ce3c4d8b308036f7258b4c9aea0113b37d47b7dd556a608994d5ab49a34fdaa9"

URI_aarch64_picosat = "${EPEL_MIRROR}/aarch64/Packages/p/picosat-965-30.el10_3.aarch64.rpm;name=aarch64_picosat;unpack=0"
SRC_URI:append = " ${URI_aarch64_picosat}"
SRC_URI[aarch64_picosat.sha256sum] = "e98192780c055581daf941f602a3918815912ed36907fbe45b0ce801b421a584"

URI_aarch64_picosat-R = "${EPEL_MIRROR}/aarch64/Packages/p/picosat-R-965-30.el10_3.aarch64.rpm;name=aarch64_picosat-R;unpack=0"
SRC_URI:append = " ${URI_aarch64_picosat-R}"
SRC_URI[aarch64_picosat-R.sha256sum] = "d52856f95442e6902d09cf747ad393bbac3692127c570c8e879000e3384d5f84"

URI_aarch64_picosat-devel = "${EPEL_MIRROR}/aarch64/Packages/p/picosat-devel-965-30.el10_3.aarch64.rpm;name=aarch64_picosat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_picosat-devel}"
SRC_URI[aarch64_picosat-devel.sha256sum] = "579eeb9ca205f42feb7832017579737993910b1328043b590ec05c61b5d54336"

URI_aarch64_picosat-libs = "${EPEL_MIRROR}/aarch64/Packages/p/picosat-libs-965-30.el10_3.aarch64.rpm;name=aarch64_picosat-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_picosat-libs}"
SRC_URI[aarch64_picosat-libs.sha256sum] = "ed7a1136ba0ffbe682868cb611a80f81dce7d6be2c16bc752c0d4141a6f6f2a8"

RDEPENDS:picosat = " \
 bzip2 \
 glibc \
 gzip \
 picosat-libs \
 "
RDEPENDS:picosat-R = " \
 R-core \
 glibc \
 "
RDEPENDS:picosat-devel = " \
 picosat-R \
 picosat-libs \
 "
RDEPENDS:picosat-libs = " \
 glibc \
 "
