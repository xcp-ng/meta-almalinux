# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nbclient"
PV = "0.10.2"
PR = "3.el10_1"
PACKAGES = " \
 python3-nbclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-nbclient-0.10.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "437eaaa5d48fbfae57a81bd03ae5bdf3235321ceaa2f84162eee4881d978289a"

URI_x86_64_v2_python3-nbclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nbclient-0.10.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-nbclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nbclient}"
SRC_URI[x86_64_v2_python3-nbclient.sha256sum] = "09f654a2968af723cdca5dae49149dc2d54f5805d913d6f098c95356e16549b3"

URI_aarch64_python3-nbclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nbclient-0.10.2-3.el10_1.noarch.rpm;name=aarch64_python3-nbclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nbclient}"
SRC_URI[aarch64_python3-nbclient.sha256sum] = "6a7d7bc7fcba429bdc37064d70ec890e8cdcd154df17c9417969ae42b5f87d4f"

RDEPENDS:python3-nbclient = " \
 python3 \
 python3-jupyter-client \
 python3-jupyter-core \
 python3-nbformat \
 python3-traitlets \
 "
