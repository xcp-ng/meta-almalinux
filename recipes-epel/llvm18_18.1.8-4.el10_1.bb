# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llvm18"
PV = "18.1.8"
PR = "4.el10_1"
PACKAGES = " \
 llvm18 \
 llvm18-cmake-utils \
 llvm18-devel \
 llvm18-doc \
 llvm18-googletest \
 llvm18-libs \
 llvm18-static \
 llvm18-test \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/llvm18-18.1.8-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c00ffce7e600ff6ee0d6664fef797ba3e821cbe1fe395b37cb35cbfee155070"

URI_x86_64_v2_llvm18 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-18.1.8-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm18;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18}"
SRC_URI[x86_64_v2_llvm18.sha256sum] = "a7e9f23014026b609a4c92bf1cce349ed4d1209b4bad74e155f30d091775e3f0"

URI_x86_64_v2_llvm18-cmake-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-cmake-utils-18.1.8-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm18-cmake-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18-cmake-utils}"
SRC_URI[x86_64_v2_llvm18-cmake-utils.sha256sum] = "c4320d76e634e415f71de897375d3829d24f5070064fb6ec916add6d4b4c3366"

URI_x86_64_v2_llvm18-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-devel-18.1.8-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm18-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18-devel}"
SRC_URI[x86_64_v2_llvm18-devel.sha256sum] = "c223f69c5c4573419995ed5e193aff0e0d0cd4f836da512720360633ac22035b"

URI_x86_64_v2_llvm18-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-doc-18.1.8-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_llvm18-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18-doc}"
SRC_URI[x86_64_v2_llvm18-doc.sha256sum] = "d7d569576a149754703a33b718227256ae18def4d73ebac41789694ce5f8c651"

URI_x86_64_v2_llvm18-googletest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-googletest-18.1.8-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm18-googletest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18-googletest}"
SRC_URI[x86_64_v2_llvm18-googletest.sha256sum] = "5892fe7be00728a41dea6ad058c9dd283f51d4d32c91a5d69d3ed8d409095e3c"

URI_x86_64_v2_llvm18-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-libs-18.1.8-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm18-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18-libs}"
SRC_URI[x86_64_v2_llvm18-libs.sha256sum] = "7976b0abb872c681879034cd8949c0ba2a5c070e3b64b7185857d5b7cb5ee46f"

URI_x86_64_v2_llvm18-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-static-18.1.8-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm18-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18-static}"
SRC_URI[x86_64_v2_llvm18-static.sha256sum] = "bdb656170d38e3d26d374802f0629a15b01febd2154538548a29df42e694757a"

URI_x86_64_v2_llvm18-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-test-18.1.8-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm18-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18-test}"
SRC_URI[x86_64_v2_llvm18-test.sha256sum] = "d409116f9f3903f31d5b843146be6c69d9842fac3846a1a3e0e4e743104af919"

URI_aarch64_llvm18 = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-18.1.8-4.el10_1.aarch64.rpm;name=aarch64_llvm18;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18}"
SRC_URI[aarch64_llvm18.sha256sum] = "a0ea0f71a03c0786864b1f0a8d299cbf80baaec5ea7ce8dcb1eb1a7ce07b8e11"

URI_aarch64_llvm18-cmake-utils = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-cmake-utils-18.1.8-4.el10_1.aarch64.rpm;name=aarch64_llvm18-cmake-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18-cmake-utils}"
SRC_URI[aarch64_llvm18-cmake-utils.sha256sum] = "b00481a79b0b8b4b0f1bf396e4e8dcae883ef303c7a315353bd3fbd44b953ce8"

URI_aarch64_llvm18-devel = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-devel-18.1.8-4.el10_1.aarch64.rpm;name=aarch64_llvm18-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18-devel}"
SRC_URI[aarch64_llvm18-devel.sha256sum] = "d839674f5c8461bd137e81fd5b9466ae0921224988535451ccc3b3b27d3f3637"

URI_aarch64_llvm18-doc = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-doc-18.1.8-4.el10_1.noarch.rpm;name=aarch64_llvm18-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18-doc}"
SRC_URI[aarch64_llvm18-doc.sha256sum] = "b7c101c0d42e9efdafe84841f9a28e175b7bc797dc3e2561b0e8ce25165748e5"

URI_aarch64_llvm18-googletest = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-googletest-18.1.8-4.el10_1.aarch64.rpm;name=aarch64_llvm18-googletest;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18-googletest}"
SRC_URI[aarch64_llvm18-googletest.sha256sum] = "d6d57054307df348ffb7796be7d12c5c346d8fe69cba86897224ea51a4b24176"

URI_aarch64_llvm18-libs = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-libs-18.1.8-4.el10_1.aarch64.rpm;name=aarch64_llvm18-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18-libs}"
SRC_URI[aarch64_llvm18-libs.sha256sum] = "1cc1cd9c850a634f8aef09964057644d0e4a24b0d0669a36b92b5ac4e7648ffa"

URI_aarch64_llvm18-static = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-static-18.1.8-4.el10_1.aarch64.rpm;name=aarch64_llvm18-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18-static}"
SRC_URI[aarch64_llvm18-static.sha256sum] = "36b79eb2230e79959bd24508de61b1e8b3ed8d088ff6b21f67c49c8d2d55eab9"

URI_aarch64_llvm18-test = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-test-18.1.8-4.el10_1.aarch64.rpm;name=aarch64_llvm18-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18-test}"
SRC_URI[aarch64_llvm18-test.sha256sum] = "f05392f033f6ac4a926f68c246371d7288ce503012f69367f9ccf1b02d0e12cf"

RDEPENDS:llvm18 = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm18-libs \
 ncurses-libs \
 python3 \
 zlib-ng-compat \
 "
RDEPENDS:llvm18-cmake-utils = " \
 "
RDEPENDS:llvm18-devel = " \
 alternatives \
 bash \
 libedit-devel \
 llvm18 \
 llvm18-googletest \
 llvm18-libs \
 llvm18-static \
 llvm18-test \
 "
RDEPENDS:llvm18-doc = " \
 llvm18 \
 "
RDEPENDS:llvm18-googletest = " \
 "
RDEPENDS:llvm18-libs = " \
 glibc \
 libedit \
 libffi \
 libgcc \
 libstdc++ \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:llvm18-static = " \
 "
RDEPENDS:llvm18-test = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm18 \
 llvm18-libs \
 ncurses-libs \
 "
