# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rmlint"
PV = "2.10.3"
PR = "6.el10_3"
PACKAGES = " \
 rmlint \
 rmlint-gui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rmlint-2.10.3-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8b71370b8147dd3e3e68cbde6cbf6b44cea5a9704ed09af049f7e4b2958b3cd"

URI_x86_64_v2_rmlint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rmlint-2.10.3-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rmlint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rmlint}"
SRC_URI[x86_64_v2_rmlint.sha256sum] = "85730c909a6b4eb93fe1346d765c9430f774803bcf4dd48a6c7e49519d806dd0"

URI_x86_64_v2_rmlint-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rmlint-gui-2.10.3-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rmlint-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rmlint-gui}"
SRC_URI[x86_64_v2_rmlint-gui.sha256sum] = "0bc282a7e83b4578a0ccca735449542273dbf984dc43247ed28b9fe64d9b8934"

URI_aarch64_rmlint = "${EPEL_MIRROR}/aarch64/Packages/r/rmlint-2.10.3-6.el10_3.aarch64.rpm;name=aarch64_rmlint;unpack=0"
SRC_URI:append = " ${URI_aarch64_rmlint}"
SRC_URI[aarch64_rmlint.sha256sum] = "a643651066832ed1c8510d99297023a9605472c085f67e4460fab32f3228f3fe"

URI_aarch64_rmlint-gui = "${EPEL_MIRROR}/aarch64/Packages/r/rmlint-gui-2.10.3-6.el10_3.noarch.rpm;name=aarch64_rmlint-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_rmlint-gui}"
SRC_URI[aarch64_rmlint-gui.sha256sum] = "6b823d2a4caf5cf38f9662cd45abf59cb40279ab77164fd14803d430f81e017c"

RDEPENDS:rmlint = " \
 elfutils-libelf \
 glib2 \
 glibc \
 json-glib \
 libblkid \
 "
RDEPENDS:rmlint-gui = " \
 gtksourceview4 \
 hicolor-icon-theme \
 python3 \
 python3-cairo \
 python3-colorlog \
 python3-gobject-base \
 python3-parsedatetime \
 rmlint \
 "
