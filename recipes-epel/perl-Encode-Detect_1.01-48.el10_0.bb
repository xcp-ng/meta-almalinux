# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Encode-Detect"
PV = "1.01"
PR = "48.el10_0"
PACKAGES = " \
 perl-Encode-Detect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Encode-Detect-1.01-48.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5cac243b2df0e1db6dc0ccd2bc71f052180285106a013d1d0471667b50ef6074"

URI_x86_64_v2_perl-Encode-Detect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Encode-Detect-1.01-48.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Encode-Detect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Encode-Detect}"
SRC_URI[x86_64_v2_perl-Encode-Detect.sha256sum] = "b89f33330e90ea5328fe8f88f4f60c4ecc67eacaa57671545c0a9d1a3180b487"

URI_aarch64_perl-Encode-Detect = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Encode-Detect-1.01-48.el10_0.aarch64.rpm;name=aarch64_perl-Encode-Detect;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Encode-Detect}"
SRC_URI[aarch64_perl-Encode-Detect.sha256sum] = "08847cfb55e04f0c2f7f96bbbb1c0bef8fc6410217d4754d0f135c0b4142dca5"

RDEPENDS:perl-Encode-Detect = " \
 glibc \
 libgcc \
 libstdc++ \
 perl-DynaLoader \
 perl-Encode \
 perl-Encode-Detect \
 perl-base \
 perl-libs \
 "
