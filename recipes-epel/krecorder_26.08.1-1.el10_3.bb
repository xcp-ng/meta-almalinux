# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krecorder"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 krecorder \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/krecorder-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d75d62234e7befa37befda70a93c4c8667cabbfbbeea553ae4918daef33674a5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krecorder-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krecorder;unpack=0"
SRC_URI[x86_64_v2_krecorder.sha256sum] = "11d435754a16c80ed2a6d7840a40959178cb2c89690b571cd549334fb8eb0825"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/krecorder-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_krecorder;unpack=0"
SRC_URI[aarch64_krecorder.sha256sum] = "3b86a9689e92830abaebed37611d3f4e85dd087cf63cc7d32a0b5510a11b565d"

RDEPENDS:krecorder = " \
 glibc \
 gstreamer1-plugins-good \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
