# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-notify-types"
PV = "2.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-notify-types+default-devel \
 rust-notify-types+serde-devel \
 rust-notify-types+serialization-compat-6-devel \
 rust-notify-types-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-notify-types-2.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82f06da5baa959fa3b685b3a23cec254a035dd01276b64bcf81827732edf7622"

URI_x86_64_v2_rust-notify-types+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-types+default-devel-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-types+default-devel}"
SRC_URI[x86_64_v2_rust-notify-types+default-devel.sha256sum] = "439d57691c95b4d8eb63e73c8764b7a5a47c9a0d7c473ace30f467a300bd994e"

URI_x86_64_v2_rust-notify-types+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-types+serde-devel-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-types+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-types+serde-devel}"
SRC_URI[x86_64_v2_rust-notify-types+serde-devel.sha256sum] = "58de3d52ebe6b292cf6f3900988762042bcfc10a9b62f38b9b8415b1ee396577"

URI_x86_64_v2_rust-notify-types+serialization-compat-6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-types+serialization-compat-6-devel-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-types+serialization-compat-6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-types+serialization-compat-6-devel}"
SRC_URI[x86_64_v2_rust-notify-types+serialization-compat-6-devel.sha256sum] = "0fcbff8e0960a7b653c45a972c61e8f1b839c9439384ff77a14bf260109ac910"

URI_x86_64_v2_rust-notify-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-types-devel-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-types-devel}"
SRC_URI[x86_64_v2_rust-notify-types-devel.sha256sum] = "8cb9be16c67d36978dc13cdc802031e0044629de9bb742d8d3315e4689b98630"

URI_aarch64_rust-notify-types+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-types+default-devel-2.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-notify-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-types+default-devel}"
SRC_URI[aarch64_rust-notify-types+default-devel.sha256sum] = "63f3ad672d3b86864d06507fc2c750842aa62ace103d1ad3327bcc37e67c79ea"

URI_aarch64_rust-notify-types+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-types+serde-devel-2.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-notify-types+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-types+serde-devel}"
SRC_URI[aarch64_rust-notify-types+serde-devel.sha256sum] = "b707003774f21909d464599e6ac6793c947291cecfe83dd1f9bb5a746bc36d4f"

URI_aarch64_rust-notify-types+serialization-compat-6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-types+serialization-compat-6-devel-2.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-notify-types+serialization-compat-6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-types+serialization-compat-6-devel}"
SRC_URI[aarch64_rust-notify-types+serialization-compat-6-devel.sha256sum] = "4230b4bb16d20eaf686986449ffc6864b510053a755e4a1171001ec9fd5a675f"

URI_aarch64_rust-notify-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-types-devel-2.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-notify-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-types-devel}"
SRC_URI[aarch64_rust-notify-types-devel.sha256sum] = "e15d1ac9feab8471ce393f7ef55d18112d5ae3d739c790956c03c6da76637676"

RDEPENDS:rust-notify-types+default-devel = " \
 cargo \
 rust-notify-types-devel \
 "
RDEPENDS:rust-notify-types+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-notify-types-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-notify-types+serialization-compat-6-devel = " \
 cargo \
 rust-notify-types-devel \
 "
RDEPENDS:rust-notify-types-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 "
