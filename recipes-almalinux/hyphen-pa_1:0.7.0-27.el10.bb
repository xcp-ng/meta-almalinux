# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-pa"
PE = "1"
PV = "0.7.0"
PR = "27.el10"
PACKAGES = " \
 hyphen-pa \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-pa-0.7.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e61406d0a453950fff946873eab0e6dfc322dac63e550d1bd8b8f9ca9a16a616"

URI_x86_64_v2_hyphen-pa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-pa-0.7.0-27.el10.noarch.rpm;name=x86_64_v2_hyphen-pa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-pa}"
SRC_URI[x86_64_v2_hyphen-pa.sha256sum] = "7d3d3500df2499740c57889b30904109067a24e537cf011cbc58deedf8b19b61"

URI_aarch64_hyphen-pa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-pa-0.7.0-27.el10.noarch.rpm;name=aarch64_hyphen-pa;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-pa}"
SRC_URI[aarch64_hyphen-pa.sha256sum] = "7d3d3500df2499740c57889b30904109067a24e537cf011cbc58deedf8b19b61"

RDEPENDS:hyphen-pa = " \
 hyphen \
 "
