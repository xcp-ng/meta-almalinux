# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-elm"
PV = "5.9.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-elm+default-devel \
 rust-tree-sitter-elm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-elm-5.9.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8da5b1d16c587068fb31b531638150b17db44e5fee473fbb9190d5c33fe602b"

URI_x86_64_v2_rust-tree-sitter-elm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-elm+default-devel-5.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-elm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-elm+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-elm+default-devel.sha256sum] = "efd465128726af11904d6ca53bc6eec340ca0ce351421a90d365b27504aa1fa6"

URI_x86_64_v2_rust-tree-sitter-elm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-elm-devel-5.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-elm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-elm-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-elm-devel.sha256sum] = "9eaff30e3aea98ee6e563c4a430e044d060eddd32ca3a8aa1272d2e5be83a747"

URI_aarch64_rust-tree-sitter-elm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-elm+default-devel-5.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-elm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-elm+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-elm+default-devel.sha256sum] = "cd4787e4232d3451d5baaed8f0fedf0185d271d27589a8a6790e6fc04267432e"

URI_aarch64_rust-tree-sitter-elm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-elm-devel-5.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-elm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-elm-devel}"
SRC_URI[aarch64_rust-tree-sitter-elm-devel.sha256sum] = "b1391a99a2ee3215325c6245b26db3e502910cd4e50ba0cc5123d45d2446d18a"

RDEPENDS:rust-tree-sitter-elm+default-devel = " \
 cargo \
 rust-tree-sitter-elm-devel \
 "
RDEPENDS:rust-tree-sitter-elm-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
