# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grub2-breeze-theme"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 grub2-breeze-theme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/grub2-breeze-theme-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de35d2dc4aad4fc3677d3c2603292741fc60fe19a6287b87c5c9221d8503bcbe"

URI_x86_64_v2_grub2-breeze-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grub2-breeze-theme-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grub2-breeze-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-breeze-theme}"
SRC_URI[x86_64_v2_grub2-breeze-theme.sha256sum] = "665f7da62c1fd14a87055a6b18d8d35dc79d0de085e0f6e80f034f22976bdd30"

URI_aarch64_grub2-breeze-theme = "${EPEL_MIRROR}/aarch64/Packages/g/grub2-breeze-theme-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_grub2-breeze-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-breeze-theme}"
SRC_URI[aarch64_grub2-breeze-theme.sha256sum] = "6c43ee1dc127723d7413df6fc16c369e760ba6136ccac66ed55b8feb9ba485be"

RDEPENDS:grub2-breeze-theme:x86_64_v2 = " \
 grub2-pc \
"
RDEPENDS:grub2-breeze-theme:aarch64 = " \
 grub2-efi-aa64 \
"
