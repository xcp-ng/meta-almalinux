# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mawk"
PE = "1"
PV = "1.3.4"
PR = "3.20240905.el10_0"
PACKAGES = " \
 mawk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mawk-1.3.4-3.20240905.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "adfb9f09bf47cc656e2e1ee862fa69dde63739ac06a9ae3bd3e8471b9e91c618"

URI_x86_64_v2_mawk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mawk-1.3.4-3.20240905.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mawk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mawk}"
SRC_URI[x86_64_v2_mawk.sha256sum] = "ca683092929a911150503d1e23eab6ed2b471a958d1b2cb9e21aed6cb6d42d9f"

URI_aarch64_mawk = "${EPEL_MIRROR}/aarch64/Packages/m/mawk-1.3.4-3.20240905.el10_0.aarch64.rpm;name=aarch64_mawk;unpack=0"
SRC_URI:append = " ${URI_aarch64_mawk}"
SRC_URI[aarch64_mawk.sha256sum] = "8d17b054a08def6f02264ba89bd25813deed4f161b226eddd902d4334b64695d"

RDEPENDS:mawk = " \
 glibc \
 "
