# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nsd"
PV = "4.15.0"
PR = "1.el10_3"
PACKAGES = " \
 nsd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nsd-4.15.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f20d0e075c57e0a583b12d8e88d6f2e1c264b2c9643d9ada89b2ef292ab98d34"

URI_x86_64_v2_nsd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nsd-4.15.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nsd}"
SRC_URI[x86_64_v2_nsd.sha256sum] = "5006c3317f227e635a8ddabb28110c0d26483c8c0b07cfce86d719f3df546951"

URI_aarch64_nsd = "${EPEL_MIRROR}/aarch64/Packages/n/nsd-4.15.0-1.el10_3.aarch64.rpm;name=aarch64_nsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nsd}"
SRC_URI[aarch64_nsd.sha256sum] = "9f40fc9d478c3f0acaf0c9e8dc0c4b5ed07789f1611e31f2e885d015c2980e90"

RDEPENDS:nsd = " \
 bash \
 fstrm \
 glibc \
 libevent \
 openssl-libs \
 protobuf-c \
 systemd-libs \
 "
