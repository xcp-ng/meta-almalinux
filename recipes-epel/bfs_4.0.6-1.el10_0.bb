# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bfs"
PV = "4.0.6"
PR = "1.el10_0"
PACKAGES = " \
 bfs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bfs-4.0.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8404234eb9d826a5812c32d0f73b7df62b9a08267af6fcecd3b293546cccf1c"

URI_x86_64_v2_bfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bfs-4.0.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bfs}"
SRC_URI[x86_64_v2_bfs.sha256sum] = "b2a510d94ee93c15e17390cf3624f9a11f19480dfcb5b5750c4fde165dd57a5f"

URI_aarch64_bfs = "${EPEL_MIRROR}/aarch64/Packages/b/bfs-4.0.6-1.el10_0.aarch64.rpm;name=aarch64_bfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_bfs}"
SRC_URI[aarch64_bfs.sha256sum] = "e0eac2e06c189069a13634758a89dd0ec855fb79d726b8ee1d58596e4612996b"

RDEPENDS:bfs = " \
 glibc \
 libacl \
 libcap \
 libselinux \
 liburing \
 oniguruma \
 "
