# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osbuild"
PV = "141.2"
PR = "1.el10_0.alma.1"
PACKAGES = " \
 osbuild \
 osbuild-depsolve-dnf \
 osbuild-luks2 \
 osbuild-lvm2 \
 osbuild-ostree \
 osbuild-selinux \
 python3-osbuild \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/osbuild-141.2-1.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "720d71608eb4e88834f2f9ebc5c6ec766cf5aa7d9596b94f5ed1101589a036c9"

URI_x86_64_v2_osbuild = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-141.2-1.el10_0.alma.1.noarch.rpm;name=x86_64_v2_osbuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild}"
SRC_URI[x86_64_v2_osbuild.sha256sum] = "f5117aa2fdae907b8f0a73e825977b9d1a3320418f9b9bca509c57eb1f676bac"

URI_x86_64_v2_osbuild-depsolve-dnf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-depsolve-dnf-141.2-1.el10_0.alma.1.noarch.rpm;name=x86_64_v2_osbuild-depsolve-dnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-depsolve-dnf}"
SRC_URI[x86_64_v2_osbuild-depsolve-dnf.sha256sum] = "945f2c7a9be322f3a014b9701bf2e479392eefbbe13bc6303414908284018f85"

URI_x86_64_v2_osbuild-luks2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-luks2-141.2-1.el10_0.alma.1.noarch.rpm;name=x86_64_v2_osbuild-luks2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-luks2}"
SRC_URI[x86_64_v2_osbuild-luks2.sha256sum] = "11ad1d8b1f6b2077ecbfdd48d39ad64e34c490be0912ab3e7cbbeb4d4b1b5228"

URI_x86_64_v2_osbuild-lvm2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-lvm2-141.2-1.el10_0.alma.1.noarch.rpm;name=x86_64_v2_osbuild-lvm2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-lvm2}"
SRC_URI[x86_64_v2_osbuild-lvm2.sha256sum] = "f872fb3508589f9c85a31ec447c7eedc43ad1d1c0f7e5e31ba57d99ffba95950"

URI_x86_64_v2_osbuild-ostree = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-ostree-141.2-1.el10_0.alma.1.noarch.rpm;name=x86_64_v2_osbuild-ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-ostree}"
SRC_URI[x86_64_v2_osbuild-ostree.sha256sum] = "879f69d1df4de3949ea8bf55e05f4522806444c86fb6adbddd5da2d7a6c15bd0"

URI_x86_64_v2_osbuild-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-selinux-141.2-1.el10_0.alma.1.noarch.rpm;name=x86_64_v2_osbuild-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-selinux}"
SRC_URI[x86_64_v2_osbuild-selinux.sha256sum] = "ea05fd3cca9590b59fe131bbd833fcd04ff5d585ed3ca73f8fd0108c43d886f0"

URI_x86_64_v2_python3-osbuild = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-osbuild-141.2-1.el10_0.alma.1.noarch.rpm;name=x86_64_v2_python3-osbuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-osbuild}"
SRC_URI[x86_64_v2_python3-osbuild.sha256sum] = "130675e4a6609c66688ed83cf1a4ba869e7ac5396b29f414475e9618f56b64f1"

URI_aarch64_osbuild = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-141.2-1.el10_0.alma.1.noarch.rpm;name=aarch64_osbuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild}"
SRC_URI[aarch64_osbuild.sha256sum] = "f5117aa2fdae907b8f0a73e825977b9d1a3320418f9b9bca509c57eb1f676bac"

URI_aarch64_osbuild-depsolve-dnf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-depsolve-dnf-141.2-1.el10_0.alma.1.noarch.rpm;name=aarch64_osbuild-depsolve-dnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-depsolve-dnf}"
SRC_URI[aarch64_osbuild-depsolve-dnf.sha256sum] = "945f2c7a9be322f3a014b9701bf2e479392eefbbe13bc6303414908284018f85"

URI_aarch64_osbuild-luks2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-luks2-141.2-1.el10_0.alma.1.noarch.rpm;name=aarch64_osbuild-luks2;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-luks2}"
SRC_URI[aarch64_osbuild-luks2.sha256sum] = "11ad1d8b1f6b2077ecbfdd48d39ad64e34c490be0912ab3e7cbbeb4d4b1b5228"

URI_aarch64_osbuild-lvm2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-lvm2-141.2-1.el10_0.alma.1.noarch.rpm;name=aarch64_osbuild-lvm2;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-lvm2}"
SRC_URI[aarch64_osbuild-lvm2.sha256sum] = "f872fb3508589f9c85a31ec447c7eedc43ad1d1c0f7e5e31ba57d99ffba95950"

URI_aarch64_osbuild-ostree = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-ostree-141.2-1.el10_0.alma.1.noarch.rpm;name=aarch64_osbuild-ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-ostree}"
SRC_URI[aarch64_osbuild-ostree.sha256sum] = "879f69d1df4de3949ea8bf55e05f4522806444c86fb6adbddd5da2d7a6c15bd0"

URI_aarch64_osbuild-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-selinux-141.2-1.el10_0.alma.1.noarch.rpm;name=aarch64_osbuild-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-selinux}"
SRC_URI[aarch64_osbuild-selinux.sha256sum] = "ea05fd3cca9590b59fe131bbd833fcd04ff5d585ed3ca73f8fd0108c43d886f0"

URI_aarch64_python3-osbuild = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-osbuild-141.2-1.el10_0.alma.1.noarch.rpm;name=aarch64_python3-osbuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-osbuild}"
SRC_URI[aarch64_python3-osbuild.sha256sum] = "130675e4a6609c66688ed83cf1a4ba869e7ac5396b29f414475e9618f56b64f1"

RDEPENDS:osbuild = " \
 bash \
 bubblewrap \
 curl \
 e2fsprogs \
 glibc \
 osbuild-selinux \
 policycoreutils \
 python3 \
 python3-librepo \
 python3-osbuild \
 qemu-img \
 skopeo \
 systemd \
 tar \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:osbuild-depsolve-dnf = " \
 osbuild \
 python3 \
 python3-dnf \
 "
RDEPENDS:osbuild-luks2 = " \
 cryptsetup \
 osbuild \
 python3 \
 "
RDEPENDS:osbuild-lvm2 = " \
 lvm2 \
 osbuild \
 python3 \
 "
RDEPENDS:osbuild-ostree = " \
 osbuild \
 ostree \
 python3 \
 rpm-ostree \
 "
RDEPENDS:osbuild-selinux = " \
 bash \
 libselinux-utils \
 osbuild \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:python3-osbuild = " \
 python3 \
 python3-jsonschema \
 "
