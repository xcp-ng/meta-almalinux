# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-metakernel"
PV = "0.32.0"
PR = "1.el10_2"
PACKAGES = " \
 python-metakernel-doc \
 python3-metakernel \
 python3-metakernel-echo \
 python3-metakernel-python \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-metakernel-0.32.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5725390e95f862bff2f9f0d47d207acdf566a9914423c7a041efeba25e4a5d77"

URI_x86_64_v2_python-metakernel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-metakernel-doc-0.32.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-metakernel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-metakernel-doc}"
SRC_URI[x86_64_v2_python-metakernel-doc.sha256sum] = "bd4a08d40df21b5325b81bcefe5d30bea28d6c08d74a883ae4b89bc31fbdcb4b"

URI_x86_64_v2_python3-metakernel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-metakernel-0.32.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-metakernel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-metakernel}"
SRC_URI[x86_64_v2_python3-metakernel.sha256sum] = "48a8b39616eca4d9b7522347d44ffa1ed73aa8f266625ccea599dcebc51e87b7"

URI_x86_64_v2_python3-metakernel-echo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-metakernel-echo-0.19.1-82.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-metakernel-echo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-metakernel-echo}"
SRC_URI[x86_64_v2_python3-metakernel-echo.sha256sum] = "77d80c7f4d3b63b540b5c216bf29bae7f9484a6beb2714b586c4ca66090eb0da"

URI_x86_64_v2_python3-metakernel-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-metakernel-python-0.19.1-82.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-metakernel-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-metakernel-python}"
SRC_URI[x86_64_v2_python3-metakernel-python.sha256sum] = "eb617ff5d83bd59bb0554925402552a3bc4835195389ab8f7a19f8f141eae908"

URI_aarch64_python-metakernel-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-metakernel-doc-0.32.0-1.el10_2.noarch.rpm;name=aarch64_python-metakernel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-metakernel-doc}"
SRC_URI[aarch64_python-metakernel-doc.sha256sum] = "1c56cd6871bd614ed5cf86f74d06266a43f9bf253b60fbd958f1ced37a28843b"

URI_aarch64_python3-metakernel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-metakernel-0.32.0-1.el10_2.noarch.rpm;name=aarch64_python3-metakernel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-metakernel}"
SRC_URI[aarch64_python3-metakernel.sha256sum] = "d75d255e0f6ec84bd50deca283196844136d3c4d7323b6b1a6d686463d82f127"

URI_aarch64_python3-metakernel-echo = "${EPEL_MIRROR}/aarch64/Packages/p/python3-metakernel-echo-0.19.1-82.el10_2.noarch.rpm;name=aarch64_python3-metakernel-echo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-metakernel-echo}"
SRC_URI[aarch64_python3-metakernel-echo.sha256sum] = "82618849fe08b66a928f1a7b6eead66b798ed6dcb48b6f1081b57ba5ddcdb2fb"

URI_aarch64_python3-metakernel-python = "${EPEL_MIRROR}/aarch64/Packages/p/python3-metakernel-python-0.19.1-82.el10_2.noarch.rpm;name=aarch64_python3-metakernel-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-metakernel-python}"
SRC_URI[aarch64_python3-metakernel-python.sha256sum] = "1c0f9c2cfe88b42fac3b4517f516d145798271e44ba471ed9db434e9f0d77e9b"

RDEPENDS:python-metakernel-doc = " \
 "
RDEPENDS:python3-metakernel = " \
 python3 \
 python3-comm \
 python3-ipykernel \
 python3-jedi \
 python3-jupyter-core \
 python3-pexpect \
 "
RDEPENDS:python3-metakernel-echo = " \
 python-jupyter-filesystem \
 python3 \
 python3-metakernel \
 "
RDEPENDS:python3-metakernel-python = " \
 python-jupyter-filesystem \
 python3 \
 python3-ipython \
 python3-jedi \
 python3-metakernel \
 "
