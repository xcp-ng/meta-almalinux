# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-net"
PV = "0.26.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-hickory-net+default-devel \
 rust-hickory-net+mdns-devel \
 rust-hickory-net+serde-devel \
 rust-hickory-net+socket2-devel \
 rust-hickory-net+tokio-devel \
 rust-hickory-net+webpki-roots-devel \
 rust-hickory-net-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-net-0.26.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11ea0ff7bced638824cfbbeb26d7aecf14de5c41e3569a6f4cb90f2ff52ec559"

URI_x86_64_v2_rust-hickory-net+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-net+default-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-net+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-net+default-devel}"
SRC_URI[x86_64_v2_rust-hickory-net+default-devel.sha256sum] = "13b390e8d283980a4f545f5548af8c0eb57121528b9c3ca631a1e7225ea48d28"

URI_x86_64_v2_rust-hickory-net+mdns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-net+mdns-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-net+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-net+mdns-devel}"
SRC_URI[x86_64_v2_rust-hickory-net+mdns-devel.sha256sum] = "d44b3fe2bfb22a0573def4ddf28e6dd63934ba559ce58059696ff61b81823b09"

URI_x86_64_v2_rust-hickory-net+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-net+serde-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-net+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-net+serde-devel}"
SRC_URI[x86_64_v2_rust-hickory-net+serde-devel.sha256sum] = "43c402ef2f9dfae4fc7d330c21951df5749df1ef91b65790e936d614001b5d15"

URI_x86_64_v2_rust-hickory-net+socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-net+socket2-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-net+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-net+socket2-devel}"
SRC_URI[x86_64_v2_rust-hickory-net+socket2-devel.sha256sum] = "4000534b6a3f28216789cb3c68c015c69ad725797eefe244edcd7ff9e1564677"

URI_x86_64_v2_rust-hickory-net+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-net+tokio-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-net+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-net+tokio-devel}"
SRC_URI[x86_64_v2_rust-hickory-net+tokio-devel.sha256sum] = "145a6cd62c0d1cfd3976c47c0510ea82de7a7cf992a39c0f19f397a2b59bd27e"

URI_x86_64_v2_rust-hickory-net+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-net+webpki-roots-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-net+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-net+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-hickory-net+webpki-roots-devel.sha256sum] = "ab7013199a719a1a2e2633d942b09754a2bed9272f0bc386995dfcca5bf51b76"

URI_x86_64_v2_rust-hickory-net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-net-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-net-devel}"
SRC_URI[x86_64_v2_rust-hickory-net-devel.sha256sum] = "9b65e678bc144e0529b60b8c71dc53a549ab139871ffb6cee5ac0d808e27e8c8"

URI_aarch64_rust-hickory-net+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-net+default-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-net+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-net+default-devel}"
SRC_URI[aarch64_rust-hickory-net+default-devel.sha256sum] = "9a1a52f4f162ad91bdd5717b9823e12563509efb9e8099e379992db9f06bdc64"

URI_aarch64_rust-hickory-net+mdns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-net+mdns-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-net+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-net+mdns-devel}"
SRC_URI[aarch64_rust-hickory-net+mdns-devel.sha256sum] = "5d26fa665742b7d52b7032f8f135926151148380dadd30878a8d80263d925cd6"

URI_aarch64_rust-hickory-net+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-net+serde-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-net+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-net+serde-devel}"
SRC_URI[aarch64_rust-hickory-net+serde-devel.sha256sum] = "7f6e28e71f49561f065c626f7792aab5d4752db00d8cf6373488c26185694816"

URI_aarch64_rust-hickory-net+socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-net+socket2-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-net+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-net+socket2-devel}"
SRC_URI[aarch64_rust-hickory-net+socket2-devel.sha256sum] = "34a8a22bf2e2e8ca33bba77868a152a0833a9f18b465a8f6a3b3b66067697b99"

URI_aarch64_rust-hickory-net+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-net+tokio-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-net+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-net+tokio-devel}"
SRC_URI[aarch64_rust-hickory-net+tokio-devel.sha256sum] = "8615a70bdd1555046c9752826d8ac87f90deba4adb8defc0efcab0117e860e2e"

URI_aarch64_rust-hickory-net+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-net+webpki-roots-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-net+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-net+webpki-roots-devel}"
SRC_URI[aarch64_rust-hickory-net+webpki-roots-devel.sha256sum] = "524f9bbb07b0c1a07297bbc3f886f120f6de649ee211c862751ab9b4c60c31c1"

URI_aarch64_rust-hickory-net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-net-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-net-devel}"
SRC_URI[aarch64_rust-hickory-net-devel.sha256sum] = "62c91b8b832fbbdda849c1fdfc50504ee714f97c8ce8a578137d6dee43f32387"

RDEPENDS:rust-hickory-net+default-devel = " \
 cargo \
 rust-hickory-net+tokio-devel \
 rust-hickory-net-devel \
 "
RDEPENDS:rust-hickory-net+mdns-devel = " \
 cargo \
 rust-hickory-net-devel \
 rust-socket2+all-devel \
 rust-socket2+default-devel \
 "
RDEPENDS:rust-hickory-net+serde-devel = " \
 cargo \
 rust-hickory-net-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-url+serde-devel \
 "
RDEPENDS:rust-hickory-net+socket2-devel = " \
 cargo \
 rust-hickory-net-devel \
 rust-socket2+default-devel \
 "
RDEPENDS:rust-hickory-net+tokio-devel = " \
 cargo \
 rust-hickory-net-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-hickory-net+webpki-roots-devel = " \
 cargo \
 rust-hickory-net-devel \
 rust-webpki-roots+default-devel \
 "
RDEPENDS:rust-hickory-net-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-cfg-if+default-devel \
 rust-data-encoding+alloc-devel \
 rust-data-encoding-devel \
 rust-futures-channel+alloc-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util+async-await-macro-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 rust-idna+alloc-devel \
 rust-idna+compiled_data-devel \
 rust-idna-devel \
 rust-ipnet-devel \
 rust-rand+alloc-devel \
 rust-rand+std_rng-devel \
 rust-rand-devel \
 rust-thiserror-devel \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+default-devel \
 rust-tracing-devel \
 rust-url-devel \
 "
