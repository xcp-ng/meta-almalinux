# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-vsort"
PV = "0.2.0"
PR = "6.el10_2"
PACKAGES = " \
 rust-vsort+default-devel \
 rust-vsort-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-vsort-0.2.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22b79f0abf437d4810b82e68cca64fe378b3a710556aa2e8ce6282c7daa097b5"

URI_x86_64_v2_rust-vsort+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vsort+default-devel-0.2.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vsort+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vsort+default-devel}"
SRC_URI[x86_64_v2_rust-vsort+default-devel.sha256sum] = "1d06f2c7704ff96f753e39e66277ce94c797b8772ecc2ab98f78c9356fbb338b"

URI_x86_64_v2_rust-vsort-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vsort-devel-0.2.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vsort-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vsort-devel}"
SRC_URI[x86_64_v2_rust-vsort-devel.sha256sum] = "ab43cd289afd2b0d5b5007668b7bcfc2fa8621f8bcd7695bf349c311ae47363b"

URI_aarch64_rust-vsort+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vsort+default-devel-0.2.0-6.el10_2.noarch.rpm;name=aarch64_rust-vsort+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vsort+default-devel}"
SRC_URI[aarch64_rust-vsort+default-devel.sha256sum] = "5ad32b91754e924caac84c8261c0bb0c128d43846c5fdf5971ec0c46b5081a93"

URI_aarch64_rust-vsort-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vsort-devel-0.2.0-6.el10_2.noarch.rpm;name=aarch64_rust-vsort-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vsort-devel}"
SRC_URI[aarch64_rust-vsort-devel.sha256sum] = "4508dcb08de3189492f3e491d162580f4ee482d25d56067f32b118e581b3a1cb"

RDEPENDS:rust-vsort+default-devel = " \
 cargo \
 rust-vsort-devel \
 "
RDEPENDS:rust-vsort-devel = " \
 cargo \
 "
