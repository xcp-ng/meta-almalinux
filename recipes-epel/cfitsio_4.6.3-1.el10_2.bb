# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cfitsio"
PV = "4.6.3"
PR = "1.el10_2"
PACKAGES = " \
 cfitsio \
 cfitsio-devel \
 cfitsio-docs \
 cfitsio-static \
 cfitsio-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cfitsio-4.6.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a9e71f0df5f33bdfd270956c090e407ab0f13279365d0dd3323135ff1d666a8"

URI_x86_64_v2_cfitsio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cfitsio-4.6.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cfitsio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cfitsio}"
SRC_URI[x86_64_v2_cfitsio.sha256sum] = "0551e988fde5acc453074a5c2b3a5bebaa79889a44a4d31a26d340c17d89f388"

URI_x86_64_v2_cfitsio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cfitsio-devel-4.6.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cfitsio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cfitsio-devel}"
SRC_URI[x86_64_v2_cfitsio-devel.sha256sum] = "8c76809b7c30c7b0e612087ac503cdbdb6d7be6d22f66511f01bcf5df6c81590"

URI_x86_64_v2_cfitsio-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cfitsio-docs-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_cfitsio-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cfitsio-docs}"
SRC_URI[x86_64_v2_cfitsio-docs.sha256sum] = "07dfa5dc5c5448806d8b8ce1348311092e9983502fbf7deb77f24aa0fd2d3c94"

URI_x86_64_v2_cfitsio-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cfitsio-static-4.6.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cfitsio-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cfitsio-static}"
SRC_URI[x86_64_v2_cfitsio-static.sha256sum] = "2e347101871f9362cd0aad6b3653032f17ac9b102672b2bb14f66fa208ec192a"

URI_x86_64_v2_cfitsio-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cfitsio-utils-4.6.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cfitsio-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cfitsio-utils}"
SRC_URI[x86_64_v2_cfitsio-utils.sha256sum] = "2d6dc1af1a49c78f17f30a2af5a22d4adcdddfd9b221469359ad64f6ea973bf4"

URI_aarch64_cfitsio = "${EPEL_MIRROR}/aarch64/Packages/c/cfitsio-4.6.3-1.el10_2.aarch64.rpm;name=aarch64_cfitsio;unpack=0"
SRC_URI:append = " ${URI_aarch64_cfitsio}"
SRC_URI[aarch64_cfitsio.sha256sum] = "8c117bd05898128dbfc2a78979e3fc3a4166d6b8d328bbef49d90d056d9ac0f0"

URI_aarch64_cfitsio-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cfitsio-devel-4.6.3-1.el10_2.aarch64.rpm;name=aarch64_cfitsio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cfitsio-devel}"
SRC_URI[aarch64_cfitsio-devel.sha256sum] = "65d878b27b7bd6e64d73d773e8aebb2fbb5cf4882607bc905570c510e1808c7e"

URI_aarch64_cfitsio-docs = "${EPEL_MIRROR}/aarch64/Packages/c/cfitsio-docs-4.6.3-1.el10_2.noarch.rpm;name=aarch64_cfitsio-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cfitsio-docs}"
SRC_URI[aarch64_cfitsio-docs.sha256sum] = "34f555947d4f62a9bb67a29617efd8e81854f48659cc43e878f506021f1d19fd"

URI_aarch64_cfitsio-static = "${EPEL_MIRROR}/aarch64/Packages/c/cfitsio-static-4.6.3-1.el10_2.aarch64.rpm;name=aarch64_cfitsio-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_cfitsio-static}"
SRC_URI[aarch64_cfitsio-static.sha256sum] = "fcefd4f6aca09e054fc5020575356351be1148286e2d964bcb34aeecbe07df3c"

URI_aarch64_cfitsio-utils = "${EPEL_MIRROR}/aarch64/Packages/c/cfitsio-utils-4.6.3-1.el10_2.aarch64.rpm;name=aarch64_cfitsio-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_cfitsio-utils}"
SRC_URI[aarch64_cfitsio-utils.sha256sum] = "4404f4f35c0708787ed5a0cc9dc833d9ab7084c90c618d456d888818bc61ed92"

RDEPENDS:cfitsio = " \
 bzip2-libs \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:cfitsio-devel = " \
 cfitsio \
 pkgconf-pkg-config \
 "
RDEPENDS:cfitsio-docs = " \
 "
RDEPENDS:cfitsio-static = " \
 "
RDEPENDS:cfitsio-utils = " \
 cfitsio \
 glibc \
 "
