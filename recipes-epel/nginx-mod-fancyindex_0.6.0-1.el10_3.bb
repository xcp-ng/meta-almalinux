# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx-mod-fancyindex"
PV = "0.6.0"
PR = "1.el10_3"
PACKAGES = " \
 nginx-mod-fancyindex \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nginx-mod-fancyindex-0.6.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7b080de639e763fa6a62c6ef0d7d6116e198be75a580eefe07a5a1a1cfc27004"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nginx-mod-fancyindex-0.6.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-fancyindex;unpack=0"
SRC_URI[x86_64_v2_nginx-mod-fancyindex.sha256sum] = "fb3c0543c41d4334e2bf637ba1572ff9a2fd84114e16652206bdc5f478a5a1df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nginx-mod-fancyindex-0.6.0-1.el10_3.aarch64.rpm;name=aarch64_nginx-mod-fancyindex;unpack=0"
SRC_URI[aarch64_nginx-mod-fancyindex.sha256sum] = "387f1e31147bc1d21f13e7016d0799b3fcf6b4112359c82c5a6ff5192e5eb0a8"

RDEPENDS:nginx-mod-fancyindex = " \
 glibc \
 nginx \
 "
