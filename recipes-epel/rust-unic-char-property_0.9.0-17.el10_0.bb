# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-char-property"
PV = "0.9.0"
PR = "17.el10_0"
PACKAGES = " \
 rust-unic-char-property+default-devel \
 rust-unic-char-property-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-char-property-0.9.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ccd43d64ca9b99613af758e5a58ca3da9fa02da3c79b9a573ff6bc1fd2f8d24e"

URI_x86_64_v2_rust-unic-char-property+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-char-property+default-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-char-property+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-char-property+default-devel}"
SRC_URI[x86_64_v2_rust-unic-char-property+default-devel.sha256sum] = "1d4f8cbed69cd570bd96e6b512cb62208411b98cc54947f5c3a5ad36886e6671"

URI_x86_64_v2_rust-unic-char-property-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-char-property-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-char-property-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-char-property-devel}"
SRC_URI[x86_64_v2_rust-unic-char-property-devel.sha256sum] = "6212dcd1663254dd5ea2a9f8c27d72c5404971760dfeca3e4320803ab32aeccd"

URI_aarch64_rust-unic-char-property+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-char-property+default-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-char-property+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-char-property+default-devel}"
SRC_URI[aarch64_rust-unic-char-property+default-devel.sha256sum] = "ae26b5da1b45036f50fd90a63ae768c3cabf885c5b035b64f872b8297d27eb69"

URI_aarch64_rust-unic-char-property-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-char-property-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-char-property-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-char-property-devel}"
SRC_URI[aarch64_rust-unic-char-property-devel.sha256sum] = "a01a6005d32b8cbcb8d9ac7552e4804ff72d358f18fff37f4e550bed485b337f"

RDEPENDS:rust-unic-char-property+default-devel = " \
 cargo \
 rust-unic-char-property-devel \
 "
RDEPENDS:rust-unic-char-property-devel = " \
 cargo \
 rust-unic-char-range+default-devel \
 "
