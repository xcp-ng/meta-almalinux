# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkcddb"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 libkcddb \
 libkcddb-devel \
 libkcddb-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkcddb-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "156118d744cbfb41584691f482bcfb68b2d9e61fd00b63b6e70406c27f1f2017"

URI_x86_64_v2_libkcddb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcddb-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcddb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcddb}"
SRC_URI[x86_64_v2_libkcddb.sha256sum] = "41d47b197ee37abf978936ee66658f8bedfc146ad82267722539c3d5073947b6"

URI_x86_64_v2_libkcddb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcddb-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcddb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcddb-devel}"
SRC_URI[x86_64_v2_libkcddb-devel.sha256sum] = "28b6b040e3183914bace5e45060f3d1f57590b3f46d44265ab0c5287a6d7865e"

URI_x86_64_v2_libkcddb-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcddb-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libkcddb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcddb-doc}"
SRC_URI[x86_64_v2_libkcddb-doc.sha256sum] = "998ee0f6a7c5dc0fe43af57962aeefe37ff2b90e9a0b2a2c863a3593a7a1596a"

URI_aarch64_libkcddb = "${EPEL_MIRROR}/aarch64/Packages/l/libkcddb-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkcddb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcddb}"
SRC_URI[aarch64_libkcddb.sha256sum] = "38d45e02462dabaab851e409a6cd0acfd6d28789f9fa714ed5e2597774d43fb5"

URI_aarch64_libkcddb-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkcddb-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkcddb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcddb-devel}"
SRC_URI[aarch64_libkcddb-devel.sha256sum] = "8d22073146da5a021aeac6f83f2ba770db8475ee6758a90ec9ade7a1cc4d58d2"

URI_aarch64_libkcddb-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkcddb-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_libkcddb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcddb-doc}"
SRC_URI[aarch64_libkcddb-doc.sha256sum] = "3305fc4f1d10b063058453d7c1922c0a5e3d6b7580f10a849a561cda0b90315b"

RDEPENDS:libkcddb = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 libgcc \
 libkcddb-doc \
 libmusicbrainz5 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkcddb-devel = " \
 cmake-filesystem \
 libkcddb \
 "
RDEPENDS:libkcddb-doc = " \
 libkcddb \
 "
