# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-iter"
PV = "0.1.46"
PR = "1.el10_2"
PACKAGES = " \
 rust-num-iter+default-devel \
 rust-num-iter+i128-devel \
 rust-num-iter+std-devel \
 rust-num-iter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-iter-0.1.46-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32b4e09a64beb62ca25bcc60caf133f4d3f62b64bfc34938d24cdcdc89be5585"

URI_x86_64_v2_rust-num-iter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-iter+default-devel-0.1.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-iter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-iter+default-devel}"
SRC_URI[x86_64_v2_rust-num-iter+default-devel.sha256sum] = "44eb5c28df84bf6b66aec69b5564f7ad4b49c44c9dcc0416db86b7d9e7b75516"

URI_x86_64_v2_rust-num-iter+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-iter+i128-devel-0.1.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-iter+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-iter+i128-devel}"
SRC_URI[x86_64_v2_rust-num-iter+i128-devel.sha256sum] = "70488e83cb004b5d42e9c3cadeba292a8512ca2d0f27329723bc0e5bc7f62276"

URI_x86_64_v2_rust-num-iter+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-iter+std-devel-0.1.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-iter+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-iter+std-devel}"
SRC_URI[x86_64_v2_rust-num-iter+std-devel.sha256sum] = "6fe98a71f1b0e4695c256746e8e01713b653ff2c4d80f874ecaee77c57b51b93"

URI_x86_64_v2_rust-num-iter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-iter-devel-0.1.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-iter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-iter-devel}"
SRC_URI[x86_64_v2_rust-num-iter-devel.sha256sum] = "25bf2620eaeff7c29c940393ab829787f72c027923ea8298d0d8330f308eb3d2"

URI_aarch64_rust-num-iter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-iter+default-devel-0.1.46-1.el10_2.noarch.rpm;name=aarch64_rust-num-iter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-iter+default-devel}"
SRC_URI[aarch64_rust-num-iter+default-devel.sha256sum] = "839ed42212634a9dd6552b7fd2e5d9f8653891fbcd22928af9ad67b60339a69b"

URI_aarch64_rust-num-iter+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-iter+i128-devel-0.1.46-1.el10_2.noarch.rpm;name=aarch64_rust-num-iter+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-iter+i128-devel}"
SRC_URI[aarch64_rust-num-iter+i128-devel.sha256sum] = "89ada340744fcf2c7aafbed1f9df21b3a082509bde5577454417ba0cc944ecc5"

URI_aarch64_rust-num-iter+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-iter+std-devel-0.1.46-1.el10_2.noarch.rpm;name=aarch64_rust-num-iter+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-iter+std-devel}"
SRC_URI[aarch64_rust-num-iter+std-devel.sha256sum] = "2f6e7da833f01fa79c453f33d2cdfdf4e340b0cfb532dfb2dae6fda198386502"

URI_aarch64_rust-num-iter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-iter-devel-0.1.46-1.el10_2.noarch.rpm;name=aarch64_rust-num-iter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-iter-devel}"
SRC_URI[aarch64_rust-num-iter-devel.sha256sum] = "f68e7c2c4db8c63520db35b230c70f06390d0a1ac672e1e1396fff28e27aa00a"

RDEPENDS:rust-num-iter+default-devel = " \
 cargo \
 rust-num-iter+std-devel \
 rust-num-iter-devel \
 "
RDEPENDS:rust-num-iter+i128-devel = " \
 cargo \
 rust-num-iter-devel \
 "
RDEPENDS:rust-num-iter+std-devel = " \
 cargo \
 rust-num-integer+std-devel \
 rust-num-iter-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-num-iter-devel = " \
 cargo \
 rust \
 rust-num-integer+i128-devel \
 rust-num-integer-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
