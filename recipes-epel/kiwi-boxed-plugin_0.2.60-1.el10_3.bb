# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi-boxed-plugin"
PV = "0.2.60"
PR = "1.el10_3"
PACKAGES = " \
 kiwi-boxed-plugin \
 python3-kiwi-boxed-plugin \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kiwi-boxed-plugin-0.2.60-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "600bdb41dddc96cf7d797017cd812c5d10381e88b2fe4af7bc84e1cac696b5f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-boxed-plugin-0.2.60-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-boxed-plugin;unpack=0"
SRC_URI[x86_64_v2_kiwi-boxed-plugin.sha256sum] = "3a9fc08ab91f115a4f5f4a6caa60f434f4c60912fada9bac128e5a1891cd42d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-boxed-plugin-0.2.60-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi-boxed-plugin;unpack=0"
SRC_URI[x86_64_v2_python3-kiwi-boxed-plugin.sha256sum] = "3d2edee87158eec01eb3fbe4352421723c83ce17041804f16218fa06a3d38c3b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-boxed-plugin-0.2.60-1.el10_3.noarch.rpm;name=aarch64_kiwi-boxed-plugin;unpack=0"
SRC_URI[aarch64_kiwi-boxed-plugin.sha256sum] = "38af3a3dd416238da28685b6900802de72150b7568971309d3f475a385120354"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-boxed-plugin-0.2.60-1.el10_3.noarch.rpm;name=aarch64_python3-kiwi-boxed-plugin;unpack=0"
SRC_URI[aarch64_python3-kiwi-boxed-plugin.sha256sum] = "7c19720947ec913eb5a6540436fe71c036cfa39977770ef65cd2935efdf1a6c5"

RDEPENDS:kiwi-boxed-plugin = " \
 python3-kiwi-boxed-plugin \
 "
RDEPENDS:python3-kiwi-boxed-plugin = " \
 python3 \
 python3-cerberus \
 python3-docopt-ng \
 python3-kiwi \
 python3-progressbar2 \
 python3-pyyaml \
 python3-requests \
 qemu-kvm \
 "
