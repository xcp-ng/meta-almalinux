# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytesize"
PV = "2.4.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-bytesize+arbitrary-devel \
 rust-bytesize+default-devel \
 rust-bytesize+serde-devel \
 rust-bytesize+std-devel \
 rust-bytesize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytesize-2.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c9c4aa35f4c7e7c264de823408fd2bccab8d96721db88790361eb623c046dc9"

URI_x86_64_v2_rust-bytesize+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize+arbitrary-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-bytesize+arbitrary-devel.sha256sum] = "b9d0d1a5500bd2ad7eb8c395cc2504c4e7bf3435086e3e833587c941ad5bee14"

URI_x86_64_v2_rust-bytesize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize+default-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize+default-devel}"
SRC_URI[x86_64_v2_rust-bytesize+default-devel.sha256sum] = "dde0ad7630ebedc903e4846fd3990399bdc465e6a9a161fc6169838220ea1d50"

URI_x86_64_v2_rust-bytesize+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize+serde-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize+serde-devel}"
SRC_URI[x86_64_v2_rust-bytesize+serde-devel.sha256sum] = "29477c42206960822747cbeafde6a02dfc027bf88512db72e17cb82f026f3c71"

URI_x86_64_v2_rust-bytesize+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize+std-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize+std-devel}"
SRC_URI[x86_64_v2_rust-bytesize+std-devel.sha256sum] = "8e6b0aa323c6c6c081f083f46001c4c2077653dc451a36a83a20151fced4aabd"

URI_x86_64_v2_rust-bytesize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize-devel}"
SRC_URI[x86_64_v2_rust-bytesize-devel.sha256sum] = "d9abc27675d7791d92be74202148a5f39663250a20471c2d122504e52308d906"

URI_aarch64_rust-bytesize+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize+arbitrary-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-bytesize+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize+arbitrary-devel}"
SRC_URI[aarch64_rust-bytesize+arbitrary-devel.sha256sum] = "8765c1496795ba3edb51fc7e4aa8b6942f9677464b2301a57aacee04e64e81ff"

URI_aarch64_rust-bytesize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize+default-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-bytesize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize+default-devel}"
SRC_URI[aarch64_rust-bytesize+default-devel.sha256sum] = "a9dd35109d468d6c061baa18723603003ecbc19065ede408588e2f369efecb07"

URI_aarch64_rust-bytesize+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize+serde-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-bytesize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize+serde-devel}"
SRC_URI[aarch64_rust-bytesize+serde-devel.sha256sum] = "8f69348c109a132df02991db56d75d0d37072d0df22b1806d0d0f63d9b6f46e0"

URI_aarch64_rust-bytesize+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize+std-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-bytesize+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize+std-devel}"
SRC_URI[aarch64_rust-bytesize+std-devel.sha256sum] = "57f20e6264b893b961968f7dbad0319813b9cf021c1f047ac336c6d1c13f0a2e"

URI_aarch64_rust-bytesize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-bytesize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize-devel}"
SRC_URI[aarch64_rust-bytesize-devel.sha256sum] = "729e76bb98f871039b225df1522f82d9e696e32b7de8323b16c2d95dce15a9b1"

RDEPENDS:rust-bytesize+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-bytesize-devel \
 "
RDEPENDS:rust-bytesize+default-devel = " \
 cargo \
 rust-bytesize+std-devel \
 rust-bytesize-devel \
 "
RDEPENDS:rust-bytesize+serde-devel = " \
 cargo \
 rust-bytesize-devel \
 rust-serde_core+default-devel \
 "
RDEPENDS:rust-bytesize+std-devel = " \
 cargo \
 rust-bytesize-devel \
 "
RDEPENDS:rust-bytesize-devel = " \
 cargo \
 rust \
 "
