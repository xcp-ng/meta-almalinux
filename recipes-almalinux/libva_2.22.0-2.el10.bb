# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libva"
PV = "2.22.0"
PR = "2.el10"
PACKAGES = " \
 libva \
 libva-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libva-2.22.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9bea30667e17d6a7c7b4eca96e28e2505ef1656df6f978bb9824fbed4c3babf"

URI_x86_64_v2_libva = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libva-2.22.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libva;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libva}"
SRC_URI[x86_64_v2_libva.sha256sum] = "9437180a43b650d77e246410e81ab4a1b7f89746c20c9511e9c3b98ad3d14e06"

URI_x86_64_v2_libva-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libva-devel-2.22.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libva-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libva-devel}"
SRC_URI[x86_64_v2_libva-devel.sha256sum] = "26aa4edfa363236783a8a76e7e8f94ce4cfdb8065d164af8170b7fb45b3404ae"

URI_aarch64_libva = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libva-2.22.0-2.el10.aarch64.rpm;name=aarch64_libva;unpack=0"
SRC_URI:append = " ${URI_aarch64_libva}"
SRC_URI[aarch64_libva.sha256sum] = "eea9a628d7045637599c2538ed75985f4e16375d629564149ba89cd70809344b"

URI_aarch64_libva-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libva-devel-2.22.0-2.el10.aarch64.rpm;name=aarch64_libva-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libva-devel}"
SRC_URI[aarch64_libva-devel.sha256sum] = "3306a65464da654cdc89b54be59b061138099d995ce58ed2bf2d87c01cf2a5ac"

RDEPENDS:libva = " \
 glibc \
 libX11 \
 libX11-xcb \
 libXext \
 libXfixes \
 libdrm \
 libglvnd-glx \
 libwayland-client \
 libxcb \
 mesa-filesystem \
 "
RDEPENDS:libva-devel = " \
 libva \
 libva-devel \
 pkgconf-pkg-config \
 wayland-devel \
 "
