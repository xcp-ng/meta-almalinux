# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ding-libs"
PV = "0.6.2"
PR = "58.el10"
PACKAGES = " \
 libbasicobjects \
 libbasicobjects-devel \
 libcollection \
 libcollection-devel \
 libdhash \
 libdhash-devel \
 libini_config \
 libini_config-devel \
 libpath_utils \
 libpath_utils-devel \
 libref_array \
 libref_array-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ding-libs-0.6.2-58.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09d0cce9c5ab27726c8bf825dd0e73419fb3e147d3a29777e22e068aed3adb5e"

URI_x86_64_v2_libbasicobjects = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libbasicobjects-0.1.1-58.el10.x86_64_v2.rpm;name=x86_64_v2_libbasicobjects;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbasicobjects}"
SRC_URI[x86_64_v2_libbasicobjects.sha256sum] = "e65c6957c022be2150e69e07066e42fcfa8fc85d119e14a49766b3152b77fda8"

URI_x86_64_v2_libbasicobjects-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libbasicobjects-devel-0.1.1-58.el10.x86_64_v2.rpm;name=x86_64_v2_libbasicobjects-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbasicobjects-devel}"
SRC_URI[x86_64_v2_libbasicobjects-devel.sha256sum] = "519892ca9fa21be25ccdc1066a591c21104f032072736fd74f935cd64689f770"

URI_x86_64_v2_libcollection = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcollection-0.7.0-58.el10.x86_64_v2.rpm;name=x86_64_v2_libcollection;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcollection}"
SRC_URI[x86_64_v2_libcollection.sha256sum] = "f8396afd5162a2c9cb1098edb653fe1ffe51ecbf1850c27890a44b0a8dc32787"

URI_x86_64_v2_libcollection-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libcollection-devel-0.7.0-58.el10.x86_64_v2.rpm;name=x86_64_v2_libcollection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcollection-devel}"
SRC_URI[x86_64_v2_libcollection-devel.sha256sum] = "18611f23d770feb57a37290eaf7ec8b4d6bbae8c397cadfd599c095f2976972b"

URI_x86_64_v2_libdhash = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libdhash-0.5.0-58.el10.x86_64_v2.rpm;name=x86_64_v2_libdhash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdhash}"
SRC_URI[x86_64_v2_libdhash.sha256sum] = "156222338aacca0eda8197657f6bf98082a4c96cf6284afedf97a50988b4abd7"

URI_x86_64_v2_libdhash-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdhash-devel-0.5.0-58.el10.x86_64_v2.rpm;name=x86_64_v2_libdhash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdhash-devel}"
SRC_URI[x86_64_v2_libdhash-devel.sha256sum] = "3febec51594f5600be86472612861fead97a22b854e680acfb7debc89c2991b0"

URI_x86_64_v2_libini_config = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libini_config-1.3.1-58.el10.x86_64_v2.rpm;name=x86_64_v2_libini_config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libini_config}"
SRC_URI[x86_64_v2_libini_config.sha256sum] = "5b2e9c895ed580b768d1929cdc75583a5f36595d1dd96b557151e7a4f3c3d185"

URI_x86_64_v2_libini_config-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libini_config-devel-1.3.1-58.el10.x86_64_v2.rpm;name=x86_64_v2_libini_config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libini_config-devel}"
SRC_URI[x86_64_v2_libini_config-devel.sha256sum] = "0f1d7a1a25fad8401ebdc40c412ce54f099293464b1b241372471cba5af730dd"

URI_x86_64_v2_libpath_utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpath_utils-0.2.1-58.el10.x86_64_v2.rpm;name=x86_64_v2_libpath_utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpath_utils}"
SRC_URI[x86_64_v2_libpath_utils.sha256sum] = "ca482ba9d2289548af431e0f83e33153facfef89b37b00319c54420c6d5319ce"

URI_x86_64_v2_libpath_utils-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libpath_utils-devel-0.2.1-58.el10.x86_64_v2.rpm;name=x86_64_v2_libpath_utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpath_utils-devel}"
SRC_URI[x86_64_v2_libpath_utils-devel.sha256sum] = "cf0c48804d8e7342da81b179b461fc06d5997694db8832431c8ec0f6785ce8ed"

URI_x86_64_v2_libref_array = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libref_array-0.1.5-58.el10.x86_64_v2.rpm;name=x86_64_v2_libref_array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libref_array}"
SRC_URI[x86_64_v2_libref_array.sha256sum] = "a781f443e4f9e1e18dd76268fb6d2eadf7c1cd64d1f2f16e3d1992a917295fb1"

URI_x86_64_v2_libref_array-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libref_array-devel-0.1.5-58.el10.x86_64_v2.rpm;name=x86_64_v2_libref_array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libref_array-devel}"
SRC_URI[x86_64_v2_libref_array-devel.sha256sum] = "7c6cff1cc03f23188777a19eb725316936cae93b490d1e0d8562878afa10a948"

URI_aarch64_libbasicobjects = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libbasicobjects-0.1.1-58.el10.aarch64.rpm;name=aarch64_libbasicobjects;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbasicobjects}"
SRC_URI[aarch64_libbasicobjects.sha256sum] = "250352d2e9d21454c8fa62b21f5bceb79e45113a3bb1bfa024af7d817e1262e0"

URI_aarch64_libbasicobjects-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libbasicobjects-devel-0.1.1-58.el10.aarch64.rpm;name=aarch64_libbasicobjects-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbasicobjects-devel}"
SRC_URI[aarch64_libbasicobjects-devel.sha256sum] = "68c27d32aee194fbe19cb0252d27b759fcb966fa929f24a9b882f65c7526438c"

URI_aarch64_libcollection = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcollection-0.7.0-58.el10.aarch64.rpm;name=aarch64_libcollection;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcollection}"
SRC_URI[aarch64_libcollection.sha256sum] = "b1367b73856ff85e597e5a9ca75017e8b01286e5073387724fa9931845cd2acb"

URI_aarch64_libcollection-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libcollection-devel-0.7.0-58.el10.aarch64.rpm;name=aarch64_libcollection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcollection-devel}"
SRC_URI[aarch64_libcollection-devel.sha256sum] = "1ea036a4f913b0f09d9c7940d0401f69dc1667d5486b4a57f4ba23e45c440d1e"

URI_aarch64_libdhash = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libdhash-0.5.0-58.el10.aarch64.rpm;name=aarch64_libdhash;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdhash}"
SRC_URI[aarch64_libdhash.sha256sum] = "a95bcaae8e7109d46ea253010f5f448e79a647520f18b389d8d4af6a81f75103"

URI_aarch64_libdhash-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdhash-devel-0.5.0-58.el10.aarch64.rpm;name=aarch64_libdhash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdhash-devel}"
SRC_URI[aarch64_libdhash-devel.sha256sum] = "4edc9965e9e86e22d62aa4dbe1e94dbad3bd094c9e23c597ce6f5d7067e5de09"

URI_aarch64_libini_config = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libini_config-1.3.1-58.el10.aarch64.rpm;name=aarch64_libini_config;unpack=0"
SRC_URI:append = " ${URI_aarch64_libini_config}"
SRC_URI[aarch64_libini_config.sha256sum] = "1d553c33fbe2eb24112cf4812ab054cd11e52455422825d5ca5275ac200fc366"

URI_aarch64_libini_config-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libini_config-devel-1.3.1-58.el10.aarch64.rpm;name=aarch64_libini_config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libini_config-devel}"
SRC_URI[aarch64_libini_config-devel.sha256sum] = "cfc9466f94811576f940f69f6aca538bfdb66bfc963155328789153038788a5e"

URI_aarch64_libpath_utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpath_utils-0.2.1-58.el10.aarch64.rpm;name=aarch64_libpath_utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpath_utils}"
SRC_URI[aarch64_libpath_utils.sha256sum] = "5b196a1ffe67a9910aece3af3b3984eb4101bf922ac5af9ccb7f0b3b843328c0"

URI_aarch64_libpath_utils-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libpath_utils-devel-0.2.1-58.el10.aarch64.rpm;name=aarch64_libpath_utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpath_utils-devel}"
SRC_URI[aarch64_libpath_utils-devel.sha256sum] = "e9e7b6d21624d38c99e852f5ff76ebbf7c8788355752c7b9e863a63c5e28e023"

URI_aarch64_libref_array = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libref_array-0.1.5-58.el10.aarch64.rpm;name=aarch64_libref_array;unpack=0"
SRC_URI:append = " ${URI_aarch64_libref_array}"
SRC_URI[aarch64_libref_array.sha256sum] = "45c4f7a74db3582765b5bb99ec02ac507f6bcf72cbb3a213d1c1246e3f005cd5"

URI_aarch64_libref_array-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libref_array-devel-0.1.5-58.el10.aarch64.rpm;name=aarch64_libref_array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libref_array-devel}"
SRC_URI[aarch64_libref_array-devel.sha256sum] = "76414f8a1ccebe9b7706e0247e810f08b1b1eaa4bcb6bb8dcf0521101ba2d109"

RDEPENDS:libbasicobjects = " \
 glibc \
 "
RDEPENDS:libbasicobjects-devel = " \
 libbasicobjects \
 pkgconf-pkg-config \
 "
RDEPENDS:libcollection = " \
 glibc \
 "
RDEPENDS:libcollection-devel = " \
 libcollection \
 pkgconf-pkg-config \
 "
RDEPENDS:libdhash = " \
 glibc \
 "
RDEPENDS:libdhash-devel = " \
 libdhash \
 pkgconf-pkg-config \
 "
RDEPENDS:libini_config = " \
 glibc \
 libbasicobjects \
 libcollection \
 libpath_utils \
 libref_array \
 "
RDEPENDS:libini_config-devel = " \
 libbasicobjects-devel \
 libcollection-devel \
 libini_config \
 libref_array-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libpath_utils = " \
 glibc \
 "
RDEPENDS:libpath_utils-devel = " \
 libpath_utils \
 pkgconf-pkg-config \
 "
RDEPENDS:libref_array = " \
 glibc \
 "
RDEPENDS:libref_array-devel = " \
 libref_array \
 pkgconf-pkg-config \
 "
