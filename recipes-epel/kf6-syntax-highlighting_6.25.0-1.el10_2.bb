# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-syntax-highlighting"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-syntax-highlighting \
 kf6-syntax-highlighting-devel \
 kf6-syntax-highlighting-doc \
 kf6-syntax-highlighting-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-syntax-highlighting-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "245ca1c70dfb3aa6b4aab9e7bb32fb000eec1f9ea3e3548972bada2e3c0dde73"

URI_x86_64_v2_kf6-syntax-highlighting = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syntax-highlighting;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syntax-highlighting}"
SRC_URI[x86_64_v2_kf6-syntax-highlighting.sha256sum] = "290b29891918171cfa14a4e38915b78d5c5bff4303969a3fcc36134091442b91"

URI_x86_64_v2_kf6-syntax-highlighting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syntax-highlighting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syntax-highlighting-devel}"
SRC_URI[x86_64_v2_kf6-syntax-highlighting-devel.sha256sum] = "a1f53b06edc00835b7fe0b95f81b8664a75dba9cd1e16ba648f6e8c846ecb9cc"

URI_x86_64_v2_kf6-syntax-highlighting-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syntax-highlighting-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syntax-highlighting-doc}"
SRC_URI[x86_64_v2_kf6-syntax-highlighting-doc.sha256sum] = "948d427ab926802845e3ad6b66939edf0ca030eff8fc5f57ed2117f822aa5787"

URI_x86_64_v2_kf6-syntax-highlighting-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syntax-highlighting-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syntax-highlighting-html}"
SRC_URI[x86_64_v2_kf6-syntax-highlighting-html.sha256sum] = "c5745cd5666848f69dc49df4978fa511f9ed66674cf8944f21f9ba462ee775bf"

URI_aarch64_kf6-syntax-highlighting = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-syntax-highlighting;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syntax-highlighting}"
SRC_URI[aarch64_kf6-syntax-highlighting.sha256sum] = "b42d8496d0b1b78832b85be1e56625dd656215fd1dab8b260a80947bf03b615f"

URI_aarch64_kf6-syntax-highlighting-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-syntax-highlighting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syntax-highlighting-devel}"
SRC_URI[aarch64_kf6-syntax-highlighting-devel.sha256sum] = "e3faa04c218e5c1865e359b2b6d297eeebdf404036ddd50cbce76f27d6371dae"

URI_aarch64_kf6-syntax-highlighting-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-syntax-highlighting-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syntax-highlighting-doc}"
SRC_URI[aarch64_kf6-syntax-highlighting-doc.sha256sum] = "5adfbfc130b2d55faae15407816f90178ba18e9408abef5540939dd739dc888d"

URI_aarch64_kf6-syntax-highlighting-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-syntax-highlighting-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syntax-highlighting-html}"
SRC_URI[aarch64_kf6-syntax-highlighting-html.sha256sum] = "8e2b3218b5379e4401ee3ab1b87372572679aed8dec81b37aa1965fea338ec92"

RDEPENDS:kf6-syntax-highlighting = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-syntax-highlighting-devel = " \
 cmake-filesystem \
 kf6-syntax-highlighting \
 "
RDEPENDS:kf6-syntax-highlighting-doc = " \
 "
RDEPENDS:kf6-syntax-highlighting-html = " \
 "
