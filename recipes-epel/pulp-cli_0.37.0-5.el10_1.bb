# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pulp-cli"
PV = "0.37.0"
PR = "5.el10_1"
PACKAGES = " \
 pulp-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pulp-cli-0.37.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91cd9f63c94c28627c11f08ef7d6b09e0b8ccc10c67df0ba07e0c5db79977970"

URI_x86_64_v2_pulp-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulp-cli-0.37.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pulp-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulp-cli}"
SRC_URI[x86_64_v2_pulp-cli.sha256sum] = "5b14548170ec03aa1b62355841e37f9c72ac3e9b79e7b0ea9954dfbc062ce009"

URI_aarch64_pulp-cli = "${EPEL_MIRROR}/aarch64/Packages/p/pulp-cli-0.37.0-5.el10_1.noarch.rpm;name=aarch64_pulp-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulp-cli}"
SRC_URI[aarch64_pulp-cli.sha256sum] = "8bd38b6d31e3c7bc54add5c23ad71ffbec8e468b068a61387b0c81cba3a17be4"

RDEPENDS:pulp-cli = " \
 python3 \
 python3-click \
 python3-pulp-glue \
 python3-pyyaml \
 python3-schema \
 python3-tomli-w \
 "
