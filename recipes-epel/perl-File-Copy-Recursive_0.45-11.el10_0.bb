# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-Copy-Recursive"
PV = "0.45"
PR = "11.el10_0"
PACKAGES = " \
 perl-File-Copy-Recursive \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-File-Copy-Recursive-0.45-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "03552bb74c63d5d67b3806236d543ccc572a5f2542f48f9a4e50b443cf74cb3c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Copy-Recursive-0.45-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Copy-Recursive;unpack=0"
SRC_URI[x86_64_v2_perl-File-Copy-Recursive.sha256sum] = "d0a4795dac20ba847a4e0e729cf501f6f972e24235b4982b353c431856596e07"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Copy-Recursive-0.45-11.el10_0.noarch.rpm;name=aarch64_perl-File-Copy-Recursive;unpack=0"
SRC_URI[aarch64_perl-File-Copy-Recursive.sha256sum] = "fb400602d3f11e0e7e96bffbf27f9ac5c9dee563ad6bf843aa110dcb2d06ece9"

RDEPENDS:perl-File-Copy-Recursive = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Copy \
 perl-PathTools \
 perl-libs \
 perl-vars \
 "
