# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ts"
PV = "0.20110323.1"
PR = "18.el10"
PACKAGES = " \
 hunspell-ts \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ts-0.20110323.1-18.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "923ec0b7930b70de19fcfb1a945277ccec2ddb4e4e9880029204652df9ae8da4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ts-0.20110323.1-18.el10.noarch.rpm;name=x86_64_v2_hunspell-ts;unpack=0"
SRC_URI[x86_64_v2_hunspell-ts.sha256sum] = "2a34b414d87c1105cc8c755abbd7f03b0e3be5ff91bcfce51d2e61900de89d43"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ts-0.20110323.1-18.el10.noarch.rpm;name=aarch64_hunspell-ts;unpack=0"
SRC_URI[aarch64_hunspell-ts.sha256sum] = "2a34b414d87c1105cc8c755abbd7f03b0e3be5ff91bcfce51d2e61900de89d43"

RDEPENDS:hunspell-ts = " \
 hunspell-filesystem \
 "
