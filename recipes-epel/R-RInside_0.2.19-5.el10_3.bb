# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-RInside"
PV = "0.2.19"
PR = "5.el10_3"
PACKAGES = " \
 R-RInside \
 R-RInside-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-RInside-0.2.19-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e8340ea7847caa590f754904bc2eba9e4f862c37da71275b46baa2a80b6fce5"

URI_x86_64_v2_R-RInside = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-RInside-0.2.19-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-RInside;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-RInside}"
SRC_URI[x86_64_v2_R-RInside.sha256sum] = "1227659bfe9eaa587087e7e53f4c3e8fdc9abee43b017b32f2ab83db3ab801e3"

URI_x86_64_v2_R-RInside-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-RInside-examples-0.2.19-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-RInside-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-RInside-examples}"
SRC_URI[x86_64_v2_R-RInside-examples.sha256sum] = "99a9f5bcfb49eec2d144214ec3e68d1bfd5cc07fa309d47be6738c49287b0bdd"

URI_aarch64_R-RInside = "${EPEL_MIRROR}/aarch64/Packages/r/R-RInside-0.2.19-5.el10_3.aarch64.rpm;name=aarch64_R-RInside;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-RInside}"
SRC_URI[aarch64_R-RInside.sha256sum] = "f09471e16ac656f12785ff5305f4d653140f0c9127316f0e2d0b2f8172110ad2"

URI_aarch64_R-RInside-examples = "${EPEL_MIRROR}/aarch64/Packages/r/R-RInside-examples-0.2.19-5.el10_3.aarch64.rpm;name=aarch64_R-RInside-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-RInside-examples}"
SRC_URI[aarch64_R-RInside-examples.sha256sum] = "f5961a745d14d7b2a190a52feb0a37fc18ff11d46d82f3f8bab746d2fb85fc27"

RDEPENDS:R-RInside = " \
 R-Rcpp \
 R-core \
 R-core-devel \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:R-RInside-examples = " \
 R-RInside \
 "
