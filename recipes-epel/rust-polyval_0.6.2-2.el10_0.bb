# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-polyval"
PV = "0.6.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-polyval+default-devel \
 rust-polyval+std-devel \
 rust-polyval+zeroize-devel \
 rust-polyval-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-polyval-0.6.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3dd247160c503fb935d123750e8a006277a77bfbe9e55d7ab14b12d053f87295"

URI_x86_64_v2_rust-polyval+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polyval+default-devel-0.6.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polyval+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polyval+default-devel}"
SRC_URI[x86_64_v2_rust-polyval+default-devel.sha256sum] = "24f72d071c5b33697a0b6bf0051d0e9bbdd2639acb9d37135fff51e959927d5f"

URI_x86_64_v2_rust-polyval+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polyval+std-devel-0.6.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polyval+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polyval+std-devel}"
SRC_URI[x86_64_v2_rust-polyval+std-devel.sha256sum] = "1be0ffb3ef155d5d56946a967a5365ab89ebbd8c610012b45761baa606be8872"

URI_x86_64_v2_rust-polyval+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polyval+zeroize-devel-0.6.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polyval+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polyval+zeroize-devel}"
SRC_URI[x86_64_v2_rust-polyval+zeroize-devel.sha256sum] = "ac3b69294fcbe2ab740539c38aa2bd1fcd497c4bff2a08445cfcfb7141b2a762"

URI_x86_64_v2_rust-polyval-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polyval-devel-0.6.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polyval-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polyval-devel}"
SRC_URI[x86_64_v2_rust-polyval-devel.sha256sum] = "45358f28c35cb9a835274def5d476e1843380fc603cd4d8a6a6167f0252c7e81"

URI_aarch64_rust-polyval+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polyval+default-devel-0.6.2-2.el10_0.noarch.rpm;name=aarch64_rust-polyval+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polyval+default-devel}"
SRC_URI[aarch64_rust-polyval+default-devel.sha256sum] = "f506fe2a934aab1722b049202a5e8f264e101b68c1e4f614e31b846fd45b02fd"

URI_aarch64_rust-polyval+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polyval+std-devel-0.6.2-2.el10_0.noarch.rpm;name=aarch64_rust-polyval+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polyval+std-devel}"
SRC_URI[aarch64_rust-polyval+std-devel.sha256sum] = "21c40d2bc60590c4faf98c0c11da9ba6c2aa8c18e89406e605b47cd88069def9"

URI_aarch64_rust-polyval+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polyval+zeroize-devel-0.6.2-2.el10_0.noarch.rpm;name=aarch64_rust-polyval+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polyval+zeroize-devel}"
SRC_URI[aarch64_rust-polyval+zeroize-devel.sha256sum] = "09e2285edd4925bc39b67cccb0619fe15fb43a6e78a56a26ba482e576d5e64ce"

URI_aarch64_rust-polyval-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polyval-devel-0.6.2-2.el10_0.noarch.rpm;name=aarch64_rust-polyval-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polyval-devel}"
SRC_URI[aarch64_rust-polyval-devel.sha256sum] = "1e5b14ef42b6d278f0395d181184aaec30b8e401d118aaa0bcc119b2383870e4"

RDEPENDS:rust-polyval+default-devel = " \
 cargo \
 rust-polyval-devel \
 "
RDEPENDS:rust-polyval+std-devel = " \
 cargo \
 rust-polyval-devel \
 rust-universal-hash+std-devel \
 "
RDEPENDS:rust-polyval+zeroize-devel = " \
 cargo \
 rust-polyval-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-polyval-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-cpufeatures0.2+default-devel \
 rust-opaque-debug+default-devel \
 rust-universal-hash-devel \
 "
