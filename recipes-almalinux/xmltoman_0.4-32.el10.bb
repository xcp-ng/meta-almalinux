# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xmltoman"
PV = "0.4"
PR = "32.el10"
PACKAGES = " \
 xmltoman \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/xmltoman-0.4-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19099299b3c5348ac6eb2fbc8f03c15fa7ef0551e368fa547a984c681b71dbe9"

URI_x86_64_v2_xmltoman = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmltoman-0.4-32.el10.noarch.rpm;name=x86_64_v2_xmltoman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmltoman}"
SRC_URI[x86_64_v2_xmltoman.sha256sum] = "65df5ce60db64a2a1e1e8b6200511b70dbfc5b4f285b953c71a3d54a511d8d36"

URI_aarch64_xmltoman = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmltoman-0.4-32.el10.noarch.rpm;name=aarch64_xmltoman;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmltoman}"
SRC_URI[aarch64_xmltoman.sha256sum] = "65df5ce60db64a2a1e1e8b6200511b70dbfc5b4f285b953c71a3d54a511d8d36"

RDEPENDS:xmltoman = " \
 perl-XML-Parser \
 perl-interpreter \
 "
