# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-systemmonitor"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-systemmonitor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-systemmonitor-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45c00c91495052eded1c4ff7b3902e5e2a1ec2a65c2c35b4d155cfe88d9df314"

URI_x86_64_v2_plasma-systemmonitor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-systemmonitor-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-systemmonitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-systemmonitor}"
SRC_URI[x86_64_v2_plasma-systemmonitor.sha256sum] = "63a72ed31054de674caf48300dd7064f082cb93cd12d53855f8159f8bc1bd3ce"

URI_aarch64_plasma-systemmonitor = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-systemmonitor-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-systemmonitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-systemmonitor}"
SRC_URI[aarch64_plasma-systemmonitor.sha256sum] = "0aa4dc5bdd8eb6e569e8c12ba18ed5d6b16c49ec7a30ee9d63a5d9b09efe424b"

RDEPENDS:plasma-systemmonitor = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kitemmodels \
 kf6-knewstuff \
 kf6-kservice \
 kf6-kwindowsystem \
 ksystemstats \
 libksysguard \
 libstdc++ \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
