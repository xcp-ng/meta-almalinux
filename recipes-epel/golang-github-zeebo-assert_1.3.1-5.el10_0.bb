# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-zeebo-assert"
PV = "1.3.1"
PR = "5.el10_0"
PACKAGES = " \
 golang-github-zeebo-assert-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-zeebo-assert-1.3.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d586ef0077b03a0d6afab9e8b473d7c32a2228440471cd8ba8392fec2199ab66"

URI_x86_64_v2_golang-github-zeebo-assert-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-zeebo-assert-devel-1.3.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-zeebo-assert-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-zeebo-assert-devel}"
SRC_URI[x86_64_v2_golang-github-zeebo-assert-devel.sha256sum] = "270ee02e71ce1170ae8c7fbc0dad06ce6bf3662d5c84f838c69d630c57a92307"

URI_aarch64_golang-github-zeebo-assert-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-zeebo-assert-devel-1.3.1-5.el10_0.noarch.rpm;name=aarch64_golang-github-zeebo-assert-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-zeebo-assert-devel}"
SRC_URI[aarch64_golang-github-zeebo-assert-devel.sha256sum] = "ea0335450f31e8f73fb1176382520c5a8bbce764f684c7fd4e501b3196781480"

RDEPENDS:golang-github-zeebo-assert-devel = " \
 go-filesystem \
 "
