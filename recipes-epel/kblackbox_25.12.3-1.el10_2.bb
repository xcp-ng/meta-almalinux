# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kblackbox"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kblackbox \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kblackbox-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5cccc2cf995e8d889f31d731a0347aba141376cec231946d6815212fc298179d"

URI_x86_64_v2_kblackbox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kblackbox-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kblackbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kblackbox}"
SRC_URI[x86_64_v2_kblackbox.sha256sum] = "5fb5441204a6925a65a8a555aebb19f679664b27d5ac3d10d330aa0e6e90e568"

URI_aarch64_kblackbox = "${EPEL_MIRROR}/aarch64/Packages/k/kblackbox-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kblackbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_kblackbox}"
SRC_URI[aarch64_kblackbox.sha256sum] = "fccec7e4c61263b50619e9407bd4b00775c88d4b03cbfde14d1371bd4f15af73"

RDEPENDS:kblackbox = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
