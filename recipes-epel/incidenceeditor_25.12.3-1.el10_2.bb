# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "incidenceeditor"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 incidenceeditor \
 incidenceeditor-devel \
 incidenceeditor-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/incidenceeditor-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49a82a373b0f818e42c39f7373a077bb6aa98711fd89dafa5cd13e27ba1f929f"

URI_x86_64_v2_incidenceeditor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/incidenceeditor-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_incidenceeditor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_incidenceeditor}"
SRC_URI[x86_64_v2_incidenceeditor.sha256sum] = "df37d778fa83f1bfd4bde81def404323c4fc8595360613fe31e09640a1b9f524"

URI_x86_64_v2_incidenceeditor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/incidenceeditor-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_incidenceeditor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_incidenceeditor-devel}"
SRC_URI[x86_64_v2_incidenceeditor-devel.sha256sum] = "611a6d126e8c505a6b95020b07ae5ff321360e16b10066953904a70f25a3806d"

URI_x86_64_v2_incidenceeditor-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/incidenceeditor-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_incidenceeditor-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_incidenceeditor-doc}"
SRC_URI[x86_64_v2_incidenceeditor-doc.sha256sum] = "be2a4700fdb96e85c61b24b2c2a4a80b5b21447f6ffc578ad25f787aa8ed5c2f"

URI_aarch64_incidenceeditor = "${EPEL_MIRROR}/aarch64/Packages/i/incidenceeditor-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_incidenceeditor;unpack=0"
SRC_URI:append = " ${URI_aarch64_incidenceeditor}"
SRC_URI[aarch64_incidenceeditor.sha256sum] = "5d6284633a2f7558660ac589fccdcd00f1d5f6dc594efb7996105846b31ad244"

URI_aarch64_incidenceeditor-devel = "${EPEL_MIRROR}/aarch64/Packages/i/incidenceeditor-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_incidenceeditor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_incidenceeditor-devel}"
SRC_URI[aarch64_incidenceeditor-devel.sha256sum] = "9d0ab24c2eb35d9fc740fe3a14c55bc0471c9f7c16762b2262549fb816c253c5"

URI_aarch64_incidenceeditor-doc = "${EPEL_MIRROR}/aarch64/Packages/i/incidenceeditor-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_incidenceeditor-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_incidenceeditor-doc}"
SRC_URI[aarch64_incidenceeditor-doc.sha256sum] = "e6ce383db2b4321ea2e49178bc6452ad3c4b96954f602effcb0edc60511e806c"

RDEPENDS:incidenceeditor = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 calendarsupport \
 eventviews \
 glibc \
 kcalutils \
 kdiagram \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kidentitymanagement \
 kldap \
 kmime \
 kpimtextedit \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:incidenceeditor-devel = " \
 calendarsupport-devel \
 cmake-filesystem \
 eventviews-devel \
 incidenceeditor \
 kcalutils-devel \
 kf6-kcalendarcore-devel \
 kmime-devel \
 "
RDEPENDS:incidenceeditor-doc = " \
 "
