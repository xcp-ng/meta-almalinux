# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "brotli"
PV = "1.1.0"
PR = "6.el10"
PACKAGES = " \
 brotli \
 brotli-devel \
 libbrotli \
 python3-brotli \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/brotli-1.1.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ccea9b9dd0231357cec20bc6d0f15b6cea055eace6991302e8b1e7d0de77c785"

URI_x86_64_v2_brotli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brotli-1.1.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_brotli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brotli}"
SRC_URI[x86_64_v2_brotli.sha256sum] = "2ce067c61e5346e988ee9f337ff47f29019e85ec4ea2d07810ec253bbe0dfb19"

URI_x86_64_v2_brotli-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brotli-devel-1.1.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brotli-devel}"
SRC_URI[x86_64_v2_brotli-devel.sha256sum] = "9549b5f246e81c6460d4e9d77c6bce662cae092dc75e05452b76c4f4af59ae76"

URI_x86_64_v2_libbrotli = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libbrotli-1.1.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_libbrotli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbrotli}"
SRC_URI[x86_64_v2_libbrotli.sha256sum] = "18a9671b1a5321f55d4be9a12cc9a3d909f2d9e9ee7852283c272748d176b812"

URI_x86_64_v2_python3-brotli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-brotli-1.1.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_python3-brotli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-brotli}"
SRC_URI[x86_64_v2_python3-brotli.sha256sum] = "be0abbc7e0c4c5b1e4b7cd10d26d9d8d698d4a9c8baff6bf9548c6ce11ca9a54"

URI_aarch64_brotli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brotli-1.1.0-6.el10.aarch64.rpm;name=aarch64_brotli;unpack=0"
SRC_URI:append = " ${URI_aarch64_brotli}"
SRC_URI[aarch64_brotli.sha256sum] = "6ec012d4ab40d2aaace3c640447276cd5142bed8a8aee34072423380b018243a"

URI_aarch64_brotli-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brotli-devel-1.1.0-6.el10.aarch64.rpm;name=aarch64_brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_brotli-devel}"
SRC_URI[aarch64_brotli-devel.sha256sum] = "f450d77a692d3b27e9eec37bb00fdf15a2ca1d154ffb9f2913306bfb916e290c"

URI_aarch64_libbrotli = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libbrotli-1.1.0-6.el10.aarch64.rpm;name=aarch64_libbrotli;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbrotli}"
SRC_URI[aarch64_libbrotli.sha256sum] = "b8a767f6311f491daf3d8f65a605b3efb8007f8e317290f45bea13f4930adc96"

URI_aarch64_python3-brotli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-brotli-1.1.0-6.el10.aarch64.rpm;name=aarch64_python3-brotli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-brotli}"
SRC_URI[aarch64_python3-brotli.sha256sum] = "e57a16cec9de6a39cf51ae0c833cd683bd39d481c6b2285a9aad4772af184bf8"

RDEPENDS:brotli = " \
 glibc \
 libbrotli \
 "
RDEPENDS:brotli-devel = " \
 brotli \
 brotli-devel \
 libbrotli \
 pkgconf-pkg-config \
 "
RDEPENDS:libbrotli = " \
 glibc \
 "
RDEPENDS:python3-brotli = " \
 glibc \
 python3 \
 "
