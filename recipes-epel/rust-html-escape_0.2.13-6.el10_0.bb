# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-html-escape"
PV = "0.2.13"
PR = "6.el10_0"
PACKAGES = " \
 rust-html-escape+default-devel \
 rust-html-escape+std-devel \
 rust-html-escape-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-html-escape-0.2.13-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0695970d5404eee2040fbf7afb5c489d7a0113acbdb19d803a8112de374bcd0d"

URI_x86_64_v2_rust-html-escape+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html-escape+default-devel-0.2.13-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html-escape+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html-escape+default-devel}"
SRC_URI[x86_64_v2_rust-html-escape+default-devel.sha256sum] = "05926287be2a6776dd2d55e28ab412a4e89dc154fc3476e6cc672a24d9e23abe"

URI_x86_64_v2_rust-html-escape+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html-escape+std-devel-0.2.13-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html-escape+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html-escape+std-devel}"
SRC_URI[x86_64_v2_rust-html-escape+std-devel.sha256sum] = "596225e2e772c92d7620678683fc20d1fc51282ee17b6d22953bd59c1303abea"

URI_x86_64_v2_rust-html-escape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html-escape-devel-0.2.13-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html-escape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html-escape-devel}"
SRC_URI[x86_64_v2_rust-html-escape-devel.sha256sum] = "ce07d94d217af205bacb0b8f9cbe9211252f5e47c1435f230fe6558bfc9e65b2"

URI_aarch64_rust-html-escape+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html-escape+default-devel-0.2.13-6.el10_0.noarch.rpm;name=aarch64_rust-html-escape+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html-escape+default-devel}"
SRC_URI[aarch64_rust-html-escape+default-devel.sha256sum] = "7b6ef6049aa02d28f7b4af64229e1148c6082cd3c64d0eaa801969eb4fe3b9c1"

URI_aarch64_rust-html-escape+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html-escape+std-devel-0.2.13-6.el10_0.noarch.rpm;name=aarch64_rust-html-escape+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html-escape+std-devel}"
SRC_URI[aarch64_rust-html-escape+std-devel.sha256sum] = "19657fcb9eba248013b03941ea92c2e02b25258a0c7881759fa25743a901f117"

URI_aarch64_rust-html-escape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html-escape-devel-0.2.13-6.el10_0.noarch.rpm;name=aarch64_rust-html-escape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html-escape-devel}"
SRC_URI[aarch64_rust-html-escape-devel.sha256sum] = "573d6be6fbe8bb3661553210363c4be0b9b9827f75e11c35ccba97931843231c"

RDEPENDS:rust-html-escape+default-devel = " \
 cargo \
 rust-html-escape+std-devel \
 rust-html-escape-devel \
 "
RDEPENDS:rust-html-escape+std-devel = " \
 cargo \
 rust-html-escape-devel \
 "
RDEPENDS:rust-html-escape-devel = " \
 cargo \
 rust-utf8-width+default-devel \
 "
