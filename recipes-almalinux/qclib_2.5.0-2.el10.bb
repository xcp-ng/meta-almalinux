# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qclib"
PV = "2.5.0"
PR = "2.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qclib-2.5.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c95e052bb96acc87026ee4027c2f29ec4d81995d79ad34225e01109ebd91a930"

