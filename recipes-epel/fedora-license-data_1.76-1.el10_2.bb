# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-license-data"
PV = "1.76"
PR = "1.el10_2"
PACKAGES = " \
 fedora-license-data \
 rpmlint-fedora-license-data \
 rpmlint-fedora-license-data-legacy \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fedora-license-data-1.76-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "260c54daca51e0dbe106578a96fece30a6fbbe34dcff2db1d8edf6995b830a5a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-license-data-1.76-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-license-data;unpack=0"
SRC_URI[x86_64_v2_fedora-license-data.sha256sum] = "20cf3ec69903f8ec7b115064b8e082301ba0c295db97b34835ec263cd5fdc957"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmlint-fedora-license-data-1.76-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rpmlint-fedora-license-data;unpack=0"
SRC_URI[x86_64_v2_rpmlint-fedora-license-data.sha256sum] = "cbbed78d5a3e375fd81019393deb5f5ca1c5dac581eaee8b51114b897b61fdfc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmlint-fedora-license-data-legacy-1.76-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rpmlint-fedora-license-data-legacy;unpack=0"
SRC_URI[x86_64_v2_rpmlint-fedora-license-data-legacy.sha256sum] = "42e9bc326fa6196f18bf676b17fcab35602577e75229dd9f52beb2c3882c1555"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fedora-license-data-1.76-1.el10_2.noarch.rpm;name=aarch64_fedora-license-data;unpack=0"
SRC_URI[aarch64_fedora-license-data.sha256sum] = "0612a0e72647f53be39f56143072312ca565e5f607646992a8f544da46067a28"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rpmlint-fedora-license-data-1.76-1.el10_2.noarch.rpm;name=aarch64_rpmlint-fedora-license-data;unpack=0"
SRC_URI[aarch64_rpmlint-fedora-license-data.sha256sum] = "a5baa619cecbf9caad4613ee9eac52860e1c1043efa1e0e6d32e8207f6df2d2f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rpmlint-fedora-license-data-legacy-1.76-1.el10_2.noarch.rpm;name=aarch64_rpmlint-fedora-license-data-legacy;unpack=0"
SRC_URI[aarch64_rpmlint-fedora-license-data-legacy.sha256sum] = "6ec2b69bdefeba71c0fa55eb3353c98380a80a0d0e8fb8fee984cf09d6dcef37"

RDEPENDS:fedora-license-data = " \
 "
RDEPENDS:rpmlint-fedora-license-data = " \
 rpmlint \
 "
RDEPENDS:rpmlint-fedora-license-data-legacy = " \
 rpmlint \
 "
