# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "syncthing"
PV = "1.30.0"
PR = "1.el10_1"
PACKAGES = " \
 syncthing \
 syncthing-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/syncthing-1.30.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c8d3e3154c458080fefddf2d6ccf77493deea4718a2b2f44e2affd60d15462e"

URI_x86_64_v2_syncthing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syncthing-1.30.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syncthing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syncthing}"
SRC_URI[x86_64_v2_syncthing.sha256sum] = "2594f09818bc53e5f9f74d0c78a4172454118549f93a760eb2f1a45a16489e15"

URI_x86_64_v2_syncthing-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syncthing-tools-1.30.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syncthing-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syncthing-tools}"
SRC_URI[x86_64_v2_syncthing-tools.sha256sum] = "d73816a22644c57312e81845d4ed97c3decd954ad00b225f3ea7dfe6c614d970"

URI_aarch64_syncthing = "${EPEL_MIRROR}/aarch64/Packages/s/syncthing-1.30.0-1.el10_1.aarch64.rpm;name=aarch64_syncthing;unpack=0"
SRC_URI:append = " ${URI_aarch64_syncthing}"
SRC_URI[aarch64_syncthing.sha256sum] = "02dd75f6d8e5a806de8a31cdccc020094eb658945b2dde10d557d8c82514bddb"

URI_aarch64_syncthing-tools = "${EPEL_MIRROR}/aarch64/Packages/s/syncthing-tools-1.30.0-1.el10_1.aarch64.rpm;name=aarch64_syncthing-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_syncthing-tools}"
SRC_URI[aarch64_syncthing-tools.sha256sum] = "a3c8364c6b051f8a4aae89f4c9443292c835e51b11da7e2a25c04b05081dfa5b"

RDEPENDS:syncthing = " \
 bash \
 glibc \
 hicolor-icon-theme \
 "
RDEPENDS:syncthing-tools = " \
 glibc \
 "
