# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-left-right"
PV = "0.11.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-left-right+default-devel \
 rust-left-right-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-left-right-0.11.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "debf798d4f68e3b13a3db454522274fc1516343da4da9f2b3bb8ad2f59b4bf56"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-left-right+default-devel-0.11.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-left-right+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-left-right+default-devel.sha256sum] = "d569a0045f7df26cf69da5e02690b0bbeaffcc659ed429b063286a3ca76e95f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-left-right-devel-0.11.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-left-right-devel;unpack=0"
SRC_URI[x86_64_v2_rust-left-right-devel.sha256sum] = "dfee0b127cb283552bded3ad6e0ad9fce8074238500b756d6254b7c77549968e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-left-right+default-devel-0.11.8-1.el10_3.noarch.rpm;name=aarch64_rust-left-right+default-devel;unpack=0"
SRC_URI[aarch64_rust-left-right+default-devel.sha256sum] = "ef742a664e14ffbd383946b28c0abd40fa98cececbbf51febe5d333224d9dfa8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-left-right-devel-0.11.8-1.el10_3.noarch.rpm;name=aarch64_rust-left-right-devel;unpack=0"
SRC_URI[aarch64_rust-left-right-devel.sha256sum] = "c01b01f092aaf24a688fba49c24096a97304e48048ea93c9c67f11d5c856dd17"

RDEPENDS:rust-left-right+default-devel = " \
 cargo \
 rust-left-right-devel \
 "
RDEPENDS:rust-left-right-devel = " \
 cargo \
 rust-crossbeam-utils-devel \
 rust-slab+default-devel \
 "
