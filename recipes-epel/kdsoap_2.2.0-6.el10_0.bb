# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdsoap"
PV = "2.2.0"
PR = "6.el10_0"
PACKAGES = " \
 kdsoap \
 kdsoap-devel \
 kdsoap-devel-common \
 kdsoap-doc \
 kdsoap6 \
 kdsoap6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdsoap-2.2.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f72b9425d2271bd90b7ce766b49aa867fcca09d796ff7033d2b70c84975bbfb2"

URI_x86_64_v2_kdsoap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdsoap-2.2.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdsoap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdsoap}"
SRC_URI[x86_64_v2_kdsoap.sha256sum] = "323cb71657af70678a1da4b0385de0762869fa76059e46c9f778d303161a21e7"

URI_x86_64_v2_kdsoap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdsoap-devel-2.2.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdsoap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdsoap-devel}"
SRC_URI[x86_64_v2_kdsoap-devel.sha256sum] = "54ffba8ac592abefe33fead7a3df581fa552ec937d2f30e3ffbef8e6193e7293"

URI_x86_64_v2_kdsoap-devel-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdsoap-devel-common-2.2.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdsoap-devel-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdsoap-devel-common}"
SRC_URI[x86_64_v2_kdsoap-devel-common.sha256sum] = "334053f89b72dc6552144025e01c28c0742088fa76a6287a26451d5f4199ba07"

URI_x86_64_v2_kdsoap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdsoap-doc-2.2.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kdsoap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdsoap-doc}"
SRC_URI[x86_64_v2_kdsoap-doc.sha256sum] = "234cb3f173d1a16f3177ac40294376bec9a2af03ce46d7d069ef4114a52fd0cd"

URI_x86_64_v2_kdsoap6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdsoap6-2.2.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdsoap6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdsoap6}"
SRC_URI[x86_64_v2_kdsoap6.sha256sum] = "ed93f777436d44d7f4ddf172637ccb6146357f85844bf1c275e4218f3f6acea4"

URI_x86_64_v2_kdsoap6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdsoap6-devel-2.2.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdsoap6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdsoap6-devel}"
SRC_URI[x86_64_v2_kdsoap6-devel.sha256sum] = "96e462b95a54e1b5ced05c9159406391c8526d3dd9f68ab2cd59a0f2aa6848d8"

URI_aarch64_kdsoap = "${EPEL_MIRROR}/aarch64/Packages/k/kdsoap-2.2.0-6.el10_0.aarch64.rpm;name=aarch64_kdsoap;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdsoap}"
SRC_URI[aarch64_kdsoap.sha256sum] = "204744cf026dc2aaf08004a67b95fd4ebae02b7b5034d95b6f5512f7d84008cf"

URI_aarch64_kdsoap-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdsoap-devel-2.2.0-6.el10_0.aarch64.rpm;name=aarch64_kdsoap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdsoap-devel}"
SRC_URI[aarch64_kdsoap-devel.sha256sum] = "587de7996416cf3e0e1d48c600e9bf2406e3b3f520efc8331613a4a16d3776fa"

URI_aarch64_kdsoap-devel-common = "${EPEL_MIRROR}/aarch64/Packages/k/kdsoap-devel-common-2.2.0-6.el10_0.aarch64.rpm;name=aarch64_kdsoap-devel-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdsoap-devel-common}"
SRC_URI[aarch64_kdsoap-devel-common.sha256sum] = "6d0180a15e0dc4791865cab596d9c7aae66797091476dee3c96e73639be30ff5"

URI_aarch64_kdsoap-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kdsoap-doc-2.2.0-6.el10_0.noarch.rpm;name=aarch64_kdsoap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdsoap-doc}"
SRC_URI[aarch64_kdsoap-doc.sha256sum] = "6ef58704ef4b15fa392f861ba38bcfb51e94e38ce86fb0837e1080eb5313e404"

URI_aarch64_kdsoap6 = "${EPEL_MIRROR}/aarch64/Packages/k/kdsoap6-2.2.0-6.el10_0.aarch64.rpm;name=aarch64_kdsoap6;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdsoap6}"
SRC_URI[aarch64_kdsoap6.sha256sum] = "350f0509dd2403893cd986711bd5ab4cccdc0290cd21a9983e5fd7818f504845"

URI_aarch64_kdsoap6-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdsoap6-devel-2.2.0-6.el10_0.aarch64.rpm;name=aarch64_kdsoap6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdsoap6-devel}"
SRC_URI[aarch64_kdsoap6-devel.sha256sum] = "6534a89e6628502d567d59481ff1d2ab54f1c56e3c9d9bf702afa67e3e16857b"

RDEPENDS:kdsoap = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:kdsoap-devel = " \
 cmake-filesystem \
 glibc \
 kdsoap \
 kdsoap-devel-common \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:kdsoap-devel-common = " \
 "
RDEPENDS:kdsoap-doc = " \
 "
RDEPENDS:kdsoap6 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kdsoap6-devel = " \
 cmake-filesystem \
 glibc \
 kdsoap-devel-common \
 kdsoap6 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
