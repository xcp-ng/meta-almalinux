# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-cli-tools"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kde-cli-tools \
 kdesu \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-cli-tools-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5415c36b38293cdc7c81e8ee6f3532d673786e12ac32ced8d191977351740d0"

URI_x86_64_v2_kde-cli-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-cli-tools-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-cli-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-cli-tools}"
SRC_URI[x86_64_v2_kde-cli-tools.sha256sum] = "a89663fce04d9a4f94a430ee5d6e2a6dc8c405929d5399ec4bc8ce9fbee40ba5"

URI_x86_64_v2_kdesu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdesu-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdesu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdesu}"
SRC_URI[x86_64_v2_kdesu.sha256sum] = "bae2920b32c320a5fd0123b328be5a331b627b0dc95dff6f8181f495db530715"

URI_aarch64_kde-cli-tools = "${EPEL_MIRROR}/aarch64/Packages/k/kde-cli-tools-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kde-cli-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-cli-tools}"
SRC_URI[aarch64_kde-cli-tools.sha256sum] = "0feff54a6e7f2ccf34cb159a7fd72a4eb8ce1b269a61b22101cb833b6d903bd1"

URI_aarch64_kdesu = "${EPEL_MIRROR}/aarch64/Packages/k/kdesu-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kdesu;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdesu}"
SRC_URI[aarch64_kdesu.sha256sum] = "f873781bdddf9b2db50125cc6de0844186e272a44dea8eddd23f6acd96e8e689"

RDEPENDS:kde-cli-tools = " \
 bash \
 glibc \
 kdesu \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kservice \
 kf6-kwindowsystem \
 libkworkspace6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:kdesu = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdesu \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
