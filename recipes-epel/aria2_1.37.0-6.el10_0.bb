# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aria2"
PV = "1.37.0"
PR = "6.el10_0"
PACKAGES = " \
 aria2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aria2-1.37.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa2fc38b8196b93194c39af238f9f5115a95bf5c603ba9028627778cca0cc6fe"

URI_x86_64_v2_aria2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aria2-1.37.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aria2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aria2}"
SRC_URI[x86_64_v2_aria2.sha256sum] = "f46290e708b30480ab18a5cf7e8efc54062a4eac7c59468b6dccb4a5164017ea"

URI_aarch64_aria2 = "${EPEL_MIRROR}/aarch64/Packages/a/aria2-1.37.0-6.el10_0.aarch64.rpm;name=aarch64_aria2;unpack=0"
SRC_URI:append = " ${URI_aarch64_aria2}"
SRC_URI[aarch64_aria2.sha256sum] = "4bf0e9b4634b4e218203e15ef3c669c8047aa6d874cf386130ba7eb4cbb5f620"

RDEPENDS:aria2 = " \
 c-ares \
 glibc \
 gnutls \
 libgcc \
 libgcrypt \
 libstdc++ \
 libxml2 \
 sqlite-libs \
 zlib-ng-compat \
 "
