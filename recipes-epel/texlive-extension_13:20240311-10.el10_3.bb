# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "texlive-extension"
PE = "13"
PV = "20240311"
PR = "10.el10_3"
PACKAGES = " \
 texlive-adobemapping \
 texlive-ascmac \
 texlive-atenddvi \
 texlive-auto-pst-pdf \
 texlive-babel-french \
 texlive-babel-german \
 texlive-bibunits \
 texlive-boondox \
 texlive-chemformula \
 texlive-chemgreek \
 texlive-chktex \
 texlive-cjk \
 texlive-cjkpunct \
 texlive-convbkmk \
 texlive-ctex \
 texlive-ctie \
 texlive-cweb \
 texlive-ellipse \
 texlive-emulateapj \
 texlive-everyhook \
 texlive-fandol \
 texlive-filemod \
 texlive-fltpoint \
 texlive-fontaxes \
 texlive-german \
 texlive-germbib \
 texlive-gincltex \
 texlive-glossaries-english \
 texlive-glossaries-french \
 texlive-glossaries-german \
 texlive-hyphen-german \
 texlive-ieeetran \
 texlive-ipaex \
 texlive-japanese-otf \
 texlive-kantlipsum \
 texlive-lacheck \
 texlive-latex-base-dev \
 texlive-latex-firstaid-dev \
 texlive-lipsum \
 texlive-listingsutf8 \
 texlive-ltablex \
 texlive-luatexja \
 texlive-mdframed \
 texlive-media9 \
 texlive-mhchem \
 texlive-newtx \
 texlive-nomencl \
 texlive-ntheorem \
 texlive-ocgx2 \
 texlive-opensans \
 texlive-pgfplots \
 texlive-picinpar \
 texlive-pict2e \
 texlive-picture \
 texlive-platex \
 texlive-platex-tools \
 texlive-ps2eps \
 texlive-ptex \
 texlive-ptex-base \
 texlive-ptex-fonts \
 texlive-revtex4 \
 texlive-selinput \
 texlive-sidecap \
 texlive-siunitx \
 texlive-slantsc \
 texlive-standalone \
 texlive-sttools \
 texlive-supertabular \
 texlive-tcolorbox \
 texlive-tie \
 texlive-tikzfill \
 texlive-ttfutils \
 texlive-units \
 texlive-uplatex \
 texlive-uptex \
 texlive-uptex-base \
 texlive-uptex-fonts \
 texlive-web \
 texlive-xcjk2uni \
 texlive-xecjk \
 texlive-xltabular \
 texlive-xpinyin \
 texlive-zhmetrics \
 texlive-zhmetrics-uptex \
 texlive-zhnumber \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/texlive-extension-20240311-10.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ff0ff751325df1f3e580a672aca746895be3c35f8470e3d0a7bc0af4056d1d4"

URI_x86_64_v2_texlive-adobemapping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-adobemapping-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-adobemapping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-adobemapping}"
SRC_URI[x86_64_v2_texlive-adobemapping.sha256sum] = "e3d7e1c05be839490f9d01ab12775ca319ef34bbf6432f67a2536d90f9b3fc76"

URI_x86_64_v2_texlive-ascmac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ascmac-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ascmac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ascmac}"
SRC_URI[x86_64_v2_texlive-ascmac.sha256sum] = "8036c61160bf2459223a31e9ed206580ea9849b9efa3d1b68a8d8009ad3625cf"

URI_x86_64_v2_texlive-atenddvi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-atenddvi-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-atenddvi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-atenddvi}"
SRC_URI[x86_64_v2_texlive-atenddvi.sha256sum] = "3576bbf5ba8375c8bfdc377c87ebfdbc86b8cb629cc16a5207df1427c5aa17a1"

URI_x86_64_v2_texlive-auto-pst-pdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-auto-pst-pdf-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-auto-pst-pdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-auto-pst-pdf}"
SRC_URI[x86_64_v2_texlive-auto-pst-pdf.sha256sum] = "4c6d7aa02e67c93ccfbe5448627ad3bca9292d481168646766a4d0da2ccb0683"

URI_x86_64_v2_texlive-babel-french = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-babel-french-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-babel-french;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-babel-french}"
SRC_URI[x86_64_v2_texlive-babel-french.sha256sum] = "0369da8641915896130833e0bd621c35254ff28d1ab0236207929b874613f5ed"

URI_x86_64_v2_texlive-babel-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-babel-german-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-babel-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-babel-german}"
SRC_URI[x86_64_v2_texlive-babel-german.sha256sum] = "45ed937390ea0438fcb48758d66fed4eee18a878ed571109bf967700b13ebd6b"

URI_x86_64_v2_texlive-bibunits = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-bibunits-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-bibunits;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bibunits}"
SRC_URI[x86_64_v2_texlive-bibunits.sha256sum] = "8689fa02dc7b99159b5b271e21e55d2ad53297154aa36b487853ba753c1de28a"

URI_x86_64_v2_texlive-boondox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-boondox-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-boondox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-boondox}"
SRC_URI[x86_64_v2_texlive-boondox.sha256sum] = "9f7f516569edc9a87f46ff5df5a964027d4dffd934c9037045056ffa1e543f4e"

URI_x86_64_v2_texlive-chemformula = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-chemformula-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-chemformula;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-chemformula}"
SRC_URI[x86_64_v2_texlive-chemformula.sha256sum] = "b2af0585463c8bbfa6e2ad94bcd9e777e15f7c51009d5306b77d6943b6f83d62"

URI_x86_64_v2_texlive-chemgreek = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-chemgreek-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-chemgreek;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-chemgreek}"
SRC_URI[x86_64_v2_texlive-chemgreek.sha256sum] = "ade00bbf5c5f953c1c022ceee230a0199c07f4290c98cc1d113ed9d3b5a54e4f"

URI_x86_64_v2_texlive-chktex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-chktex-20240311-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-chktex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-chktex}"
SRC_URI[x86_64_v2_texlive-chktex.sha256sum] = "f3c191918bfaf96dbca841aa121b21dba47512fb70f33a2383a72f8c28dd936d"

URI_x86_64_v2_texlive-cjk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-cjk-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-cjk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cjk}"
SRC_URI[x86_64_v2_texlive-cjk.sha256sum] = "b4d7517612efa7484a1aa0bd0041ac7a18b69525c64bbee11742d14ee69de6dc"

URI_x86_64_v2_texlive-cjkpunct = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-cjkpunct-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-cjkpunct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cjkpunct}"
SRC_URI[x86_64_v2_texlive-cjkpunct.sha256sum] = "a96ee3bffe4249e57691ca4bbb17a245146e92d4b491ab136b333e06f7383cba"

URI_x86_64_v2_texlive-convbkmk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-convbkmk-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-convbkmk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-convbkmk}"
SRC_URI[x86_64_v2_texlive-convbkmk.sha256sum] = "34e52c94f88a523b78bfc8ea4bb17a53f0b7091859084bfd85c6cf96ecb60024"

URI_x86_64_v2_texlive-ctex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ctex-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ctex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ctex}"
SRC_URI[x86_64_v2_texlive-ctex.sha256sum] = "a62ad51d0d85a2cc6ac955230a0716b2ba551c6f4b4a9065b9b2d712839d73f6"

URI_x86_64_v2_texlive-ctie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ctie-20240311-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ctie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ctie}"
SRC_URI[x86_64_v2_texlive-ctie.sha256sum] = "5de340b43b5f12ea3f988af4c628640fc0f892de251593227cbd9928b6cd53f2"

URI_x86_64_v2_texlive-cweb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-cweb-20240311-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-cweb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cweb}"
SRC_URI[x86_64_v2_texlive-cweb.sha256sum] = "ed54c1893b6d61690a06613d5d321b563c356d33aca82902bab88e8ba69a64d7"

URI_x86_64_v2_texlive-ellipse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ellipse-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ellipse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ellipse}"
SRC_URI[x86_64_v2_texlive-ellipse.sha256sum] = "7ba309d5bb7324d7cc911d0d4faae8987c2d5f53f2654545f77181e8da52435c"

URI_x86_64_v2_texlive-emulateapj = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-emulateapj-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-emulateapj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-emulateapj}"
SRC_URI[x86_64_v2_texlive-emulateapj.sha256sum] = "ff8904ab9589744a8cb4c4d070da4f58375add7745f063d967ce8f0722bb7550"

URI_x86_64_v2_texlive-everyhook = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-everyhook-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-everyhook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-everyhook}"
SRC_URI[x86_64_v2_texlive-everyhook.sha256sum] = "881d36e1f8f43d6b4e85c9cf0d3036d7317b63d4ddf1beb9e5afffcdabcc2839"

URI_x86_64_v2_texlive-fandol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-fandol-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-fandol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fandol}"
SRC_URI[x86_64_v2_texlive-fandol.sha256sum] = "d3e3ffaa062d5d418bddefc9ed56295ef8da83c68cdb28c86a837c27613f464e"

URI_x86_64_v2_texlive-filemod = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-filemod-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-filemod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-filemod}"
SRC_URI[x86_64_v2_texlive-filemod.sha256sum] = "3cd8c644bce101cf30b7ecad773a961d6ac1c50d99c3a73a2c8574c7866e30f2"

URI_x86_64_v2_texlive-fltpoint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-fltpoint-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-fltpoint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fltpoint}"
SRC_URI[x86_64_v2_texlive-fltpoint.sha256sum] = "6e527ef205c10e13c85fcf8dd4d5048d4c3b77d5809b7bf439ec2ead782c231e"

URI_x86_64_v2_texlive-fontaxes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-fontaxes-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-fontaxes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fontaxes}"
SRC_URI[x86_64_v2_texlive-fontaxes.sha256sum] = "ce232f016b37ed14503f7b8636e811d8f25b4f7bea762212be5400f756df6acc"

URI_x86_64_v2_texlive-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-german-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-german}"
SRC_URI[x86_64_v2_texlive-german.sha256sum] = "f89fe59c6815d1c233e31b3d477ac447be68f2ad48691cca8f44779d67014895"

URI_x86_64_v2_texlive-germbib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-germbib-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-germbib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-germbib}"
SRC_URI[x86_64_v2_texlive-germbib.sha256sum] = "b59653bc264a284d5a45b061b20914d5d7d5cbd4774fbf7ecf7d2903f0a8cf5d"

URI_x86_64_v2_texlive-gincltex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-gincltex-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-gincltex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-gincltex}"
SRC_URI[x86_64_v2_texlive-gincltex.sha256sum] = "8e1b02e7a882eae884534d82ed18968349df36f2622aef3ccc16b56d38f32fab"

URI_x86_64_v2_texlive-glossaries-english = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-glossaries-english-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-glossaries-english;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-glossaries-english}"
SRC_URI[x86_64_v2_texlive-glossaries-english.sha256sum] = "ea098bd5e66a678cab4e08d3fa048c2abc99b50810640276de5e42dae1a9cc82"

URI_x86_64_v2_texlive-glossaries-french = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-glossaries-french-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-glossaries-french;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-glossaries-french}"
SRC_URI[x86_64_v2_texlive-glossaries-french.sha256sum] = "012f0484f75f7ff9d01674c9a6b7f1a2f45b92717ac4223b0c4d5269b0f692dc"

URI_x86_64_v2_texlive-glossaries-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-glossaries-german-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-glossaries-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-glossaries-german}"
SRC_URI[x86_64_v2_texlive-glossaries-german.sha256sum] = "2dbfacb7682968482f9f13e6dc1414033379cf8973660c36cdf8f7b60a681360"

URI_x86_64_v2_texlive-hyphen-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-hyphen-german-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-hyphen-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hyphen-german}"
SRC_URI[x86_64_v2_texlive-hyphen-german.sha256sum] = "af7aab0be79e2ad66d0bb7891de2c1a9606745239fd6523ab871196cb670e7ff"

URI_x86_64_v2_texlive-ieeetran = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ieeetran-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ieeetran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ieeetran}"
SRC_URI[x86_64_v2_texlive-ieeetran.sha256sum] = "094303810dedee1b9a80ecbeebb535d0944c8aeb45d9f6b63be239d70ccc5a93"

URI_x86_64_v2_texlive-ipaex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ipaex-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ipaex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ipaex}"
SRC_URI[x86_64_v2_texlive-ipaex.sha256sum] = "0e99f70ce5e97d0699be29c11ab6fb001b9311392d9f915d34b3f9a401f56831"

URI_x86_64_v2_texlive-japanese-otf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-japanese-otf-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-japanese-otf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-japanese-otf}"
SRC_URI[x86_64_v2_texlive-japanese-otf.sha256sum] = "7d29e968eae4217fbf133c35fdea6681f1a517a965d16158142d6353b32d973c"

URI_x86_64_v2_texlive-kantlipsum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-kantlipsum-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-kantlipsum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kantlipsum}"
SRC_URI[x86_64_v2_texlive-kantlipsum.sha256sum] = "cebae2573eaca9b207344fe2cacd3e551ac8205cf4ce57c28e59c6473e4a8fc4"

URI_x86_64_v2_texlive-lacheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-lacheck-20240311-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-lacheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lacheck}"
SRC_URI[x86_64_v2_texlive-lacheck.sha256sum] = "ebea231d987eaa91eafcc2348b586e2690ee7d037b0e1bd5bd32def9f14d70a3"

URI_x86_64_v2_texlive-latex-base-dev = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-latex-base-dev-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-latex-base-dev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latex-base-dev}"
SRC_URI[x86_64_v2_texlive-latex-base-dev.sha256sum] = "c6644ed5c8ae477cea829b5d6f1704fcf0ce79850edec47ee638ebb0bfe59862"
RPROVIDES:texlive-latex-base-dev:x86_64_v2 = "virtual/tex_alltt.sty_ virtual/tex_article.cls_ virtual/tex_doc.sty_ virtual/tex_exscale.sty_ virtual/tex_fix-cm.sty_ virtual/tex_fixltx2e.sty_ virtual/tex_flafter.sty_ virtual/tex_fontenc.sty_ virtual/tex_ifthen.sty_ virtual/tex_inputenc.sty_ virtual/tex_latexsym.sty_ virtual/tex_makeidx.sty_ virtual/tex_oldlfont.sty_ virtual/tex_shortvrb.sty_ virtual/tex_t1cmr.fd_ virtual/tex_textcomp.sty_"

URI_x86_64_v2_texlive-latex-firstaid-dev = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-latex-firstaid-dev-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-latex-firstaid-dev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latex-firstaid-dev}"
SRC_URI[x86_64_v2_texlive-latex-firstaid-dev.sha256sum] = "2124f7f6e3167fd0fa44a0ddb5603d88865e4e75e1be62013a6e90d211e5dee3"

URI_x86_64_v2_texlive-lipsum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-lipsum-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-lipsum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lipsum}"
SRC_URI[x86_64_v2_texlive-lipsum.sha256sum] = "a59e987f937428f65cad16d94ff02073f81d6f6ddcd9b5de67cb4d21f8958d54"

URI_x86_64_v2_texlive-listingsutf8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-listingsutf8-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-listingsutf8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-listingsutf8}"
SRC_URI[x86_64_v2_texlive-listingsutf8.sha256sum] = "480a03aabc35527e470c769ac94e4cbe82e721a9ef45c94e192d14d46d4db69e"

URI_x86_64_v2_texlive-ltablex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ltablex-20240311-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ltablex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ltablex}"
SRC_URI[x86_64_v2_texlive-ltablex.sha256sum] = "19a487a9ce201801bbe49e160cc460d5e8105bb93387bcb15b29539627e70f76"

URI_x86_64_v2_texlive-luatexja = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-luatexja-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-luatexja;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-luatexja}"
SRC_URI[x86_64_v2_texlive-luatexja.sha256sum] = "f72009376482d65c59f1df31011731795df27195b884f45673fd7342cb7b17e3"

URI_x86_64_v2_texlive-mdframed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-mdframed-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-mdframed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mdframed}"
SRC_URI[x86_64_v2_texlive-mdframed.sha256sum] = "901a6d80a1203a84fda52bf0486f1c03f8c055bc912189542408c072c160f4b0"

URI_x86_64_v2_texlive-media9 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-media9-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-media9;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-media9}"
SRC_URI[x86_64_v2_texlive-media9.sha256sum] = "a60eedb7bbec5bc279c300623b4a3670bc56e9f86385e1419ca6db8dedcacebf"

URI_x86_64_v2_texlive-mhchem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-mhchem-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-mhchem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mhchem}"
SRC_URI[x86_64_v2_texlive-mhchem.sha256sum] = "fec321980404c09a7c90bc6ad25feeb35a0e50dfc3414fdd21a9e81bb92ad29d"

URI_x86_64_v2_texlive-newtx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-newtx-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-newtx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-newtx}"
SRC_URI[x86_64_v2_texlive-newtx.sha256sum] = "94c8411a1c8c1e087bc0c5301a6c9a3750f4847853b6b8e8f3ddb3d8b168c594"

URI_x86_64_v2_texlive-nomencl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-nomencl-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-nomencl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-nomencl}"
SRC_URI[x86_64_v2_texlive-nomencl.sha256sum] = "3ea7fffd02261744f8d7b365bdb71ac0efa8321e4fbebc04f9938ba3a5ccff2a"

URI_x86_64_v2_texlive-ntheorem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ntheorem-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ntheorem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ntheorem}"
SRC_URI[x86_64_v2_texlive-ntheorem.sha256sum] = "2048e454fab288e339c481c5a7db2b55641b704fc9cb7aa0b263348f584e1bde"

URI_x86_64_v2_texlive-ocgx2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ocgx2-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ocgx2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ocgx2}"
SRC_URI[x86_64_v2_texlive-ocgx2.sha256sum] = "707ba687bd1b11473efa04407465e4ace488dcd14b2f3b19456db17fbed03ed9"

URI_x86_64_v2_texlive-opensans = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-opensans-20240311-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-opensans;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-opensans}"
SRC_URI[x86_64_v2_texlive-opensans.sha256sum] = "8cc67b51fd03d32f2b2da0c30622812838b013ab6cac5913fc56ceb28ee842eb"

URI_x86_64_v2_texlive-pgfplots = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-pgfplots-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-pgfplots;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pgfplots}"
SRC_URI[x86_64_v2_texlive-pgfplots.sha256sum] = "c962a562514313df00c3183b0203f72d717faf04aab01ce4526779ad2a4c9a11"

URI_x86_64_v2_texlive-picinpar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-picinpar-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-picinpar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-picinpar}"
SRC_URI[x86_64_v2_texlive-picinpar.sha256sum] = "b1e4a96962bedaef637b7458c6d78af18ceb3b660095722a8875293a7f05eafe"

URI_x86_64_v2_texlive-pict2e = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-pict2e-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-pict2e;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pict2e}"
SRC_URI[x86_64_v2_texlive-pict2e.sha256sum] = "9e1e160b03c82d96eedbd4fa1127b9810becc4293fa6f4f9e618c9310cc6bcde"

URI_x86_64_v2_texlive-picture = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-picture-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-picture;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-picture}"
SRC_URI[x86_64_v2_texlive-picture.sha256sum] = "bb7bcff58d858397f56d5cdfa06c35c8b57cd0d87f756737ed4f77f5d1b367e5"

URI_x86_64_v2_texlive-platex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-platex-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-platex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-platex}"
SRC_URI[x86_64_v2_texlive-platex.sha256sum] = "e1b9a992c78ac4c76d03c60ed586e5b842fc4888b9aa33d2b6c64a0dd19d6876"

URI_x86_64_v2_texlive-platex-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-platex-tools-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-platex-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-platex-tools}"
SRC_URI[x86_64_v2_texlive-platex-tools.sha256sum] = "6363025a595813589e9c1e1f8b4840b650ea68e6d620215baaf56ec089e67fbc"

URI_x86_64_v2_texlive-ps2eps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ps2eps-20240311-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ps2eps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ps2eps}"
SRC_URI[x86_64_v2_texlive-ps2eps.sha256sum] = "5a728481e82bb77d6cd76f1837b9e7b3232e59ec4971b7bc3b2a29c7abbc29d4"

URI_x86_64_v2_texlive-ptex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ptex-20240311-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ptex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ptex}"
SRC_URI[x86_64_v2_texlive-ptex.sha256sum] = "97d753fbe8b42a2807be34b261ecc278f8472859d100f3506d32c20837ee81bb"

URI_x86_64_v2_texlive-ptex-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ptex-base-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ptex-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ptex-base}"
SRC_URI[x86_64_v2_texlive-ptex-base.sha256sum] = "964cc74a6005c547a6eadc241bf2f18ea62df11e41d9fd0ab05ad8f124d9db88"

URI_x86_64_v2_texlive-ptex-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ptex-fonts-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ptex-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ptex-fonts}"
SRC_URI[x86_64_v2_texlive-ptex-fonts.sha256sum] = "3809b22594f60886ee79cfdf2c439d815510620912bd632959481b9e7176fd64"

URI_x86_64_v2_texlive-revtex4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-revtex4-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-revtex4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-revtex4}"
SRC_URI[x86_64_v2_texlive-revtex4.sha256sum] = "3e1266c4ea79284cbbea82e6ff7fb93123f9b951226602bcc71e2d902fd781ab"

URI_x86_64_v2_texlive-selinput = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-selinput-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-selinput;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-selinput}"
SRC_URI[x86_64_v2_texlive-selinput.sha256sum] = "4bf6aa83083b20b383ef0e6c77f3a8ede9003f4cb4cd7e74d6017ba9c85bb493"

URI_x86_64_v2_texlive-sidecap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-sidecap-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-sidecap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sidecap}"
SRC_URI[x86_64_v2_texlive-sidecap.sha256sum] = "664507535eaa0abf9948ddaaf0511e4ce1abde4b39c761243b2f9d68d399df58"

URI_x86_64_v2_texlive-siunitx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-siunitx-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-siunitx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-siunitx}"
SRC_URI[x86_64_v2_texlive-siunitx.sha256sum] = "21083f7a9298fb55eb499dec88808817766725d06b099d52ec35e5f052ec7a45"

URI_x86_64_v2_texlive-slantsc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-slantsc-20240311-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-slantsc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-slantsc}"
SRC_URI[x86_64_v2_texlive-slantsc.sha256sum] = "0c2ec17aacb9733fea7f051ada1d205e8ed7e4f86c353fd2198173d1b0fb4ac2"

URI_x86_64_v2_texlive-standalone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-standalone-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-standalone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-standalone}"
SRC_URI[x86_64_v2_texlive-standalone.sha256sum] = "ef69701f17c5886923ff3783a9665f0a10e9115fd4a719d7261b16d6d763002d"

URI_x86_64_v2_texlive-sttools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-sttools-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-sttools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sttools}"
SRC_URI[x86_64_v2_texlive-sttools.sha256sum] = "fdc4565d2cda0ca1d63d52d6ec90be0e191d0c504a3d8a28d8739d516ab3f39a"

URI_x86_64_v2_texlive-supertabular = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-supertabular-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-supertabular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-supertabular}"
SRC_URI[x86_64_v2_texlive-supertabular.sha256sum] = "f86cc8baeb5c1c69b3f548e054c7904198923cb83cac4e8b63e2d9027cadbe5c"

URI_x86_64_v2_texlive-tcolorbox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-tcolorbox-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-tcolorbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tcolorbox}"
SRC_URI[x86_64_v2_texlive-tcolorbox.sha256sum] = "2f1672dcae20bf063240884a4c24e242855d11e35662ed571427c3c052468286"

URI_x86_64_v2_texlive-tie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-tie-20240311-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-tie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tie}"
SRC_URI[x86_64_v2_texlive-tie.sha256sum] = "b8b41da65eef8bcd98812f85a6163044a6818eb3678feaefeeef163e8331959f"

URI_x86_64_v2_texlive-tikzfill = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-tikzfill-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-tikzfill;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tikzfill}"
SRC_URI[x86_64_v2_texlive-tikzfill.sha256sum] = "96f2bbe1ca71a6e07517640103959696f82de434d87bf8081dc2da0460f15a75"

URI_x86_64_v2_texlive-ttfutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ttfutils-20240311-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ttfutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ttfutils}"
SRC_URI[x86_64_v2_texlive-ttfutils.sha256sum] = "873325c382081303515d1f6f3246fee2ceb24604478b0b0631c559294160d52d"

URI_x86_64_v2_texlive-units = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-units-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-units;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-units}"
SRC_URI[x86_64_v2_texlive-units.sha256sum] = "81c41d5f28e1d8037496b33cca425c10174dc3fb5ddd508956f859b756b6a00a"

URI_x86_64_v2_texlive-uplatex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uplatex-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-uplatex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uplatex}"
SRC_URI[x86_64_v2_texlive-uplatex.sha256sum] = "82a1cd34c333c450bbe3d9e006701835a0c0c61aeef027404f3af912f7c5dedc"

URI_x86_64_v2_texlive-uptex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uptex-20240311-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-uptex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uptex}"
SRC_URI[x86_64_v2_texlive-uptex.sha256sum] = "dcb62523ba234e83bded9f3df8e764c5a71c8df49b0ef54fbf7114b8b50dacac"

URI_x86_64_v2_texlive-uptex-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uptex-base-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-uptex-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uptex-base}"
SRC_URI[x86_64_v2_texlive-uptex-base.sha256sum] = "f78988d0a3dfaa4388dfafc050e22df99da791ff484c2ee35821bde1667fe94d"

URI_x86_64_v2_texlive-uptex-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uptex-fonts-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-uptex-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uptex-fonts}"
SRC_URI[x86_64_v2_texlive-uptex-fonts.sha256sum] = "9e7d08c7e7c3a71160a54cca84b3e88f1e9dd571b0944a6f4d244d49655d80f8"

URI_x86_64_v2_texlive-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-web-20240311-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-web}"
SRC_URI[x86_64_v2_texlive-web.sha256sum] = "f077968f0583874316b86627e2f7980fd0c8682151e7fd6ee532efe93e949332"

URI_x86_64_v2_texlive-xcjk2uni = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-xcjk2uni-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-xcjk2uni;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xcjk2uni}"
SRC_URI[x86_64_v2_texlive-xcjk2uni.sha256sum] = "9cc5b77bbeaf5244fa4e0ef01880712fc0c7c3d48d20d9bf7646795495ffc35b"

URI_x86_64_v2_texlive-xecjk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-xecjk-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-xecjk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xecjk}"
SRC_URI[x86_64_v2_texlive-xecjk.sha256sum] = "179fcb605877367885c173ba41c70cf9ca497789bfe323d5aa3215b5119640f7"

URI_x86_64_v2_texlive-xltabular = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-xltabular-20240311-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-xltabular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xltabular}"
SRC_URI[x86_64_v2_texlive-xltabular.sha256sum] = "268edef33211cbcf97e76e30ffedbf3f37389f3a2be942ee85de80027a1b824a"

URI_x86_64_v2_texlive-xpinyin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-xpinyin-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-xpinyin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xpinyin}"
SRC_URI[x86_64_v2_texlive-xpinyin.sha256sum] = "e5a639a0d253ac16b0f289a0d6fe3c6eb702d32f127a8396eaef47f305322e03"

URI_x86_64_v2_texlive-zhmetrics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-zhmetrics-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-zhmetrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zhmetrics}"
SRC_URI[x86_64_v2_texlive-zhmetrics.sha256sum] = "6eda6728b6ec0ac163c9eace1db9488baeffbd03ab48877a3483f108b933564c"

URI_x86_64_v2_texlive-zhmetrics-uptex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-zhmetrics-uptex-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-zhmetrics-uptex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zhmetrics-uptex}"
SRC_URI[x86_64_v2_texlive-zhmetrics-uptex.sha256sum] = "46b50234759fe13935a1c1531d132e69e0de0668b48091a407480aeeb3bdfb09"

URI_x86_64_v2_texlive-zhnumber = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-zhnumber-20240311-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-zhnumber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zhnumber}"
SRC_URI[x86_64_v2_texlive-zhnumber.sha256sum] = "3a1d6abd067ab7694db2c86ab6396fca2dc26e9748bf2b2bbf94e9419f15ec28"

URI_aarch64_texlive-adobemapping = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-adobemapping-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-adobemapping;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-adobemapping}"
SRC_URI[aarch64_texlive-adobemapping.sha256sum] = "11eeb5201afc047133c46e888105821cd418bcf8cad7911ef15912f68804a2c7"

URI_aarch64_texlive-ascmac = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ascmac-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-ascmac;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ascmac}"
SRC_URI[aarch64_texlive-ascmac.sha256sum] = "f3fb7384fe9dfa3118bbd1822c23b3f6490337b9e98c23fdc42fa014a25ce1b4"

URI_aarch64_texlive-atenddvi = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-atenddvi-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-atenddvi;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-atenddvi}"
SRC_URI[aarch64_texlive-atenddvi.sha256sum] = "7eea335d19fab0e5545e1b02d20be7156ed1fa6a19085bda4d603207025fcb36"

URI_aarch64_texlive-auto-pst-pdf = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-auto-pst-pdf-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-auto-pst-pdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-auto-pst-pdf}"
SRC_URI[aarch64_texlive-auto-pst-pdf.sha256sum] = "0e2e060898d9a04864353b62804c7af1e3b41f94e883c7726e458c360584a3e8"

URI_aarch64_texlive-babel-french = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-babel-french-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-babel-french;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-babel-french}"
SRC_URI[aarch64_texlive-babel-french.sha256sum] = "8e1ab3e2e1fd87ae7ddb423984dd2e55318926f5888e066e8f591ff1ef10ac78"

URI_aarch64_texlive-babel-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-babel-german-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-babel-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-babel-german}"
SRC_URI[aarch64_texlive-babel-german.sha256sum] = "7c549c36308c441ce280e1950a72ce25831120b5fd2e2716b47bb1ddd939c4b1"

URI_aarch64_texlive-bibunits = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-bibunits-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-bibunits;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bibunits}"
SRC_URI[aarch64_texlive-bibunits.sha256sum] = "3746bc335c3199aed62c8f506ddf2f5b9e21d922faaa3d1c82b23e0dd3133f14"

URI_aarch64_texlive-boondox = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-boondox-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-boondox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-boondox}"
SRC_URI[aarch64_texlive-boondox.sha256sum] = "306cc6cd5c99ce49a0b6229a07a12ef34af1810e0a677b2d73ee853dc5331966"

URI_aarch64_texlive-chemformula = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-chemformula-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-chemformula;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-chemformula}"
SRC_URI[aarch64_texlive-chemformula.sha256sum] = "116f2b5cf59653c9837a24e55e73a8b3548e1cd683e48df66b320ff0f8cb6913"

URI_aarch64_texlive-chemgreek = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-chemgreek-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-chemgreek;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-chemgreek}"
SRC_URI[aarch64_texlive-chemgreek.sha256sum] = "e8334228a1620add16740c88a22d31208446d85496beb9023dc0eab630c9f1fa"

URI_aarch64_texlive-chktex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-chktex-20240311-10.el10_3.aarch64.rpm;name=aarch64_texlive-chktex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-chktex}"
SRC_URI[aarch64_texlive-chktex.sha256sum] = "36748e28e34e21b613c0104fbae1b8fcac1e23270fa5a1ca3a69990c8511f26c"

URI_aarch64_texlive-cjk = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-cjk-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-cjk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cjk}"
SRC_URI[aarch64_texlive-cjk.sha256sum] = "f26beb5fd8d0e1bd831f018af33eabc604ed6634986137457518194879acd7d0"

URI_aarch64_texlive-cjkpunct = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-cjkpunct-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-cjkpunct;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cjkpunct}"
SRC_URI[aarch64_texlive-cjkpunct.sha256sum] = "fccfd7a0757515b539d6418407fc2fa5da008feed6013b095b925e3609d6b728"

URI_aarch64_texlive-convbkmk = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-convbkmk-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-convbkmk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-convbkmk}"
SRC_URI[aarch64_texlive-convbkmk.sha256sum] = "ec873c20846ffef3142c28a4c6a32392a780a9ce8f9e7319bc6de7f11c91f4d9"

URI_aarch64_texlive-ctex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ctex-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-ctex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ctex}"
SRC_URI[aarch64_texlive-ctex.sha256sum] = "ee47b0bd1c83f42526e0262fe7df306c65a7ada24880a7f6b9ace765e4e02e1c"

URI_aarch64_texlive-ctie = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ctie-20240311-10.el10_3.aarch64.rpm;name=aarch64_texlive-ctie;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ctie}"
SRC_URI[aarch64_texlive-ctie.sha256sum] = "e22b41b874a03381a31f8d7a23f85cd20a6870c15c3df02932a12b3ca86019cf"

URI_aarch64_texlive-cweb = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-cweb-20240311-10.el10_3.aarch64.rpm;name=aarch64_texlive-cweb;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cweb}"
SRC_URI[aarch64_texlive-cweb.sha256sum] = "4cbfbde1e6bf6c40dd7e4d943026e71550d26768a26c07e5f00494c9554928b5"

URI_aarch64_texlive-ellipse = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ellipse-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-ellipse;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ellipse}"
SRC_URI[aarch64_texlive-ellipse.sha256sum] = "bc9c4b8cbfa8febfad568bf12135122caf9cf79a51fa65377e9f5296e0e3630e"

URI_aarch64_texlive-emulateapj = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-emulateapj-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-emulateapj;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-emulateapj}"
SRC_URI[aarch64_texlive-emulateapj.sha256sum] = "eb8abbbed75ce1f683b09e92065f406ef07741a3f082193023d877d5bb7e2caa"

URI_aarch64_texlive-everyhook = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-everyhook-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-everyhook;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-everyhook}"
SRC_URI[aarch64_texlive-everyhook.sha256sum] = "438ffb9233c51c2b2d1c24522fc52585d6313d40a07cd5a2b0734c522ca24bbd"

URI_aarch64_texlive-fandol = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-fandol-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-fandol;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fandol}"
SRC_URI[aarch64_texlive-fandol.sha256sum] = "e7651fa292466d77e56de7927417eb1991daa1aa933ee18a85b45354a132fdbe"

URI_aarch64_texlive-filemod = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-filemod-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-filemod;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-filemod}"
SRC_URI[aarch64_texlive-filemod.sha256sum] = "40096d2a8b00637399b7524afa7df1006de212b3f040af22fda5444f74563be0"

URI_aarch64_texlive-fltpoint = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-fltpoint-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-fltpoint;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fltpoint}"
SRC_URI[aarch64_texlive-fltpoint.sha256sum] = "caeca21d5d54e13efc6a8e6527f9b770845b18b1cd1da15a9897aad4a5c73d27"

URI_aarch64_texlive-fontaxes = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-fontaxes-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-fontaxes;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fontaxes}"
SRC_URI[aarch64_texlive-fontaxes.sha256sum] = "c1476962c4b3d5e6d1eb5afa3a0eedd038aced85a3dd0dd5673b75ccf1e3cabc"

URI_aarch64_texlive-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-german-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-german}"
SRC_URI[aarch64_texlive-german.sha256sum] = "35443511e6a2e3fc8be891172783d0ba4349385475fa23d9385ed2887c3c2e2e"

URI_aarch64_texlive-germbib = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-germbib-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-germbib;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-germbib}"
SRC_URI[aarch64_texlive-germbib.sha256sum] = "7f617f11d7d09224fcb5a31f4322729e5ac9691dc213d5ed35ec9a7ed3339f5b"

URI_aarch64_texlive-gincltex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-gincltex-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-gincltex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-gincltex}"
SRC_URI[aarch64_texlive-gincltex.sha256sum] = "a09945c792e50b68d8252ff062668b24acb71572add6e2db0d8d836c249a5d4d"

URI_aarch64_texlive-glossaries-english = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-glossaries-english-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-glossaries-english;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-glossaries-english}"
SRC_URI[aarch64_texlive-glossaries-english.sha256sum] = "cc13e5fb6500812dad6b8d35a7cde6efa6974688172b743617c104e3dc49d254"

URI_aarch64_texlive-glossaries-french = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-glossaries-french-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-glossaries-french;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-glossaries-french}"
SRC_URI[aarch64_texlive-glossaries-french.sha256sum] = "a27ae3c363e7edf37caf1fbe58c9981ab32cc6f9363138df1d9d311e531d384d"

URI_aarch64_texlive-glossaries-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-glossaries-german-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-glossaries-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-glossaries-german}"
SRC_URI[aarch64_texlive-glossaries-german.sha256sum] = "0730deb518a7a2ab640a50ff1da3e8cf2b3d3b35af029f65917a71af902223ba"

URI_aarch64_texlive-hyphen-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-hyphen-german-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-hyphen-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hyphen-german}"
SRC_URI[aarch64_texlive-hyphen-german.sha256sum] = "c093c7ce20851bdce60a7c1e63dd4b388d9059e191e6ecaa1a93e9f3c25a9067"

URI_aarch64_texlive-ieeetran = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ieeetran-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-ieeetran;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ieeetran}"
SRC_URI[aarch64_texlive-ieeetran.sha256sum] = "a052ff63ec976307cc2a4ddbadad934a269ea495ed4a4d07c668bd1bacf54cd5"

URI_aarch64_texlive-ipaex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ipaex-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-ipaex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ipaex}"
SRC_URI[aarch64_texlive-ipaex.sha256sum] = "fb9de38159b6f85c47cf1fc3507b8ba9c40026459eb3d370eac9308a08994fd6"

URI_aarch64_texlive-japanese-otf = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-japanese-otf-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-japanese-otf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-japanese-otf}"
SRC_URI[aarch64_texlive-japanese-otf.sha256sum] = "6d7da2168fe5404faa680fd678c5a72c8ea0315bb924103b0880ca3939a35801"

URI_aarch64_texlive-kantlipsum = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-kantlipsum-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-kantlipsum;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kantlipsum}"
SRC_URI[aarch64_texlive-kantlipsum.sha256sum] = "b5635dd0147b35617a0f5ad6c6cbc18b501e6b539ba6920e5733d5abc69fb6ea"

URI_aarch64_texlive-lacheck = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-lacheck-20240311-10.el10_3.aarch64.rpm;name=aarch64_texlive-lacheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lacheck}"
SRC_URI[aarch64_texlive-lacheck.sha256sum] = "ec3b7b51f144b28aedfe1660ac1977893947d221e25e102b4a0a7826536ec41a"

URI_aarch64_texlive-latex-base-dev = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-latex-base-dev-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-latex-base-dev;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latex-base-dev}"
SRC_URI[aarch64_texlive-latex-base-dev.sha256sum] = "8efcbbdb7d10861376b34effbb55479130a021509c9441ca8ac9ad62e154cac8"
RPROVIDES:texlive-latex-base-dev:aarch64 = "virtual/tex_alltt.sty_ virtual/tex_article.cls_ virtual/tex_doc.sty_ virtual/tex_exscale.sty_ virtual/tex_fix-cm.sty_ virtual/tex_fixltx2e.sty_ virtual/tex_flafter.sty_ virtual/tex_fontenc.sty_ virtual/tex_ifthen.sty_ virtual/tex_inputenc.sty_ virtual/tex_latexsym.sty_ virtual/tex_makeidx.sty_ virtual/tex_oldlfont.sty_ virtual/tex_shortvrb.sty_ virtual/tex_t1cmr.fd_ virtual/tex_textcomp.sty_"

URI_aarch64_texlive-latex-firstaid-dev = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-latex-firstaid-dev-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-latex-firstaid-dev;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latex-firstaid-dev}"
SRC_URI[aarch64_texlive-latex-firstaid-dev.sha256sum] = "2aa584e89b55c650a7ee4826688411e6531ed27441d36d881af0ddad7ceb373d"

URI_aarch64_texlive-lipsum = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-lipsum-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-lipsum;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lipsum}"
SRC_URI[aarch64_texlive-lipsum.sha256sum] = "476a48470442a259a5552f4d9dc1802d9bd6b48b637992e843691af5e401971d"

URI_aarch64_texlive-listingsutf8 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-listingsutf8-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-listingsutf8;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-listingsutf8}"
SRC_URI[aarch64_texlive-listingsutf8.sha256sum] = "ddfda90b8d7c411ceebe4100c1c96c0a26c085ccd1369f5845fe48f0ae9d38df"

URI_aarch64_texlive-ltablex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ltablex-20240311-10.el10_3.aarch64.rpm;name=aarch64_texlive-ltablex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ltablex}"
SRC_URI[aarch64_texlive-ltablex.sha256sum] = "3357733407056f6bcd85fff20b13472c049700a96f4b1ee2b3b0ee0062deb3a9"

URI_aarch64_texlive-luatexja = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-luatexja-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-luatexja;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-luatexja}"
SRC_URI[aarch64_texlive-luatexja.sha256sum] = "775a609bdedec932d9b343097c62bcadabe4e8fb2dc6d15451abf1e4ce4b16a4"

URI_aarch64_texlive-mdframed = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-mdframed-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-mdframed;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mdframed}"
SRC_URI[aarch64_texlive-mdframed.sha256sum] = "396cbb4e217988effb01361e8c9fbabeeea4ffbdc0133a4a039406383bb6a776"

URI_aarch64_texlive-media9 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-media9-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-media9;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-media9}"
SRC_URI[aarch64_texlive-media9.sha256sum] = "1e3e81eb739910ab6c6bffdcb5e9b1891aed4b5f89c79e1df332c53700461a0b"

URI_aarch64_texlive-mhchem = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-mhchem-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-mhchem;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mhchem}"
SRC_URI[aarch64_texlive-mhchem.sha256sum] = "5f5645f3509de26a22739ba5353624bfcb9d4d841f32d354147848c13d7665e5"

URI_aarch64_texlive-newtx = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-newtx-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-newtx;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-newtx}"
SRC_URI[aarch64_texlive-newtx.sha256sum] = "6d1eb0cdaa0282d6d20c26a14e0c75cfcee17c98a955f4970eb8d0b9f5846730"

URI_aarch64_texlive-nomencl = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-nomencl-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-nomencl;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-nomencl}"
SRC_URI[aarch64_texlive-nomencl.sha256sum] = "e2275c44ec5428630cd8d34b019c539b52993aaf7a847ceaf6749ef2f3ce2d79"

URI_aarch64_texlive-ntheorem = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ntheorem-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-ntheorem;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ntheorem}"
SRC_URI[aarch64_texlive-ntheorem.sha256sum] = "7b8a212b38dc7acfc52da093fa4e4ed8817246e1d2307e3a7fea28121d4630c1"

URI_aarch64_texlive-ocgx2 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ocgx2-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-ocgx2;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ocgx2}"
SRC_URI[aarch64_texlive-ocgx2.sha256sum] = "1effd2ad1de5558ca8b95fe4a2344424c9f67523c635e43d5926bcd13ce747a1"

URI_aarch64_texlive-opensans = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-opensans-20240311-10.el10_3.aarch64.rpm;name=aarch64_texlive-opensans;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-opensans}"
SRC_URI[aarch64_texlive-opensans.sha256sum] = "97504aaec4ea568d3962e413d32af36a8c70447a731acfa5792d42113034e278"

URI_aarch64_texlive-pgfplots = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-pgfplots-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-pgfplots;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pgfplots}"
SRC_URI[aarch64_texlive-pgfplots.sha256sum] = "ee1199178ed7947616c48c46868baa71390bf297c316f2f710c839cec059fb39"

URI_aarch64_texlive-picinpar = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-picinpar-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-picinpar;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-picinpar}"
SRC_URI[aarch64_texlive-picinpar.sha256sum] = "6f27d9d0eb1e33f443ddba38141da43d74456cf98d2fca83109b7092e3f859d7"

URI_aarch64_texlive-pict2e = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-pict2e-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-pict2e;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pict2e}"
SRC_URI[aarch64_texlive-pict2e.sha256sum] = "38f445b138d7f35d4e19031b3692a2844a31d8bb1a98c54624f4e045adfce83f"

URI_aarch64_texlive-picture = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-picture-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-picture;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-picture}"
SRC_URI[aarch64_texlive-picture.sha256sum] = "c9e659e46df39bacd926e935d48b6a653a826b975d44ee5cc577072fdd59e353"

URI_aarch64_texlive-platex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-platex-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-platex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-platex}"
SRC_URI[aarch64_texlive-platex.sha256sum] = "128ffc8ac52434590a1811aebfb92fae4ab7f382a9306c3e5c1c706dabc32893"

URI_aarch64_texlive-platex-tools = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-platex-tools-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-platex-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-platex-tools}"
SRC_URI[aarch64_texlive-platex-tools.sha256sum] = "09cd5a51ee1efef8d039fe8544132c685f06bc99d77f121136dad8ae9e56ee4a"

URI_aarch64_texlive-ps2eps = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ps2eps-20240311-10.el10_3.aarch64.rpm;name=aarch64_texlive-ps2eps;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ps2eps}"
SRC_URI[aarch64_texlive-ps2eps.sha256sum] = "4afadea083ddab07d9831bdd6bb2be696c458f70608031c47c0414b51c9e48db"

URI_aarch64_texlive-ptex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ptex-20240311-10.el10_3.aarch64.rpm;name=aarch64_texlive-ptex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ptex}"
SRC_URI[aarch64_texlive-ptex.sha256sum] = "8de45beb0fcb9ea3838d3813c19d22a2f32c7ec9c40c788544a3fbdd929b91ed"

URI_aarch64_texlive-ptex-base = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ptex-base-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-ptex-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ptex-base}"
SRC_URI[aarch64_texlive-ptex-base.sha256sum] = "07dc2fad3d8365590641e3b181cc09d0d30ade977dbb47ddeea3e816431769cb"

URI_aarch64_texlive-ptex-fonts = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ptex-fonts-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-ptex-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ptex-fonts}"
SRC_URI[aarch64_texlive-ptex-fonts.sha256sum] = "b07cafbc8f33eeb2572624e292c56a9ad441ba7f63b3462621d10785b97278c1"

URI_aarch64_texlive-revtex4 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-revtex4-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-revtex4;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-revtex4}"
SRC_URI[aarch64_texlive-revtex4.sha256sum] = "23e2894b8918211d0c86f29232637b559267e65782d46e122c2e1b001292b6c4"

URI_aarch64_texlive-selinput = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-selinput-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-selinput;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-selinput}"
SRC_URI[aarch64_texlive-selinput.sha256sum] = "98689f302eb904a22ed2fe30b963fe68be6ddc12ce85cf793c41569703e68457"

URI_aarch64_texlive-sidecap = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-sidecap-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-sidecap;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sidecap}"
SRC_URI[aarch64_texlive-sidecap.sha256sum] = "09b2f325ff28d0561d439f8a95a5acd16522b2fa5827a377d60b049417e5f9b9"

URI_aarch64_texlive-siunitx = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-siunitx-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-siunitx;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-siunitx}"
SRC_URI[aarch64_texlive-siunitx.sha256sum] = "58f99790ed108db632ff892cbfe6b296a02e38991acd01a0b72c7acbc2b1aeb7"

URI_aarch64_texlive-slantsc = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-slantsc-20240311-10.el10_3.aarch64.rpm;name=aarch64_texlive-slantsc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-slantsc}"
SRC_URI[aarch64_texlive-slantsc.sha256sum] = "34e45ed865bb9c816fe514fcc1babaa93da1f5a49040c8b5a4a732a75c01d414"

URI_aarch64_texlive-standalone = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-standalone-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-standalone;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-standalone}"
SRC_URI[aarch64_texlive-standalone.sha256sum] = "0112798055fd3f7b3ccd5e8f61f108df3f353e0a19f465c3129ef0c2ef9da3f9"

URI_aarch64_texlive-sttools = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-sttools-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-sttools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sttools}"
SRC_URI[aarch64_texlive-sttools.sha256sum] = "72cbb70b8816115d6eb58b7c1b9a15068a40cd3d3aec922357df6b96931b266e"

URI_aarch64_texlive-supertabular = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-supertabular-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-supertabular;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-supertabular}"
SRC_URI[aarch64_texlive-supertabular.sha256sum] = "13eb0d99a3b1be49ee8f1653db14c986b9b478e6511e41b2326d00eba54c4745"

URI_aarch64_texlive-tcolorbox = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-tcolorbox-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-tcolorbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tcolorbox}"
SRC_URI[aarch64_texlive-tcolorbox.sha256sum] = "e913ba713ba59353990785e17171a749606db73760b2c1fb2d55a81b4c314429"

URI_aarch64_texlive-tie = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-tie-20240311-10.el10_3.aarch64.rpm;name=aarch64_texlive-tie;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tie}"
SRC_URI[aarch64_texlive-tie.sha256sum] = "a1c2359119ac6bb79b2dcc7a8469bf81051ecae953b6a74b490a998f7e951a94"

URI_aarch64_texlive-tikzfill = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-tikzfill-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-tikzfill;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tikzfill}"
SRC_URI[aarch64_texlive-tikzfill.sha256sum] = "c3bad7cff449470186688cf1872bb81e95ea92b614d3a1fb098b7bc83380bf6d"

URI_aarch64_texlive-ttfutils = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ttfutils-20240311-10.el10_3.aarch64.rpm;name=aarch64_texlive-ttfutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ttfutils}"
SRC_URI[aarch64_texlive-ttfutils.sha256sum] = "02864667c735ae7b5a1d833c0cfc582a4eeb56b1202d407bb5d03b0e55a7a44a"

URI_aarch64_texlive-units = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-units-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-units;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-units}"
SRC_URI[aarch64_texlive-units.sha256sum] = "6553be934b23b9a7ad7987e5c3ae2469aea03ed1151d9a13025b1332f562e6e0"

URI_aarch64_texlive-uplatex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uplatex-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-uplatex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uplatex}"
SRC_URI[aarch64_texlive-uplatex.sha256sum] = "b4cc8c2e5716f212b597ea923eebfbc1a9007004aef9e0912e9a6374475ecfb0"

URI_aarch64_texlive-uptex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uptex-20240311-10.el10_3.aarch64.rpm;name=aarch64_texlive-uptex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uptex}"
SRC_URI[aarch64_texlive-uptex.sha256sum] = "e7919b6215bbc8a49bcb1423d767f3b2094d8edecf9e12dad53e3941818fdd6c"

URI_aarch64_texlive-uptex-base = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uptex-base-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-uptex-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uptex-base}"
SRC_URI[aarch64_texlive-uptex-base.sha256sum] = "81428aba7a28228c7299e04bf5672580be3d1b106f549e851dfcb3f0b3a6b10b"

URI_aarch64_texlive-uptex-fonts = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uptex-fonts-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-uptex-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uptex-fonts}"
SRC_URI[aarch64_texlive-uptex-fonts.sha256sum] = "5d66a052e91d4657c93ab455f5f95d33db2d3894c693449566155ab40670e8e0"

URI_aarch64_texlive-web = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-web-20240311-10.el10_3.aarch64.rpm;name=aarch64_texlive-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-web}"
SRC_URI[aarch64_texlive-web.sha256sum] = "bbbecc5e540465d30751de32e7580263758eb093967a3718a325911e26b2496f"

URI_aarch64_texlive-xcjk2uni = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-xcjk2uni-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-xcjk2uni;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xcjk2uni}"
SRC_URI[aarch64_texlive-xcjk2uni.sha256sum] = "1d1f1415c9b17eb8d387c6e7eeae809c6b6d301db599f8459272f9ac7cdb432d"

URI_aarch64_texlive-xecjk = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-xecjk-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-xecjk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xecjk}"
SRC_URI[aarch64_texlive-xecjk.sha256sum] = "39c55bbde1f3e7b3c9de79f9699b4325b54c06f97fdab695ecdff6197d59b8ed"

URI_aarch64_texlive-xltabular = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-xltabular-20240311-10.el10_3.aarch64.rpm;name=aarch64_texlive-xltabular;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xltabular}"
SRC_URI[aarch64_texlive-xltabular.sha256sum] = "3a10768c4d75c4788af73ccb7c5776f576e8181e0586d03af0f2dc9bc7f047b9"

URI_aarch64_texlive-xpinyin = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-xpinyin-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-xpinyin;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xpinyin}"
SRC_URI[aarch64_texlive-xpinyin.sha256sum] = "a15a01c87282fd0058d0dc5f1d193a65af7754afda5a833971193dabb5f645e6"

URI_aarch64_texlive-zhmetrics = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-zhmetrics-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-zhmetrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zhmetrics}"
SRC_URI[aarch64_texlive-zhmetrics.sha256sum] = "835c47e15cfa3e9eaf53e1aca826e092a1e560877965485d0d1236840d62450a"

URI_aarch64_texlive-zhmetrics-uptex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-zhmetrics-uptex-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-zhmetrics-uptex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zhmetrics-uptex}"
SRC_URI[aarch64_texlive-zhmetrics-uptex.sha256sum] = "c92020f72082601c6e8fb18628a13fcc50b6fa1cfe03e0faaf6193752abc9ab2"

URI_aarch64_texlive-zhnumber = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-zhnumber-20240311-10.el10_3.noarch.rpm;name=aarch64_texlive-zhnumber;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zhnumber}"
SRC_URI[aarch64_texlive-zhnumber.sha256sum] = "a0ec06509efae544e9fa01747d0975ce8e620e7635ffef25dcb0034f9fd3ae3e"

RDEPENDS:texlive-adobemapping = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ascmac = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-atenddvi = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-auto-pst-pdf = " \
 texlive-base \
 texlive-ifplatform \
 texlive-iftex \
 texlive-kpathsea \
 texlive-xkeyval \
 "
RDEPENDS:texlive-babel-french = " \
 texlive-base \
 texlive-carlisle \
 texlive-graphics \
 texlive-kpathsea \
 texlive-luatexbase \
 "
RDEPENDS:texlive-babel-german = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-bibunits = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-boondox = " \
 texlive-base \
 texlive-kpathsea \
 texlive-xkeyval \
 "
RDEPENDS:texlive-chemformula = " \
 texlive-amsmath \
 texlive-base \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-pgf \
 texlive-units \
 texlive-xfrac \
 "
RDEPENDS:texlive-chemgreek = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "
RDEPENDS:texlive-chktex = " \
 bash \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-cjk = " \
 texlive-arphic \
 texlive-base \
 texlive-cns \
 texlive-garuda-c90 \
 texlive-graphics \
 texlive-iftex \
 texlive-kpathsea \
 texlive-norasi-c90 \
 texlive-uhc \
 texlive-ulem \
 texlive-wadalab \
 virtual/tex_fontenc.sty_ \
 virtual/tex_inputenc.sty_ \
 "
RDEPENDS:texlive-cjkpunct = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-convbkmk = " \
 ruby \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-ctex = " \
 texlive-adobemapping \
 texlive-atbegshi \
 texlive-base \
 texlive-beamer \
 texlive-cjk \
 texlive-cjkpunct \
 texlive-count1to \
 texlive-ctex \
 texlive-ec \
 texlive-epstopdf-pkg \
 texlive-etoolbox \
 texlive-everyhook \
 texlive-everysel \
 texlive-fancyhdr \
 texlive-fandol \
 texlive-fontspec \
 texlive-hyperref \
 texlive-iftex \
 texlive-infwarerr \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-kvsetkeys \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-latex \
 texlive-ltxcmds \
 texlive-luatexja \
 texlive-mptopdf \
 texlive-multitoc \
 texlive-pdftexcmds \
 texlive-platex-tools \
 texlive-svn-prov \
 texlive-tipa \
 texlive-tools \
 texlive-ttfutils \
 texlive-ulem \
 texlive-uplatex \
 texlive-xcjk2uni \
 texlive-xecjk \
 texlive-xetex \
 texlive-xkeyval \
 texlive-xpinyin \
 texlive-xunicode \
 texlive-zhmetrics \
 texlive-zhmetrics-uptex \
 texlive-zhnumber \
 virtual/tex_fix-cm.sty_ \
 "
RDEPENDS:texlive-ctie = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-cweb = " \
 glibc \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-Pod-Usage \
 perl-libs \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 texlive-lib \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-ellipse = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-emulateapj = " \
 texlive-amsfonts \
 texlive-base \
 texlive-epsf \
 texlive-graphics \
 texlive-kpathsea \
 texlive-tools \
 virtual/tex_latexsym.sty_ \
 "
RDEPENDS:texlive-everyhook = " \
 texlive-base \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-svn-prov \
 "
RDEPENDS:texlive-fandol = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-filemod = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pdftexcmds \
 "
RDEPENDS:texlive-fltpoint = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fontaxes = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-german = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-germbib = " \
 texlive-base \
 texlive-german \
 texlive-kpathsea \
 "
RDEPENDS:texlive-gincltex = " \
 texlive-adjustbox \
 texlive-base \
 texlive-kpathsea \
 texlive-svn-prov \
 "
RDEPENDS:texlive-glossaries-english = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-glossaries-french = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-glossaries-german = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hyphen-german = " \
 bash \
 texlive-base \
 texlive-dehyph \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-kpathsea \
 virtual/coreutils \
 "
RDEPENDS:texlive-ieeetran = " \
 texlive-base \
 texlive-kpathsea \
 texlive-newtx \
 "
RDEPENDS:texlive-ipaex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-japanese-otf = " \
 texlive-base \
 texlive-japanese-otf \
 texlive-kpathsea \
 "
RDEPENDS:texlive-kantlipsum = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "
RDEPENDS:texlive-lacheck = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-latex-base-dev = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-latex-firstaid-dev = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-lipsum = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-listingsutf8 = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ltablex = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-luatexja = " \
 texlive-ascmac \
 texlive-atbegshi \
 texlive-base \
 texlive-everyhook \
 texlive-everysel \
 texlive-filehook \
 texlive-fontspec \
 texlive-footmisc \
 texlive-iftex \
 texlive-infwarerr \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-listings \
 texlive-ltxcmds \
 texlive-luaotfload \
 texlive-luatexbase \
 texlive-luatexja \
 texlive-pdftexcmds \
 texlive-sttools \
 texlive-unicode-math \
 texlive-xkeyval \
 texlive-xunicode \
 "
RDEPENDS:texlive-mdframed = " \
 texlive-amsmath \
 texlive-base \
 texlive-bera \
 texlive-booktabs \
 texlive-csquotes \
 texlive-enumitem \
 texlive-eso-pic \
 texlive-etoolbox \
 texlive-fontspec \
 texlive-geometry \
 texlive-graphics \
 texlive-hypdoc \
 texlive-iftex \
 texlive-kantlipsum \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-lipsum \
 texlive-listings \
 texlive-microtype \
 texlive-needspace \
 texlive-ntheorem \
 texlive-pgf \
 texlive-selinput \
 texlive-tools \
 texlive-xcolor \
 texlive-zref \
 virtual/tex_fontenc.sty_ \
 "
RDEPENDS:texlive-media9 = " \
 texlive-atbegshi \
 texlive-atenddvi \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-ocgx2 \
 texlive-pdftexcmds \
 texlive-pgf \
 "
RDEPENDS:texlive-mhchem = " \
 texlive-amsmath \
 texlive-babel \
 texlive-base \
 texlive-chemgreek \
 texlive-graphics \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-oberdiek \
 texlive-pgf \
 texlive-tools \
 virtual/tex_ifthen.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-newtx = " \
 texlive-amsmath \
 texlive-base \
 texlive-boondox \
 texlive-fontaxes \
 texlive-iftex \
 texlive-kastrup \
 texlive-kpathsea \
 texlive-xkeyval \
 virtual/tex_fontenc.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-nomencl = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ntheorem = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-ocgx2 = " \
 texlive-atenddvi \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 texlive-l3packages \
 texlive-media9 \
 texlive-pgf \
 "
RDEPENDS:texlive-opensans = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-slantsc \
 "
RDEPENDS:texlive-pgfplots = " \
 bash \
 texlive-base \
 texlive-graphics \
 texlive-hyperref \
 texlive-kpathsea \
 texlive-listings \
 texlive-luatex \
 texlive-luatexbase \
 texlive-pgf \
 texlive-tools \
 "
RDEPENDS:texlive-picinpar = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pict2e = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-picture = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-platex = " \
 texlive-atbegshi \
 texlive-atveryend \
 texlive-babel \
 texlive-base \
 texlive-cm \
 texlive-everyshi \
 texlive-firstaid \
 texlive-hyphen-base \
 texlive-kpathsea \
 texlive-l3backend \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-latex-base-dev \
 texlive-latex-firstaid-dev \
 texlive-latex-fonts \
 texlive-ptex \
 texlive-ptex-fonts \
 texlive-tex-ini-files \
 texlive-unicode-data \
 virtual/texlive-latex \
 "
RDEPENDS:texlive-platex-tools = " \
 texlive-base \
 texlive-kpathsea \
 texlive-platex \
 "
RDEPENDS:texlive-ps2eps = " \
 glibc \
 perl-Getopt-Long \
 perl-POSIX \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-ptex = " \
 cairo \
 glibc \
 gmp \
 libpng \
 mpfr \
 pixman \
 texlive-adobemapping \
 texlive-base \
 texlive-cm \
 texlive-etex \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-ipaex \
 texlive-japanese-otf \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-plain \
 texlive-ptex-base \
 texlive-ptex-fonts \
 texlive-tex \
 virtual/coreutils \
 virtual/tex_oldlfont.sty_ \
 virtual/tex_shortvrb.sty_ \
 virtual/texlive-latex \
 zlib-ng-compat \
 "
RDEPENDS:texlive-ptex-base = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ptex-fonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-revtex4 = " \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-base \
 texlive-kpathsea \
 texlive-natbib \
 texlive-url \
 "
RDEPENDS:texlive-selinput = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-sidecap = " \
 texlive-base \
 texlive-kpathsea \
 texlive-ragged2e \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-siunitx = " \
 texlive-amsmath \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-tools \
 texlive-translator \
 "
RDEPENDS:texlive-slantsc = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-standalone = " \
 texlive-adjustbox \
 texlive-base \
 texlive-currfile \
 texlive-filemod \
 texlive-gincltex \
 texlive-iftex \
 texlive-kpathsea \
 texlive-multido \
 texlive-pgf \
 texlive-pstricks \
 texlive-varwidth \
 texlive-xkeyval \
 "
RDEPENDS:texlive-sttools = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-supertabular = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-tcolorbox = " \
 texlive-base \
 texlive-environ \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-listingsutf8 \
 texlive-pdfcol \
 texlive-pgf \
 texlive-tikzfill \
 texlive-tools \
 "
RDEPENDS:texlive-tie = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-tikzfill = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ttfutils = " \
 freetype \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-units = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-uplatex = " \
 texlive-atbegshi \
 texlive-atveryend \
 texlive-babel \
 texlive-base \
 texlive-cm \
 texlive-everyshi \
 texlive-firstaid \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-kpathsea \
 texlive-l3backend \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-latex-base-dev \
 texlive-latex-firstaid-dev \
 texlive-latex-fonts \
 texlive-platex \
 texlive-tex-ini-files \
 texlive-unicode-data \
 texlive-uptex \
 texlive-uptex-fonts \
 virtual/texlive-latex \
 "
RDEPENDS:texlive-uptex = " \
 cairo \
 glibc \
 gmp \
 libicu \
 libpng \
 mpfr \
 pixman \
 texlive-base \
 texlive-convbkmk \
 texlive-etex \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-ipaex \
 texlive-japanese-otf \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-plain \
 texlive-ptex-base \
 texlive-uptex-base \
 texlive-uptex-fonts \
 zlib-ng-compat \
 "
RDEPENDS:texlive-uptex-base = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-uptex-fonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-web = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-xcjk2uni = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 "
RDEPENDS:texlive-xecjk = " \
 texlive-base \
 texlive-cjk \
 texlive-environ \
 texlive-fontspec \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-listings \
 texlive-tools \
 texlive-ulem \
 texlive-xunicode \
 "
RDEPENDS:texlive-xltabular = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xpinyin = " \
 texlive-base \
 texlive-cjk \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-xcjk2uni \
 texlive-xecjk \
 "
RDEPENDS:texlive-zhmetrics = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-zhmetrics-uptex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-zhnumber = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/tex_alltt.sty_ rpm/virtual/tex_article.cls_ rpm/virtual/tex_doc.sty_ rpm/virtual/tex_exscale.sty_ rpm/virtual/tex_fix-cm.sty_ rpm/virtual/tex_fixltx2e.sty_ rpm/virtual/tex_flafter.sty_ rpm/virtual/tex_fontenc.sty_ rpm/virtual/tex_ifthen.sty_ rpm/virtual/tex_inputenc.sty_ rpm/virtual/tex_latexsym.sty_ rpm/virtual/tex_makeidx.sty_ rpm/virtual/tex_oldlfont.sty_ rpm/virtual/tex_shortvrb.sty_ rpm/virtual/tex_t1cmr.fd_ rpm/virtual/tex_textcomp.sty_"

PROVIDES:append:aarch64 = " rpm/virtual/tex_alltt.sty_ rpm/virtual/tex_article.cls_ rpm/virtual/tex_doc.sty_ rpm/virtual/tex_exscale.sty_ rpm/virtual/tex_fix-cm.sty_ rpm/virtual/tex_fixltx2e.sty_ rpm/virtual/tex_flafter.sty_ rpm/virtual/tex_fontenc.sty_ rpm/virtual/tex_ifthen.sty_ rpm/virtual/tex_inputenc.sty_ rpm/virtual/tex_latexsym.sty_ rpm/virtual/tex_makeidx.sty_ rpm/virtual/tex_oldlfont.sty_ rpm/virtual/tex_shortvrb.sty_ rpm/virtual/tex_t1cmr.fd_ rpm/virtual/tex_textcomp.sty_"
