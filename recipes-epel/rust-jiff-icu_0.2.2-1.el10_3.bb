# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jiff-icu"
PV = "0.2.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-jiff-icu+alloc-devel \
 rust-jiff-icu+default-devel \
 rust-jiff-icu+std-devel \
 rust-jiff-icu+time-devel \
 rust-jiff-icu+zoned-devel \
 rust-jiff-icu-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jiff-icu-0.2.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59b8f5db6c52606d27ed219cb3d27ebf67ed3304de35f52f1e3c0da0a1f0d51d"

URI_x86_64_v2_rust-jiff-icu+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-icu+alloc-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-icu+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-icu+alloc-devel}"
SRC_URI[x86_64_v2_rust-jiff-icu+alloc-devel.sha256sum] = "2d6ec39f18ecc795e49fe8354fcc1454427a980df7c72b5034e0cc36e6121b83"

URI_x86_64_v2_rust-jiff-icu+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-icu+default-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-icu+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-icu+default-devel}"
SRC_URI[x86_64_v2_rust-jiff-icu+default-devel.sha256sum] = "348a5283afb2d31f3d3bbbac93b1b7c6dc5857c38aabb9d6874304208c647e97"

URI_x86_64_v2_rust-jiff-icu+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-icu+std-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-icu+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-icu+std-devel}"
SRC_URI[x86_64_v2_rust-jiff-icu+std-devel.sha256sum] = "7e0e68b068897bd3e4f625225e845041ef00908621d20e2b7878d962069b0425"

URI_x86_64_v2_rust-jiff-icu+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-icu+time-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-icu+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-icu+time-devel}"
SRC_URI[x86_64_v2_rust-jiff-icu+time-devel.sha256sum] = "1c8474524aef984978a882a4a4819b0ae15a00d5c4d56a6e3e8c558465dfbc89"

URI_x86_64_v2_rust-jiff-icu+zoned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-icu+zoned-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-icu+zoned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-icu+zoned-devel}"
SRC_URI[x86_64_v2_rust-jiff-icu+zoned-devel.sha256sum] = "f7cec7c1b92ba02a7f7aa0f015103c119092a034e49d2e9144cdb828b0176951"

URI_x86_64_v2_rust-jiff-icu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-icu-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-icu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-icu-devel}"
SRC_URI[x86_64_v2_rust-jiff-icu-devel.sha256sum] = "30b0809575e1512afd8a72596d88b4a32ad9cfa53ffe259ac72deb70e3c26fa1"

URI_aarch64_rust-jiff-icu+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-icu+alloc-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-icu+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-icu+alloc-devel}"
SRC_URI[aarch64_rust-jiff-icu+alloc-devel.sha256sum] = "b92c6534ee03b75faf54a1bd98db70b9c00c2a81ba86246babe13d33f2353ed7"

URI_aarch64_rust-jiff-icu+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-icu+default-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-icu+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-icu+default-devel}"
SRC_URI[aarch64_rust-jiff-icu+default-devel.sha256sum] = "8be48814a52918ec102e8628d60645be2be47f840ab695774c5bd39ccacadb6f"

URI_aarch64_rust-jiff-icu+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-icu+std-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-icu+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-icu+std-devel}"
SRC_URI[aarch64_rust-jiff-icu+std-devel.sha256sum] = "d2e9304260135b51c9545a56b3bbd2af0f59606d0317563f77d8266de5e59de1"

URI_aarch64_rust-jiff-icu+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-icu+time-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-icu+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-icu+time-devel}"
SRC_URI[aarch64_rust-jiff-icu+time-devel.sha256sum] = "10181031a6131427e31c9783c06bb99c12a5e3e4f99f39f26ec9277219d8f2e6"

URI_aarch64_rust-jiff-icu+zoned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-icu+zoned-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-icu+zoned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-icu+zoned-devel}"
SRC_URI[aarch64_rust-jiff-icu+zoned-devel.sha256sum] = "e0657d4ee0d7bcce4ee870b1312d52e3c09a615e144bdf5043a5de6a4dd172e2"

URI_aarch64_rust-jiff-icu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-icu-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-icu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-icu-devel}"
SRC_URI[aarch64_rust-jiff-icu-devel.sha256sum] = "3754a2468a6ebc92f55c9ac137de231b261e8666a21646472dd72832c2cb4c38"

RDEPENDS:rust-jiff-icu+alloc-devel = " \
 cargo \
 rust-icu_calendar+alloc-devel \
 rust-icu_time+alloc-devel \
 rust-icu_time-devel \
 rust-jiff+alloc-devel \
 rust-jiff-icu-devel \
 "
RDEPENDS:rust-jiff-icu+default-devel = " \
 cargo \
 rust-jiff-icu+std-devel \
 rust-jiff-icu+zoned-devel \
 rust-jiff-icu-devel \
 "
RDEPENDS:rust-jiff-icu+std-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-icu+alloc-devel \
 rust-jiff-icu-devel \
 "
RDEPENDS:rust-jiff-icu+time-devel = " \
 cargo \
 rust-icu_time-devel \
 rust-jiff-icu-devel \
 "
RDEPENDS:rust-jiff-icu+zoned-devel = " \
 cargo \
 rust-icu_time+compiled_data-devel \
 rust-icu_time-devel \
 rust-jiff-icu+time-devel \
 rust-jiff-icu-devel \
 "
RDEPENDS:rust-jiff-icu-devel = " \
 cargo \
 rust \
 rust-icu_calendar-devel \
 rust-jiff-devel \
 "
