# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-lxml"
PV = "6.0.2"
PR = "5.el10"
PACKAGES = " \
 python3.14-lxml \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-lxml-6.0.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e59213ffc5369e0592cd88ac7dc7591c0c41d7f4be0493a21f3178603de5fc58"

URI_x86_64_v2_python3.14-lxml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-lxml-6.0.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-lxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-lxml}"
SRC_URI[x86_64_v2_python3.14-lxml.sha256sum] = "8167eb0daf1a38b9a369dd65dcba5136c10e23756a67f38d69191b6312cf8427"

URI_aarch64_python3.14-lxml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-lxml-6.0.2-5.el10.aarch64.rpm;name=aarch64_python3.14-lxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-lxml}"
SRC_URI[aarch64_python3.14-lxml.sha256sum] = "c4d421ed9d671bdb80191f5ff88b8c34bb6b7548ab1fbe77faad4b665612bb11"

RDEPENDS:python3.14-lxml = " \
 glibc \
 libxml2 \
 libxslt \
 python3.14 \
 "
