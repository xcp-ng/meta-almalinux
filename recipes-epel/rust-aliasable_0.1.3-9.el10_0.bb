# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aliasable"
PV = "0.1.3"
PR = "9.el10_0"
PACKAGES = " \
 rust-aliasable+alloc-devel \
 rust-aliasable+default-devel \
 rust-aliasable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aliasable-0.1.3-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b318f7ecae952b56fbc93e2d2e936f7ebed9d43ab65b0b73505da854cf89bc45"

URI_x86_64_v2_rust-aliasable+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aliasable+alloc-devel-0.1.3-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aliasable+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aliasable+alloc-devel}"
SRC_URI[x86_64_v2_rust-aliasable+alloc-devel.sha256sum] = "432fd87ec7986851c2f5878315b6450fec5bcadbce8e5a1e1eef68f7e88601ef"

URI_x86_64_v2_rust-aliasable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aliasable+default-devel-0.1.3-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aliasable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aliasable+default-devel}"
SRC_URI[x86_64_v2_rust-aliasable+default-devel.sha256sum] = "efd4ac6aeafc3f439b677e2652b119f4fa7810d46f99fbf6e521bc83e60b6db8"

URI_x86_64_v2_rust-aliasable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aliasable-devel-0.1.3-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aliasable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aliasable-devel}"
SRC_URI[x86_64_v2_rust-aliasable-devel.sha256sum] = "721ee02ab6c4cad5730da7b3c1ac8e4b7195770791186b201887310eeb6b86dc"

URI_aarch64_rust-aliasable+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aliasable+alloc-devel-0.1.3-9.el10_0.noarch.rpm;name=aarch64_rust-aliasable+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aliasable+alloc-devel}"
SRC_URI[aarch64_rust-aliasable+alloc-devel.sha256sum] = "7bf136d562a585c1292539bfab08d87a24f6f99d01f67f56e210b4b74830f203"

URI_aarch64_rust-aliasable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aliasable+default-devel-0.1.3-9.el10_0.noarch.rpm;name=aarch64_rust-aliasable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aliasable+default-devel}"
SRC_URI[aarch64_rust-aliasable+default-devel.sha256sum] = "50016122ba2476a5cf1e82f3465e67dbccdde5306f922fcdf772ee40207f5928"

URI_aarch64_rust-aliasable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aliasable-devel-0.1.3-9.el10_0.noarch.rpm;name=aarch64_rust-aliasable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aliasable-devel}"
SRC_URI[aarch64_rust-aliasable-devel.sha256sum] = "c6620462181ac523e910704f2d3433a706bfca3c4e05a7c60b4206d99f695285"

RDEPENDS:rust-aliasable+alloc-devel = " \
 cargo \
 rust-aliasable-devel \
 "
RDEPENDS:rust-aliasable+default-devel = " \
 cargo \
 rust-aliasable+alloc-devel \
 rust-aliasable-devel \
 "
RDEPENDS:rust-aliasable-devel = " \
 cargo \
 "
