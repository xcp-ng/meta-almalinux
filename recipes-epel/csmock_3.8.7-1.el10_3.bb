# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "csmock"
PV = "3.8.7"
PR = "1.el10_3"
PACKAGES = " \
 csbuild \
 csmock \
 csmock-common \
 csmock-plugin-bandit \
 csmock-plugin-cbmc \
 csmock-plugin-clang \
 csmock-plugin-clippy \
 csmock-plugin-cppcheck \
 csmock-plugin-divine \
 csmock-plugin-gitleaks \
 csmock-plugin-infer \
 csmock-plugin-pylint \
 csmock-plugin-semgrep \
 csmock-plugin-shellcheck \
 csmock-plugin-shellcheck-core \
 csmock-plugin-smatch \
 csmock-plugin-snyk \
 csmock-plugin-strace \
 csmock-plugin-symbiotic \
 csmock-plugin-unicontrol \
 csmock-plugin-valgrind \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/csmock-3.8.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74126adaec0f93327caac89d21ae0b159ff20b30255f4a1b263fa62b7faf0822"

URI_x86_64_v2_csbuild = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csbuild-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csbuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csbuild}"
SRC_URI[x86_64_v2_csbuild.sha256sum] = "6cb84ad0f02a6b63efaa70163e96b7e3efcd28e9cc94572857c777cec7c51be6"

URI_x86_64_v2_csmock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock}"
SRC_URI[x86_64_v2_csmock.sha256sum] = "67ba513e556a5800ff32632019f1827696e281689986cde5bc890291eb9a4be1"

URI_x86_64_v2_csmock-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-common-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-common}"
SRC_URI[x86_64_v2_csmock-common.sha256sum] = "03a9272891433547ef48590c4d2f176af6ba36d15bd45c7da6ec95ea651c470f"

URI_x86_64_v2_csmock-plugin-bandit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-bandit-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-bandit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-bandit}"
SRC_URI[x86_64_v2_csmock-plugin-bandit.sha256sum] = "c14e91d6c24ea3f97b2d123d070dfac614a4b3005758245d4386173f78db5965"

URI_x86_64_v2_csmock-plugin-cbmc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-cbmc-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-cbmc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-cbmc}"
SRC_URI[x86_64_v2_csmock-plugin-cbmc.sha256sum] = "b18533412bcb8e92b45406c6e62c1c927c028dde66a756ae4c8580660f9d3b62"

URI_x86_64_v2_csmock-plugin-clang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-clang-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-clang}"
SRC_URI[x86_64_v2_csmock-plugin-clang.sha256sum] = "74f093217df4016df683cfa4af1379bbf9639d4c0a5a541023f0feed4b7ac71b"

URI_x86_64_v2_csmock-plugin-clippy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-clippy-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-clippy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-clippy}"
SRC_URI[x86_64_v2_csmock-plugin-clippy.sha256sum] = "d28b289b7c1bdc13c77e719f875fb14860cf69b5cb7bcb32f4e8790fa7132644"

URI_x86_64_v2_csmock-plugin-cppcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-cppcheck-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-cppcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-cppcheck}"
SRC_URI[x86_64_v2_csmock-plugin-cppcheck.sha256sum] = "f04e0b8a2e7edae5f7c546157cccb3e2168615262ebde50ed80614e275139ace"

URI_x86_64_v2_csmock-plugin-divine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-divine-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-divine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-divine}"
SRC_URI[x86_64_v2_csmock-plugin-divine.sha256sum] = "bbd3394fc931181c275147c32942ecc172b0cdfe99244991b0516aa3ef2a46cc"

URI_x86_64_v2_csmock-plugin-gitleaks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-gitleaks-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-gitleaks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-gitleaks}"
SRC_URI[x86_64_v2_csmock-plugin-gitleaks.sha256sum] = "f23a4aa50ca06f070a7cf79be4f2d56f90d9ed7266198958cae55812be3e15eb"

URI_x86_64_v2_csmock-plugin-infer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-infer-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-infer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-infer}"
SRC_URI[x86_64_v2_csmock-plugin-infer.sha256sum] = "eb104e5e8a1651d6dcfcc4a59e81919c6ac9c19adb405c36b3e4764b5be0d455"

URI_x86_64_v2_csmock-plugin-pylint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-pylint-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-pylint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-pylint}"
SRC_URI[x86_64_v2_csmock-plugin-pylint.sha256sum] = "c229e6d576b3ab03a03072ec9437e68a82a6396eabc12e9c8d10294c4948216a"

URI_x86_64_v2_csmock-plugin-semgrep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-semgrep-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-semgrep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-semgrep}"
SRC_URI[x86_64_v2_csmock-plugin-semgrep.sha256sum] = "f682003fc436dd2b7b8b2c8636497ae7ae6d9248373b39ea3bcf1059d628ef36"

URI_x86_64_v2_csmock-plugin-shellcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-shellcheck-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-shellcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-shellcheck}"
SRC_URI[x86_64_v2_csmock-plugin-shellcheck.sha256sum] = "e629cdfb6e8d9df6a714edf760517563c87f4e4ae3f7be5e5112529f993f4318"

URI_x86_64_v2_csmock-plugin-shellcheck-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-shellcheck-core-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-shellcheck-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-shellcheck-core}"
SRC_URI[x86_64_v2_csmock-plugin-shellcheck-core.sha256sum] = "e61546fd2a39fd5c6177312a47613b2bdae5ff436203598561ec1414035d3d74"

URI_x86_64_v2_csmock-plugin-smatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-smatch-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-smatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-smatch}"
SRC_URI[x86_64_v2_csmock-plugin-smatch.sha256sum] = "02f54a4cd9cf5609dfb8ff776308d433cfa8a07eff83b1904cede665b44b5654"

URI_x86_64_v2_csmock-plugin-snyk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-snyk-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-snyk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-snyk}"
SRC_URI[x86_64_v2_csmock-plugin-snyk.sha256sum] = "3c95f036d8ba58259f80e097dad61a6f856b62aa1096eab3f271db9b533559cb"

URI_x86_64_v2_csmock-plugin-strace = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-strace-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-strace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-strace}"
SRC_URI[x86_64_v2_csmock-plugin-strace.sha256sum] = "5e18460a4b553e507a4a13de85d3013a428d16ec4d617e4c1d35a9c9fb5aa73d"

URI_x86_64_v2_csmock-plugin-symbiotic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-symbiotic-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-symbiotic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-symbiotic}"
SRC_URI[x86_64_v2_csmock-plugin-symbiotic.sha256sum] = "906cc854814d2673e1f19ca2149303854f507ba5b74aa46b6028e1ebe17e1cfc"

URI_x86_64_v2_csmock-plugin-unicontrol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-unicontrol-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-unicontrol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-unicontrol}"
SRC_URI[x86_64_v2_csmock-plugin-unicontrol.sha256sum] = "3b171a6c5cc3fa0689758e53202640266b88c0f358fe97152079585206b93eb3"

URI_x86_64_v2_csmock-plugin-valgrind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-valgrind-3.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-valgrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-valgrind}"
SRC_URI[x86_64_v2_csmock-plugin-valgrind.sha256sum] = "a07ad9264e8e640ba17ffbb56ae7b16747260005d9abf3975f56cda00d858c31"

URI_aarch64_csbuild = "${EPEL_MIRROR}/aarch64/Packages/c/csbuild-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csbuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_csbuild}"
SRC_URI[aarch64_csbuild.sha256sum] = "9eb9bddae02b977d9b12db3c43f551294a26401575300c0b0895d01e16c8397f"

URI_aarch64_csmock = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock}"
SRC_URI[aarch64_csmock.sha256sum] = "6988710405729244ecb877b2584be93420f2f21e0c0f576161b84420a0a4c9b6"

URI_aarch64_csmock-common = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-common-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-common}"
SRC_URI[aarch64_csmock-common.sha256sum] = "0a62837d8fc5f70bf03d0c6c5d39a3948b5ea1bc0da20ad1d2809490d02224d3"

URI_aarch64_csmock-plugin-bandit = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-bandit-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-bandit;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-bandit}"
SRC_URI[aarch64_csmock-plugin-bandit.sha256sum] = "5282dd83b1a769ec543fc00814768e2888e431ade28faf646bdb7cf9e7d1ea1e"

URI_aarch64_csmock-plugin-cbmc = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-cbmc-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-cbmc;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-cbmc}"
SRC_URI[aarch64_csmock-plugin-cbmc.sha256sum] = "4ab6f571e9665f77559ccd03b0e1f7d9ce137d1f0d0587dc3818667c5dee3023"

URI_aarch64_csmock-plugin-clang = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-clang-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-clang}"
SRC_URI[aarch64_csmock-plugin-clang.sha256sum] = "cc7781ffcb28777b299cd2c7bd74015573a102d72e6271eaad877b61289a7a80"

URI_aarch64_csmock-plugin-clippy = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-clippy-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-clippy;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-clippy}"
SRC_URI[aarch64_csmock-plugin-clippy.sha256sum] = "6626d70b33570031cb4a507d8dbb6a4287ef2fe513f9a26d02ab596cc61116de"

URI_aarch64_csmock-plugin-cppcheck = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-cppcheck-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-cppcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-cppcheck}"
SRC_URI[aarch64_csmock-plugin-cppcheck.sha256sum] = "4f22792f590c9c89c728b8fcbecf5c1a4a5774b47afbd602bd6b83fafd180329"

URI_aarch64_csmock-plugin-divine = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-divine-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-divine;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-divine}"
SRC_URI[aarch64_csmock-plugin-divine.sha256sum] = "5eb2bb03549ebf22a36d9ef9e416cf160e7cb42dfd3f956d49cd9cde5c15e98f"

URI_aarch64_csmock-plugin-gitleaks = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-gitleaks-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-gitleaks;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-gitleaks}"
SRC_URI[aarch64_csmock-plugin-gitleaks.sha256sum] = "0c89d9258b1c5c18c22faf2738a40b6664984525be473ec0fd29687e1f29bb45"

URI_aarch64_csmock-plugin-infer = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-infer-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-infer;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-infer}"
SRC_URI[aarch64_csmock-plugin-infer.sha256sum] = "3e38bb971d45ea1936097ede5c999fc2a43e754a0d1ec6dd5c7d90bd95ad4e12"

URI_aarch64_csmock-plugin-pylint = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-pylint-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-pylint;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-pylint}"
SRC_URI[aarch64_csmock-plugin-pylint.sha256sum] = "5535812dfa14cabdd5b7ee28459c06d8ae4a43a9e539f85918729c5f2435857e"

URI_aarch64_csmock-plugin-semgrep = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-semgrep-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-semgrep;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-semgrep}"
SRC_URI[aarch64_csmock-plugin-semgrep.sha256sum] = "4db6d6f3d224839ebcb922b7e2ac9194c2b546de780a37a77f5786eef397c5b0"

URI_aarch64_csmock-plugin-shellcheck = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-shellcheck-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-shellcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-shellcheck}"
SRC_URI[aarch64_csmock-plugin-shellcheck.sha256sum] = "eb614be486f7c5d687e8e93785fb60021daaef03647ca1224c23743a953cc646"

URI_aarch64_csmock-plugin-shellcheck-core = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-shellcheck-core-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-shellcheck-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-shellcheck-core}"
SRC_URI[aarch64_csmock-plugin-shellcheck-core.sha256sum] = "72e9d066c5d7b718bbca49e912ad57f1468915ac0741b5282781b58066fe74f3"

URI_aarch64_csmock-plugin-smatch = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-smatch-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-smatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-smatch}"
SRC_URI[aarch64_csmock-plugin-smatch.sha256sum] = "ccb53bc13cb9ebcb628ca18d49b94d20a43cc67bbb13171cfe8ce581538ed715"

URI_aarch64_csmock-plugin-snyk = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-snyk-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-snyk;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-snyk}"
SRC_URI[aarch64_csmock-plugin-snyk.sha256sum] = "f5a3ff984911db6e06e80c948e9356facbe086d7229784eed8cb8a5e02ed7d73"

URI_aarch64_csmock-plugin-strace = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-strace-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-strace;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-strace}"
SRC_URI[aarch64_csmock-plugin-strace.sha256sum] = "782357c75cb1c13fdb7d7804d1742cf8925fde02aecd5264a0a6a2f20dc9fdfe"

URI_aarch64_csmock-plugin-symbiotic = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-symbiotic-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-symbiotic;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-symbiotic}"
SRC_URI[aarch64_csmock-plugin-symbiotic.sha256sum] = "fa4d696d9861fdd8b80c32f56538b2e094d75d81db8ddc7ec2fd25b8bf2ecb46"

URI_aarch64_csmock-plugin-unicontrol = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-unicontrol-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-unicontrol;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-unicontrol}"
SRC_URI[aarch64_csmock-plugin-unicontrol.sha256sum] = "a570f5967bd0da68567100976e6dddc1825ddb8bddd1757e17d0a98c7f69865d"

URI_aarch64_csmock-plugin-valgrind = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-valgrind-3.8.7-1.el10_3.noarch.rpm;name=aarch64_csmock-plugin-valgrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-valgrind}"
SRC_URI[aarch64_csmock-plugin-valgrind.sha256sum] = "1e904ba27561955ffa9011181fd689b768d128bf20777e3a51a3a87bf22fc839"

RDEPENDS:csbuild = " \
 bash \
 csclng \
 cscppc \
 csdiff \
 csmock-common \
 cswrap \
 python3 \
 python3-GitPython \
 "
RDEPENDS:csmock = " \
 csmock-common \
 csmock-plugin-clang \
 csmock-plugin-cppcheck \
 csmock-plugin-gitleaks \
 csmock-plugin-shellcheck \
 "
RDEPENDS:csmock-common = " \
 bash \
 csdiff \
 csdiff-static \
 csgcca \
 cswrap \
 mock \
 python3 \
 tar \
 xz \
 "
RDEPENDS:csmock-plugin-bandit = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-cbmc = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-clang = " \
 csclng \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-clippy = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-cppcheck = " \
 cscppc \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-divine = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-gitleaks = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-infer = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-pylint = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-semgrep = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-shellcheck = " \
 csmock-common \
 csmock-plugin-shellcheck-core \
 python3 \
 "
RDEPENDS:csmock-plugin-shellcheck-core = " \
 bash \
 "
RDEPENDS:csmock-plugin-smatch = " \
 csmatch \
 csmock-common \
 cswrap \
 python3 \
 "
RDEPENDS:csmock-plugin-snyk = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-strace = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-symbiotic = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-unicontrol = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-valgrind = " \
 csexec \
 csmock-common \
 python3 \
 "
