# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trustfall_rustdoc"
PV = "0.41.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-trustfall_rustdoc+default-devel \
 rust-trustfall_rustdoc+rayon-devel \
 rust-trustfall_rustdoc+rustc-hash-devel \
 rust-trustfall_rustdoc+v57-devel \
 rust-trustfall_rustdoc+v60-devel \
 rust-trustfall_rustdoc+v61-devel \
 rust-trustfall_rustdoc-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-trustfall_rustdoc-0.41.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "de900d2cc0a499828d93b7f251000f844a7b5a381abd804a6498f7cc3d8f21b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall_rustdoc+default-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall_rustdoc+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall_rustdoc+default-devel.sha256sum] = "80b21e9a4b7aaec0149105fba3787b9f3903762e58d8d7cce8b467c3474840be"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall_rustdoc+rayon-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall_rustdoc+rayon-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall_rustdoc+rayon-devel.sha256sum] = "68e1a376e3a9b6ab5a19c4144ca1b05b0a5363388c2689211e3107305030aeb7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall_rustdoc+rustc-hash-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall_rustdoc+rustc-hash-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall_rustdoc+rustc-hash-devel.sha256sum] = "635e6fcc3910d9ef1fc3f9cced6a85fcf06a0b67f3a2466a2d8c31bc1a3ad9b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall_rustdoc+v57-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall_rustdoc+v57-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall_rustdoc+v57-devel.sha256sum] = "6c700432cca5c15b05f26fbf40c7223726ee41c64f87ed8c0a8c67b8e50b5745"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall_rustdoc+v60-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall_rustdoc+v60-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall_rustdoc+v60-devel.sha256sum] = "ff449153b740da4de467e9f9702c737a5e0958709de7ebd088b604a1c1fde30e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall_rustdoc+v61-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall_rustdoc+v61-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall_rustdoc+v61-devel.sha256sum] = "db95de0a2c88ba0d45fd986ae3686d02bfc8f3fd143a9dca02cb673ad9c63d0f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall_rustdoc-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall_rustdoc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall_rustdoc-devel.sha256sum] = "8f71445d780914504a429d24584b6e0b7bb24c0fe2599ba3e8084aaab0857eab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall_rustdoc+default-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall_rustdoc+default-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall_rustdoc+default-devel.sha256sum] = "6eca629990682a25f736de5c2f58aff64e679ae08897e980cb228d3344c22b28"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall_rustdoc+rayon-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall_rustdoc+rayon-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall_rustdoc+rayon-devel.sha256sum] = "7907b38d8b394f44550460600f13aa36fe8a86a98e1a399277499aa72a073ea6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall_rustdoc+rustc-hash-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall_rustdoc+rustc-hash-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall_rustdoc+rustc-hash-devel.sha256sum] = "20192d614804ba2dac2c89a6eee3d8a91cceed1ee03061f8da723211082e9212"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall_rustdoc+v57-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall_rustdoc+v57-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall_rustdoc+v57-devel.sha256sum] = "444d7c1078f3db5c8dcdae4bd47dd74b0e0fe095c96328db974f5d0efbdecdee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall_rustdoc+v60-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall_rustdoc+v60-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall_rustdoc+v60-devel.sha256sum] = "33ee2ea1e2b664de60ddd464bf6da7eb19780575e762d056c75081377f797483"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall_rustdoc+v61-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall_rustdoc+v61-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall_rustdoc+v61-devel.sha256sum] = "2746720239707a63b3ea7cd72c3a5895ab787f1dbe535c6909dd0a625af99a3e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall_rustdoc-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall_rustdoc-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall_rustdoc-devel.sha256sum] = "01fae97b76d4cab96793b55403199e1fbb0d183f4be9894f2581fd5c4ac35a32"

RDEPENDS:rust-trustfall_rustdoc+default-devel = " \
 cargo \
 rust-trustfall_rustdoc+v57-devel \
 rust-trustfall_rustdoc+v60-devel \
 rust-trustfall_rustdoc+v61-devel \
 rust-trustfall_rustdoc-devel \
 "
RDEPENDS:rust-trustfall_rustdoc+rayon-devel = " \
 cargo \
 rust-trustfall-rustdoc-adapter+default-devel \
 rust-trustfall-rustdoc-adapter+rayon-devel \
 rust-trustfall-rustdoc-adapter57+default-devel \
 rust-trustfall-rustdoc-adapter57+rayon-devel \
 rust-trustfall-rustdoc-adapter60+default-devel \
 rust-trustfall-rustdoc-adapter60+rayon-devel \
 rust-trustfall_rustdoc-devel \
 "
RDEPENDS:rust-trustfall_rustdoc+rustc-hash-devel = " \
 cargo \
 rust-trustfall-rustdoc-adapter+default-devel \
 rust-trustfall-rustdoc-adapter+rustc-hash-devel \
 rust-trustfall-rustdoc-adapter57+default-devel \
 rust-trustfall-rustdoc-adapter57+rustc-hash-devel \
 rust-trustfall-rustdoc-adapter60+default-devel \
 rust-trustfall-rustdoc-adapter60+rustc-hash-devel \
 rust-trustfall_rustdoc-devel \
 "
RDEPENDS:rust-trustfall_rustdoc+v57-devel = " \
 cargo \
 rust-trustfall-rustdoc-adapter57+default-devel \
 rust-trustfall_rustdoc-devel \
 "
RDEPENDS:rust-trustfall_rustdoc+v60-devel = " \
 cargo \
 rust-trustfall-rustdoc-adapter60+default-devel \
 rust-trustfall_rustdoc-devel \
 "
RDEPENDS:rust-trustfall_rustdoc+v61-devel = " \
 cargo \
 rust-trustfall-rustdoc-adapter+default-devel \
 rust-trustfall_rustdoc-devel \
 "
RDEPENDS:rust-trustfall_rustdoc-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-cargo_metadata+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 rust-trustfall+default-devel \
 rust-trustfall_core+default-devel \
 "
