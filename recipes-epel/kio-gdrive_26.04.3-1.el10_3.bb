# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kio-gdrive"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kio-gdrive \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kio-gdrive-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30cea6021ccdc86811d510482c50eaf9000ae433d96b0a65d36c32308747275f"

URI_x86_64_v2_kio-gdrive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-gdrive-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-gdrive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-gdrive}"
SRC_URI[x86_64_v2_kio-gdrive.sha256sum] = "32808bf8ee8c7ffb366d6fb8b860a50903c7dbc5fd34356fc4e94d86d2eae9f1"

URI_aarch64_kio-gdrive = "${EPEL_MIRROR}/aarch64/Packages/k/kio-gdrive-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kio-gdrive;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-gdrive}"
SRC_URI[aarch64_kio-gdrive.sha256sum] = "1fb6b4a31b0c204166b2ae74684c2e2d9cacd46edb84c61a218ed57c41105e7f"

RDEPENDS:kio-gdrive = " \
 accounts-qml-module-qt6 \
 glibc \
 kaccounts-integration-qt6 \
 kaccounts-providers \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-purpose \
 libaccounts-qt6 \
 libkgapi \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
