# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netcat"
PV = "1.229"
PR = "1.el10_0"
PACKAGES = " \
 netcat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netcat-1.229-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53186f86b0ac9d9fa73377fa06af015d37603080b758634a7fab067f78eed49b"

URI_x86_64_v2_netcat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcat-1.229-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcat}"
SRC_URI[x86_64_v2_netcat.sha256sum] = "0ae09979fb7c64ab4bf86902164252a7cada17508de53e5cd9472d7c924abc3b"

URI_aarch64_netcat = "${EPEL_MIRROR}/aarch64/Packages/n/netcat-1.229-1.el10_0.aarch64.rpm;name=aarch64_netcat;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcat}"
SRC_URI[aarch64_netcat.sha256sum] = "dd0e10322a8065549fdc903f55020087aa9dedcce0e8155ccee0e7a1dcfe8caf"

RDEPENDS:netcat = " \
 alternatives \
 bash \
 glibc \
 libbsd \
 libretls \
 "
