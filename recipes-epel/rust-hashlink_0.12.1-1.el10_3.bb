# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashlink"
PV = "0.12.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-hashlink+default-devel \
 rust-hashlink+serde-devel \
 rust-hashlink+serde_impl-devel \
 rust-hashlink-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hashlink-0.12.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b3827ab4639d0bfd0eef8efa5e23801ffe03185eb07da5c0f5e0dda8f73308e"

URI_x86_64_v2_rust-hashlink+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink+default-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink+default-devel}"
SRC_URI[x86_64_v2_rust-hashlink+default-devel.sha256sum] = "0e13d4dda6cbf50b1045a5242d8c14d0cc2ca37c1b2e30ba1e40f8ab46a2cc96"

URI_x86_64_v2_rust-hashlink+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink+serde-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink+serde-devel}"
SRC_URI[x86_64_v2_rust-hashlink+serde-devel.sha256sum] = "78fed85ba88dec52a7fcbe557624a1078efbb7f3de1a51d2876b596e12089000"

URI_x86_64_v2_rust-hashlink+serde_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink+serde_impl-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink+serde_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink+serde_impl-devel}"
SRC_URI[x86_64_v2_rust-hashlink+serde_impl-devel.sha256sum] = "9eecf95746445b9bb60223fd44826cd60f69d23bac26f9914c9b318cdbbf474f"

URI_x86_64_v2_rust-hashlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink-devel}"
SRC_URI[x86_64_v2_rust-hashlink-devel.sha256sum] = "64b34e5f78e0f4d0329e53ef94769c8cdfb7d216080e09c74337c56f456b7009"

URI_aarch64_rust-hashlink+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink+default-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashlink+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink+default-devel}"
SRC_URI[aarch64_rust-hashlink+default-devel.sha256sum] = "7f61f7650e1870c0abc54a6489ee42cc95f57da6e06d7c7a6f8d10fc3b364992"

URI_aarch64_rust-hashlink+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink+serde-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashlink+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink+serde-devel}"
SRC_URI[aarch64_rust-hashlink+serde-devel.sha256sum] = "49fdccb6ec63a353e2c93779371f57699f27dd14a6cc1e3dfdba5d5c1646cee8"

URI_aarch64_rust-hashlink+serde_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink+serde_impl-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashlink+serde_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink+serde_impl-devel}"
SRC_URI[aarch64_rust-hashlink+serde_impl-devel.sha256sum] = "b20da62cf660de36d8d5ed6757cf54a318d5f13ef1272b81115e7821d4315f36"

URI_aarch64_rust-hashlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink-devel}"
SRC_URI[aarch64_rust-hashlink-devel.sha256sum] = "47c6668dc3df39a17d77195c759bd6293a331bb078e9f2d2c8450bf189b09187"

RDEPENDS:rust-hashlink+default-devel = " \
 cargo \
 rust-hashlink-devel \
 "
RDEPENDS:rust-hashlink+serde-devel = " \
 cargo \
 rust-hashlink-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-hashlink+serde_impl-devel = " \
 cargo \
 rust-hashlink+serde-devel \
 rust-hashlink-devel \
 "
RDEPENDS:rust-hashlink-devel = " \
 cargo \
 rust \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown-devel \
 "
