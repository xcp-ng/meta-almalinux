# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures"
PV = "0.3.34"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures+alloc-devel \
 rust-futures+async-await-devel \
 rust-futures+bilock-devel \
 rust-futures+cfg-target-has-atomic-devel \
 rust-futures+default-devel \
 rust-futures+executor-devel \
 rust-futures+futures-executor-devel \
 rust-futures+spin-devel \
 rust-futures+std-devel \
 rust-futures+thread-pool-devel \
 rust-futures+unstable-devel \
 rust-futures+write-all-vectored-devel \
 rust-futures-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-futures-0.3.34-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "26965741c059592f90365ce88ff11c29373b49945bcd1ade56c01d96ba772e8a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+alloc-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures+alloc-devel.sha256sum] = "9ef7e637684a558405661ed8b849620f16f76c146a8135f1188de4cb41e4d2f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+async-await-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+async-await-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures+async-await-devel.sha256sum] = "df2f9d287e577f55593eb0b6ca917cf636f160afbb996e341f9c8a8a5998b46b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+bilock-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+bilock-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures+bilock-devel.sha256sum] = "1a9e6490e10ceda5ca39cf7bd290a977067d58b8d0bbb1e1ddc480d678bdbb58"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+cfg-target-has-atomic-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+cfg-target-has-atomic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures+cfg-target-has-atomic-devel.sha256sum] = "769cbba8bfadd96d72147094b893beb3740aec7f918c50535fd1256ea3524228"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+default-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures+default-devel.sha256sum] = "ba4763af3fcb55c50ce8e5fc2ba289347e45760b0df28df970a0a0087452f3e6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+executor-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+executor-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures+executor-devel.sha256sum] = "da7f6d356183522a86078843769738008dd4fcaa2f0cf053bb158c4d111110bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+futures-executor-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+futures-executor-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures+futures-executor-devel.sha256sum] = "a08646b7af51859e0b004e4116e15d68b49ef4f6f59dd7c144b0761673ad090c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+spin-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+spin-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures+spin-devel.sha256sum] = "3412eaf182491245cad5157c81d6cfaa9b7a7b96956485122c6032d8a1752520"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+std-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures+std-devel.sha256sum] = "0cc27820f6ef58e45606c9dc24969eb12bdf2d63c643c13355093699669adc54"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+thread-pool-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+thread-pool-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures+thread-pool-devel.sha256sum] = "c2a22261019161019409ab995afd96510594dbf679fe7012f50a49853e29eb9a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+unstable-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+unstable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures+unstable-devel.sha256sum] = "f1383a87b54ca60d9dced728d15f7009c8cb332ee09fe88d2cd1f5b57e4c2e20"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+write-all-vectored-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+write-all-vectored-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures+write-all-vectored-devel.sha256sum] = "e4d631745c5ed6e594a152fd4e71bd30b69f7eb385102f1bac8171c4493a103a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-devel.sha256sum] = "16d1f1bf0a0041a263412d844006d579be0a217ce531429f6dec6f4e6209157e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+alloc-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-futures+alloc-devel.sha256sum] = "edf48d650472009f9fc256afec7596183006b57018a22f60c1a6608ce7a4e6e3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+async-await-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures+async-await-devel;unpack=0"
SRC_URI[aarch64_rust-futures+async-await-devel.sha256sum] = "eaa489a276ff4253cd877162837079fb66f7d58004e2dc487908452892dfc2f3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+bilock-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures+bilock-devel;unpack=0"
SRC_URI[aarch64_rust-futures+bilock-devel.sha256sum] = "4e9b5a23152c7bc1dee7f5b2fac79321b4d01c5a53cd19c3b93f147df871b7c9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+cfg-target-has-atomic-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures+cfg-target-has-atomic-devel;unpack=0"
SRC_URI[aarch64_rust-futures+cfg-target-has-atomic-devel.sha256sum] = "ce8b8109635abac498a7638cc94585a0d27215147f385a47a9061a7099752460"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+default-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures+default-devel;unpack=0"
SRC_URI[aarch64_rust-futures+default-devel.sha256sum] = "cba078ffc486eed950dfd42fa293870f6574d2050b17549f8ad8687f0219036e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+executor-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures+executor-devel;unpack=0"
SRC_URI[aarch64_rust-futures+executor-devel.sha256sum] = "20b0aa76d7c1b838ff32091148141d7265c6a16d17e474a76aadb018a9e26e6f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+futures-executor-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures+futures-executor-devel;unpack=0"
SRC_URI[aarch64_rust-futures+futures-executor-devel.sha256sum] = "844b81ea7d11438fce01c728f0e6b29c0f8a72812488102bd8d2136337bf6c8e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+spin-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures+spin-devel;unpack=0"
SRC_URI[aarch64_rust-futures+spin-devel.sha256sum] = "753adedcdd854b94b3bbf65b7f3545a658eac96cd7278c1f3df808829530edb6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+std-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures+std-devel;unpack=0"
SRC_URI[aarch64_rust-futures+std-devel.sha256sum] = "a4285f35de2deb9d31f94e7994aa8e06015aba83296192364f920573ad6bec5f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+thread-pool-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures+thread-pool-devel;unpack=0"
SRC_URI[aarch64_rust-futures+thread-pool-devel.sha256sum] = "4d0f80c39b5150a8def6336a8dbf42bfe92bc9354df2880f884bd70bcca95fe8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+unstable-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures+unstable-devel;unpack=0"
SRC_URI[aarch64_rust-futures+unstable-devel.sha256sum] = "4bf2bd7b51dc692c921b5e7594a902d0e279423c3c66337782cc1078fcaa687f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+write-all-vectored-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures+write-all-vectored-devel;unpack=0"
SRC_URI[aarch64_rust-futures+write-all-vectored-devel.sha256sum] = "82f0fd0775235584cb2146509134285aba778d461135c92a67ddd1c63b9e7e5f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-devel;unpack=0"
SRC_URI[aarch64_rust-futures-devel.sha256sum] = "06f46ef23f766c3358cf45898c2121939508b8805ecad4227fd4b54a44e30173"

RDEPENDS:rust-futures+alloc-devel = " \
 cargo \
 rust-futures-channel+alloc-devel \
 rust-futures-core+alloc-devel \
 rust-futures-devel \
 rust-futures-sink+alloc-devel \
 rust-futures-task+alloc-devel \
 rust-futures-util+alloc-devel \
 "
RDEPENDS:rust-futures+async-await-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-util+async-await-devel \
 rust-futures-util+async-await-macro-devel \
 "
RDEPENDS:rust-futures+bilock-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-util+bilock-devel \
 "
RDEPENDS:rust-futures+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-devel \
 "
RDEPENDS:rust-futures+default-devel = " \
 cargo \
 rust-futures+async-await-devel \
 rust-futures+executor-devel \
 rust-futures+std-devel \
 rust-futures-devel \
 "
RDEPENDS:rust-futures+executor-devel = " \
 cargo \
 rust-futures+std-devel \
 rust-futures-devel \
 rust-futures-executor+std-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures+futures-executor-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures+spin-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-util+spin-devel \
 "
RDEPENDS:rust-futures+std-devel = " \
 cargo \
 rust-futures+alloc-devel \
 rust-futures-core+std-devel \
 rust-futures-devel \
 rust-futures-io+std-devel \
 rust-futures-sink+std-devel \
 rust-futures-task+std-devel \
 rust-futures-util+channel-devel \
 rust-futures-util+io-devel \
 rust-futures-util+std-devel \
 "
RDEPENDS:rust-futures+thread-pool-devel = " \
 cargo \
 rust-futures+executor-devel \
 rust-futures-devel \
 rust-futures-executor+thread-pool-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures+unstable-devel = " \
 cargo \
 rust-futures-channel+unstable-devel \
 rust-futures-core+unstable-devel \
 rust-futures-devel \
 rust-futures-io+unstable-devel \
 rust-futures-task+unstable-devel \
 rust-futures-util+unstable-devel \
 "
RDEPENDS:rust-futures+write-all-vectored-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-util+write-all-vectored-devel \
 "
RDEPENDS:rust-futures-devel = " \
 cargo \
 rust \
 rust-futures-channel+sink-devel \
 rust-futures-channel-devel \
 rust-futures-core-devel \
 rust-futures-io-devel \
 rust-futures-sink-devel \
 rust-futures-task-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 "
