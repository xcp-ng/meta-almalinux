# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cbindgen"
PV = "0.29.4"
PR = "1.el10_2"
PACKAGES = " \
 cbindgen \
 rust-cbindgen+clap-devel \
 rust-cbindgen+default-devel \
 rust-cbindgen+unstable_ir-devel \
 rust-cbindgen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cbindgen-0.29.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94b0223b3d0d8be0a353087661dc6e293c5a8d53a8340d8067b3c9e817aad2dd"

URI_x86_64_v2_cbindgen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cbindgen-0.29.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cbindgen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cbindgen}"
SRC_URI[x86_64_v2_cbindgen.sha256sum] = "01db1ac83f1e58c60d18cf61ee3bb02215d0d57c5d31e8f9e81c4cc09faa6c5c"

URI_x86_64_v2_rust-cbindgen+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbindgen+clap-devel-0.29.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbindgen+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbindgen+clap-devel}"
SRC_URI[x86_64_v2_rust-cbindgen+clap-devel.sha256sum] = "a1739d0f99a1426204f2ad98f0aab170f19eaeb04f2f69f44f31e77a596c6038"

URI_x86_64_v2_rust-cbindgen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbindgen+default-devel-0.29.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbindgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbindgen+default-devel}"
SRC_URI[x86_64_v2_rust-cbindgen+default-devel.sha256sum] = "5768fef0d8843eebc82328259e163066f7f7761acdccef768cbc59f7b7f80779"

URI_x86_64_v2_rust-cbindgen+unstable_ir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbindgen+unstable_ir-devel-0.29.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbindgen+unstable_ir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbindgen+unstable_ir-devel}"
SRC_URI[x86_64_v2_rust-cbindgen+unstable_ir-devel.sha256sum] = "e1985a639f2fbcd8d1b3f2ea080ccfb67f43b588056524e832557331607d633c"

URI_x86_64_v2_rust-cbindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbindgen-devel-0.29.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbindgen-devel}"
SRC_URI[x86_64_v2_rust-cbindgen-devel.sha256sum] = "0d7fdb531b8236f8548cca019047a2ee1478f9a6773a9bd4477ed39dba69b84e"

URI_aarch64_cbindgen = "${EPEL_MIRROR}/aarch64/Packages/c/cbindgen-0.29.4-1.el10_2.aarch64.rpm;name=aarch64_cbindgen;unpack=0"
SRC_URI:append = " ${URI_aarch64_cbindgen}"
SRC_URI[aarch64_cbindgen.sha256sum] = "758a823c85a12687a638b4b799df24932da10d72566b4aa15e8281ba4870c818"

URI_aarch64_rust-cbindgen+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbindgen+clap-devel-0.29.4-1.el10_2.noarch.rpm;name=aarch64_rust-cbindgen+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbindgen+clap-devel}"
SRC_URI[aarch64_rust-cbindgen+clap-devel.sha256sum] = "346fe940018a3142dc462bd2c819c97955ad2d764e514092dc5e1aa5d849900d"

URI_aarch64_rust-cbindgen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbindgen+default-devel-0.29.4-1.el10_2.noarch.rpm;name=aarch64_rust-cbindgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbindgen+default-devel}"
SRC_URI[aarch64_rust-cbindgen+default-devel.sha256sum] = "c9e9ef6dcbdca3b122049600d35a208259146d645e29c9f5630321a2850f9fcd"

URI_aarch64_rust-cbindgen+unstable_ir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbindgen+unstable_ir-devel-0.29.4-1.el10_2.noarch.rpm;name=aarch64_rust-cbindgen+unstable_ir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbindgen+unstable_ir-devel}"
SRC_URI[aarch64_rust-cbindgen+unstable_ir-devel.sha256sum] = "5cc354aecd7f48b960ae8f66bffb9d7a6e146b58800ceade8dce0ec7fc81d056"

URI_aarch64_rust-cbindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbindgen-devel-0.29.4-1.el10_2.noarch.rpm;name=aarch64_rust-cbindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbindgen-devel}"
SRC_URI[aarch64_rust-cbindgen-devel.sha256sum] = "7dd5b567cd0ee022119668db12b7356a93336554b6b98c530eee20a77f6089ef"

RDEPENDS:cbindgen = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-cbindgen+clap-devel = " \
 cargo \
 rust-cbindgen-devel \
 rust-clap+default-devel \
 "
RDEPENDS:rust-cbindgen+default-devel = " \
 cargo \
 rust-cbindgen+clap-devel \
 rust-cbindgen-devel \
 "
RDEPENDS:rust-cbindgen+unstable_ir-devel = " \
 cargo \
 rust-cbindgen-devel \
 "
RDEPENDS:rust-cbindgen-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-indexmap+default-devel \
 rust-log+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-serde_json+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+extra-traits-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 rust-tempfile+default-devel \
 rust-toml0.9+parse-devel \
 rust-toml0.9+serde-devel \
 rust-toml0.9+std-devel \
 rust-toml0.9-devel \
 "
