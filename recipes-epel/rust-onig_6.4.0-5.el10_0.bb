# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onig"
PV = "6.4.0"
PR = "5.el10_0"
PACKAGES = " \
 rust-onig+default-devel \
 rust-onig+generate-devel \
 rust-onig+posix-api-devel \
 rust-onig+print-debug-devel \
 rust-onig+std-pattern-devel \
 rust-onig-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onig-6.4.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2e5cfdc75e359006224f170019716a718749d3e8955fa276bbe2dbd477ab27d"

URI_x86_64_v2_rust-onig+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig+default-devel-6.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig+default-devel}"
SRC_URI[x86_64_v2_rust-onig+default-devel.sha256sum] = "b4486363e9493aa8565f76d1ee7913639cb634e56fdd427a081d5c3faee71ef6"

URI_x86_64_v2_rust-onig+generate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig+generate-devel-6.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig+generate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig+generate-devel}"
SRC_URI[x86_64_v2_rust-onig+generate-devel.sha256sum] = "41e1f46bd256021b37ad08e4758da579fadeebb5dabf504188a7809ee16a473d"

URI_x86_64_v2_rust-onig+posix-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig+posix-api-devel-6.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig+posix-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig+posix-api-devel}"
SRC_URI[x86_64_v2_rust-onig+posix-api-devel.sha256sum] = "538064749c22c4512a806c05d1b76005015229da82bc8e6db04eadc1d4c2b920"

URI_x86_64_v2_rust-onig+print-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig+print-debug-devel-6.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig+print-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig+print-debug-devel}"
SRC_URI[x86_64_v2_rust-onig+print-debug-devel.sha256sum] = "932111d9c1a7aa31a9c85fe715031d31f880557b15f629580ede10818c69a9c8"

URI_x86_64_v2_rust-onig+std-pattern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig+std-pattern-devel-6.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig+std-pattern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig+std-pattern-devel}"
SRC_URI[x86_64_v2_rust-onig+std-pattern-devel.sha256sum] = "0cee924ba70b50e72fbacc56284119c77b396ece7d860c346e347853a4f40bea"

URI_x86_64_v2_rust-onig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig-devel-6.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig-devel}"
SRC_URI[x86_64_v2_rust-onig-devel.sha256sum] = "54de58dcd892f5ce0e63ac521cbbd0e7109cf09a1c00b85fef6cc3515d76bdbe"

URI_aarch64_rust-onig+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig+default-devel-6.4.0-5.el10_0.noarch.rpm;name=aarch64_rust-onig+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig+default-devel}"
SRC_URI[aarch64_rust-onig+default-devel.sha256sum] = "4ccf477672c977ca70e0828d3807836d5a8d0bdf881b1f326f2208c2ee54be5e"

URI_aarch64_rust-onig+generate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig+generate-devel-6.4.0-5.el10_0.noarch.rpm;name=aarch64_rust-onig+generate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig+generate-devel}"
SRC_URI[aarch64_rust-onig+generate-devel.sha256sum] = "80dcf6f042f43f4fb49cdfad4e495843c30d7a4fcddce56ff1d7ee66615f228f"

URI_aarch64_rust-onig+posix-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig+posix-api-devel-6.4.0-5.el10_0.noarch.rpm;name=aarch64_rust-onig+posix-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig+posix-api-devel}"
SRC_URI[aarch64_rust-onig+posix-api-devel.sha256sum] = "879c0da62e97d04f2bf1b0441fe2f6282dff26e46fdfc5c8359065a054468039"

URI_aarch64_rust-onig+print-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig+print-debug-devel-6.4.0-5.el10_0.noarch.rpm;name=aarch64_rust-onig+print-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig+print-debug-devel}"
SRC_URI[aarch64_rust-onig+print-debug-devel.sha256sum] = "a9766594a5314236b8077e53bd70f2b4098adad700e6fa2a5775d887610d0eea"

URI_aarch64_rust-onig+std-pattern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig+std-pattern-devel-6.4.0-5.el10_0.noarch.rpm;name=aarch64_rust-onig+std-pattern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig+std-pattern-devel}"
SRC_URI[aarch64_rust-onig+std-pattern-devel.sha256sum] = "0448b569d02683cfe9e83e85626f0544b2dc9957c39ddaf34ab002f25bf00976"

URI_aarch64_rust-onig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig-devel-6.4.0-5.el10_0.noarch.rpm;name=aarch64_rust-onig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig-devel}"
SRC_URI[aarch64_rust-onig-devel.sha256sum] = "d76a077bce86eba6990ea6aee05bffe1208089968bc7e5c1ac3f0397dcc428c7"

RDEPENDS:rust-onig+default-devel = " \
 cargo \
 rust-onig+generate-devel \
 rust-onig-devel \
 "
RDEPENDS:rust-onig+generate-devel = " \
 cargo \
 rust-onig-devel \
 rust-onig_sys+generate-devel \
 "
RDEPENDS:rust-onig+posix-api-devel = " \
 cargo \
 rust-onig-devel \
 rust-onig_sys+posix-api-devel \
 "
RDEPENDS:rust-onig+print-debug-devel = " \
 cargo \
 rust-onig-devel \
 rust-onig_sys+print-debug-devel \
 "
RDEPENDS:rust-onig+std-pattern-devel = " \
 cargo \
 rust-onig-devel \
 "
RDEPENDS:rust-onig-devel = " \
 cargo \
 rust-bitflags1+default-devel \
 rust-once_cell+default-devel \
 rust-onig_sys-devel \
 "
