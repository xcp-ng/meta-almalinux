# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-connections"
PV = "47.2.1"
PR = "7.el10"
PACKAGES = " \
 gnome-connections \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-connections-47.2.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "769109301f264308510e1242f7276df8f3a7cc91107cd8dab5f22299fb6205c7"

URI_x86_64_v2_gnome-connections = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-connections-47.2.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-connections;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-connections}"
SRC_URI[x86_64_v2_gnome-connections.sha256sum] = "1941a1bad04ac46813dcb81363db2ef4ec766ddcfb3880812a5abd1b1df8b557"

URI_aarch64_gnome-connections = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-connections-47.2.1-7.el10.aarch64.rpm;name=aarch64_gnome-connections;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-connections}"
SRC_URI[aarch64_gnome-connections.sha256sum] = "dfe4bba8e424e9b6fe1ab0a6d208a94f85cfb60942f88622dbe253e15ca90104"

RDEPENDS:gnome-connections = " \
 cairo \
 freerdp-libs \
 fuse3-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk-vnc2 \
 gtk3 \
 gvnc \
 gvncpulse \
 hicolor-icon-theme \
 libhandy \
 libsecret \
 libwinpr \
 libxml2 \
 "
