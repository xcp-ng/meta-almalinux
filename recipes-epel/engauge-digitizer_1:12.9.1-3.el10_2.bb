# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "engauge-digitizer"
PE = "1"
PV = "12.9.1"
PR = "3.el10_2"
PACKAGES = " \
 engauge-digitizer \
 engauge-digitizer-doc \
 engauge-digitizer-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/engauge-digitizer-12.9.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2906948c6cb3b9882e3ddf92151b75c6bac79544a8dd8ac3ea1a9494671820c3"

URI_x86_64_v2_engauge-digitizer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/engauge-digitizer-12.9.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_engauge-digitizer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_engauge-digitizer}"
SRC_URI[x86_64_v2_engauge-digitizer.sha256sum] = "e55b6b036d44ae5fd686b7a933e5bd6e0f4bac9103de20a5afbcbfb6fc70aa1c"

URI_x86_64_v2_engauge-digitizer-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/engauge-digitizer-doc-12.9.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_engauge-digitizer-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_engauge-digitizer-doc}"
SRC_URI[x86_64_v2_engauge-digitizer-doc.sha256sum] = "fd9f0132c1ea78e153cf5d10f4cd587f0149adf718aaa7f8523195899db21098"

URI_x86_64_v2_engauge-digitizer-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/engauge-digitizer-samples-12.9.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_engauge-digitizer-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_engauge-digitizer-samples}"
SRC_URI[x86_64_v2_engauge-digitizer-samples.sha256sum] = "dd0c6ce60ce8f0059ad8504a8a8c82c8c8e1cb25d3765b37f08904580c8a627d"

URI_aarch64_engauge-digitizer = "${EPEL_MIRROR}/aarch64/Packages/e/engauge-digitizer-12.9.1-3.el10_2.aarch64.rpm;name=aarch64_engauge-digitizer;unpack=0"
SRC_URI:append = " ${URI_aarch64_engauge-digitizer}"
SRC_URI[aarch64_engauge-digitizer.sha256sum] = "33fdf979dd2fbbfbe42d23e09b2ff21109e9705f7a58562773cfa63843abce03"

URI_aarch64_engauge-digitizer-doc = "${EPEL_MIRROR}/aarch64/Packages/e/engauge-digitizer-doc-12.9.1-3.el10_2.noarch.rpm;name=aarch64_engauge-digitizer-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_engauge-digitizer-doc}"
SRC_URI[aarch64_engauge-digitizer-doc.sha256sum] = "53dc7a9b34d7f044b04100d397c563381320c4bf89f6e6318173e3dd06f757db"

URI_aarch64_engauge-digitizer-samples = "${EPEL_MIRROR}/aarch64/Packages/e/engauge-digitizer-samples-12.9.1-3.el10_2.aarch64.rpm;name=aarch64_engauge-digitizer-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_engauge-digitizer-samples}"
SRC_URI[aarch64_engauge-digitizer-samples.sha256sum] = "bb658a9173a96712fb8d30ce70b4c05f6602bfe8313d6c8acf774c136be4a1f6"

RDEPENDS:engauge-digitizer = " \
 fftw-libs-double \
 glibc \
 libgcc \
 libstdc++ \
 log4cpp \
 openjpeg2 \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-help \
 "
RDEPENDS:engauge-digitizer-doc = " \
 "
RDEPENDS:engauge-digitizer-samples = " \
 engauge-digitizer \
 "
