# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rkyv0.7"
PV = "0.7.46"
PR = "1.el10_1"
PACKAGES = " \
 rust-rkyv0.7+alloc-devel \
 rust-rkyv0.7+arbitrary_enum_discriminant-devel \
 rust-rkyv0.7+archive_be-devel \
 rust-rkyv0.7+archive_le-devel \
 rust-rkyv0.7+arrayvec-devel \
 rust-rkyv0.7+bytecheck-devel \
 rust-rkyv0.7+copy-devel \
 rust-rkyv0.7+copy_unsafe-devel \
 rust-rkyv0.7+default-devel \
 rust-rkyv0.7+hashbrown-devel \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7+size_16-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+size_64-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7+strict-devel \
 rust-rkyv0.7+validation-devel \
 rust-rkyv0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rkyv0.7-0.7.46-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d66157c60db538220125f6d59cad2617843180a6c94ab472dd3e10b8b6186f4"

URI_x86_64_v2_rust-rkyv0.7+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+alloc-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+alloc-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+alloc-devel.sha256sum] = "01442418e2a102f31a712759c56c3c21c9be81d30d745585f61bf5a5097fd852"

URI_x86_64_v2_rust-rkyv0.7+arbitrary_enum_discriminant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+arbitrary_enum_discriminant-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+arbitrary_enum_discriminant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+arbitrary_enum_discriminant-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+arbitrary_enum_discriminant-devel.sha256sum] = "42e8923314ed30854df878626bb5f95b7050a32b197da3dad042448d6c2743ec"

URI_x86_64_v2_rust-rkyv0.7+archive_be-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+archive_be-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+archive_be-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+archive_be-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+archive_be-devel.sha256sum] = "af6eb0b66a1449d05d186d83565eeaf104d245a03377b5a100c3f4d70b03ccb8"

URI_x86_64_v2_rust-rkyv0.7+archive_le-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+archive_le-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+archive_le-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+archive_le-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+archive_le-devel.sha256sum] = "bc46c98a88aee2dbdd1d30b6b283d529a2b32d12ee2aec640af5308216f256c5"

URI_x86_64_v2_rust-rkyv0.7+arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+arrayvec-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+arrayvec-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+arrayvec-devel.sha256sum] = "953f8bd5d431bd063806a9d7ebc2b1f7c77943371b33b23cb14b91ee4c9d9e48"

URI_x86_64_v2_rust-rkyv0.7+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+bytecheck-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+bytecheck-devel.sha256sum] = "232b7d0a152265a390f9e0126851271162566f7d1c380985fdaecb9799f12598"

URI_x86_64_v2_rust-rkyv0.7+copy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+copy-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+copy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+copy-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+copy-devel.sha256sum] = "d65169dd0cc2a468e5633b646aae0e092d08c536a79c499c7d2b941a073e8796"

URI_x86_64_v2_rust-rkyv0.7+copy_unsafe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+copy_unsafe-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+copy_unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+copy_unsafe-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+copy_unsafe-devel.sha256sum] = "18e85082a96843910f8c87df94b0835e675f5c2ea005ce641bc746fab31784e8"

URI_x86_64_v2_rust-rkyv0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+default-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+default-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+default-devel.sha256sum] = "0168a4d2bddbba7add93c5b0603eb8a616f1f1cdcdc03b83c4a68f32cc8401ef"

URI_x86_64_v2_rust-rkyv0.7+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+hashbrown-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+hashbrown-devel.sha256sum] = "bccfcf642c717c15a75648d666203d0c4905530219f45e2a73519c0205c5d15d"

URI_x86_64_v2_rust-rkyv0.7+rend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+rend-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+rend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+rend-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+rend-devel.sha256sum] = "30ba3636197e825765f1023990c2fff89cf4db1384715b361b1698bdb681e2e1"

URI_x86_64_v2_rust-rkyv0.7+size_16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+size_16-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+size_16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+size_16-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+size_16-devel.sha256sum] = "ab9df26e42d671234677c4ca5daa7f4f0ff5bf571f8c485cbdfd9949cfbf0dd8"

URI_x86_64_v2_rust-rkyv0.7+size_32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+size_32-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+size_32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+size_32-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+size_32-devel.sha256sum] = "46c5c69ae04f6bca1e6d384d2a4c2304cec4145da0d3ad33c331ebf1981a9b66"

URI_x86_64_v2_rust-rkyv0.7+size_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+size_64-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+size_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+size_64-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+size_64-devel.sha256sum] = "6fe36a063220282405a65610ddfd9e6dcd645e8907f29d3a2c8b45a306186dbb"

URI_x86_64_v2_rust-rkyv0.7+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+std-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+std-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+std-devel.sha256sum] = "bfbcf4c3b360967b0133c68bc56613709e880300c4cae977cbed064a7ec41483"

URI_x86_64_v2_rust-rkyv0.7+strict-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+strict-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+strict-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+strict-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+strict-devel.sha256sum] = "284a77e49334d273f7d1d02eb8f3c5b6ab64271a0753c33c6e68a97d96a96a6f"

URI_x86_64_v2_rust-rkyv0.7+validation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+validation-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+validation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+validation-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+validation-devel.sha256sum] = "7438e110384580a108e748c6fab4b0384e160c9be5c46d360c19136ca0b5e775"

URI_x86_64_v2_rust-rkyv0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7-devel.sha256sum] = "a96853a36b4d3aba4c28dd5ff17a9ea53cf12634bbffe77d59b2c79bdbac3dfa"

URI_aarch64_rust-rkyv0.7+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+alloc-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+alloc-devel}"
SRC_URI[aarch64_rust-rkyv0.7+alloc-devel.sha256sum] = "317e9bb3ca1d4db6dd75b5b6646697b4634d5e13cecb6de6e1105bfef2ee04a8"

URI_aarch64_rust-rkyv0.7+arbitrary_enum_discriminant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+arbitrary_enum_discriminant-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+arbitrary_enum_discriminant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+arbitrary_enum_discriminant-devel}"
SRC_URI[aarch64_rust-rkyv0.7+arbitrary_enum_discriminant-devel.sha256sum] = "af7dab938b0677a78df6738cf65b9e151023d494a08764a317faa2f1eedba1ee"

URI_aarch64_rust-rkyv0.7+archive_be-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+archive_be-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+archive_be-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+archive_be-devel}"
SRC_URI[aarch64_rust-rkyv0.7+archive_be-devel.sha256sum] = "09428ff646e79f8b33bdc6c7bc0447c96d4eed4343c5ce534848c3006efb4a8c"

URI_aarch64_rust-rkyv0.7+archive_le-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+archive_le-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+archive_le-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+archive_le-devel}"
SRC_URI[aarch64_rust-rkyv0.7+archive_le-devel.sha256sum] = "02be9c091da20b7dbd746f7fdf45608bdb37a0c581945375c79d175be24282ba"

URI_aarch64_rust-rkyv0.7+arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+arrayvec-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+arrayvec-devel}"
SRC_URI[aarch64_rust-rkyv0.7+arrayvec-devel.sha256sum] = "0a09569bb0cf740b19c09580d2c1f31d456168677b7ba4160161df11961277b7"

URI_aarch64_rust-rkyv0.7+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+bytecheck-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+bytecheck-devel}"
SRC_URI[aarch64_rust-rkyv0.7+bytecheck-devel.sha256sum] = "54379d028382f201406a1a12ab37e2da3786c5b77b6bf88a2b8cb5a5f05ad967"

URI_aarch64_rust-rkyv0.7+copy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+copy-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+copy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+copy-devel}"
SRC_URI[aarch64_rust-rkyv0.7+copy-devel.sha256sum] = "f6b41815816948f3eab993c2927f34531bba7cce7b1b32a473ba0480f3d6c24c"

URI_aarch64_rust-rkyv0.7+copy_unsafe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+copy_unsafe-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+copy_unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+copy_unsafe-devel}"
SRC_URI[aarch64_rust-rkyv0.7+copy_unsafe-devel.sha256sum] = "894dfecd663a7a3d37a98179818ebf1e74e98630c3fd54e1890bf4fc6737c3b7"

URI_aarch64_rust-rkyv0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+default-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+default-devel}"
SRC_URI[aarch64_rust-rkyv0.7+default-devel.sha256sum] = "42136597e4616a3a5971d292767e3fe9c150bcf107d86ac189b91f53e45fe8e2"

URI_aarch64_rust-rkyv0.7+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+hashbrown-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+hashbrown-devel}"
SRC_URI[aarch64_rust-rkyv0.7+hashbrown-devel.sha256sum] = "da208a30279479efc6a16d716969ee8240d984bf8dc7cc54deea13c43c0f7d85"

URI_aarch64_rust-rkyv0.7+rend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+rend-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+rend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+rend-devel}"
SRC_URI[aarch64_rust-rkyv0.7+rend-devel.sha256sum] = "8ba34f942bc54100dde8b6c114729445f80ae42d3cfb934c46d3caaddf2ed8bc"

URI_aarch64_rust-rkyv0.7+size_16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+size_16-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+size_16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+size_16-devel}"
SRC_URI[aarch64_rust-rkyv0.7+size_16-devel.sha256sum] = "d87e27dedb574d3a4cefbb4d7c329757cfb472de417cf991fb076a0251e16588"

URI_aarch64_rust-rkyv0.7+size_32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+size_32-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+size_32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+size_32-devel}"
SRC_URI[aarch64_rust-rkyv0.7+size_32-devel.sha256sum] = "8763531e3bbd7462f850543a1d8f96593894aeb4495f2ffb85ba7c65db4ea0eb"

URI_aarch64_rust-rkyv0.7+size_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+size_64-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+size_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+size_64-devel}"
SRC_URI[aarch64_rust-rkyv0.7+size_64-devel.sha256sum] = "032df92bbf8e420015be30bd05b5b9be0bd228318e6093dfa945ea345e7fbdf3"

URI_aarch64_rust-rkyv0.7+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+std-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+std-devel}"
SRC_URI[aarch64_rust-rkyv0.7+std-devel.sha256sum] = "14a3226c00e1e18e3141cc066acf63c137a9c04c7c94b98453af48d173582d1b"

URI_aarch64_rust-rkyv0.7+strict-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+strict-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+strict-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+strict-devel}"
SRC_URI[aarch64_rust-rkyv0.7+strict-devel.sha256sum] = "be463fac729f437ade7e99b887b7ca1a56d2392063848f6970b27c88fbd7002b"

URI_aarch64_rust-rkyv0.7+validation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+validation-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7+validation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+validation-devel}"
SRC_URI[aarch64_rust-rkyv0.7+validation-devel.sha256sum] = "ca571293e23fe6dc0afa390199072aee20391b409feeb3271af26ed2c7a760e3"

URI_aarch64_rust-rkyv0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7-devel}"
SRC_URI[aarch64_rust-rkyv0.7-devel.sha256sum] = "2f0109e3a3f064456832f9680022f8eff7bdfebed0e5b6bac5d4917c71de6f01"

RDEPENDS:rust-rkyv0.7+alloc-devel = " \
 cargo \
 rust-rkyv0.7+hashbrown-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+arbitrary_enum_discriminant-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel \
 "
RDEPENDS:rust-rkyv0.7+archive_be-devel = " \
 cargo \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7-devel \
 rust-rkyv_derive0.7+archive_be-devel \
 "
RDEPENDS:rust-rkyv0.7+archive_le-devel = " \
 cargo \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7-devel \
 rust-rkyv_derive0.7+archive_le-devel \
 "
RDEPENDS:rust-rkyv0.7+arrayvec-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+bytecheck-devel = " \
 cargo \
 rust-bytecheck0.6-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+copy-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 rust-rkyv_derive0.7+copy-devel \
 "
RDEPENDS:rust-rkyv0.7+copy_unsafe-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+default-devel = " \
 cargo \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+hashbrown-devel = " \
 cargo \
 rust-hashbrown0.14+default-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+rend-devel = " \
 cargo \
 rust-rend0.4-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+size_16-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+size_32-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+size_64-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+std-devel = " \
 cargo \
 rust-bytecheck0.6+std-devel \
 rust-bytecheck0.6-devel \
 rust-ptr_meta0.1+std-devel \
 rust-rend0.4+std-devel \
 rust-rend0.4-devel \
 rust-rkyv0.7+alloc-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+strict-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 rust-rkyv_derive0.7+strict-devel \
 "
RDEPENDS:rust-rkyv0.7+validation-devel = " \
 cargo \
 rust-rend0.4+validation-devel \
 rust-rend0.4-devel \
 rust-rkyv0.7+alloc-devel \
 rust-rkyv0.7+bytecheck-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7-devel = " \
 cargo \
 rust-ptr_meta0.1-devel \
 rust-rkyv_derive0.7+default-devel \
 rust-seahash+default-devel \
 "
