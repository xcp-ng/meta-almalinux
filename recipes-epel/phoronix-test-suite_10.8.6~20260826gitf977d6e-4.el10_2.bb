# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "phoronix-test-suite"
PV = "10.8.6~20260826gitf977d6e"
PR = "4.el10_2"
PACKAGES = " \
 phoronix-test-suite \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/phoronix-test-suite-10.8.6~20260826gitf977d6e-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1c2ec973e08685f05cd89c406eea8a86fcb0ae063b515e22df34180d72a8ba36"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/phoronix-test-suite-10.8.6~20260826gitf977d6e-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_phoronix-test-suite;unpack=0"
SRC_URI[x86_64_v2_phoronix-test-suite.sha256sum] = "bb7c2d323e70ab72251e2720c24a098060a70b97cbbe83c62f3ca7f184f5f529"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/phoronix-test-suite-10.8.6~20260826gitf977d6e-4.el10_2.noarch.rpm;name=aarch64_phoronix-test-suite;unpack=0"
SRC_URI[aarch64_phoronix-test-suite.sha256sum] = "cdeb0fbe4b82ed9a261f99781f4af1e790c171fe05c456e5d709815e317b879a"

RDEPENDS:phoronix-test-suite = " \
 bash \
 hicolor-icon-theme \
 systemd \
 virtual/php-cli \
 virtual/php-curl \
 virtual/php-gd \
 virtual/php-json \
 virtual/php-openssl \
 virtual/php-posix \
 virtual/php-sqlite3 \
 virtual/php-xml \
 "
