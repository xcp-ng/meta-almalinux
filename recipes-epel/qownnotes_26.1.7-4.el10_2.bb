# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qownnotes"
PV = "26.1.7"
PR = "4.el10_2"
PACKAGES = " \
 qownnotes \
 qownnotes-translations \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qownnotes-26.1.7-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c94a73d82fdff558590047e85304601f63227ae1a294c5cb68cd2cb52ac3b95d"

URI_x86_64_v2_qownnotes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qownnotes-26.1.7-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qownnotes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qownnotes}"
SRC_URI[x86_64_v2_qownnotes.sha256sum] = "864961b08b3099bf5a6b2ad9b592aaa9e27a9b04f22811c3d52bd36049d27a47"

URI_x86_64_v2_qownnotes-translations = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qownnotes-translations-26.1.7-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qownnotes-translations;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qownnotes-translations}"
SRC_URI[x86_64_v2_qownnotes-translations.sha256sum] = "0a38da7232478b2743c44b3c8e8dabc800e42c3ffcd84ccf8db07879a24dd5f0"

URI_aarch64_qownnotes = "${EPEL_MIRROR}/aarch64/Packages/q/qownnotes-26.1.7-4.el10_2.aarch64.rpm;name=aarch64_qownnotes;unpack=0"
SRC_URI:append = " ${URI_aarch64_qownnotes}"
SRC_URI[aarch64_qownnotes.sha256sum] = "39a5e030b1f947b0197c86823ee5c75845c882deb4f5eca6a7c191ce2ab0adff"

URI_aarch64_qownnotes-translations = "${EPEL_MIRROR}/aarch64/Packages/q/qownnotes-translations-26.1.7-4.el10_2.noarch.rpm;name=aarch64_qownnotes-translations;unpack=0"
SRC_URI:append = " ${URI_aarch64_qownnotes-translations}"
SRC_URI[aarch64_qownnotes-translations.sha256sum] = "d9f7d12e1a01a688bec869031fc9eb74f4ddbe9e25983a00200df96601f54417"

RDEPENDS:qownnotes = " \
 botan2 \
 glibc \
 hicolor-icon-theme \
 libX11 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 "
RDEPENDS:qownnotes-translations = " \
 qownnotes \
 "
