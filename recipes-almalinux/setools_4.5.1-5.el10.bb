# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setools"
PV = "4.5.1"
PR = "5.el10"
PACKAGES = " \
 python3-setools \
 setools \
 setools-console \
 setools-console-analyses \
 setools-gui \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/setools-4.5.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5212688ec08b57c7bf24e072e5a54f4c723a70dfb00e97dbc0f29b08b5910a6"

URI_x86_64_v2_python3-setools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-setools-4.5.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-setools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-setools}"
SRC_URI[x86_64_v2_python3-setools.sha256sum] = "504f3f9aff9415100b75249f81cfa93e469a8b38109a5424aacb5a8abb54093c"

URI_x86_64_v2_setools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-4.5.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_setools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools}"
SRC_URI[x86_64_v2_setools.sha256sum] = "e67b0dd6bee0a39ca3ac764a4588f3ec98f30255a94df9f6fdad006dfd721efa"

URI_x86_64_v2_setools-console = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/setools-console-4.5.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_setools-console;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools-console}"
SRC_URI[x86_64_v2_setools-console.sha256sum] = "eff9d00ca8284d3479b3c1b5a2876423a7d6d21124654d5988a718bd37e78e3d"

URI_x86_64_v2_setools-console-analyses = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-console-analyses-4.5.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_setools-console-analyses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools-console-analyses}"
SRC_URI[x86_64_v2_setools-console-analyses.sha256sum] = "c381d47c9dde6805c8498f35073c13320aa79ca8c7664c88168ef43efef46581"

URI_x86_64_v2_setools-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-gui-4.5.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_setools-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools-gui}"
SRC_URI[x86_64_v2_setools-gui.sha256sum] = "5f9e6e96f797b6e9247e79fbdfbab1d21e6ea178b35786625bcacb6843a92afa"

URI_aarch64_python3-setools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-setools-4.5.1-5.el10.aarch64.rpm;name=aarch64_python3-setools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-setools}"
SRC_URI[aarch64_python3-setools.sha256sum] = "5ceb4785d3c0dc243159dfc99574aa59e675680221913c0ac55e0476edfbf2fb"

URI_aarch64_setools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-4.5.1-5.el10.aarch64.rpm;name=aarch64_setools;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools}"
SRC_URI[aarch64_setools.sha256sum] = "a9da8f8dd1f6e2cfdeecf56a185c5387c75d98327315cfa607c394a81da8f67c"

URI_aarch64_setools-console = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/setools-console-4.5.1-5.el10.aarch64.rpm;name=aarch64_setools-console;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools-console}"
SRC_URI[aarch64_setools-console.sha256sum] = "fa2803fbcafd012c73f9188ed81a4d289af0bf7e82d08a4ca0c702b3ba6a45bc"

URI_aarch64_setools-console-analyses = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-console-analyses-4.5.1-5.el10.aarch64.rpm;name=aarch64_setools-console-analyses;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools-console-analyses}"
SRC_URI[aarch64_setools-console-analyses.sha256sum] = "45d7ccdfec31fe4ec88a74147fa8ba864ed3fb668f9fb335cb9851c2cf3ac8dd"

URI_aarch64_setools-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-gui-4.5.1-5.el10.aarch64.rpm;name=aarch64_setools-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools-gui}"
SRC_URI[aarch64_setools-gui.sha256sum] = "44b8c999742fac569c6fe0a6f6e0842f06b411b1043a78a9c32175dcc0e14e53"

RDEPENDS:python3-setools = " \
 glibc \
 libselinux \
 libsepol \
 python3 \
 python3-setuptools \
 "
RDEPENDS:setools = " \
 setools-console \
 setools-console-analyses \
 setools-gui \
 "
RDEPENDS:setools-console = " \
 libselinux \
 python3 \
 python3-setools \
 "
RDEPENDS:setools-console-analyses = " \
 libselinux \
 python3 \
 python3-networkx \
 python3-setools \
 "
RDEPENDS:setools-gui = " \
 python3 \
 python3-networkx \
 python3-pyqt6 \
 python3-pyqt6-sip \
 python3-setools \
 "
