# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wayland-protocols"
PV = "1.49"
PR = "2.el10"
PACKAGES = " \
 wayland-protocols-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wayland-protocols-1.49-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c570b19920a9c7b302cbd75b57d99b6ae686a45a32577a1df8f930a1ffdbfd70"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wayland-protocols-devel-1.49-2.el10.noarch.rpm;name=x86_64_v2_wayland-protocols-devel;unpack=0"
SRC_URI[x86_64_v2_wayland-protocols-devel.sha256sum] = "861dc5b664ad450fcea5fc6e5466ce68785d246c5589d41ec1ec3accb05f6fcf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wayland-protocols-devel-1.49-2.el10.noarch.rpm;name=aarch64_wayland-protocols-devel;unpack=0"
SRC_URI[aarch64_wayland-protocols-devel.sha256sum] = "861dc5b664ad450fcea5fc6e5466ce68785d246c5589d41ec1ec3accb05f6fcf"

RDEPENDS:wayland-protocols-devel = " \
 pkgconf-pkg-config \
 "
