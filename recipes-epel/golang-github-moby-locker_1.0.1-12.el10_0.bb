# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-moby-locker"
PV = "1.0.1"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-moby-locker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-moby-locker-1.0.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "449fbf9659f87bcb68603d4aa56d68f7ffe5d9719fdd80635a71e8462c533969"

URI_x86_64_v2_golang-github-moby-locker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-moby-locker-devel-1.0.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-moby-locker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-moby-locker-devel}"
SRC_URI[x86_64_v2_golang-github-moby-locker-devel.sha256sum] = "d43c4d0d76383dfddae3e16e5f6702cd631d6746e7a7f596a66812c7a2edca94"

URI_aarch64_golang-github-moby-locker-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-moby-locker-devel-1.0.1-12.el10_0.noarch.rpm;name=aarch64_golang-github-moby-locker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-moby-locker-devel}"
SRC_URI[aarch64_golang-github-moby-locker-devel.sha256sum] = "8c0f00688f6b7e806628a03056c24cff831d55a4b5c97c682c0c4b2f18f16a05"

RDEPENDS:golang-github-moby-locker-devel = " \
 go-filesystem \
 "
