# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-dev-utils"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kde-dev-utils \
 kde-dev-utils-common \
 kpartloader \
 kuiviewer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-dev-utils-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0146df4d2f20a5db59cbde8f673275a7c2b445b9c1ed35db07d59f7b1363df0"

URI_x86_64_v2_kde-dev-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-dev-utils-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-dev-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-dev-utils}"
SRC_URI[x86_64_v2_kde-dev-utils.sha256sum] = "b6deef99f8c944f92fa8da67ff5250a42fcacf1ad7a302ff26b40113e8184f1d"

URI_x86_64_v2_kde-dev-utils-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-dev-utils-common-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kde-dev-utils-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-dev-utils-common}"
SRC_URI[x86_64_v2_kde-dev-utils-common.sha256sum] = "e97d3a77717839c666ee162a18c20953a7a83a1a71269edd0767f4d39749a8be"

URI_x86_64_v2_kpartloader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpartloader-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpartloader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpartloader}"
SRC_URI[x86_64_v2_kpartloader.sha256sum] = "9c4c27fd7af4d5dda0543fff35a42617d4578a57129d7a218f75f88843299572"

URI_x86_64_v2_kuiviewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kuiviewer-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kuiviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kuiviewer}"
SRC_URI[x86_64_v2_kuiviewer.sha256sum] = "6593af7100fc4230d9f84da736f1d395b91559ec00277568b64bbe3fbf6a7463"

URI_aarch64_kde-dev-utils = "${EPEL_MIRROR}/aarch64/Packages/k/kde-dev-utils-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kde-dev-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-dev-utils}"
SRC_URI[aarch64_kde-dev-utils.sha256sum] = "15c46b93f40518c65d7065cad0d0cf5ad8f837b3cd98eadee885915100a2d5a6"

URI_aarch64_kde-dev-utils-common = "${EPEL_MIRROR}/aarch64/Packages/k/kde-dev-utils-common-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kde-dev-utils-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-dev-utils-common}"
SRC_URI[aarch64_kde-dev-utils-common.sha256sum] = "875c283ceb42f74e6704a558d696629e14c6c6d9787dee651836cb04bcd0bab5"

URI_aarch64_kpartloader = "${EPEL_MIRROR}/aarch64/Packages/k/kpartloader-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kpartloader;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpartloader}"
SRC_URI[aarch64_kpartloader.sha256sum] = "760ec676a1cc490f2b1c87fb04403fa0d58ad6f4ce633e250b09561a512e6a5e"

URI_aarch64_kuiviewer = "${EPEL_MIRROR}/aarch64/Packages/k/kuiviewer-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kuiviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_kuiviewer}"
SRC_URI[aarch64_kuiviewer.sha256sum] = "cf03987e6f6130030d62f953c26f00fe9718a7d8809de12e73accc9e4f3e5077"

RDEPENDS:kde-dev-utils = " \
 kpartloader \
 kuiviewer \
 "
RDEPENDS:kde-dev-utils-common = " \
 "
RDEPENDS:kpartloader = " \
 glibc \
 kde-dev-utils-common \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kuiviewer = " \
 glibc \
 kde-dev-utils-common \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-designer \
 "
