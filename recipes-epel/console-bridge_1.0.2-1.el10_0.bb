# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "console-bridge"
PV = "1.0.2"
PR = "1.el10_0"
PACKAGES = " \
 console-bridge \
 console-bridge-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/console-bridge-1.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4646cdfd6f229e1382226fe6cfd445ac001971a652fa3f28d96e3195890310e2"

URI_x86_64_v2_console-bridge = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/console-bridge-1.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_console-bridge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_console-bridge}"
SRC_URI[x86_64_v2_console-bridge.sha256sum] = "5a37f73ca43ade572581aa10c2dec1d1795f2c5d514e47eb45e8d659ecf2b65d"

URI_x86_64_v2_console-bridge-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/console-bridge-devel-1.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_console-bridge-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_console-bridge-devel}"
SRC_URI[x86_64_v2_console-bridge-devel.sha256sum] = "f86d672805e147431ec9adc9e56abb2176a83a8ee56d3a241a852a7aa5a60534"

URI_aarch64_console-bridge = "${EPEL_MIRROR}/aarch64/Packages/c/console-bridge-1.0.2-1.el10_0.aarch64.rpm;name=aarch64_console-bridge;unpack=0"
SRC_URI:append = " ${URI_aarch64_console-bridge}"
SRC_URI[aarch64_console-bridge.sha256sum] = "160267b5b42f418459555bab76a4c69d208473c34e0974f18a5aa18d480465c7"

URI_aarch64_console-bridge-devel = "${EPEL_MIRROR}/aarch64/Packages/c/console-bridge-devel-1.0.2-1.el10_0.aarch64.rpm;name=aarch64_console-bridge-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_console-bridge-devel}"
SRC_URI[aarch64_console-bridge-devel.sha256sum] = "46d6f36ed0cb09f915ca9cabd87c0576369728f7e834f018156056000bac3278"

RDEPENDS:console-bridge = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:console-bridge-devel = " \
 console-bridge \
 pkgconf-pkg-config \
 "
