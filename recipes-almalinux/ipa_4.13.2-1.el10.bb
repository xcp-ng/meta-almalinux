# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipa"
PV = "4.13.2"
PR = "1.el10"
PACKAGES = " \
 ipa-client \
 ipa-client-common \
 ipa-client-encrypted-dns \
 ipa-client-epn \
 ipa-client-samba \
 ipa-common \
 ipa-selinux \
 ipa-selinux-luna \
 ipa-selinux-nfast \
 ipa-server \
 ipa-server-common \
 ipa-server-dns \
 ipa-server-encrypted-dns \
 ipa-server-trust-ad \
 python3-ipaclient \
 python3-ipalib \
 python3-ipaserver \
 python3-ipatests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ipa-4.13.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cfcdfca1d1bdeb3cfaf9b8bc19fb95359b599bec124aeec42b92685982f1424"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3-ipaclient: augeas-libs >= 1.12.1-0
# - python3-ipaserver: augeas-libs >= 1.12.1-0

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - python3-ipaclient: augeas-libs >= 1.12.1-0
# - python3-ipaserver: augeas-libs >= 1.12.1-0

URI_x86_64_v2_ipa-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-4.13.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_ipa-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-client}"
SRC_URI[x86_64_v2_ipa-client.sha256sum] = "0e76ec2c839cff9ed8471428748af04d8017b9f444df169828e8523bdac8eb30"

URI_x86_64_v2_ipa-client-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-common-4.13.2-1.el10.noarch.rpm;name=x86_64_v2_ipa-client-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-client-common}"
SRC_URI[x86_64_v2_ipa-client-common.sha256sum] = "f7b5cc3da2253160713604fb18e8c53c600c2596be2693a28a14614cfc5db6a5"

URI_x86_64_v2_ipa-client-encrypted-dns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-encrypted-dns-4.13.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_ipa-client-encrypted-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-client-encrypted-dns}"
SRC_URI[x86_64_v2_ipa-client-encrypted-dns.sha256sum] = "e8ee8b531069eb032b83322661df812f1e26963b47f32e68965af218a1673d63"

URI_x86_64_v2_ipa-client-epn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-epn-4.13.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_ipa-client-epn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-client-epn}"
SRC_URI[x86_64_v2_ipa-client-epn.sha256sum] = "d112e837614a16005c07d5e966f146d3cfa67cc7d23810afb82e310f11dd6e07"

URI_x86_64_v2_ipa-client-samba = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-samba-4.13.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_ipa-client-samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-client-samba}"
SRC_URI[x86_64_v2_ipa-client-samba.sha256sum] = "5c5769bc905d5e4ac288719c780932100bd5707a83e87f5d13543c82e4e98924"

URI_x86_64_v2_ipa-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-common-4.13.2-1.el10.noarch.rpm;name=x86_64_v2_ipa-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-common}"
SRC_URI[x86_64_v2_ipa-common.sha256sum] = "59738815a090e30a9ede85fb069581a3dfc2b14e3f66cba4af66687ba2dd46c8"

URI_x86_64_v2_ipa-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-selinux-4.13.2-1.el10.noarch.rpm;name=x86_64_v2_ipa-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-selinux}"
SRC_URI[x86_64_v2_ipa-selinux.sha256sum] = "a26848673125d0f027ad344c8288f37125b8cb00bad9c2cf2eb9bd6cf09d1d58"

URI_x86_64_v2_ipa-selinux-luna = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-selinux-luna-4.13.2-1.el10.noarch.rpm;name=x86_64_v2_ipa-selinux-luna;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-selinux-luna}"
SRC_URI[x86_64_v2_ipa-selinux-luna.sha256sum] = "7fa14251ed01947da5c737f5d5e2c1942458c053e43bfa6b5068f89b90402432"

URI_x86_64_v2_ipa-selinux-nfast = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-selinux-nfast-4.13.2-1.el10.noarch.rpm;name=x86_64_v2_ipa-selinux-nfast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-selinux-nfast}"
SRC_URI[x86_64_v2_ipa-selinux-nfast.sha256sum] = "5d4f896339086aaa87f30b042d8df61f2eac31a8fdd0a73baa4d9913e5387cac"

URI_x86_64_v2_ipa-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-4.13.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_ipa-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-server}"
SRC_URI[x86_64_v2_ipa-server.sha256sum] = "ac824ea581573336b7f8f34e74407a244fecd039ef7733adaf206dbfbcb394c4"

URI_x86_64_v2_ipa-server-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-common-4.13.2-1.el10.noarch.rpm;name=x86_64_v2_ipa-server-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-server-common}"
SRC_URI[x86_64_v2_ipa-server-common.sha256sum] = "d8430d676f62d158d1b8eaa0b2de98d83cad0119977bbe239291408c606a866d"

URI_x86_64_v2_ipa-server-dns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-dns-4.13.2-1.el10.noarch.rpm;name=x86_64_v2_ipa-server-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-server-dns}"
SRC_URI[x86_64_v2_ipa-server-dns.sha256sum] = "c648a592cae5e8d6c3e23be07eb8ef9f3234264814bdb867b3ae072db6c7bf64"

URI_x86_64_v2_ipa-server-encrypted-dns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-encrypted-dns-4.13.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_ipa-server-encrypted-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-server-encrypted-dns}"
SRC_URI[x86_64_v2_ipa-server-encrypted-dns.sha256sum] = "86ac133cba5f0e309608f6571d8a09351844a0d305d50e6517e169dc331a06ab"

URI_x86_64_v2_ipa-server-trust-ad = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-trust-ad-4.13.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_ipa-server-trust-ad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-server-trust-ad}"
SRC_URI[x86_64_v2_ipa-server-trust-ad.sha256sum] = "879c21e2dbe2bba02c381d25322dec35e834cbb76530c7462c988b07ccdc9f01"

URI_x86_64_v2_python3-ipaclient = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ipaclient-4.13.2-1.el10.noarch.rpm;name=x86_64_v2_python3-ipaclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipaclient}"
SRC_URI[x86_64_v2_python3-ipaclient.sha256sum] = "b84ffd180c4ac547a4b8bd22c7e34cc995299b6904f5601d6f70f9112ea806aa"

URI_x86_64_v2_python3-ipalib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ipalib-4.13.2-1.el10.noarch.rpm;name=x86_64_v2_python3-ipalib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipalib}"
SRC_URI[x86_64_v2_python3-ipalib.sha256sum] = "9f3e06037454a2abc32c64cb846b18cc555ea087e0426f3064a9c46d8bb74345"

URI_x86_64_v2_python3-ipaserver = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ipaserver-4.13.2-1.el10.noarch.rpm;name=x86_64_v2_python3-ipaserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipaserver}"
SRC_URI[x86_64_v2_python3-ipaserver.sha256sum] = "bf4ca871128a655f33071b61103730470659652f279ebcef497af4e8af7b08a7"

URI_x86_64_v2_python3-ipatests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-ipatests-4.13.2-1.el10.noarch.rpm;name=x86_64_v2_python3-ipatests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipatests}"
SRC_URI[x86_64_v2_python3-ipatests.sha256sum] = "f9e245b392c869510b68a4c21c1ecb4b876fe1a9ed537a7f4383835792fd6a2f"

URI_aarch64_ipa-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-4.13.2-1.el10.aarch64.rpm;name=aarch64_ipa-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-client}"
SRC_URI[aarch64_ipa-client.sha256sum] = "a5f6e41249b6745fa641c779e5d7454eef1b94dbeb5fc875c0fef9a07222eb3e"

URI_aarch64_ipa-client-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-common-4.13.2-1.el10.noarch.rpm;name=aarch64_ipa-client-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-client-common}"
SRC_URI[aarch64_ipa-client-common.sha256sum] = "f7b5cc3da2253160713604fb18e8c53c600c2596be2693a28a14614cfc5db6a5"

URI_aarch64_ipa-client-encrypted-dns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-encrypted-dns-4.13.2-1.el10.aarch64.rpm;name=aarch64_ipa-client-encrypted-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-client-encrypted-dns}"
SRC_URI[aarch64_ipa-client-encrypted-dns.sha256sum] = "2140c7932845d0cf6b8b2e38d3b414af1a4fa6c9fba420fa059381b30cab639d"

URI_aarch64_ipa-client-epn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-epn-4.13.2-1.el10.aarch64.rpm;name=aarch64_ipa-client-epn;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-client-epn}"
SRC_URI[aarch64_ipa-client-epn.sha256sum] = "24dfff338f817c0d3a5e7e29c3fe5a395fbf61ec6aa543a06659ff2c11d78686"

URI_aarch64_ipa-client-samba = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-samba-4.13.2-1.el10.aarch64.rpm;name=aarch64_ipa-client-samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-client-samba}"
SRC_URI[aarch64_ipa-client-samba.sha256sum] = "ada1a52d31a0aac4b408bf76e7456e5200be7a557680cac8aa2974f18d9f615e"

URI_aarch64_ipa-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-common-4.13.2-1.el10.noarch.rpm;name=aarch64_ipa-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-common}"
SRC_URI[aarch64_ipa-common.sha256sum] = "59738815a090e30a9ede85fb069581a3dfc2b14e3f66cba4af66687ba2dd46c8"

URI_aarch64_ipa-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-selinux-4.13.2-1.el10.noarch.rpm;name=aarch64_ipa-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-selinux}"
SRC_URI[aarch64_ipa-selinux.sha256sum] = "a26848673125d0f027ad344c8288f37125b8cb00bad9c2cf2eb9bd6cf09d1d58"

URI_aarch64_ipa-selinux-luna = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-selinux-luna-4.13.2-1.el10.noarch.rpm;name=aarch64_ipa-selinux-luna;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-selinux-luna}"
SRC_URI[aarch64_ipa-selinux-luna.sha256sum] = "7fa14251ed01947da5c737f5d5e2c1942458c053e43bfa6b5068f89b90402432"

URI_aarch64_ipa-selinux-nfast = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-selinux-nfast-4.13.2-1.el10.noarch.rpm;name=aarch64_ipa-selinux-nfast;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-selinux-nfast}"
SRC_URI[aarch64_ipa-selinux-nfast.sha256sum] = "5d4f896339086aaa87f30b042d8df61f2eac31a8fdd0a73baa4d9913e5387cac"

URI_aarch64_ipa-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-4.13.2-1.el10.aarch64.rpm;name=aarch64_ipa-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-server}"
SRC_URI[aarch64_ipa-server.sha256sum] = "3e1eaf0707882172692f21f8da54639b797ea07568d2c617eadf3381fe205ed2"

URI_aarch64_ipa-server-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-common-4.13.2-1.el10.noarch.rpm;name=aarch64_ipa-server-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-server-common}"
SRC_URI[aarch64_ipa-server-common.sha256sum] = "d8430d676f62d158d1b8eaa0b2de98d83cad0119977bbe239291408c606a866d"

URI_aarch64_ipa-server-dns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-dns-4.13.2-1.el10.noarch.rpm;name=aarch64_ipa-server-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-server-dns}"
SRC_URI[aarch64_ipa-server-dns.sha256sum] = "c648a592cae5e8d6c3e23be07eb8ef9f3234264814bdb867b3ae072db6c7bf64"

URI_aarch64_ipa-server-encrypted-dns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-encrypted-dns-4.13.2-1.el10.aarch64.rpm;name=aarch64_ipa-server-encrypted-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-server-encrypted-dns}"
SRC_URI[aarch64_ipa-server-encrypted-dns.sha256sum] = "51da51f872ea1ef3fc8c343e9ad7a9249173bb552b949fadc9b385acd1d75f45"

URI_aarch64_ipa-server-trust-ad = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-trust-ad-4.13.2-1.el10.aarch64.rpm;name=aarch64_ipa-server-trust-ad;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-server-trust-ad}"
SRC_URI[aarch64_ipa-server-trust-ad.sha256sum] = "8ae43ef96593104a4d228866545f19e0862712e611282709974feae25c54ad43"

URI_aarch64_python3-ipaclient = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ipaclient-4.13.2-1.el10.noarch.rpm;name=aarch64_python3-ipaclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipaclient}"
SRC_URI[aarch64_python3-ipaclient.sha256sum] = "b84ffd180c4ac547a4b8bd22c7e34cc995299b6904f5601d6f70f9112ea806aa"

URI_aarch64_python3-ipalib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ipalib-4.13.2-1.el10.noarch.rpm;name=aarch64_python3-ipalib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipalib}"
SRC_URI[aarch64_python3-ipalib.sha256sum] = "9f3e06037454a2abc32c64cb846b18cc555ea087e0426f3064a9c46d8bb74345"

URI_aarch64_python3-ipaserver = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ipaserver-4.13.2-1.el10.noarch.rpm;name=aarch64_python3-ipaserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipaserver}"
SRC_URI[aarch64_python3-ipaserver.sha256sum] = "bf4ca871128a655f33071b61103730470659652f279ebcef497af4e8af7b08a7"

URI_aarch64_python3-ipatests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-ipatests-4.13.2-1.el10.noarch.rpm;name=aarch64_python3-ipatests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipatests}"
SRC_URI[aarch64_python3-ipatests.sha256sum] = "f9e245b392c869510b68a4c21c1ecb4b876fe1a9ed537a7f4383835792fd6a2f"

RDEPENDS:ipa-client = " \
 authselect \
 autofs \
 bash \
 bind-utils \
 certmonger \
 chrony \
 curl \
 cyrus-sasl-gssapi \
 glibc \
 hostname \
 ipa-client-common \
 ipa-common \
 jansson \
 krb5-libs \
 krb5-pkinit \
 krb5-workstation \
 libcom_err \
 libini_config \
 libnfsidmap \
 libsss_autofs \
 libsss_sudo \
 nss-tools \
 oddjob-mkhomedir \
 openldap \
 openssl-libs \
 policycoreutils \
 popt \
 python3 \
 python3-gssapi \
 python3-ipaclient \
 python3-ldap \
 python3-sssdconfig \
 sssd-idp \
 sssd-ipa \
 sssd-krb5 \
 sssd-tools \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_ge_7.21.7-2 \
 virtual/nfs-utils_or_nfsv4-client-utils \
 "
RDEPENDS:ipa-client-common = " \
 "
RDEPENDS:ipa-client-encrypted-dns = " \
 unbound \
 "
RDEPENDS:ipa-client-epn = " \
 bash \
 ipa-client \
 python3 \
 systemd \
 "
RDEPENDS:ipa-client-samba = " \
 cifs-utils \
 ipa-client \
 python3 \
 python3-samba \
 samba \
 samba-client \
 samba-common-tools \
 samba-winbind \
 sssd-winbind-idmap \
 tdb-tools \
 "
RDEPENDS:ipa-common = " \
 ipa-selinux \
 "
RDEPENDS:ipa-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:ipa-selinux-luna = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:ipa-selinux-nfast = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:ipa-server = " \
 389-ds-base \
 acl \
 bash \
 certmonger \
 chrony \
 cracklib-dicts \
 cyrus-sasl-gssapi \
 fontawesome4-fonts \
 glibc \
 gssproxy \
 gzip \
 httpd \
 idm-pki-acme \
 idm-pki-ca \
 idm-pki-kra \
 ipa-client \
 ipa-common \
 ipa-server-common \
 jansson \
 krb5-libs \
 krb5-server \
 libcom_err \
 libgcc \
 libpwquality \
 libsss_certmap \
 libsss_nss_idmap \
 libtalloc \
 libtevent \
 libunistring \
 libuuid \
 libverto \
 mod_auth_gssapi \
 mod_lookup_identity \
 mod_session \
 mod_ssl \
 nss-tools \
 oddjob \
 open-sans-fonts \
 openldap \
 openldap-clients \
 openssl \
 openssl-libs \
 p11-kit \
 policycoreutils \
 popt \
 python3 \
 python3-gssapi \
 python3-ipaserver \
 python3-ldap \
 python3-mod_wsgi \
 python3-systemd \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 selinux-policy \
 shadow-utils \
 slapi-nis \
 softhsm \
 sssd-dbus \
 systemd \
 tar \
 "
RDEPENDS:ipa-server-common = " \
 almalinux-logos-ipa \
 httpd \
 ipa-client-common \
 systemd \
 "
RDEPENDS:ipa-server-dns = " \
 bash \
 bind \
 bind-dnssec-utils \
 bind-dyndb-ldap \
 bind-utils \
 ipa-server \
 opendnssec \
 pkcs11-provider \
 python3 \
 softhsm \
 systemd \
 "
RDEPENDS:ipa-server-encrypted-dns = " \
 bind-dyndb-ldap \
 ipa-client-encrypted-dns \
 "
RDEPENDS:ipa-server-trust-ad = " \
 alternatives \
 bash \
 glibc \
 ipa-common \
 ipa-server \
 krb5-libs \
 libcom_err \
 libpwquality \
 libsss_idmap \
 libtalloc \
 libtevent \
 openldap \
 openssl-libs \
 python3 \
 python3-libsss_nss_idmap \
 python3-samba \
 python3-sss \
 samba \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 samba-winbind \
 sssd-winbind-idmap \
 "
RDEPENDS:python3-ipaclient = " \
 ipa-client-common \
 ipa-common \
 python3 \
 python3-augeas \
 python3-cryptography \
 python3-dns \
 python3-ipalib \
 python3-jinja2 \
 python3-qrcode \
 python3-six \
 "
RDEPENDS:python3-ipalib = " \
 gnupg2 \
 ipa-common \
 keyutils \
 python3 \
 python3-argcomplete \
 python3-cffi \
 python3-cryptography \
 python3-dateutil \
 python3-dbus \
 python3-dns \
 python3-gssapi \
 python3-ifaddr \
 python3-jwcrypto \
 python3-ldap \
 python3-libipa_hbac \
 python3-netaddr \
 python3-packaging \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-pyusb \
 python3-qrcode \
 python3-requests \
 python3-six \
 python3-sss-murmur \
 python3-systemd \
 python3-urllib3 \
 python3-yubico \
 "
RDEPENDS:python3-ipaserver = " \
 ipa-common \
 ipa-server-common \
 python3 \
 python3-augeas \
 python3-cryptography \
 python3-dbus \
 python3-dns \
 python3-gssapi \
 python3-idm-pki \
 python3-ipaclient \
 python3-ipalib \
 python3-jwcrypto \
 python3-kdcproxy \
 python3-ldap \
 python3-lxml \
 python3-netaddr \
 python3-psutil \
 python3-pyasn1 \
 python3-requests \
 python3-six \
 python3-sssdconfig \
 python3-urllib3 \
 rpm-libs \
 "
RDEPENDS:python3-ipatests = " \
 iptables-nft \
 openssh-clients \
 python3-cryptography \
 python3-ipaclient \
 python3-ipaserver \
 python3-sssdconfig \
 tar \
 xz \
 "
