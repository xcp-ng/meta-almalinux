# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libbpf-sys"
PV = "1.5.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-libbpf-sys+bindgen-devel \
 rust-libbpf-sys+bindgen-source-devel \
 rust-libbpf-sys+default-devel \
 rust-libbpf-sys+novendor-devel \
 rust-libbpf-sys+static-devel \
 rust-libbpf-sys+static-libbpf-devel \
 rust-libbpf-sys+static-libelf-devel \
 rust-libbpf-sys+static-zlib-devel \
 rust-libbpf-sys+vendored-devel \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys+vendored-libelf-devel \
 rust-libbpf-sys+vendored-zlib-devel \
 rust-libbpf-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libbpf-sys-1.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b230191fe7bde810987773144237c308f512144de7b16e91e229e8d5dd96814e"

URI_x86_64_v2_rust-libbpf-sys+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+bindgen-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+bindgen-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+bindgen-devel.sha256sum] = "fbff46b5c1fe5f313b8804dabed6a492afe11935a387dc10953aeb3b693e56db"

URI_x86_64_v2_rust-libbpf-sys+bindgen-source-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+bindgen-source-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+bindgen-source-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+bindgen-source-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+bindgen-source-devel.sha256sum] = "e391a92e41fbdb06ed54766f65813b6945e12f3fa061ac0e2364967caf02c362"

URI_x86_64_v2_rust-libbpf-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+default-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+default-devel.sha256sum] = "6e203a469481d245622ffad7c85e4c3ac7271a88d6c453a7cb2f7166bd423b4b"

URI_x86_64_v2_rust-libbpf-sys+novendor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+novendor-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+novendor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+novendor-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+novendor-devel.sha256sum] = "40cec6ae66ae2d5304727d0c8135779921f1b33b9a0124c1a77c34cc8f54f61c"

URI_x86_64_v2_rust-libbpf-sys+static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+static-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+static-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+static-devel.sha256sum] = "50801b77ea6db329ed37fa3788ea420bb944052af2d27b53a68ee54779e43c1e"

URI_x86_64_v2_rust-libbpf-sys+static-libbpf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+static-libbpf-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+static-libbpf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+static-libbpf-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+static-libbpf-devel.sha256sum] = "c677bb4155d7e224420a8874cd1e0ede2b87f28c1ff7f82f3095c24a9d9323a2"

URI_x86_64_v2_rust-libbpf-sys+static-libelf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+static-libelf-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+static-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+static-libelf-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+static-libelf-devel.sha256sum] = "71b8c1bf8a9b67993b550763dd549414260ae2183040b7ff36fb45dacc6734ca"

URI_x86_64_v2_rust-libbpf-sys+static-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+static-zlib-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+static-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+static-zlib-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+static-zlib-devel.sha256sum] = "0655fd674b52356f4c283967cfdd5ae4617852758ac268166f7511cf50ddbf4c"

URI_x86_64_v2_rust-libbpf-sys+vendored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+vendored-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+vendored-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+vendored-devel.sha256sum] = "2997258e510e5a17747db2ba3757183d4defeb8406396858d5651a4053f08307"

URI_x86_64_v2_rust-libbpf-sys+vendored-libbpf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+vendored-libbpf-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+vendored-libbpf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+vendored-libbpf-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+vendored-libbpf-devel.sha256sum] = "c0bdc4dd8d4b5548f246ab900e0ac09fe0e27ad7f63c591f2739adfa8070d8b5"

URI_x86_64_v2_rust-libbpf-sys+vendored-libelf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+vendored-libelf-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+vendored-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+vendored-libelf-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+vendored-libelf-devel.sha256sum] = "efad091d211599ed1599aa16bb000229384bc56b3905481cce3541a460f55ca0"

URI_x86_64_v2_rust-libbpf-sys+vendored-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+vendored-zlib-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+vendored-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+vendored-zlib-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+vendored-zlib-devel.sha256sum] = "b73aa92187feec14942d857dd31d46460b21732f6bc541e1238a5e20e7199862"

URI_x86_64_v2_rust-libbpf-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys-devel.sha256sum] = "d911a08472b7ab284ff576b1ca2aa1c435fd166eac0412ed68d04cac1a2b6ac4"

URI_aarch64_rust-libbpf-sys+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+bindgen-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-libbpf-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+bindgen-devel}"
SRC_URI[aarch64_rust-libbpf-sys+bindgen-devel.sha256sum] = "3b35ecba195f355d47eb7f33c6082e9b043edc0ded6a91ccfba7af77ba080768"

URI_aarch64_rust-libbpf-sys+bindgen-source-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+bindgen-source-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-libbpf-sys+bindgen-source-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+bindgen-source-devel}"
SRC_URI[aarch64_rust-libbpf-sys+bindgen-source-devel.sha256sum] = "25d39fb7d6b6f954dcb44ecdd514345f61ee6679bfdb712715855bfb30b4466e"

URI_aarch64_rust-libbpf-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+default-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-libbpf-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+default-devel}"
SRC_URI[aarch64_rust-libbpf-sys+default-devel.sha256sum] = "7bd51cece867a79bf1a70be3a260c2a75df25f745288c54f5ceb4177ec41fda3"

URI_aarch64_rust-libbpf-sys+novendor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+novendor-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-libbpf-sys+novendor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+novendor-devel}"
SRC_URI[aarch64_rust-libbpf-sys+novendor-devel.sha256sum] = "5fa126fd1bf5699762b8e5dd6f2414ba28d096d349c6da98118a6abb99d4f82b"

URI_aarch64_rust-libbpf-sys+static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+static-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-libbpf-sys+static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+static-devel}"
SRC_URI[aarch64_rust-libbpf-sys+static-devel.sha256sum] = "e0b3e6e0f45723236880ad499e0630111e9cb9f667cc4bb6eb04c49a3ff203ba"

URI_aarch64_rust-libbpf-sys+static-libbpf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+static-libbpf-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-libbpf-sys+static-libbpf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+static-libbpf-devel}"
SRC_URI[aarch64_rust-libbpf-sys+static-libbpf-devel.sha256sum] = "eb77ef9834a04d4e9a354c7c517e1bdf39da6477bab9c33fd8f7a4b96ed602ac"

URI_aarch64_rust-libbpf-sys+static-libelf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+static-libelf-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-libbpf-sys+static-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+static-libelf-devel}"
SRC_URI[aarch64_rust-libbpf-sys+static-libelf-devel.sha256sum] = "bf6723f8a00266cdcbd96533f86d0d9c6760f9baf13007fa596551958d43ef75"

URI_aarch64_rust-libbpf-sys+static-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+static-zlib-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-libbpf-sys+static-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+static-zlib-devel}"
SRC_URI[aarch64_rust-libbpf-sys+static-zlib-devel.sha256sum] = "59b390bd5e292f77f24112fff6aa39e83ce1f7c7e7c6083b720148660408bbb0"

URI_aarch64_rust-libbpf-sys+vendored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+vendored-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-libbpf-sys+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+vendored-devel}"
SRC_URI[aarch64_rust-libbpf-sys+vendored-devel.sha256sum] = "36ed8511177f3af3ddf1a5dcc48745612b84e79f00193ac15986677b175c9f10"

URI_aarch64_rust-libbpf-sys+vendored-libbpf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+vendored-libbpf-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-libbpf-sys+vendored-libbpf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+vendored-libbpf-devel}"
SRC_URI[aarch64_rust-libbpf-sys+vendored-libbpf-devel.sha256sum] = "0af154cfbc9a2adf5eae9ff68d1cdb804fe4a773866dc89cc653288d26240582"

URI_aarch64_rust-libbpf-sys+vendored-libelf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+vendored-libelf-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-libbpf-sys+vendored-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+vendored-libelf-devel}"
SRC_URI[aarch64_rust-libbpf-sys+vendored-libelf-devel.sha256sum] = "39193a19f3543f26a42ff9695bd6336c4faf2500499798e44a426643aa73ef5c"

URI_aarch64_rust-libbpf-sys+vendored-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+vendored-zlib-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-libbpf-sys+vendored-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+vendored-zlib-devel}"
SRC_URI[aarch64_rust-libbpf-sys+vendored-zlib-devel.sha256sum] = "b8c6a3be51a9a3761292a2f3d6e6f59e5245c90252989ea03ffb0241fe219623"

URI_aarch64_rust-libbpf-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-libbpf-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys-devel}"
SRC_URI[aarch64_rust-libbpf-sys-devel.sha256sum] = "803f8f2dee1e2b2e2194c8f6a98d3ab544fc9bbbfecc616f987e97063bbb9f61"

RDEPENDS:rust-libbpf-sys+bindgen-devel = " \
 cargo \
 rust-bindgen0.69+default-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+bindgen-source-devel = " \
 cargo \
 rust-libbpf-sys+bindgen-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+default-devel = " \
 cargo \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+novendor-devel = " \
 cargo \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+static-devel = " \
 cargo \
 rust-libbpf-sys+static-libbpf-devel \
 rust-libbpf-sys+static-libelf-devel \
 rust-libbpf-sys+static-zlib-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+static-libbpf-devel = " \
 cargo \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+static-libelf-devel = " \
 cargo \
 rust-libbpf-sys+static-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+static-zlib-devel = " \
 cargo \
 rust-libbpf-sys+static-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+vendored-devel = " \
 cargo \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys+vendored-libelf-devel \
 rust-libbpf-sys+vendored-zlib-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+vendored-libbpf-devel = " \
 cargo \
 rust-libbpf-sys+static-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+vendored-libelf-devel = " \
 cargo \
 rust-libbpf-sys+static-libelf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+vendored-zlib-devel = " \
 cargo \
 rust-libbpf-sys+static-zlib-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys-devel = " \
 bash \
 cargo \
 elfutils-libelf-devel \
 kernel-headers \
 rust-cc+default-devel \
 rust-nix0.29+fs-devel \
 rust-nix0.29-devel \
 rust-pkg-config+default-devel \
 zlib-ng-compat-devel \
 "
