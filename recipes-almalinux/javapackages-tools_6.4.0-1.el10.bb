# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "javapackages-tools"
PV = "6.4.0"
PR = "1.el10"
PACKAGES = " \
 javapackages-common \
 javapackages-compat \
 javapackages-filesystem \
 javapackages-generators \
 javapackages-local-openjdk21 \
 javapackages-tools \
 maven-local-openjdk21 \
 python3-javapackages \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/javapackages-tools-6.4.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f5200cb1e3df9c60b3ddb953403ed8e95bd305965dfac61094f39a8a65708b0"

URI_x86_64_v2_javapackages-common = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/javapackages-common-6.4.0-1.el10.noarch.rpm;name=x86_64_v2_javapackages-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javapackages-common}"
SRC_URI[x86_64_v2_javapackages-common.sha256sum] = "238af1385b639bb0d9b85f341d1a08504a370bef83ffe23ec632bfb31e331360"

URI_x86_64_v2_javapackages-compat = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/javapackages-compat-6.4.0-1.el10.noarch.rpm;name=x86_64_v2_javapackages-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javapackages-compat}"
SRC_URI[x86_64_v2_javapackages-compat.sha256sum] = "b28c8b44803cbf63e1155edc16a9ff873e10c9c68b5694a599de9812ed2ca588"

URI_x86_64_v2_javapackages-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/javapackages-filesystem-6.4.0-1.el10.noarch.rpm;name=x86_64_v2_javapackages-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javapackages-filesystem}"
SRC_URI[x86_64_v2_javapackages-filesystem.sha256sum] = "5ec49522c2266cab0594b13ef86d5c2e60294c3dca82f6cb67acf71a7ef73132"

URI_x86_64_v2_javapackages-generators = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/javapackages-generators-6.4.0-1.el10.noarch.rpm;name=x86_64_v2_javapackages-generators;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javapackages-generators}"
SRC_URI[x86_64_v2_javapackages-generators.sha256sum] = "eb9d8ef15a4c48e0ea76468a1340b84ee1a3bf993c5c715ab58f94fab29c319f"

URI_x86_64_v2_javapackages-local-openjdk21 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/javapackages-local-openjdk21-6.4.0-1.el10.noarch.rpm;name=x86_64_v2_javapackages-local-openjdk21;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javapackages-local-openjdk21}"
SRC_URI[x86_64_v2_javapackages-local-openjdk21.sha256sum] = "ea6ea030fe0fb3cd602c9f6889273917b7b04d3f0827ecc57f918c950636df1d"

URI_x86_64_v2_javapackages-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/javapackages-tools-6.4.0-1.el10.noarch.rpm;name=x86_64_v2_javapackages-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javapackages-tools}"
SRC_URI[x86_64_v2_javapackages-tools.sha256sum] = "a264043f2abdd857d29bcde9cee5c51cb448e3f6397d40e442084a3b260a0845"

URI_x86_64_v2_maven-local-openjdk21 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-local-openjdk21-6.4.0-1.el10.noarch.rpm;name=x86_64_v2_maven-local-openjdk21;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-local-openjdk21}"
SRC_URI[x86_64_v2_maven-local-openjdk21.sha256sum] = "9866a5ec515f915dba847e1ef00afddf5d8a0a86e94e3eed11aff71ba4fe784e"

URI_x86_64_v2_python3-javapackages = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-javapackages-6.4.0-1.el10.noarch.rpm;name=x86_64_v2_python3-javapackages;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-javapackages}"
SRC_URI[x86_64_v2_python3-javapackages.sha256sum] = "bd35a0fe99a7d25a30133fd6ba01054ebc64a161ac460075b5704da90472be50"

URI_aarch64_javapackages-common = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/javapackages-common-6.4.0-1.el10.noarch.rpm;name=aarch64_javapackages-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_javapackages-common}"
SRC_URI[aarch64_javapackages-common.sha256sum] = "238af1385b639bb0d9b85f341d1a08504a370bef83ffe23ec632bfb31e331360"

URI_aarch64_javapackages-compat = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/javapackages-compat-6.4.0-1.el10.noarch.rpm;name=aarch64_javapackages-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_javapackages-compat}"
SRC_URI[aarch64_javapackages-compat.sha256sum] = "b28c8b44803cbf63e1155edc16a9ff873e10c9c68b5694a599de9812ed2ca588"

URI_aarch64_javapackages-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/javapackages-filesystem-6.4.0-1.el10.noarch.rpm;name=aarch64_javapackages-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_javapackages-filesystem}"
SRC_URI[aarch64_javapackages-filesystem.sha256sum] = "5ec49522c2266cab0594b13ef86d5c2e60294c3dca82f6cb67acf71a7ef73132"

URI_aarch64_javapackages-generators = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/javapackages-generators-6.4.0-1.el10.noarch.rpm;name=aarch64_javapackages-generators;unpack=0"
SRC_URI:append = " ${URI_aarch64_javapackages-generators}"
SRC_URI[aarch64_javapackages-generators.sha256sum] = "eb9d8ef15a4c48e0ea76468a1340b84ee1a3bf993c5c715ab58f94fab29c319f"

URI_aarch64_javapackages-local-openjdk21 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/javapackages-local-openjdk21-6.4.0-1.el10.noarch.rpm;name=aarch64_javapackages-local-openjdk21;unpack=0"
SRC_URI:append = " ${URI_aarch64_javapackages-local-openjdk21}"
SRC_URI[aarch64_javapackages-local-openjdk21.sha256sum] = "ea6ea030fe0fb3cd602c9f6889273917b7b04d3f0827ecc57f918c950636df1d"

URI_aarch64_javapackages-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/javapackages-tools-6.4.0-1.el10.noarch.rpm;name=aarch64_javapackages-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_javapackages-tools}"
SRC_URI[aarch64_javapackages-tools.sha256sum] = "a264043f2abdd857d29bcde9cee5c51cb448e3f6397d40e442084a3b260a0845"

URI_aarch64_maven-local-openjdk21 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-local-openjdk21-6.4.0-1.el10.noarch.rpm;name=aarch64_maven-local-openjdk21;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-local-openjdk21}"
SRC_URI[aarch64_maven-local-openjdk21.sha256sum] = "9866a5ec515f915dba847e1ef00afddf5d8a0a86e94e3eed11aff71ba4fe784e"

URI_aarch64_python3-javapackages = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-javapackages-6.4.0-1.el10.noarch.rpm;name=aarch64_python3-javapackages;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-javapackages}"
SRC_URI[aarch64_python3-javapackages.sha256sum] = "bd35a0fe99a7d25a30133fd6ba01054ebc64a161ac460075b5704da90472be50"

RDEPENDS:javapackages-common = " \
 javapackages-generators \
 "
RDEPENDS:javapackages-compat = " \
 javapackages-local-openjdk21 \
 "
RDEPENDS:javapackages-filesystem = " \
 "
RDEPENDS:javapackages-generators = " \
 javapackages-tools \
 python3 \
 python3-javapackages \
 "
RDEPENDS:javapackages-local-openjdk21 = " \
 ant-openjdk21 \
 java-21-openjdk-devel \
 javapackages-common \
 xmvn-generator \
 xmvn-tools \
 "
RDEPENDS:javapackages-tools = " \
 bash \
 findutils \
 javapackages-filesystem \
 virtual/coreutils \
 "
RDEPENDS:maven-local-openjdk21 = " \
 java-21-openjdk-devel \
 javapackages-local-openjdk21 \
 javapackages-tools \
 maven-compiler-plugin \
 maven-jar-plugin \
 maven-resources-plugin \
 maven-surefire-plugin \
 xmvn-minimal \
 xmvn-mojo \
 xmvn-toolchain-openjdk21 \
 "
RDEPENDS:python3-javapackages = " \
 python3 \
 python3-lxml \
 "
