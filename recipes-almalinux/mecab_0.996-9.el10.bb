# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mecab"
PV = "0.996"
PR = "9.el10"
PACKAGES = " \
 mecab \
 mecab-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mecab-0.996-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fcb3383e9a9ca1a5bf7ecbf121575749e7b9902805237b64a0de3d4c40fa0f2"

URI_x86_64_v2_mecab = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mecab-0.996-9.el10.x86_64_v2.rpm;name=x86_64_v2_mecab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mecab}"
SRC_URI[x86_64_v2_mecab.sha256sum] = "9a42dab32fa5e9c19a19a78a87e7c1ac413c078d1332764d78e05da5a09724fa"

URI_x86_64_v2_mecab-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mecab-devel-0.996-9.el10.x86_64_v2.rpm;name=x86_64_v2_mecab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mecab-devel}"
SRC_URI[x86_64_v2_mecab-devel.sha256sum] = "667af5220f06e751817c1277dd59980430fee8f17c957ecbb3d0424e022221d8"

URI_aarch64_mecab = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mecab-0.996-9.el10.aarch64.rpm;name=aarch64_mecab;unpack=0"
SRC_URI:append = " ${URI_aarch64_mecab}"
SRC_URI[aarch64_mecab.sha256sum] = "1b4a43f8151ff6d85f50ece3612df3cad91081f15c25355b7b3903ca9f388a31"

URI_aarch64_mecab-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mecab-devel-0.996-9.el10.aarch64.rpm;name=aarch64_mecab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mecab-devel}"
SRC_URI[aarch64_mecab-devel.sha256sum] = "1be0554a3f01cd5bbec1430f341dc44ed48639a515671f8536b69ae90da7ed80"

RDEPENDS:mecab = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:mecab-devel = " \
 bash \
 mecab \
 "
