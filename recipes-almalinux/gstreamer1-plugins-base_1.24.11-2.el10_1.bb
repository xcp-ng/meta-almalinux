# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-base"
PV = "1.24.11"
PR = "2.el10_1"
PACKAGES = " \
 gstreamer1-plugins-base \
 gstreamer1-plugins-base-devel \
 gstreamer1-plugins-base-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-base-1.24.11-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4608476c22b9fcffdaffe1782fd905a71a785f113f480409af645d8a59a82dfb"

URI_x86_64_v2_gstreamer1-plugins-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-1.24.11-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-base}"
SRC_URI[x86_64_v2_gstreamer1-plugins-base.sha256sum] = "2f85681e52802246dcd5e86f88b96e44d3b4f98b68dd41f1b8ebc9f49e0cc10e"

URI_x86_64_v2_gstreamer1-plugins-base-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-devel-1.24.11-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-base-devel}"
SRC_URI[x86_64_v2_gstreamer1-plugins-base-devel.sha256sum] = "fa3795dfdd1c839565887d459c87d0b8e9fbe0999b7c205c0642a2828e5ea5e3"

URI_x86_64_v2_gstreamer1-plugins-base-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-tools-1.24.11-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-base-tools}"
SRC_URI[x86_64_v2_gstreamer1-plugins-base-tools.sha256sum] = "9df3367b7adb67ff26365d294abeba20fbd34b8edb3632ca3b51404e3c1375cc"

URI_aarch64_gstreamer1-plugins-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-1.24.11-2.el10_1.aarch64.rpm;name=aarch64_gstreamer1-plugins-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-base}"
SRC_URI[aarch64_gstreamer1-plugins-base.sha256sum] = "97281e51134cf3b638081740d58ede2f1b1652fab6491abbae963de6e07ae947"

URI_aarch64_gstreamer1-plugins-base-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-devel-1.24.11-2.el10_1.aarch64.rpm;name=aarch64_gstreamer1-plugins-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-base-devel}"
SRC_URI[aarch64_gstreamer1-plugins-base-devel.sha256sum] = "7353e8fb7b23084bf11d574f3e4064a7c26471ddae0a43b5641ded3c07fd43fc"

URI_aarch64_gstreamer1-plugins-base-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-tools-1.24.11-2.el10_1.aarch64.rpm;name=aarch64_gstreamer1-plugins-base-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-base-tools}"
SRC_URI[aarch64_gstreamer1-plugins-base-tools.sha256sum] = "f1db203b62d58d037a0bcea2af7691b6779e9aae2b86e6a245b9a1810bb9f139"

RDEPENDS:gstreamer1-plugins-base = " \
 alsa-lib \
 cairo \
 glib2 \
 glibc \
 graphene \
 gstreamer1 \
 iso-codes \
 libX11 \
 libX11-xcb \
 libXext \
 libXi \
 libXv \
 libdrm \
 libglvnd-egl \
 libglvnd-glx \
 libgudev \
 libjpeg-turbo \
 libogg \
 libpng \
 libtheora \
 libvorbis \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxcb \
 mesa-libgbm \
 opus \
 orc \
 pango \
 zlib-ng-compat \
 "
RDEPENDS:gstreamer1-plugins-base-devel = " \
 glib2-devel \
 gstreamer1-devel \
 gstreamer1-plugins-base \
 gstreamer1-plugins-base-devel \
 libX11-devel \
 libdrm-devel \
 libglvnd-devel \
 libgudev-devel \
 mesa-libgbm-devel \
 orc-devel \
 pkgconf-pkg-config \
 wayland-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:gstreamer1-plugins-base-tools = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 "
