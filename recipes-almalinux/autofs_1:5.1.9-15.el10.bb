# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "autofs"
PE = "1"
PV = "5.1.9"
PR = "15.el10"
PACKAGES = " \
 autofs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/autofs-5.1.9-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e52c72429b7bc2023004c0a21aad865fbe2e3b46434204446a8fa1edc0023af8"

URI_x86_64_v2_autofs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/autofs-5.1.9-15.el10.x86_64_v2.rpm;name=x86_64_v2_autofs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_autofs}"
SRC_URI[x86_64_v2_autofs.sha256sum] = "e288aa7f2540b7e795a18afad200615a89666360a6b6226589c1e7a56ab15f66"

URI_aarch64_autofs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/autofs-5.1.9-15.el10.aarch64.rpm;name=aarch64_autofs;unpack=0"
SRC_URI:append = " ${URI_aarch64_autofs}"
SRC_URI[aarch64_autofs.sha256sum] = "d8b24eb8505740fc41af033def8dc8b0af14a94abfe599d901ec8853cd9d55d0"

RDEPENDS:autofs = " \
 bash \
 cyrus-sasl-lib \
 gawk \
 glibc \
 grep \
 kmod \
 krb5-libs \
 libcom_err \
 libgcc \
 libtirpc \
 libxml2 \
 openldap \
 procps-ng \
 sed \
 systemd \
 systemd-libs \
 virtual/coreutils \
 "
