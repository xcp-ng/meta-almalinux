# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Type-Tiny"
PV = "2.006000"
PR = "1.el10_0"
PACKAGES = " \
 perl-Test-TypeTiny \
 perl-Type-Tiny \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Type-Tiny-2.006000-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8df9f0787fc6b1387d3e3b0c4944994dabfb8282e2c45bb652bb9aec334f75a2"

URI_x86_64_v2_perl-Test-TypeTiny = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-TypeTiny-2.006000-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-TypeTiny;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-TypeTiny}"
SRC_URI[x86_64_v2_perl-Test-TypeTiny.sha256sum] = "8d1286cf5611439ebb1bf6e27c792cfce7bdb5b666a13998a45a52a77100f39e"

URI_x86_64_v2_perl-Type-Tiny = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Type-Tiny-2.006000-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Type-Tiny;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Type-Tiny}"
SRC_URI[x86_64_v2_perl-Type-Tiny.sha256sum] = "19fcc0426a74cd53169c85f83c594bc8334d89c523cfa0ce840fa72e2c08d235"

URI_aarch64_perl-Test-TypeTiny = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-TypeTiny-2.006000-1.el10_0.noarch.rpm;name=aarch64_perl-Test-TypeTiny;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-TypeTiny}"
SRC_URI[aarch64_perl-Test-TypeTiny.sha256sum] = "1d89818cb3a6bee37329117e67e084d16bb76ce4d61e88bc77f386782a2a1e95"

URI_aarch64_perl-Type-Tiny = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Type-Tiny-2.006000-1.el10_0.noarch.rpm;name=aarch64_perl-Type-Tiny;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Type-Tiny}"
SRC_URI[aarch64_perl-Type-Tiny.sha256sum] = "664aff1da59373151658c14c1d9ab582b574f4b8625325cac58006e71a157979"

RDEPENDS:perl-Test-TypeTiny = " \
 perl-Exporter-Tiny \
 perl-Scalar-List-Utils \
 perl-Test-Simple \
 perl-Type-Tiny \
 perl-libs \
 "
RDEPENDS:perl-Type-Tiny = " \
 perl-B \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter-Tiny \
 perl-Scalar-List-Utils \
 perl-Text-Balanced \
 perl-Type-Tiny \
 perl-libs \
 perl-mro \
 perl-namespace-clean \
 "
