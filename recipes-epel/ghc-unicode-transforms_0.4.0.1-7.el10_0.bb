# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-unicode-transforms"
PV = "0.4.0.1"
PR = "7.el10_0"
PACKAGES = " \
 ghc-unicode-data \
 ghc-unicode-data-devel \
 ghc-unicode-data-doc \
 ghc-unicode-data-prof \
 ghc-unicode-transforms \
 ghc-unicode-transforms-devel \
 ghc-unicode-transforms-doc \
 ghc-unicode-transforms-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-unicode-transforms-0.4.0.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7dc831784a8ff3a87408d6780c231724cc404eee33c2fa296d29d0fef30a3444"

URI_x86_64_v2_ghc-unicode-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unicode-data-0.6.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unicode-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unicode-data}"
SRC_URI[x86_64_v2_ghc-unicode-data.sha256sum] = "65716a6d6c7faa231f0c0f5c0a2f568c50ff3c505b5a6e36a2ca73a19ea24929"

URI_x86_64_v2_ghc-unicode-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unicode-data-devel-0.6.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unicode-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unicode-data-devel}"
SRC_URI[x86_64_v2_ghc-unicode-data-devel.sha256sum] = "fcb2e42f8ce64d15b5c7053b615b8d4e416a4f4fcfde4fda4866e544b7a86f85"

URI_x86_64_v2_ghc-unicode-data-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unicode-data-doc-0.6.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-unicode-data-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unicode-data-doc}"
SRC_URI[x86_64_v2_ghc-unicode-data-doc.sha256sum] = "675e4c817ba8f4fea90b363d83316b153768252b8609992b37aef5d5227c017e"

URI_x86_64_v2_ghc-unicode-data-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unicode-data-prof-0.6.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unicode-data-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unicode-data-prof}"
SRC_URI[x86_64_v2_ghc-unicode-data-prof.sha256sum] = "053f8bb395bd65e2829e88970d1df3cc815761a3708d55faa06f0a1b139d10eb"

URI_x86_64_v2_ghc-unicode-transforms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unicode-transforms-0.4.0.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unicode-transforms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unicode-transforms}"
SRC_URI[x86_64_v2_ghc-unicode-transforms.sha256sum] = "8fdd3b338732a495be05434813ad2aa714d6209e8ea4324cda429dfbb7be5213"

URI_x86_64_v2_ghc-unicode-transforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unicode-transforms-devel-0.4.0.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unicode-transforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unicode-transforms-devel}"
SRC_URI[x86_64_v2_ghc-unicode-transforms-devel.sha256sum] = "907fd511c93d568546a463726194d27af9a240ff95e225e1aa9aca6b725e1e16"

URI_x86_64_v2_ghc-unicode-transforms-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unicode-transforms-doc-0.4.0.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-unicode-transforms-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unicode-transforms-doc}"
SRC_URI[x86_64_v2_ghc-unicode-transforms-doc.sha256sum] = "3ddac5ebe3e2af133415464825bc78fe2a253bc9731ce066c89d238dba3d9931"

URI_x86_64_v2_ghc-unicode-transforms-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unicode-transforms-prof-0.4.0.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unicode-transforms-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unicode-transforms-prof}"
SRC_URI[x86_64_v2_ghc-unicode-transforms-prof.sha256sum] = "717287f81ff2d957303fae4b72347d21c9f22b25a3e7b44efb95d3a94fcd44cd"

URI_aarch64_ghc-unicode-data = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unicode-data-0.6.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-unicode-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unicode-data}"
SRC_URI[aarch64_ghc-unicode-data.sha256sum] = "a00f9ea89dd61f307795789979d0a3509673fb188ec452b1bc41a6574890013e"

URI_aarch64_ghc-unicode-data-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unicode-data-devel-0.6.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-unicode-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unicode-data-devel}"
SRC_URI[aarch64_ghc-unicode-data-devel.sha256sum] = "b0777bb239e8510a422247c1c34332383d3314c7036e7a62ba12acc43720c39e"

URI_aarch64_ghc-unicode-data-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unicode-data-doc-0.6.0-7.el10_0.noarch.rpm;name=aarch64_ghc-unicode-data-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unicode-data-doc}"
SRC_URI[aarch64_ghc-unicode-data-doc.sha256sum] = "e5f0264ba15521857a2f12060d1ded0ffc9c1dc6bba8b1182cab61da7f889275"

URI_aarch64_ghc-unicode-data-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unicode-data-prof-0.6.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-unicode-data-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unicode-data-prof}"
SRC_URI[aarch64_ghc-unicode-data-prof.sha256sum] = "a45b0ad5e9c814a4a4d9176ccd939fbbe2d9501806e6a1a0aff4df6a0fc4dec2"

URI_aarch64_ghc-unicode-transforms = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unicode-transforms-0.4.0.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-unicode-transforms;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unicode-transforms}"
SRC_URI[aarch64_ghc-unicode-transforms.sha256sum] = "2f068740358d22b3c4b7a673c0f9abf7b96b008c0e48b12588aa1a69f70dc745"

URI_aarch64_ghc-unicode-transforms-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unicode-transforms-devel-0.4.0.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-unicode-transforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unicode-transforms-devel}"
SRC_URI[aarch64_ghc-unicode-transforms-devel.sha256sum] = "77777ed67a9e0c1525cd87867db3d7ee15bfe0bba8bc217fec3179e1b0e3c757"

URI_aarch64_ghc-unicode-transforms-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unicode-transforms-doc-0.4.0.1-7.el10_0.noarch.rpm;name=aarch64_ghc-unicode-transforms-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unicode-transforms-doc}"
SRC_URI[aarch64_ghc-unicode-transforms-doc.sha256sum] = "2a8c337b3f7196a7b4503d5133c3415b7758aafab82e7f217ff805bbc433f3c7"

URI_aarch64_ghc-unicode-transforms-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unicode-transforms-prof-0.4.0.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-unicode-transforms-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unicode-transforms-prof}"
SRC_URI[aarch64_ghc-unicode-transforms-prof.sha256sum] = "7a08532dc0ba156b9e70166434c7cb3b7345e6daeaa1dc3171b21c801b47e009"

RDEPENDS:ghc-unicode-data = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-unicode-data-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-unicode-data \
 "
RDEPENDS:ghc-unicode-data-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-unicode-data-prof = " \
 ghc-base-prof \
 ghc-unicode-data-devel \
 "
RDEPENDS:ghc-unicode-transforms = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-unicode-data \
 glibc \
 gmp \
 "
RDEPENDS:ghc-unicode-transforms-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-text-devel \
 ghc-unicode-data-devel \
 ghc-unicode-transforms \
 "
RDEPENDS:ghc-unicode-transforms-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-unicode-transforms-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-text-prof \
 ghc-unicode-data-prof \
 ghc-unicode-transforms-devel \
 "
