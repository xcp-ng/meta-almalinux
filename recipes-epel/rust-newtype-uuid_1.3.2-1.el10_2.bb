# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-newtype-uuid"
PV = "1.3.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-newtype-uuid+alloc-devel \
 rust-newtype-uuid+default-devel \
 rust-newtype-uuid+proptest1-devel \
 rust-newtype-uuid+schemars08-devel \
 rust-newtype-uuid+serde-devel \
 rust-newtype-uuid+std-devel \
 rust-newtype-uuid+v4-devel \
 rust-newtype-uuid+v7-devel \
 rust-newtype-uuid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-newtype-uuid-1.3.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8088f1aa0f11193918b6849f99de3ef32e14a1b30a867732e3c2e38254af020b"

URI_x86_64_v2_rust-newtype-uuid+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+alloc-devel-1.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+alloc-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+alloc-devel.sha256sum] = "70f331996e84a0ef9b4e731025b3638a1cac5993186e5002b057a9d6bc53e381"

URI_x86_64_v2_rust-newtype-uuid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+default-devel-1.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+default-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+default-devel.sha256sum] = "cfc60936c941f232d777406d2ed704c5edb6c1533ff31f2b59ab8ed269ed2682"

URI_x86_64_v2_rust-newtype-uuid+proptest1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+proptest1-devel-1.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+proptest1-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+proptest1-devel.sha256sum] = "208472c8adeca69bb6367d051ce342e3fedf2da64819677ea0ddaa05085cbab2"

URI_x86_64_v2_rust-newtype-uuid+schemars08-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+schemars08-devel-1.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+schemars08-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+schemars08-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+schemars08-devel.sha256sum] = "29726a04b228e11367aeed5db231b5b79455713a491517c2b6201b17aa36391e"

URI_x86_64_v2_rust-newtype-uuid+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+serde-devel-1.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+serde-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+serde-devel.sha256sum] = "c89ab2d5323f23c273f5bb4926e8765827138305d8cef9bb5fb8523571a531a0"

URI_x86_64_v2_rust-newtype-uuid+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+std-devel-1.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+std-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+std-devel.sha256sum] = "0d7a58905798516252c5c63940d1bef35989f6e2c8184ae07642985124414353"

URI_x86_64_v2_rust-newtype-uuid+v4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+v4-devel-1.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+v4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+v4-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+v4-devel.sha256sum] = "9839bacc74b941d8a6b7a64bd2d7b82a411757027bb18051338328cfc6649645"

URI_x86_64_v2_rust-newtype-uuid+v7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+v7-devel-1.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+v7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+v7-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+v7-devel.sha256sum] = "1f8279ded218eafee651668fda58f2cadf7d0733db5f51f0cf688343b3170305"

URI_x86_64_v2_rust-newtype-uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid-devel-1.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid-devel.sha256sum] = "89b39cd5f41a8a3a5a5abbeec094c361439427e6e915907838fbf99ccd72ae2c"

URI_aarch64_rust-newtype-uuid+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+alloc-devel-1.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+alloc-devel}"
SRC_URI[aarch64_rust-newtype-uuid+alloc-devel.sha256sum] = "48e21dad6cc202ae038873cd4d007fe26c96ec942b14508e15d0b38cb03f6f27"

URI_aarch64_rust-newtype-uuid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+default-devel-1.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+default-devel}"
SRC_URI[aarch64_rust-newtype-uuid+default-devel.sha256sum] = "9c0dbe6ed79dc6d72aa22557b50667b1c33ff9e133d0390fd20d262cd788503f"

URI_aarch64_rust-newtype-uuid+proptest1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+proptest1-devel-1.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+proptest1-devel}"
SRC_URI[aarch64_rust-newtype-uuid+proptest1-devel.sha256sum] = "173dd84922914e3a3077a6c657cc2afd8182ed1489aace05cff907145da4b038"

URI_aarch64_rust-newtype-uuid+schemars08-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+schemars08-devel-1.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+schemars08-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+schemars08-devel}"
SRC_URI[aarch64_rust-newtype-uuid+schemars08-devel.sha256sum] = "179952fca788bba3599cfe15a694fbd22b6e4f84cf893d5aed4add1659e16ab7"

URI_aarch64_rust-newtype-uuid+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+serde-devel-1.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+serde-devel}"
SRC_URI[aarch64_rust-newtype-uuid+serde-devel.sha256sum] = "9f81701312c088fb3630a09c11ff9ff6be093a5743424b7815e451fd81e7e637"

URI_aarch64_rust-newtype-uuid+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+std-devel-1.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+std-devel}"
SRC_URI[aarch64_rust-newtype-uuid+std-devel.sha256sum] = "485e15b6a65bf1c0df484ef631f1b248e573418f5372a820c97f30b41f68982e"

URI_aarch64_rust-newtype-uuid+v4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+v4-devel-1.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+v4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+v4-devel}"
SRC_URI[aarch64_rust-newtype-uuid+v4-devel.sha256sum] = "2d9563e593262ceab0706d1354616cbf192fec7e4d1e6df701615fadd381d2f2"

URI_aarch64_rust-newtype-uuid+v7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+v7-devel-1.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+v7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+v7-devel}"
SRC_URI[aarch64_rust-newtype-uuid+v7-devel.sha256sum] = "176389457eb89bec68c3916a5d58d3b904810a677530e6f4e93a3cdbdbfc19f8"

URI_aarch64_rust-newtype-uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid-devel-1.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid-devel}"
SRC_URI[aarch64_rust-newtype-uuid-devel.sha256sum] = "9bdbb2764a11bc09e17f506ebb9c8c4618c87bdbdf6fbe95ffe636b40b0ff2a5"

RDEPENDS:rust-newtype-uuid+alloc-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 "
RDEPENDS:rust-newtype-uuid+default-devel = " \
 cargo \
 rust-newtype-uuid+std-devel \
 rust-newtype-uuid-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-newtype-uuid+proptest1-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-newtype-uuid+schemars08-devel = " \
 cargo \
 rust-newtype-uuid+std-devel \
 rust-newtype-uuid-devel \
 rust-schemars0.8+default-devel \
 rust-schemars0.8+uuid1-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-newtype-uuid+serde-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-uuid+serde-devel \
 "
RDEPENDS:rust-newtype-uuid+std-devel = " \
 cargo \
 rust-newtype-uuid+alloc-devel \
 rust-newtype-uuid-devel \
 rust-uuid+std-devel \
 "
RDEPENDS:rust-newtype-uuid+v4-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-uuid+v4-devel \
 "
RDEPENDS:rust-newtype-uuid+v7-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-uuid+v7-devel \
 "
RDEPENDS:rust-newtype-uuid-devel = " \
 cargo \
 rust \
 rust-uuid-devel \
 "
