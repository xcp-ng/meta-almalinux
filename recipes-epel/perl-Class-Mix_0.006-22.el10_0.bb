# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Mix"
PV = "0.006"
PR = "22.el10_0"
PACKAGES = " \
 perl-Class-Mix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-Mix-0.006-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de61c386f40dd1b545232f37aad7456a66f8b4acc3ea865a2e52b7943950c1e9"

URI_x86_64_v2_perl-Class-Mix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Mix-0.006-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Mix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Mix}"
SRC_URI[x86_64_v2_perl-Class-Mix.sha256sum] = "6b813bb25db9a07343aebcf808a289ba26468dd8a68eb067ab0073f9fe2a06d2"

URI_aarch64_perl-Class-Mix = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Mix-0.006-22.el10_0.noarch.rpm;name=aarch64_perl-Class-Mix;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Mix}"
SRC_URI[aarch64_perl-Class-Mix.sha256sum] = "6035a25da95dc5b31587fde5bce8e4e6b24cf5a4d7b5af3a42e556488e5fd974"

RDEPENDS:perl-Class-Mix = " \
 perl-Carp \
 perl-Exporter \
 perl-Params-Classify \
 perl-constant \
 perl-if \
 perl-libs \
 perl-mro \
 perl-parent \
 "
