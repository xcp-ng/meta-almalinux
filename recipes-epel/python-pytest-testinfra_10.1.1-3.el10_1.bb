# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-testinfra"
PV = "10.1.1"
PR = "3.el10_1"
PACKAGES = " \
 python3-pytest-testinfra \
 python3-pytest-testinfra+paramiko \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-testinfra-10.1.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a3d590cdc5dddc425dd7053491526bc2a7b163ef1bebbb597cb341de3714f5e"

URI_x86_64_v2_python3-pytest-testinfra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-testinfra-10.1.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-testinfra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-testinfra}"
SRC_URI[x86_64_v2_python3-pytest-testinfra.sha256sum] = "2b745e6a58fdd58ab1048e3d2a000df451306d77ca575ea59187f4f117b18409"

URI_x86_64_v2_python3-pytest-testinfra+paramiko = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-testinfra+paramiko-10.1.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-testinfra+paramiko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-testinfra+paramiko}"
SRC_URI[x86_64_v2_python3-pytest-testinfra+paramiko.sha256sum] = "f758b53ab0d58fd16c7e8f1aa06e4afad6f026d293703c73bab9de085a284b85"

URI_aarch64_python3-pytest-testinfra = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-testinfra-10.1.1-3.el10_1.noarch.rpm;name=aarch64_python3-pytest-testinfra;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-testinfra}"
SRC_URI[aarch64_python3-pytest-testinfra.sha256sum] = "fc50491c2c1f2b508681da0c93bd543c624dd1ceeaa6edac8de7f3a894cdf87e"

URI_aarch64_python3-pytest-testinfra+paramiko = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-testinfra+paramiko-10.1.1-3.el10_1.noarch.rpm;name=aarch64_python3-pytest-testinfra+paramiko;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-testinfra+paramiko}"
SRC_URI[aarch64_python3-pytest-testinfra+paramiko.sha256sum] = "d33d5d4a86229a6e2306469ff4284a561d6bd368447aaac1a4d273130edf6e90"

RDEPENDS:python3-pytest-testinfra = " \
 python3 \
 python3-pytest \
 "
RDEPENDS:python3-pytest-testinfra+paramiko = " \
 python3 \
 python3-paramiko \
 python3-pytest-testinfra \
 "
