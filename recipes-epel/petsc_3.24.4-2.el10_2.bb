# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "petsc"
PV = "3.24.4"
PR = "2.el10_2"
PACKAGES = " \
 petsc \
 petsc-devel \
 petsc-doc \
 petsc-mpich \
 petsc-mpich-devel \
 petsc-openmpi \
 petsc-openmpi-devel \
 petsc64 \
 petsc64-devel \
 python3-petsc-mpich \
 python3-petsc-openmpi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/petsc-3.24.4-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a657c66265a9407406dc7f1fcf6216ef4853fc8b1c1af25a55fe6c5d1556d63"

URI_x86_64_v2_petsc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc-3.24.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc}"
SRC_URI[x86_64_v2_petsc.sha256sum] = "eb1f675799d29ce143dc7c872e48e5c67932fd29088996bae218147b7f52c0af"

URI_x86_64_v2_petsc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc-devel-3.24.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc-devel}"
SRC_URI[x86_64_v2_petsc-devel.sha256sum] = "08a0f89e7d2d50e9917d6727d7f6e58026e78f579ced64a8516d302aa90ec3cb"

URI_x86_64_v2_petsc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc-doc-3.24.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_petsc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc-doc}"
SRC_URI[x86_64_v2_petsc-doc.sha256sum] = "ef129917fafe6ed4971b83632b5a608a01a486c23583454d6d35669c586e1361"

URI_x86_64_v2_petsc-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc-mpich-3.24.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc-mpich}"
SRC_URI[x86_64_v2_petsc-mpich.sha256sum] = "6e815b30b1d7dd1e4a89443c671ddade2878cdcac1c3935a098511cf2acdd2a9"

URI_x86_64_v2_petsc-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc-mpich-devel-3.24.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc-mpich-devel}"
SRC_URI[x86_64_v2_petsc-mpich-devel.sha256sum] = "bf56f6b1c2abca39b5c0cde55ecb1e7050825b127a75b049637799a11dba598d"

URI_x86_64_v2_petsc-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc-openmpi-3.24.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc-openmpi}"
SRC_URI[x86_64_v2_petsc-openmpi.sha256sum] = "a48c3fcdcf8191d11e194294d101bcb140d06af2f203fb816f5180eb709ef836"

URI_x86_64_v2_petsc-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc-openmpi-devel-3.24.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc-openmpi-devel}"
SRC_URI[x86_64_v2_petsc-openmpi-devel.sha256sum] = "e5e3dbc3680f6d6e717658a108f32fd7dc7ff5a419c808e7172393a90e59bfd5"

URI_x86_64_v2_petsc64 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc64-3.24.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc64}"
SRC_URI[x86_64_v2_petsc64.sha256sum] = "d86f8cc95d5cc73e3bc96f7305f3cecc330f9253e41b565d1ea807fae7316472"

URI_x86_64_v2_petsc64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc64-devel-3.24.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc64-devel}"
SRC_URI[x86_64_v2_petsc64-devel.sha256sum] = "ec049976e21c792a16c6dbc8ee9fb96e7e874b42ed449887762f962cc5d28212"

URI_x86_64_v2_python3-petsc-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-petsc-mpich-3.24.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-petsc-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-petsc-mpich}"
SRC_URI[x86_64_v2_python3-petsc-mpich.sha256sum] = "257a95d76b0f4db0f8a63a5154fb7c8221f516664d8a0285d6df92eaff50fae7"

URI_x86_64_v2_python3-petsc-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-petsc-openmpi-3.24.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-petsc-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-petsc-openmpi}"
SRC_URI[x86_64_v2_python3-petsc-openmpi.sha256sum] = "c69d5af22dea6a11dbcf269de3f0c9b7054bedbf955e2ac356a085b2def1670f"

URI_aarch64_petsc = "${EPEL_MIRROR}/aarch64/Packages/p/petsc-3.24.4-2.el10_2.aarch64.rpm;name=aarch64_petsc;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc}"
SRC_URI[aarch64_petsc.sha256sum] = "8f3e205aa64f5c19623f1a506decb6569647c4d9409742efbf616566a7652cf9"

URI_aarch64_petsc-devel = "${EPEL_MIRROR}/aarch64/Packages/p/petsc-devel-3.24.4-2.el10_2.aarch64.rpm;name=aarch64_petsc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc-devel}"
SRC_URI[aarch64_petsc-devel.sha256sum] = "a2520b7f18f0275ddf5e249b0335a29b9f816a2645c32e24a4413301399a088a"

URI_aarch64_petsc-doc = "${EPEL_MIRROR}/aarch64/Packages/p/petsc-doc-3.24.4-2.el10_2.noarch.rpm;name=aarch64_petsc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc-doc}"
SRC_URI[aarch64_petsc-doc.sha256sum] = "625f9277d42ec1f738ebed83865cd833d8d8e4caa66c1b372c08f91a305c9bb1"

URI_aarch64_petsc-mpich = "${EPEL_MIRROR}/aarch64/Packages/p/petsc-mpich-3.24.4-2.el10_2.aarch64.rpm;name=aarch64_petsc-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc-mpich}"
SRC_URI[aarch64_petsc-mpich.sha256sum] = "1fb91aeddb3a484d3e6bfeb10a7b9462980b8e2d74ddd4a110e2bcba74283ffa"

URI_aarch64_petsc-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/p/petsc-mpich-devel-3.24.4-2.el10_2.aarch64.rpm;name=aarch64_petsc-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc-mpich-devel}"
SRC_URI[aarch64_petsc-mpich-devel.sha256sum] = "687ab382c961cfb393422d4803eb5db89562789226db30a6b5faa8cd7f5d9304"

URI_aarch64_petsc-openmpi = "${EPEL_MIRROR}/aarch64/Packages/p/petsc-openmpi-3.24.4-2.el10_2.aarch64.rpm;name=aarch64_petsc-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc-openmpi}"
SRC_URI[aarch64_petsc-openmpi.sha256sum] = "495e72e386c78658585601bc796382a1328b824e8e703d1cac287d9cdffc2eef"

URI_aarch64_petsc-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/p/petsc-openmpi-devel-3.24.4-2.el10_2.aarch64.rpm;name=aarch64_petsc-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc-openmpi-devel}"
SRC_URI[aarch64_petsc-openmpi-devel.sha256sum] = "26b9a97d893534a2798aed5bd032a09c5bc138c55991463179e81cc74002b112"

URI_aarch64_petsc64 = "${EPEL_MIRROR}/aarch64/Packages/p/petsc64-3.24.4-2.el10_2.aarch64.rpm;name=aarch64_petsc64;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc64}"
SRC_URI[aarch64_petsc64.sha256sum] = "89405c5e1512fe5ab263e693b921c4b2a4f843c84c94fee7b770ce19142aca65"

URI_aarch64_petsc64-devel = "${EPEL_MIRROR}/aarch64/Packages/p/petsc64-devel-3.24.4-2.el10_2.aarch64.rpm;name=aarch64_petsc64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc64-devel}"
SRC_URI[aarch64_petsc64-devel.sha256sum] = "43e1b3902f65297ad0fbbd61097d37879b00187dab07237940a4ce951af71831"

URI_aarch64_python3-petsc-mpich = "${EPEL_MIRROR}/aarch64/Packages/p/python3-petsc-mpich-3.24.4-2.el10_2.aarch64.rpm;name=aarch64_python3-petsc-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-petsc-mpich}"
SRC_URI[aarch64_python3-petsc-mpich.sha256sum] = "6c3931af884cd04e806e6fdb116c45031587894387d1aebd6ec61a185de2f805"

URI_aarch64_python3-petsc-openmpi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-petsc-openmpi-3.24.4-2.el10_2.aarch64.rpm;name=aarch64_python3-petsc-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-petsc-openmpi}"
SRC_URI[aarch64_python3-petsc-openmpi.sha256sum] = "37b7553b38dec2f752030a02cfd12073a86364f5ad7d66ee3b1adad448914646"

RDEPENDS:petsc = " \
 SuperLU \
 flexiblas-netlib \
 glibc \
 hdf5 \
 libX11 \
 libgcc \
 libstdc++ \
 metis \
 "
RDEPENDS:petsc-devel = " \
 gcc-gfortran \
 petsc \
 pkgconf-pkg-config \
 "
RDEPENDS:petsc-doc = " \
 "
RDEPENDS:petsc-mpich = " \
 MUMPS-mpich \
 flexiblas-netlib \
 glibc \
 hdf5-mpich \
 hypre-mpich \
 libX11 \
 libgcc \
 libstdc++ \
 metis \
 mpich \
 ptscotch-mpich \
 scalapack-mpich \
 superlu_dist-mpich \
 "
RDEPENDS:petsc-mpich-devel = " \
 hdf5-mpich-devel \
 mpich-devel \
 petsc-mpich \
 "
RDEPENDS:petsc-openmpi = " \
 MUMPS-openmpi \
 flexiblas-netlib \
 glibc \
 hdf5-openmpi \
 hypre-openmpi \
 libX11 \
 libgcc \
 libstdc++ \
 metis \
 openmpi \
 ptscotch-openmpi \
 scalapack-openmpi \
 superlu_dist-openmpi \
 "
RDEPENDS:petsc-openmpi-devel = " \
 hdf5-openmpi-devel \
 openmpi-devel \
 petsc-openmpi \
 "
RDEPENDS:petsc64 = " \
 flexiblas-netlib64 \
 glibc \
 hdf5 \
 libX11 \
 libgcc \
 libstdc++ \
 metis64 \
 "
RDEPENDS:petsc64-devel = " \
 gcc-gfortran \
 petsc64 \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-petsc-mpich = " \
 MUMPS-mpich \
 glibc \
 hdf5-mpich \
 mpich \
 petsc-mpich \
 ptscotch-mpich \
 python3 \
 scalapack-mpich \
 "
RDEPENDS:python3-petsc-openmpi = " \
 MUMPS-openmpi \
 glibc \
 hdf5-openmpi \
 openmpi \
 petsc-openmpi \
 ptscotch-openmpi \
 python3 \
 scalapack-openmpi \
 "
