# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keditbookmarks"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 keditbookmarks \
 keditbookmarks-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/keditbookmarks-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d17dc884bbcf050663eabb2e7986a4e04cf541fbea722ba776b074344c3456b3"

URI_x86_64_v2_keditbookmarks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keditbookmarks-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keditbookmarks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keditbookmarks}"
SRC_URI[x86_64_v2_keditbookmarks.sha256sum] = "b51446145ff410a37632a9094a939e18316c0f932345e104590f8c9891bbb07c"

URI_x86_64_v2_keditbookmarks-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keditbookmarks-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keditbookmarks-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keditbookmarks-libs}"
SRC_URI[x86_64_v2_keditbookmarks-libs.sha256sum] = "bb250ddfcaedf97118b1a1810f2266bec0c49b1a36ec829f995116ea678d8fd7"

URI_aarch64_keditbookmarks = "${EPEL_MIRROR}/aarch64/Packages/k/keditbookmarks-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_keditbookmarks;unpack=0"
SRC_URI:append = " ${URI_aarch64_keditbookmarks}"
SRC_URI[aarch64_keditbookmarks.sha256sum] = "9fc77c7cdf5a71d483d8c7f27988d66aa531e298bef324b8faa225874e4f30f0"

URI_aarch64_keditbookmarks-libs = "${EPEL_MIRROR}/aarch64/Packages/k/keditbookmarks-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_keditbookmarks-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_keditbookmarks-libs}"
SRC_URI[aarch64_keditbookmarks-libs.sha256sum] = "df483fe7c9ab7f401a262eaba1958473ceab4ccbee971649eff64c1f8e0a1bb4"

RDEPENDS:keditbookmarks = " \
 glibc \
 keditbookmarks-libs \
 kf6-kbookmarks \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:keditbookmarks-libs = " \
 glibc \
 keditbookmarks \
 kf6-kbookmarks \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
