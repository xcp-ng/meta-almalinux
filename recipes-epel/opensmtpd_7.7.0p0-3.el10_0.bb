# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opensmtpd"
PV = "7.7.0p0"
PR = "3.el10_0"
PACKAGES = " \
 opensmtpd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/opensmtpd-7.7.0p0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7c9263cb37dec28c1567371b691281b71926f78dad4f0cf5f31a6f13ea9f16b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opensmtpd-7.7.0p0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opensmtpd;unpack=0"
SRC_URI[x86_64_v2_opensmtpd.sha256sum] = "4bf5f40019b3f1c2b898d41f3954de023970ced4a27ab4b73fd7d6d52dd8502c"
RPROVIDES:opensmtpd:append:x86_64_v2 = " virtual//usr/bin/mailq virtual//usr/sbin/sendmail virtual/smtpdaemon"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/opensmtpd-7.7.0p0-3.el10_0.aarch64.rpm;name=aarch64_opensmtpd;unpack=0"
SRC_URI[aarch64_opensmtpd.sha256sum] = "2d6e4c93b3f6d5b4ac50078228402aaccc5987edf4976dbe5c8c141924d23033"
RPROVIDES:opensmtpd:append:aarch64 = " virtual//usr/bin/mailq virtual//usr/sbin/sendmail virtual/smtpdaemon"

RDEPENDS:opensmtpd = " \
 bash \
 glibc \
 libdb \
 libevent \
 libxcrypt \
 openssl-libs \
 pam-libs \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
