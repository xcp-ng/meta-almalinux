# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "geany"
PV = "2.0"
PR = "6.el10_0"
PACKAGES = " \
 geany \
 geany-devel \
 geany-libgeany \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/geany-2.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a38bdeb190c5c6bbd8204cef975d6117ea75a1cd5793230118e9da26426f6da"

URI_x86_64_v2_geany = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/geany-2.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_geany;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_geany}"
SRC_URI[x86_64_v2_geany.sha256sum] = "03ef6086e75a06a31b5cfd639aa85c16a94bb2c280c5cc0797abab5eacddb199"

URI_x86_64_v2_geany-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/geany-devel-2.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_geany-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_geany-devel}"
SRC_URI[x86_64_v2_geany-devel.sha256sum] = "4f8e09f93867eb771313bad62c87df228294b14ee8b23646119597dbedf4bde1"

URI_x86_64_v2_geany-libgeany = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/geany-libgeany-2.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_geany-libgeany;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_geany-libgeany}"
SRC_URI[x86_64_v2_geany-libgeany.sha256sum] = "84b5020faa5af3af78970e5c9c3fa260530c9a55aa79ceb6cccbc3b8e58bd876"

URI_aarch64_geany = "${EPEL_MIRROR}/aarch64/Packages/g/geany-2.0-6.el10_0.aarch64.rpm;name=aarch64_geany;unpack=0"
SRC_URI:append = " ${URI_aarch64_geany}"
SRC_URI[aarch64_geany.sha256sum] = "0466bf57443c5c2f54c4eef90962bfdc341136239ca8f4a7f7563d9274ac80d6"

URI_aarch64_geany-devel = "${EPEL_MIRROR}/aarch64/Packages/g/geany-devel-2.0-6.el10_0.aarch64.rpm;name=aarch64_geany-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_geany-devel}"
SRC_URI[aarch64_geany-devel.sha256sum] = "b461d03a803d16b472788774e1c2cc8de8ddfa15bdad939c96e6e3072526c609"

URI_aarch64_geany-libgeany = "${EPEL_MIRROR}/aarch64/Packages/g/geany-libgeany-2.0-6.el10_0.aarch64.rpm;name=aarch64_geany-libgeany;unpack=0"
SRC_URI:append = " ${URI_aarch64_geany-libgeany}"
SRC_URI[aarch64_geany-libgeany.sha256sum] = "124268a0192114001d6f16c5812385c7ebc61eeee587c96f5d05a4f11ef80e38"

RDEPENDS:geany = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 geany-libgeany \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 pango \
 vte291 \
 "
RDEPENDS:geany-devel = " \
 geany \
 glib2-devel \
 gtk3-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:geany-libgeany = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 geany \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libgcc \
 libstdc++ \
 pango \
 "
