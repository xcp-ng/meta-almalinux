# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-thread_order"
PV = "1.1.1"
PR = "13.el10"
PACKAGES = " \
 rubygem-thread_order \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/rubygem-thread_order-1.1.1-13.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b7e4e3391d7dad2a83f2ea9e64da6a6039d5ae6718f55385684fa3c654e4d95b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rubygem-thread_order-1.1.1-13.el10.noarch.rpm;name=x86_64_v2_rubygem-thread_order;unpack=0"
SRC_URI[x86_64_v2_rubygem-thread_order.sha256sum] = "fa949e04fb511e648fcfc3cd8b8da2e055f8dec883bc965791afe24b813c6871"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rubygem-thread_order-1.1.1-13.el10.noarch.rpm;name=aarch64_rubygem-thread_order;unpack=0"
SRC_URI[aarch64_rubygem-thread_order.sha256sum] = "fa949e04fb511e648fcfc3cd8b8da2e055f8dec883bc965791afe24b813c6871"

RDEPENDS:rubygem-thread_order = " \
 rubygems \
 "
