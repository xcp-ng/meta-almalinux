# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quick-xml"
PV = "0.38.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-quick-xml+arbitrary-devel \
 rust-quick-xml+async-tokio-devel \
 rust-quick-xml+default-devel \
 rust-quick-xml+document-features-devel \
 rust-quick-xml+encoding-devel \
 rust-quick-xml+encoding_rs-devel \
 rust-quick-xml+escape-html-devel \
 rust-quick-xml+overlapped-lists-devel \
 rust-quick-xml+serde-devel \
 rust-quick-xml+serde-types-devel \
 rust-quick-xml+serialize-devel \
 rust-quick-xml+tokio-devel \
 rust-quick-xml-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-quick-xml-0.38.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "49898d0cf3d290e00401397a6e822a189523e03ce08817939177cd77cf217a00"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+arbitrary-devel-0.38.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-quick-xml+arbitrary-devel.sha256sum] = "23adda292afe57f6f5fe06ca43c87989ca59d6f69c18171cc0079b8409cb2479"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+async-tokio-devel-0.38.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+async-tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-quick-xml+async-tokio-devel.sha256sum] = "874c0a7f834a8dbeb8178629a0c32e22e7a1ab4816e7d5778f194b9ebeb5d528"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+default-devel-0.38.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-quick-xml+default-devel.sha256sum] = "9a6897b187681b2e0f945fa69a3b48f7f4e5d79d3b51f4ae9b3d651328f697c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+document-features-devel-0.38.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+document-features-devel;unpack=0"
SRC_URI[x86_64_v2_rust-quick-xml+document-features-devel.sha256sum] = "038e62f5228e4b53608e5d2400b530dba3fd79df6ddb6499169f1a0bbbbbad71"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+encoding-devel-0.38.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+encoding-devel;unpack=0"
SRC_URI[x86_64_v2_rust-quick-xml+encoding-devel.sha256sum] = "021acbb11aca69ece4e9e1679ec32341b3f71c447c3c47c59d247f3763c5ba8f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+encoding_rs-devel-0.38.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+encoding_rs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-quick-xml+encoding_rs-devel.sha256sum] = "2b41eee21bb21282f6e9065989c77cad572eba1bbbe1ceb7520913bc497aee57"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+escape-html-devel-0.38.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+escape-html-devel;unpack=0"
SRC_URI[x86_64_v2_rust-quick-xml+escape-html-devel.sha256sum] = "fa970b52e1e2f969f88aa0d380185b723fc53ca73208655db2c095b70f7bd54d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+overlapped-lists-devel-0.38.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+overlapped-lists-devel;unpack=0"
SRC_URI[x86_64_v2_rust-quick-xml+overlapped-lists-devel.sha256sum] = "7cbbda5781db7b04f1187cca843ae4d6ac360ea9aa667b538e8ff6ce78ecde2e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+serde-devel-0.38.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-quick-xml+serde-devel.sha256sum] = "204b4c7e60b369b98c24759ba0d71d733be9d3fa9abab9abcd0d011d3817fc94"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+serde-types-devel-0.38.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+serde-types-devel;unpack=0"
SRC_URI[x86_64_v2_rust-quick-xml+serde-types-devel.sha256sum] = "bb5544c08c04311ab982036ad42bcc509d6e2949ec05a62a1b294bc424e7760a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+serialize-devel-0.38.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+serialize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-quick-xml+serialize-devel.sha256sum] = "6d50da77463edae7d28bdbc3de68383134528c52a9e1bc340c7b6a4a503a6b86"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+tokio-devel-0.38.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-quick-xml+tokio-devel.sha256sum] = "4e019216ed99ff1ec2c8ec93540d785870456817e3ef81deb2a0e44113314199"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml-devel-0.38.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml-devel;unpack=0"
SRC_URI[x86_64_v2_rust-quick-xml-devel.sha256sum] = "f461af2d17ef2d2bb587822747ffade4fd5dccfe430768d1824d0df169c85d3d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+arbitrary-devel-0.38.4-1.el10_2.noarch.rpm;name=aarch64_rust-quick-xml+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-quick-xml+arbitrary-devel.sha256sum] = "c6c71f9b47fbd8596ebd5c5b4e7fb3633dfa751e3bbee0bb97454ee996a2a76e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+async-tokio-devel-0.38.4-1.el10_2.noarch.rpm;name=aarch64_rust-quick-xml+async-tokio-devel;unpack=0"
SRC_URI[aarch64_rust-quick-xml+async-tokio-devel.sha256sum] = "73160db9a2f7ab62d7442152ac113c03990d880d600848a17136fc36012fb400"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+default-devel-0.38.4-1.el10_2.noarch.rpm;name=aarch64_rust-quick-xml+default-devel;unpack=0"
SRC_URI[aarch64_rust-quick-xml+default-devel.sha256sum] = "dba4a5223b9597e49600daca35ec5d166ddb872e388ff313d089d73e2a4bd7fc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+document-features-devel-0.38.4-1.el10_2.noarch.rpm;name=aarch64_rust-quick-xml+document-features-devel;unpack=0"
SRC_URI[aarch64_rust-quick-xml+document-features-devel.sha256sum] = "eb9f8969c2fa8098a6ec111881b0d4704c024547eda753b926e114599b27b957"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+encoding-devel-0.38.4-1.el10_2.noarch.rpm;name=aarch64_rust-quick-xml+encoding-devel;unpack=0"
SRC_URI[aarch64_rust-quick-xml+encoding-devel.sha256sum] = "32e5b283580637a799fa0dc99eb3a5cf0a3c7a77b2cc4ef3d856cb0c4c797091"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+encoding_rs-devel-0.38.4-1.el10_2.noarch.rpm;name=aarch64_rust-quick-xml+encoding_rs-devel;unpack=0"
SRC_URI[aarch64_rust-quick-xml+encoding_rs-devel.sha256sum] = "a92979d93676c6c1b876899637ea54730429f322c7f82a72e1b3a3774e90f328"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+escape-html-devel-0.38.4-1.el10_2.noarch.rpm;name=aarch64_rust-quick-xml+escape-html-devel;unpack=0"
SRC_URI[aarch64_rust-quick-xml+escape-html-devel.sha256sum] = "e22fb9576d77643c4064d550bc45ae29e6e3e4b9260535365bdea6b81e2a2b22"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+overlapped-lists-devel-0.38.4-1.el10_2.noarch.rpm;name=aarch64_rust-quick-xml+overlapped-lists-devel;unpack=0"
SRC_URI[aarch64_rust-quick-xml+overlapped-lists-devel.sha256sum] = "766543882bbabdd448e11f1087fa7254ec6cc4efa7a9aa5ff6c3745b34fca52b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+serde-devel-0.38.4-1.el10_2.noarch.rpm;name=aarch64_rust-quick-xml+serde-devel;unpack=0"
SRC_URI[aarch64_rust-quick-xml+serde-devel.sha256sum] = "804ed7519a289a8e99de6256e67ea799edde0d13e347c358fc29b6f2449d261b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+serde-types-devel-0.38.4-1.el10_2.noarch.rpm;name=aarch64_rust-quick-xml+serde-types-devel;unpack=0"
SRC_URI[aarch64_rust-quick-xml+serde-types-devel.sha256sum] = "942f811c96db2bb05e4866f6ea54762334517616adad14e5066aef6600f42e6e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+serialize-devel-0.38.4-1.el10_2.noarch.rpm;name=aarch64_rust-quick-xml+serialize-devel;unpack=0"
SRC_URI[aarch64_rust-quick-xml+serialize-devel.sha256sum] = "0435fc38e99d6ec2f8ef12045cc5eb7ef69e14fd398989c1f3cb692eccdc41bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+tokio-devel-0.38.4-1.el10_2.noarch.rpm;name=aarch64_rust-quick-xml+tokio-devel;unpack=0"
SRC_URI[aarch64_rust-quick-xml+tokio-devel.sha256sum] = "489a065a0c5c301f57b3a7332631925bde14d8ed2d11a0b2e57e563f252f0479"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml-devel-0.38.4-1.el10_2.noarch.rpm;name=aarch64_rust-quick-xml-devel;unpack=0"
SRC_URI[aarch64_rust-quick-xml-devel.sha256sum] = "32a6eef2b0fd1c088b9ff770718c2fff9ca3a3f11338d513cb924c2fe431cd0d"

RDEPENDS:rust-quick-xml+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+async-tokio-devel = " \
 cargo \
 rust-quick-xml+tokio-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+default-devel = " \
 cargo \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+encoding-devel = " \
 cargo \
 rust-quick-xml+encoding_rs-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+encoding_rs-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+escape-html-devel = " \
 cargo \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+overlapped-lists-devel = " \
 cargo \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+serde-devel = " \
 cargo \
 rust-quick-xml-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-quick-xml+serde-types-devel = " \
 cargo \
 rust-quick-xml-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-quick-xml+serialize-devel = " \
 cargo \
 rust-quick-xml+serde-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+tokio-devel = " \
 cargo \
 rust-quick-xml-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-quick-xml-devel = " \
 cargo \
 rust \
 rust-memchr+default-devel \
 "
