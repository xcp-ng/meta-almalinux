# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MIME-Base64"
PV = "3.16"
PR = "511.el10"
PACKAGES = " \
 perl-MIME-Base64 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/perl-MIME-Base64-3.16-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a08f0517960ee3e16370304d4d8ec0123b6c84ab9e7b8736455152abf2e64827"

URI_x86_64_v2_perl-MIME-Base64 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/perl-MIME-Base64-3.16-511.el10.x86_64_v2.rpm;name=x86_64_v2_perl-MIME-Base64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MIME-Base64}"
SRC_URI[x86_64_v2_perl-MIME-Base64.sha256sum] = "dd00112676f4aa0aa2142d0c99f2a3b892fd9d4fbf6d6d293cc3fb08f32b7fd1"

URI_aarch64_perl-MIME-Base64 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/perl-MIME-Base64-3.16-511.el10.aarch64.rpm;name=aarch64_perl-MIME-Base64;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MIME-Base64}"
SRC_URI[aarch64_perl-MIME-Base64.sha256sum] = "57953c7b222f50d367df7365dc2148ecd5c014e7e16bbcce3a72c473b3804acd"

RDEPENDS:perl-MIME-Base64 = " \
 glibc \
 perl-Exporter \
 perl-MIME-Base64 \
 perl-libs \
 "
