# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libusb1"
PV = "1.0.28"
PR = "1.el10"
PACKAGES = " \
 libusb1 \
 libusb1-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libusb1-1.0.28-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c9b322bacf764f4f3041f9401da15cca151eec9ce9fb203342c81da27244703"

URI_x86_64_v2_libusb1 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libusb1-1.0.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_libusb1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusb1}"
SRC_URI[x86_64_v2_libusb1.sha256sum] = "0e67a76ae75bfcccdd5362488d9e9c08cc33fb288a6fcd02347b253cd99e99e5"

URI_x86_64_v2_libusb1-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libusb1-devel-1.0.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_libusb1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusb1-devel}"
SRC_URI[x86_64_v2_libusb1-devel.sha256sum] = "5f4e4cbd0f7dc49040c9db6845602d04b64c1a4d5a83ea54658367116e57ed57"

URI_aarch64_libusb1 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libusb1-1.0.28-1.el10.aarch64.rpm;name=aarch64_libusb1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusb1}"
SRC_URI[aarch64_libusb1.sha256sum] = "270321e445729f7e89841b6260c8668771382c053d3a923e656e2cf15a076656"

URI_aarch64_libusb1-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libusb1-devel-1.0.28-1.el10.aarch64.rpm;name=aarch64_libusb1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusb1-devel}"
SRC_URI[aarch64_libusb1-devel.sha256sum] = "fdc41c9af56b7affdc93985d63c68e1d4d4b42281d15c05e312f996b59d07b0e"

RDEPENDS:libusb1 = " \
 glibc \
 systemd-libs \
 "
RDEPENDS:libusb1-devel = " \
 libusb1 \
 pkgconf-pkg-config \
 "
