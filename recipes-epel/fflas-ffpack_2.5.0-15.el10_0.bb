# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fflas-ffpack"
PV = "2.5.0"
PR = "15.el10_0"
PACKAGES = " \
 fflas-ffpack-devel \
 fflas-ffpack-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fflas-ffpack-2.5.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "851805294d929ceaec8909a22ecd79f25c40052b8b01cf5d775fca532eaa0339"

URI_x86_64_v2_fflas-ffpack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fflas-ffpack-devel-2.5.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fflas-ffpack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fflas-ffpack-devel}"
SRC_URI[x86_64_v2_fflas-ffpack-devel.sha256sum] = "46f29d68240704f43cf29993c738999a12397855c6251cd6280b35a7dc1ad89c"

URI_x86_64_v2_fflas-ffpack-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fflas-ffpack-doc-2.5.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fflas-ffpack-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fflas-ffpack-doc}"
SRC_URI[x86_64_v2_fflas-ffpack-doc.sha256sum] = "5797583cdbdd962e36901849a2f204e96b8a7307bba894b4a362559a68cb2cba"

URI_aarch64_fflas-ffpack-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fflas-ffpack-devel-2.5.0-15.el10_0.aarch64.rpm;name=aarch64_fflas-ffpack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fflas-ffpack-devel}"
SRC_URI[aarch64_fflas-ffpack-devel.sha256sum] = "f849dbc85afff435e002a28803df74b78d8154e91f8f6878c7d2d79cabf492aa"

URI_aarch64_fflas-ffpack-doc = "${EPEL_MIRROR}/aarch64/Packages/f/fflas-ffpack-doc-2.5.0-15.el10_0.noarch.rpm;name=aarch64_fflas-ffpack-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fflas-ffpack-doc}"
SRC_URI[aarch64_fflas-ffpack-doc.sha256sum] = "c1c1e5969baa1c5554661cf253a0fa7d78feab930c4cccbe0d15443d003247bf"

RDEPENDS:fflas-ffpack-devel = " \
 bash \
 flexiblas-devel \
 givaro-devel \
 gmp-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:fflas-ffpack-doc = " \
 "
