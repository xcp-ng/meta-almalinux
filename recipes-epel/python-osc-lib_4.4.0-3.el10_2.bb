# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-osc-lib"
PV = "4.4.0"
PR = "3.el10_2"
PACKAGES = " \
 python-osc-lib-doc \
 python3-osc-lib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-osc-lib-4.4.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df9a7ec206935a2866c585fc68ecec23bd8bd3485c0ec29fce91dbc327b56975"

URI_x86_64_v2_python-osc-lib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-osc-lib-doc-4.4.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-osc-lib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-osc-lib-doc}"
SRC_URI[x86_64_v2_python-osc-lib-doc.sha256sum] = "9025ebc89bfb048cdea68f02580ade35ba377b439c9eb5cde04cc415dc4c4fe3"

URI_x86_64_v2_python3-osc-lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-osc-lib-4.4.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-osc-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-osc-lib}"
SRC_URI[x86_64_v2_python3-osc-lib.sha256sum] = "500e5cd50936b32cc41cf50b329597450888cf3ebb061477ae53e586b80a4258"

URI_aarch64_python-osc-lib-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-osc-lib-doc-4.4.0-3.el10_2.noarch.rpm;name=aarch64_python-osc-lib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-osc-lib-doc}"
SRC_URI[aarch64_python-osc-lib-doc.sha256sum] = "9fcda9a4028a6e709b331d7e1b72fc44f90590ab923602ccf5ac99c8218c7eb6"

URI_aarch64_python3-osc-lib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-osc-lib-4.4.0-3.el10_2.noarch.rpm;name=aarch64_python3-osc-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-osc-lib}"
SRC_URI[aarch64_python3-osc-lib.sha256sum] = "8200674ca4c7cba9abb9922bbd277ab759041b70a5e3dc6e73f8167230f32220"

RDEPENDS:python-osc-lib-doc = " \
 "
RDEPENDS:python3-osc-lib = " \
 python3 \
 python3-cliff \
 python3-keystoneauth1 \
 python3-openstacksdk \
 python3-oslo-i18n \
 python3-oslo-utils \
 python3-pbr \
 python3-requests \
 python3-stevedore \
 "
