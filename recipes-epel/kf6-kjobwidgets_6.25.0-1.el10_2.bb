# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kjobwidgets"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kjobwidgets \
 kf6-kjobwidgets-devel \
 kf6-kjobwidgets-doc \
 kf6-kjobwidgets-html \
 python3-kf6-kjobwidgets \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kjobwidgets-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd2611bb4c3861331b8666a9ea3491f92244fb4db53f1769446bcf174ee25ec1"

URI_x86_64_v2_kf6-kjobwidgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kjobwidgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kjobwidgets}"
SRC_URI[x86_64_v2_kf6-kjobwidgets.sha256sum] = "b5d7cc4b874bd0a2bb0807f20c9d575984c4460eec56836309fca04fe691fe3c"

URI_x86_64_v2_kf6-kjobwidgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kjobwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kjobwidgets-devel}"
SRC_URI[x86_64_v2_kf6-kjobwidgets-devel.sha256sum] = "dbef7e9dacdcc76e5300ea23abd8e9c703f4ff64ea7cba583a9c52ffa4f6a756"

URI_x86_64_v2_kf6-kjobwidgets-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kjobwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kjobwidgets-doc}"
SRC_URI[x86_64_v2_kf6-kjobwidgets-doc.sha256sum] = "5e5224af24c98096cc4c858b7da0b478ba90f6c700ae906878db5ce083869d5e"

URI_x86_64_v2_kf6-kjobwidgets-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kjobwidgets-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kjobwidgets-html}"
SRC_URI[x86_64_v2_kf6-kjobwidgets-html.sha256sum] = "d85fbe848e44d3a503d19beea42559c4aabf56b5a5d908eedac217b50364d3fb"

URI_x86_64_v2_python3-kf6-kjobwidgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kjobwidgets-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kjobwidgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kjobwidgets}"
SRC_URI[x86_64_v2_python3-kf6-kjobwidgets.sha256sum] = "233ec1bc569a714fb3afbe0b8e842b911eb5da5510b052e40003af9c128a557f"

URI_aarch64_kf6-kjobwidgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kjobwidgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kjobwidgets}"
SRC_URI[aarch64_kf6-kjobwidgets.sha256sum] = "eeb9ebc75689b6619b4f627a25ba0cac2165d6a8c946b2335333049581f99a94"

URI_aarch64_kf6-kjobwidgets-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kjobwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kjobwidgets-devel}"
SRC_URI[aarch64_kf6-kjobwidgets-devel.sha256sum] = "b119f3befcf74db66bab9c41a3816aec06eae534a1c4f253fa2b06c773d335b6"

URI_aarch64_kf6-kjobwidgets-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kjobwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kjobwidgets-doc}"
SRC_URI[aarch64_kf6-kjobwidgets-doc.sha256sum] = "ef101ee8309d6def297ca1b1c66eb7b9103f0318b68743c7a5cdc9a7b7a1035a"

URI_aarch64_kf6-kjobwidgets-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kjobwidgets-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kjobwidgets-html}"
SRC_URI[aarch64_kf6-kjobwidgets-html.sha256sum] = "6232f33f0d360fd607f7fd032b55dcd40fb25026b7b573467dac0ac215e0e56d"

URI_aarch64_python3-kf6-kjobwidgets = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kjobwidgets-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_python3-kf6-kjobwidgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kjobwidgets}"
SRC_URI[aarch64_python3-kf6-kjobwidgets.sha256sum] = "3946a5887d134a672e28354a2bfce7edaea4777a814fecdd7a10b282ffa46d69"

RDEPENDS:kf6-kjobwidgets = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kjobwidgets-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kjobwidgets \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kjobwidgets-doc = " \
 "
RDEPENDS:kf6-kjobwidgets-html = " \
 "
RDEPENDS:python3-kf6-kjobwidgets = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kjobwidgets \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 "
