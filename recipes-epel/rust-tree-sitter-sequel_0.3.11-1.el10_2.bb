# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-sequel"
PV = "0.3.11"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-sequel+default-devel \
 rust-tree-sitter-sequel-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-sequel-0.3.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cc594cc90391bbdc60e951d1b2420e6ea03aa5e5c6fd8587cf3a1a5c08e10ea"

URI_x86_64_v2_rust-tree-sitter-sequel+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-sequel+default-devel-0.3.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-sequel+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-sequel+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-sequel+default-devel.sha256sum] = "41a5e778ffc1e4fafb420f998bb2b8633eb94390d0712b2127240ae15b3deaad"

URI_x86_64_v2_rust-tree-sitter-sequel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-sequel-devel-0.3.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-sequel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-sequel-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-sequel-devel.sha256sum] = "66c8a2bc34cc31ea271678677e083967b3ee870916dcbe5528c23c33797407b7"

URI_aarch64_rust-tree-sitter-sequel+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-sequel+default-devel-0.3.11-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-sequel+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-sequel+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-sequel+default-devel.sha256sum] = "5b8cabe8f27d367e2e7ccd273029b251f856e05dc66441b097bab7125fcbc227"

URI_aarch64_rust-tree-sitter-sequel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-sequel-devel-0.3.11-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-sequel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-sequel-devel}"
SRC_URI[aarch64_rust-tree-sitter-sequel-devel.sha256sum] = "ba4a7008fac09bf9483a13d7532f73de1ac05c0b89d522540ec3b9608c6be996"

RDEPENDS:rust-tree-sitter-sequel+default-devel = " \
 cargo \
 rust-tree-sitter-sequel-devel \
 "
RDEPENDS:rust-tree-sitter-sequel-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
