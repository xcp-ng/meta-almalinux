# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http"
PV = "1.5.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-http+default-devel \
 rust-http+std-devel \
 rust-http-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-http-1.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "960ad81da37eb0b0f6b20ede3bb0bae1233352ad59295d64ab0447e4ebc1b5db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http+default-devel-1.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-http+default-devel.sha256sum] = "21ab6f71c5422d3b9df524e31ee3ab33479312942cb86dc0c0aad1020189da8d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http+std-devel-1.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-http+std-devel.sha256sum] = "16f6068517a6dd4c9df0f0e23a7c1aa0ee4ebc9bbd19ef58d2450d64a33f598c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-devel-1.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-devel;unpack=0"
SRC_URI[x86_64_v2_rust-http-devel.sha256sum] = "523d5623e87ededc4c09819ad9e39ee6153808f9b651d0065ff4b657acc24a04"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-http+default-devel-1.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-http+default-devel;unpack=0"
SRC_URI[aarch64_rust-http+default-devel.sha256sum] = "e81f032a3cfc952a701368adc962ed32c39ff8a3bcb40408bb4323fe593048cc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-http+std-devel-1.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-http+std-devel;unpack=0"
SRC_URI[aarch64_rust-http+std-devel.sha256sum] = "d0274f0b545ecd691d44ce95ad0397027cf320a662e0c56ad3b0ce551ac2f74d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-http-devel-1.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-http-devel;unpack=0"
SRC_URI[aarch64_rust-http-devel.sha256sum] = "b69c039adea90cab5cc5767e0622d74444e262659402ef5a3db79d7d3d6030b8"

RDEPENDS:rust-http+default-devel = " \
 cargo \
 rust-http+std-devel \
 rust-http-devel \
 "
RDEPENDS:rust-http+std-devel = " \
 cargo \
 rust-http-devel \
 "
RDEPENDS:rust-http-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-itoa+default-devel \
 "
