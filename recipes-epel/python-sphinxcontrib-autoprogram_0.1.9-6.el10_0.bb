# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinxcontrib-autoprogram"
PV = "0.1.9"
PR = "6.el10_0"
PACKAGES = " \
 python3-sphinxcontrib-autoprogram \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinxcontrib-autoprogram-0.1.9-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b24e1fcaada3d149aa95a3fc6e8a4ad8670aef4ebda421ecf3e3ced8e6fae5a"

URI_x86_64_v2_python3-sphinxcontrib-autoprogram = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinxcontrib-autoprogram-0.1.9-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinxcontrib-autoprogram;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinxcontrib-autoprogram}"
SRC_URI[x86_64_v2_python3-sphinxcontrib-autoprogram.sha256sum] = "e75412e7c6e99ecd371824e26c2d5f35267e14e4078f24ca5d3fdf157356bc60"

URI_aarch64_python3-sphinxcontrib-autoprogram = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinxcontrib-autoprogram-0.1.9-6.el10_0.noarch.rpm;name=aarch64_python3-sphinxcontrib-autoprogram;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinxcontrib-autoprogram}"
SRC_URI[aarch64_python3-sphinxcontrib-autoprogram.sha256sum] = "7e6b0252dd89c5bf75d67793619e54e79f635ead707d17d6fc0fdb0234abf730"

RDEPENDS:python3-sphinxcontrib-autoprogram = " \
 python3 \
 python3-six \
 python3-sphinx \
 "
