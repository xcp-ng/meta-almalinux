# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmail-account-wizard"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kmail-account-wizard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmail-account-wizard-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a2bd61e894e0bfc5f274d5de5df43faab1bccf55e678ee824e16862e1f45c59"

URI_x86_64_v2_kmail-account-wizard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmail-account-wizard-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmail-account-wizard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmail-account-wizard}"
SRC_URI[x86_64_v2_kmail-account-wizard.sha256sum] = "33e24fbc3f36632162ff338dc22b8e63d77a6caaf89bd95d93a859af13dc6606"

URI_aarch64_kmail-account-wizard = "${EPEL_MIRROR}/aarch64/Packages/k/kmail-account-wizard-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmail-account-wizard;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmail-account-wizard}"
SRC_URI[aarch64_kmail-account-wizard.sha256sum] = "acbe06823dc68d5a9d7807b729caf5ab47c7c22d6adfd37c2bab80e31591b22b"

RDEPENDS:kmail-account-wizard = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kidentitymanagement \
 kmailtransport \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
