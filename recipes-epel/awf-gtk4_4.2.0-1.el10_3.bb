# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "awf-gtk4"
PV = "4.2.0"
PR = "1.el10_3"
PACKAGES = " \
 awf-gtk4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/awf-gtk4-4.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0c2c5e7260d95397a00b597e5371dda7e0df90559466ac1d0cf33a5d005349d"

URI_x86_64_v2_awf-gtk4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/awf-gtk4-4.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_awf-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_awf-gtk4}"
SRC_URI[x86_64_v2_awf-gtk4.sha256sum] = "07941b18fd4166ce83f1b1ef19f676b2e7c526d8390471d03148c599eb695475"

URI_aarch64_awf-gtk4 = "${EPEL_MIRROR}/aarch64/Packages/a/awf-gtk4-4.2.0-1.el10_3.aarch64.rpm;name=aarch64_awf-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_awf-gtk4}"
SRC_URI[aarch64_awf-gtk4.sha256sum] = "f41ab05e2eab7a96135d9afdd56295ef81d55044df88ac0749178401a7062a42"

RDEPENDS:awf-gtk4 = " \
 glib2 \
 glibc \
 gtk4 \
 hicolor-icon-theme \
 libnotify \
 pango \
 "
