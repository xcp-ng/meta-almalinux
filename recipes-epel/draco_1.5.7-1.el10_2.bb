# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "draco"
PV = "1.5.7"
PR = "1.el10_2"
PACKAGES = " \
 draco \
 draco-devel \
 draco-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/draco-1.5.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6d94f54d2fdf99fece6c6c1e3bf518ecc8af9086df836efe24802ecacaae321"

URI_x86_64_v2_draco = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/draco-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_draco;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_draco}"
SRC_URI[x86_64_v2_draco.sha256sum] = "04d48a611ca70a66cd2aeb4552b97e468993386c8e25bbd93bef18da8e387d87"

URI_x86_64_v2_draco-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/draco-devel-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_draco-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_draco-devel}"
SRC_URI[x86_64_v2_draco-devel.sha256sum] = "e366d8bdad3e561b3c1aff77caa7466fc13a9bfd900beef14e5562dca026bcb9"

URI_x86_64_v2_draco-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/draco-static-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_draco-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_draco-static}"
SRC_URI[x86_64_v2_draco-static.sha256sum] = "a9df56ec3a086e1711384e039bf5ce15ebeecdb6ee7ca171e8ec4c8ad131cb7d"

URI_aarch64_draco = "${EPEL_MIRROR}/aarch64/Packages/d/draco-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_draco;unpack=0"
SRC_URI:append = " ${URI_aarch64_draco}"
SRC_URI[aarch64_draco.sha256sum] = "d68558ac820e52d013f91d2cae9e7c95a46af739ad58a488846aede56ffe31b2"

URI_aarch64_draco-devel = "${EPEL_MIRROR}/aarch64/Packages/d/draco-devel-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_draco-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_draco-devel}"
SRC_URI[aarch64_draco-devel.sha256sum] = "0cb21fca07ba4157a52956a0de913d034ec8f916d2057aec6b21d9fb1ef1b733"

URI_aarch64_draco-static = "${EPEL_MIRROR}/aarch64/Packages/d/draco-static-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_draco-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_draco-static}"
SRC_URI[aarch64_draco-static.sha256sum] = "2f2d43a4bcfac08ad1545569c302fcbfd5efe04a7ae01c0b7ef9f5443fab4698"

RDEPENDS:draco = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:draco-devel = " \
 cmake-filesystem \
 draco \
 pkgconf-pkg-config \
 "
RDEPENDS:draco-static = " \
 draco-devel \
 "
