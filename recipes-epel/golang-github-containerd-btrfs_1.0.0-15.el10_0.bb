# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-containerd-btrfs"
PV = "1.0.0"
PR = "15.el10_0"
PACKAGES = " \
 golang-github-containerd-btrfs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-containerd-btrfs-1.0.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ebdbe1df3273366195932df224f0b7b75b84c49f3d604dcfdeb82295767f364"

URI_x86_64_v2_golang-github-containerd-btrfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-containerd-btrfs-devel-1.0.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-containerd-btrfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-containerd-btrfs-devel}"
SRC_URI[x86_64_v2_golang-github-containerd-btrfs-devel.sha256sum] = "b53de38a3cc8dc5a48c36826b89696a7bc5bf4e111857ef79806d058a8dd0874"

URI_aarch64_golang-github-containerd-btrfs-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-containerd-btrfs-devel-1.0.0-15.el10_0.noarch.rpm;name=aarch64_golang-github-containerd-btrfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-containerd-btrfs-devel}"
SRC_URI[aarch64_golang-github-containerd-btrfs-devel.sha256sum] = "a5aac8fbb5278bca003bc712b70a7ccea7234fa75da3307fc9a1ea5f9bcdb704"

RDEPENDS:golang-github-containerd-btrfs-devel = " \
 btrfs-progs-devel \
 go-filesystem \
 golang-github-pkg-errors-devel \
 "
