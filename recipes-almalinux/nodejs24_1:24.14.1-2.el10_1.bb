# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs24"
PE = "1"
PV = "24.14.1"
PR = "2.el10_1"
PACKAGES = " \
 nodejs24 \
 nodejs24-devel \
 nodejs24-docs \
 nodejs24-full-i18n \
 nodejs24-libs \
 nodejs24-npm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs24-24.14.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48ff232f0173900708a5fff567b91c7caa19dba585de5f18c1cc25a2e0d8d02c"

URI_x86_64_v2_nodejs24 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-24.14.1-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_nodejs24;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24}"
SRC_URI[x86_64_v2_nodejs24.sha256sum] = "67e333c5b71685f0d8db68c0a9ae541c5838b01467d42351b695d0d651ca9563"
RPROVIDES:nodejs24:x86_64_v2 = "virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

URI_x86_64_v2_nodejs24-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-devel-24.14.1-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_nodejs24-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24-devel}"
SRC_URI[x86_64_v2_nodejs24-devel.sha256sum] = "9fec9d56334bd835b0edd8536d83c875cbdf38213acb2d1d4bc2675510e714cf"

URI_x86_64_v2_nodejs24-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-docs-24.14.1-2.el10_1.noarch.rpm;name=x86_64_v2_nodejs24-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24-docs}"
SRC_URI[x86_64_v2_nodejs24-docs.sha256sum] = "81e6f775bc8a4c7d7c2ce500cc3f2479d761d469b23d108512ed35641fb29409"

URI_x86_64_v2_nodejs24-full-i18n = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-full-i18n-24.14.1-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_nodejs24-full-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24-full-i18n}"
SRC_URI[x86_64_v2_nodejs24-full-i18n.sha256sum] = "a6afe300570c35eb5171beb8b6a1fcf690e12ebe0cf38434ccd83466708ecb19"

URI_x86_64_v2_nodejs24-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-libs-24.14.1-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_nodejs24-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24-libs}"
SRC_URI[x86_64_v2_nodejs24-libs.sha256sum] = "dd887b23f5cfc5022e12fc9347bfda371a830430a3ba6accea0d9e9eb4cdc388"

URI_x86_64_v2_nodejs24-npm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-npm-11.11.0-1.24.14.1.2.el10_1.noarch.rpm;name=x86_64_v2_nodejs24-npm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs24-npm}"
SRC_URI[x86_64_v2_nodejs24-npm.sha256sum] = "e7f19716e6d8dcb0b9daf9491ad6784c0b082ebb17ffcf87d2608e16ee810ebf"

URI_aarch64_nodejs24 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-24.14.1-2.el10_1.aarch64.rpm;name=aarch64_nodejs24;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24}"
SRC_URI[aarch64_nodejs24.sha256sum] = "682de41649a8821c2895ebd55f87db5b9158f3adb2cac96acb0774b41516483f"
RPROVIDES:nodejs24:aarch64 = "virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

URI_aarch64_nodejs24-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-devel-24.14.1-2.el10_1.aarch64.rpm;name=aarch64_nodejs24-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24-devel}"
SRC_URI[aarch64_nodejs24-devel.sha256sum] = "94683bfd7b1012f6d76bbbb939ea9c7725a9c8d0547ac54b4af23e7f12c5c77a"

URI_aarch64_nodejs24-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-docs-24.14.1-2.el10_1.noarch.rpm;name=aarch64_nodejs24-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24-docs}"
SRC_URI[aarch64_nodejs24-docs.sha256sum] = "81e6f775bc8a4c7d7c2ce500cc3f2479d761d469b23d108512ed35641fb29409"

URI_aarch64_nodejs24-full-i18n = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-full-i18n-24.14.1-2.el10_1.aarch64.rpm;name=aarch64_nodejs24-full-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24-full-i18n}"
SRC_URI[aarch64_nodejs24-full-i18n.sha256sum] = "e8cff12220d02a45149fdeed34bc095eaa55d6267a10865853a14cb1551e0bf4"

URI_aarch64_nodejs24-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-libs-24.14.1-2.el10_1.aarch64.rpm;name=aarch64_nodejs24-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24-libs}"
SRC_URI[aarch64_nodejs24-libs.sha256sum] = "314b103e041840a984c873ce37bb313cd9bcf931cc4fb646b4cf9e2a50bf8310"

URI_aarch64_nodejs24-npm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-npm-11.11.0-1.24.14.1.2.el10_1.noarch.rpm;name=aarch64_nodejs24-npm;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs24-npm}"
SRC_URI[aarch64_nodejs24-npm.sha256sum] = "e7f19716e6d8dcb0b9daf9491ad6784c0b082ebb17ffcf87d2608e16ee810ebf"

RDEPENDS:nodejs24 = " \
 ca-certificates \
 glibc \
 nodejs24-libs \
 "
RDEPENDS:nodejs24-devel = " \
 brotli-devel \
 nodejs-packaging \
 nodejs24 \
 nodejs24-libs \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:nodejs24-docs = " \
 nodejs24 \
 "
RDEPENDS:nodejs24-full-i18n = " \
 nodejs24 \
 "
RDEPENDS:nodejs24-libs = " \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-libs \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:nodejs24-npm = " \
 bash \
 nodejs24 \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/nodejs_engine_ rpm/virtual/nodejs_engine__ge_0.8.0"

PROVIDES:append:aarch64 = " rpm/virtual/nodejs_engine_ rpm/virtual/nodejs_engine__ge_0.8.0"
