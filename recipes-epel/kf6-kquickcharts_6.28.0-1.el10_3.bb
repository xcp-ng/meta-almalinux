# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kquickcharts"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kquickcharts \
 kf6-kquickcharts-devel \
 kf6-kquickcharts-doc \
 kf6-kquickcharts-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kquickcharts-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "215c98a4357f494bb9982e7946e6ed26451e22ff6b21d0fab752629db8a3c331"

URI_x86_64_v2_kf6-kquickcharts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kquickcharts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kquickcharts}"
SRC_URI[x86_64_v2_kf6-kquickcharts.sha256sum] = "32e00359051ecd2bafd11ab966aa8794c10b0cb44e120db2956d1edc1c86620b"

URI_x86_64_v2_kf6-kquickcharts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kquickcharts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kquickcharts-devel}"
SRC_URI[x86_64_v2_kf6-kquickcharts-devel.sha256sum] = "ad76e1d2626dcfdfbf4be4f93d2c5d89f5c44d8fc0ff7b8a308fa9e338095ac4"

URI_x86_64_v2_kf6-kquickcharts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kquickcharts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kquickcharts-doc}"
SRC_URI[x86_64_v2_kf6-kquickcharts-doc.sha256sum] = "0fa18100cf9cbde7a8b224634fde338306853cd3e20c9c5e1d06d04f0f3d7815"

URI_x86_64_v2_kf6-kquickcharts-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kquickcharts-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kquickcharts-html}"
SRC_URI[x86_64_v2_kf6-kquickcharts-html.sha256sum] = "e1c41cc33362d19c1c4df4cd6449f0c4416d7ce62ecc5aa1f4420753325c41c9"

URI_aarch64_kf6-kquickcharts = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kquickcharts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kquickcharts}"
SRC_URI[aarch64_kf6-kquickcharts.sha256sum] = "d4d17eb437161776c0d2c75814726b377efb776835ce3b2e92a8e3b5c59cc772"

URI_aarch64_kf6-kquickcharts-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kquickcharts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kquickcharts-devel}"
SRC_URI[aarch64_kf6-kquickcharts-devel.sha256sum] = "8ebbb22ca6c18ae74e88238bbd888b3b99a791a8162d9090f9e64f34f09edcea"

URI_aarch64_kf6-kquickcharts-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kquickcharts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kquickcharts-doc}"
SRC_URI[aarch64_kf6-kquickcharts-doc.sha256sum] = "c8a813d4c326f044314eca3fb72c89ca73a117435bdf6c25dedd3a233e681df2"

URI_aarch64_kf6-kquickcharts-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kquickcharts-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kquickcharts-html}"
SRC_URI[aarch64_kf6-kquickcharts-html.sha256sum] = "3ffd70545996c0a8c8ee6bc10b95c47c42e30f4fa9db6c2482ef376d63181319"

RDEPENDS:kf6-kquickcharts = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kquickcharts-devel = " \
 cmake-filesystem \
 kf6-kquickcharts \
 "
RDEPENDS:kf6-kquickcharts-doc = " \
 "
RDEPENDS:kf6-kquickcharts-html = " \
 "
