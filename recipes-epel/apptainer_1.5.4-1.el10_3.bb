# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apptainer"
PV = "1.5.4"
PR = "1.el10_3"
PACKAGES = " \
 apptainer \
 apptainer-suid \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/apptainer-1.5.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e63f893b884ce4500519a4279826707c54313c37f4b397c0fef8f57b24cedde4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apptainer-1.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apptainer;unpack=0"
SRC_URI[x86_64_v2_apptainer.sha256sum] = "10689ed529cb01173947eb78194db0b925796f7482a1649bf0e447eb6b44af09"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apptainer-suid-1.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apptainer-suid;unpack=0"
SRC_URI[x86_64_v2_apptainer-suid.sha256sum] = "201216547044349507f3638fec0ae23322f62b6236a9d3d70f9e92a99ba9317d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apptainer-1.5.4-1.el10_3.aarch64.rpm;name=aarch64_apptainer;unpack=0"
SRC_URI[aarch64_apptainer.sha256sum] = "0dc4da13295243b0416b70232301748a9d8e6c18565243832cc5d4041beb69af"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apptainer-suid-1.5.4-1.el10_3.aarch64.rpm;name=aarch64_apptainer-suid;unpack=0"
SRC_URI[aarch64_apptainer-suid.sha256sum] = "6468fa72de8b0f7af08ec1a9857267ac2eb2e3bcf6ed24b1575efe0aa4fb3717"

RDEPENDS:apptainer = " \
 bash \
 fakeroot \
 fuse3-libs \
 glibc \
 libgcc \
 libseccomp \
 libtalloc \
 libzstd \
 lz4-libs \
 lzo \
 protobuf-c \
 shadow-utils-subid \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:apptainer-suid = " \
 apptainer \
 fuse3-libs \
 glibc \
 libseccomp \
 shadow-utils-subid \
 "
