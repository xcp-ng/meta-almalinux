# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freeipmi"
PV = "1.6.18"
PR = "1.el10"
PACKAGES = " \
 freeipmi \
 freeipmi-bmc-watchdog \
 freeipmi-devel \
 freeipmi-ipmidetectd \
 freeipmi-ipmiseld \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/freeipmi-1.6.18-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e27a1c3b87136e2ecc40c9c6108bda168b53740878934a62ab8164ab895d180d"

URI_x86_64_v2_freeipmi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-1.6.18-1.el10.x86_64_v2.rpm;name=x86_64_v2_freeipmi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi}"
SRC_URI[x86_64_v2_freeipmi.sha256sum] = "03b3b1a17a6625004d2d69fbc3e5883d001a23c16c73fec81c8c631e9108479c"

URI_x86_64_v2_freeipmi-bmc-watchdog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-bmc-watchdog-1.6.18-1.el10.x86_64_v2.rpm;name=x86_64_v2_freeipmi-bmc-watchdog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-bmc-watchdog}"
SRC_URI[x86_64_v2_freeipmi-bmc-watchdog.sha256sum] = "b5d2165307c5d19179b38db1c50ea1534064350aed80aede095b6af85355d104"

URI_x86_64_v2_freeipmi-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeipmi-devel-1.6.18-1.el10.x86_64_v2.rpm;name=x86_64_v2_freeipmi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-devel}"
SRC_URI[x86_64_v2_freeipmi-devel.sha256sum] = "8f2d49f89bb21dfa0bb312048de436386fc239803f69ae641d82993639bb3c87"

URI_x86_64_v2_freeipmi-ipmidetectd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-ipmidetectd-1.6.18-1.el10.x86_64_v2.rpm;name=x86_64_v2_freeipmi-ipmidetectd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-ipmidetectd}"
SRC_URI[x86_64_v2_freeipmi-ipmidetectd.sha256sum] = "41644dff54867d382d2360de001df36785a28c6572759ac40de5f15ea48dbcaa"

URI_x86_64_v2_freeipmi-ipmiseld = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-ipmiseld-1.6.18-1.el10.x86_64_v2.rpm;name=x86_64_v2_freeipmi-ipmiseld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-ipmiseld}"
SRC_URI[x86_64_v2_freeipmi-ipmiseld.sha256sum] = "66117734020e276c36af6f377f24b234dfac2ab11504c4800d7175de1de3b260"

URI_aarch64_freeipmi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-1.6.18-1.el10.aarch64.rpm;name=aarch64_freeipmi;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi}"
SRC_URI[aarch64_freeipmi.sha256sum] = "3e491f8f4e358fe62f2ac60cdd0d5d093529713ced0454c3a3b1f5134105cd2d"

URI_aarch64_freeipmi-bmc-watchdog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-bmc-watchdog-1.6.18-1.el10.aarch64.rpm;name=aarch64_freeipmi-bmc-watchdog;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-bmc-watchdog}"
SRC_URI[aarch64_freeipmi-bmc-watchdog.sha256sum] = "054cb94cd3fd34b1ec5aebfe11dd7a9ee4666354c72de94d31f1cff712870995"

URI_aarch64_freeipmi-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeipmi-devel-1.6.18-1.el10.aarch64.rpm;name=aarch64_freeipmi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-devel}"
SRC_URI[aarch64_freeipmi-devel.sha256sum] = "906c879d4a363324112a971c49c93b8a339ee8ebaede87ff2de40e9ceeab6382"

URI_aarch64_freeipmi-ipmidetectd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-ipmidetectd-1.6.18-1.el10.aarch64.rpm;name=aarch64_freeipmi-ipmidetectd;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-ipmidetectd}"
SRC_URI[aarch64_freeipmi-ipmidetectd.sha256sum] = "b63984500d0f2b3244e9dd490f650c9d7bdf2046cae2845372c50532616a5e04"

URI_aarch64_freeipmi-ipmiseld = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-ipmiseld-1.6.18-1.el10.aarch64.rpm;name=aarch64_freeipmi-ipmiseld;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-ipmiseld}"
SRC_URI[aarch64_freeipmi-ipmiseld.sha256sum] = "bacf042d6e0fd353a83a425884b28c72e40bbc806192221ce23f5c45bc54ed0d"

RDEPENDS:freeipmi = " \
 bash \
 glibc \
 libgcrypt \
 systemd \
 "
RDEPENDS:freeipmi-bmc-watchdog = " \
 bash \
 freeipmi \
 glibc \
 "
RDEPENDS:freeipmi-devel = " \
 freeipmi \
 pkgconf-pkg-config \
 "
RDEPENDS:freeipmi-ipmidetectd = " \
 bash \
 freeipmi \
 glibc \
 "
RDEPENDS:freeipmi-ipmiseld = " \
 bash \
 freeipmi \
 glibc \
 "
