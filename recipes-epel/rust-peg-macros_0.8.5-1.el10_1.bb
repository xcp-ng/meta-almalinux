# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-peg-macros"
PV = "0.8.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-peg-macros+default-devel \
 rust-peg-macros+trace-devel \
 rust-peg-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-peg-macros-0.8.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8b10f68f83b8f13f22a27a271efde878a5d96da979d926d8b24fe9f5937dcf8"

URI_x86_64_v2_rust-peg-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-macros+default-devel-0.8.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-macros+default-devel}"
SRC_URI[x86_64_v2_rust-peg-macros+default-devel.sha256sum] = "8c198f03d0aa76345c7589aaa2ebe8d8640bb8416c35582ec2425a0c8eb3c6fc"

URI_x86_64_v2_rust-peg-macros+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-macros+trace-devel-0.8.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-macros+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-macros+trace-devel}"
SRC_URI[x86_64_v2_rust-peg-macros+trace-devel.sha256sum] = "cfc05279047d9ad33d6852026538dbab6b50210d693370b6e04c684e5f63aa51"

URI_x86_64_v2_rust-peg-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-macros-devel-0.8.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-macros-devel}"
SRC_URI[x86_64_v2_rust-peg-macros-devel.sha256sum] = "d4b25de55f1dddfd8a607a01de71cfcfd923648562f887a1d356da883adc0cb1"

URI_aarch64_rust-peg-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-macros+default-devel-0.8.5-1.el10_1.noarch.rpm;name=aarch64_rust-peg-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-macros+default-devel}"
SRC_URI[aarch64_rust-peg-macros+default-devel.sha256sum] = "e3a016ddf4f75bc60109f0b82cbd4bde6f0a479c6dbbeb052837fc5547c6b62f"

URI_aarch64_rust-peg-macros+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-macros+trace-devel-0.8.5-1.el10_1.noarch.rpm;name=aarch64_rust-peg-macros+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-macros+trace-devel}"
SRC_URI[aarch64_rust-peg-macros+trace-devel.sha256sum] = "7db2c453a0b926d59b51ed19eb20c65e40cf694e307a336cc8a8acb206bb35a4"

URI_aarch64_rust-peg-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-macros-devel-0.8.5-1.el10_1.noarch.rpm;name=aarch64_rust-peg-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-macros-devel}"
SRC_URI[aarch64_rust-peg-macros-devel.sha256sum] = "3ac1a139c16932a9b71c8fc80d8e9dbbf6dfa8be1d59def9f8d83285570ede71"

RDEPENDS:rust-peg-macros+default-devel = " \
 cargo \
 rust-peg-macros-devel \
 "
RDEPENDS:rust-peg-macros+trace-devel = " \
 cargo \
 rust-peg-macros-devel \
 "
RDEPENDS:rust-peg-macros-devel = " \
 cargo \
 rust-peg-runtime+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
