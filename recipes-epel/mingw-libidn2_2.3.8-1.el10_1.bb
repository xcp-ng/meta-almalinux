# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-libidn2"
PV = "2.3.8"
PR = "1.el10_1"
PACKAGES:x86_64_v2 = " \
 mingw32-libidn2 \
 mingw32-libidn2-static \
 mingw64-libidn2 \
 mingw64-libidn2-static \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/m/mingw-libidn2-2.3.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a037e77cea8f6a0bda39b28299dc4d10b94e531844aca9fc66b35f607efc0015"

URI_x86_64_v2_mingw32-libidn2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-libidn2-2.3.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-libidn2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-libidn2}"
SRC_URI[x86_64_v2_mingw32-libidn2.sha256sum] = "32eafdbfe2de356eb2e7b52b9be730c654da10e4634a53184287ffd4f3386f6a"

URI_x86_64_v2_mingw32-libidn2-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-libidn2-static-2.3.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-libidn2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-libidn2-static}"
SRC_URI[x86_64_v2_mingw32-libidn2-static.sha256sum] = "af5fea328f575d57b111732f31873f84f796777c28021a0497f285d6ca7a36f0"

URI_x86_64_v2_mingw64-libidn2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-libidn2-2.3.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-libidn2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-libidn2}"
SRC_URI[x86_64_v2_mingw64-libidn2.sha256sum] = "7e68a21704699321254ae3ff01e8733568e730efe9462e8ee5c0245e0d7f6656"

URI_x86_64_v2_mingw64-libidn2-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-libidn2-static-2.3.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-libidn2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-libidn2-static}"
SRC_URI[x86_64_v2_mingw64-libidn2-static.sha256sum] = "31fe3c07625499ba63c480ad0a9e28d50e1887a1d1133073b23b824045c5a313"

RDEPENDS:mingw32-libidn2 = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libgcc \
 pkgconf-pkg-config \
 "
RDEPENDS:mingw32-libidn2-static = " \
 mingw32-libidn2 \
 "
RDEPENDS:mingw64-libidn2 = " \
 mingw64-crt \
 mingw64-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:mingw64-libidn2-static = " \
 mingw64-libidn2 \
 "
