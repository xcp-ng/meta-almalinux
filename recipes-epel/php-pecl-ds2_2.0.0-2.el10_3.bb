# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-ds2"
PV = "2.0.0"
PR = "2.el10_3"
PACKAGES = " \
 php-pecl-ds2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-ds2-2.0.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9aaaa798b6bbfeecea613f282b83252050efc9555b6010b2d8423a16719c211"

URI_x86_64_v2_php-pecl-ds2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-ds2-2.0.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-ds2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-ds2}"
SRC_URI[x86_64_v2_php-pecl-ds2.sha256sum] = "5912a9f7712ea0dc75eaaec1c653120a4f9963cacd4beb994c44a22375a16f3d"

URI_aarch64_php-pecl-ds2 = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-ds2-2.0.0-2.el10_3.aarch64.rpm;name=aarch64_php-pecl-ds2;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-ds2}"
SRC_URI[aarch64_php-pecl-ds2.sha256sum] = "1dd93c4bf7555ebbc8095948402a751d0e0f3d0199a59ab169645966258a5013"

RDEPENDS:php-pecl-ds2 = " \
 glibc \
 php-common \
 "
