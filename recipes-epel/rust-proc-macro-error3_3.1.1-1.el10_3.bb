# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro-error3"
PV = "3.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-proc-macro-error3+default-devel \
 rust-proc-macro-error3+syn-error-devel \
 rust-proc-macro-error3+syn2-error-devel \
 rust-proc-macro-error3+syn3-error-devel \
 rust-proc-macro-error3-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro-error3-3.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d4dd28a13952347d3aafdfd5e281d15427c0b6899e7967ce3797f9388e6a91b3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error3+default-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error3+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro-error3+default-devel.sha256sum] = "a42722684bd48addba560639cdbbf973fbdf3dd471bd00f0aab1005184b8a40b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error3+syn-error-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error3+syn-error-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro-error3+syn-error-devel.sha256sum] = "17a2ad1ee10b176190fea08d18603d45a460987094e06f0176848dcb35f144de"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error3+syn2-error-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error3+syn2-error-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro-error3+syn2-error-devel.sha256sum] = "74ec870ed4ec8e55e8ebf3ced990d50402e2be82eb9ea1f935b5971776edfcd0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error3+syn3-error-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error3+syn3-error-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro-error3+syn3-error-devel.sha256sum] = "7343426bb1459da04fd84b41a4649a02d8c1affee2aeab5bb6f671cf88df986e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error3-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error3-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro-error3-devel.sha256sum] = "caf247c5965e1f0b381da288dd1d02819cc537f9fb8e11438dd2448d12e8f6b7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error3+default-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro-error3+default-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro-error3+default-devel.sha256sum] = "dc2baf17a6754297ea9165937ba018512c33d7f6cef9e032df4893a10ea45b4d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error3+syn-error-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro-error3+syn-error-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro-error3+syn-error-devel.sha256sum] = "edda9e61977793c507dc9494d928126fb07939b10335901b305e3600c6f7d1d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error3+syn2-error-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro-error3+syn2-error-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro-error3+syn2-error-devel.sha256sum] = "1e01d625f096327adebdecf0fd58cdb81ecdce713ef7b5dcf645aa77d2fb955c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error3+syn3-error-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro-error3+syn3-error-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro-error3+syn3-error-devel.sha256sum] = "bf540c5a5a38b3aa49e76a5970e8b9c87ec32dccfddee2ff83e1461755033d41"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error3-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro-error3-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro-error3-devel.sha256sum] = "dd81b4526b3e863089664014d891171dd5d0dc46cec2a12801b38c80d84edc3e"

RDEPENDS:rust-proc-macro-error3+default-devel = " \
 cargo \
 rust-proc-macro-error3+syn3-error-devel \
 rust-proc-macro-error3-devel \
 "
RDEPENDS:rust-proc-macro-error3+syn-error-devel = " \
 cargo \
 rust-proc-macro-error3+syn3-error-devel \
 rust-proc-macro-error3-devel \
 "
RDEPENDS:rust-proc-macro-error3+syn2-error-devel = " \
 cargo \
 rust-proc-macro-error3-devel \
 rust-syn2-devel \
 "
RDEPENDS:rust-proc-macro-error3+syn3-error-devel = " \
 cargo \
 rust-proc-macro-error3-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-proc-macro-error3-devel = " \
 cargo \
 rust \
 rust-proc-macro-error-attr3+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
