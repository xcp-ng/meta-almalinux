# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kded"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kded \
 kf6-kded-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kded-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bfd31fb21f29014401f2c639078e69ca90ea0e389f425c340644b7c89e44575"

URI_x86_64_v2_kf6-kded = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kded-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kded}"
SRC_URI[x86_64_v2_kf6-kded.sha256sum] = "e572b2adf166408a000ab3292f04a1b5b279a5baee6b84e650d0f2a168476120"

URI_x86_64_v2_kf6-kded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kded-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kded-devel}"
SRC_URI[x86_64_v2_kf6-kded-devel.sha256sum] = "9394659b3ae6a8cfb95b12efb50011a67b0b3fb229866f4941170637c87cbbec"

URI_aarch64_kf6-kded = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kded-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kded;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kded}"
SRC_URI[aarch64_kf6-kded.sha256sum] = "97a4b60ae4dfb686c433b323929b1158310030bd25e5e2eb538ef63df0595d0b"

URI_aarch64_kf6-kded-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kded-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kded-devel}"
SRC_URI[aarch64_kf6-kded-devel.sha256sum] = "636c62dcb464d9140ad73206c338d0ca472f114ac694957064428dd5fa145662"

RDEPENDS:kf6-kded = " \
 bash \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kded-devel = " \
 cmake-filesystem \
 kf6-kded \
 "
