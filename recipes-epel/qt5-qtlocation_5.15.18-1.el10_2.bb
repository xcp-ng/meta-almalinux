# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtlocation"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtlocation \
 qt5-qtlocation-devel \
 qt5-qtlocation-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtlocation-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "343c810d4856d6b808e9ea80da05d8f92d8e0073474fc6244f3bdd824303adbd"

URI_x86_64_v2_qt5-qtlocation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtlocation-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtlocation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtlocation}"
SRC_URI[x86_64_v2_qt5-qtlocation.sha256sum] = "39480eac341b490b30680a717ecaf2a63d62320aa2c3ca5b55f4ec1ca38a1c3b"

URI_x86_64_v2_qt5-qtlocation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtlocation-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtlocation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtlocation-devel}"
SRC_URI[x86_64_v2_qt5-qtlocation-devel.sha256sum] = "d2de5afb025cdf40a61a70a7dc4a5d286bdde5967867748cd05b72c88a3bd61b"

URI_x86_64_v2_qt5-qtlocation-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtlocation-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtlocation-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtlocation-examples}"
SRC_URI[x86_64_v2_qt5-qtlocation-examples.sha256sum] = "3f1f8eb1151c449c738e4799f1a1797cb92c85ac92ee8defef614d3f9d610438"

URI_aarch64_qt5-qtlocation = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtlocation-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtlocation;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtlocation}"
SRC_URI[aarch64_qt5-qtlocation.sha256sum] = "0f3bc29cef277085f0a2d29ca1ab9e208fc0d6288ebea53abd7ada266a6a5b6e"

URI_aarch64_qt5-qtlocation-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtlocation-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtlocation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtlocation-devel}"
SRC_URI[aarch64_qt5-qtlocation-devel.sha256sum] = "f8abfbce4ce6c582d6a182174aed9603716260ef64bcf78ce6565e79155720cb"

URI_aarch64_qt5-qtlocation-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtlocation-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtlocation-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtlocation-examples}"
SRC_URI[aarch64_qt5-qtlocation-examples.sha256sum] = "11245d53322f5deac359ebde39ec4c7a026c903e055c6fe8e184e4a0e2714ea0"

RDEPENDS:qt5-qtlocation = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qtlocation-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtlocation \
 qt5-qtlocation-devel \
 "
RDEPENDS:qt5-qtlocation-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtlocation \
 "
