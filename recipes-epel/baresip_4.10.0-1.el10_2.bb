# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "baresip"
PV = "4.10.0"
PR = "1.el10_2"
PACKAGES = " \
 baresip \
 baresip-aac \
 baresip-alsa \
 baresip-av1 \
 baresip-avcodec \
 baresip-avfilter \
 baresip-avformat \
 baresip-codec2 \
 baresip-ctrl_dbus \
 baresip-devel \
 baresip-g722 \
 baresip-gst \
 baresip-gtk \
 baresip-jack \
 baresip-mqtt \
 baresip-opus \
 baresip-pipewire \
 baresip-plc \
 baresip-portaudio \
 baresip-pulse \
 baresip-sdl \
 baresip-snapshot \
 baresip-sndfile \
 baresip-swscale \
 baresip-tools \
 baresip-v4l2 \
 baresip-vp8 \
 baresip-vp9 \
 baresip-x11 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/baresip-4.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c272ba419ba9c7e56c44a31a7a314a5b65a6f67d330337682ff7d7c08466616"

URI_x86_64_v2_baresip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip}"
SRC_URI[x86_64_v2_baresip.sha256sum] = "2e71be2a4e41328924406d412229d8fad42a5d457490ad435fd40e19f92c256d"

URI_x86_64_v2_baresip-aac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-aac-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-aac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-aac}"
SRC_URI[x86_64_v2_baresip-aac.sha256sum] = "418685b5a25622f2214fa38bf7f7cb634af06e3a287db15b6dafeff7dedcd728"

URI_x86_64_v2_baresip-alsa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-alsa-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-alsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-alsa}"
SRC_URI[x86_64_v2_baresip-alsa.sha256sum] = "3e2a6df68687ccc8d644de5e43aae54bc11f450b0baf00eb9161c032f268177f"

URI_x86_64_v2_baresip-av1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-av1-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-av1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-av1}"
SRC_URI[x86_64_v2_baresip-av1.sha256sum] = "cf0a7ca717b636a591c8e512b098f2e16c2adc7da3246571c23145ed05fb0677"

URI_x86_64_v2_baresip-avcodec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avcodec-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avcodec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-avcodec}"
SRC_URI[x86_64_v2_baresip-avcodec.sha256sum] = "d394bf82c02057e0dce8837359e636c532f2d23567d89bdb93fa623a69015746"

URI_x86_64_v2_baresip-avfilter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avfilter-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-avfilter}"
SRC_URI[x86_64_v2_baresip-avfilter.sha256sum] = "eab119eed0d70206b0be16fa5be41cfc37f21de894710d0865b329ca3f072b61"

URI_x86_64_v2_baresip-avformat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avformat-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avformat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-avformat}"
SRC_URI[x86_64_v2_baresip-avformat.sha256sum] = "baf90b288ff631b44687e64b6a126a63f32e27e2d9294267025fad5b34d274e4"

URI_x86_64_v2_baresip-codec2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-codec2-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-codec2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-codec2}"
SRC_URI[x86_64_v2_baresip-codec2.sha256sum] = "42e7b7866720fc329baa677de45eea62be6d9c758b19f2f73514713f677489af"

URI_x86_64_v2_baresip-ctrl_dbus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-ctrl_dbus-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-ctrl_dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-ctrl_dbus}"
SRC_URI[x86_64_v2_baresip-ctrl_dbus.sha256sum] = "a61155ea8667d6f3a43fe4d99c09a20f85c334ae6a0364225096b46d5ae92bc0"

URI_x86_64_v2_baresip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-devel-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-devel}"
SRC_URI[x86_64_v2_baresip-devel.sha256sum] = "7ce3855d1c57e3909ad5a70cf6b5e6704a50f542e1bf28d47cbf1abd99ba9eb0"

URI_x86_64_v2_baresip-g722 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-g722-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-g722;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-g722}"
SRC_URI[x86_64_v2_baresip-g722.sha256sum] = "fbecb458044d66dfd87a5dc231078e98b32afb5b2a61948bc9292784891cc4fc"

URI_x86_64_v2_baresip-gst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-gst-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-gst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-gst}"
SRC_URI[x86_64_v2_baresip-gst.sha256sum] = "44945592ee8a7743a8009ccfe79069e954d63526ed688f43d1201bfa4e940359"

URI_x86_64_v2_baresip-gtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-gtk-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-gtk}"
SRC_URI[x86_64_v2_baresip-gtk.sha256sum] = "76908656026bcf7be4cd8ce7a4422c2669cd7b400da29ef734b15a42ce686a76"

URI_x86_64_v2_baresip-jack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-jack-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-jack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-jack}"
SRC_URI[x86_64_v2_baresip-jack.sha256sum] = "b948f2cb7bf662ec9916b34cb541daa72e0fc51f8e9bf7a9793c35b11daf8443"

URI_x86_64_v2_baresip-mqtt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-mqtt-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-mqtt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-mqtt}"
SRC_URI[x86_64_v2_baresip-mqtt.sha256sum] = "c929c982304e34dba80f6435d965536a76e7fc882b98f17a83096da93d5332c9"

URI_x86_64_v2_baresip-opus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-opus-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-opus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-opus}"
SRC_URI[x86_64_v2_baresip-opus.sha256sum] = "e986d467ff9d9243d204e14870ab1acb9a56a03f28e952beccbfe1e6b489783f"

URI_x86_64_v2_baresip-pipewire = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-pipewire-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-pipewire;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-pipewire}"
SRC_URI[x86_64_v2_baresip-pipewire.sha256sum] = "b4abdacdca7848c714568b7164306843bd359031fafd0a9b4750be2fc7e061f0"

URI_x86_64_v2_baresip-plc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-plc-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-plc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-plc}"
SRC_URI[x86_64_v2_baresip-plc.sha256sum] = "8b014a3caf5c117a9d8fb62a7284d7da15c7e56be24df2ae2afb508668ff2134"

URI_x86_64_v2_baresip-portaudio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-portaudio-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-portaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-portaudio}"
SRC_URI[x86_64_v2_baresip-portaudio.sha256sum] = "1c67aaf36c494f90b6a5787ff5902e64b5eef8e197b611ddccdbe3de35742a20"

URI_x86_64_v2_baresip-pulse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-pulse-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-pulse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-pulse}"
SRC_URI[x86_64_v2_baresip-pulse.sha256sum] = "023c28f3d7d9bd3783d7bb8261c3747a153386558a2223b7a6050f6bd770d3c4"

URI_x86_64_v2_baresip-sdl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-sdl-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-sdl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-sdl}"
SRC_URI[x86_64_v2_baresip-sdl.sha256sum] = "a3c84aabd48a268df889be1b57c585259ec71aadec2f2668bdfa3625d237b81b"

URI_x86_64_v2_baresip-snapshot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-snapshot-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-snapshot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-snapshot}"
SRC_URI[x86_64_v2_baresip-snapshot.sha256sum] = "16950c1dad89dfa0b72671ec1b20ba257a73733976f5569e52abb80706f01869"

URI_x86_64_v2_baresip-sndfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-sndfile-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-sndfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-sndfile}"
SRC_URI[x86_64_v2_baresip-sndfile.sha256sum] = "0b85221fdeeb3b6c7a576bf707a5c78aade175d17728615740ae1f0e5d9e2eba"

URI_x86_64_v2_baresip-swscale = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-swscale-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-swscale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-swscale}"
SRC_URI[x86_64_v2_baresip-swscale.sha256sum] = "b8e62504a4682d24853e73c5d8794628052d74f50623a38b98095a9f646c73b9"

URI_x86_64_v2_baresip-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-tools-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-tools}"
SRC_URI[x86_64_v2_baresip-tools.sha256sum] = "8e86bb150050c21fa2726a2685ba59807ba00fd2e4865be3aae56fb61b068394"

URI_x86_64_v2_baresip-v4l2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-v4l2-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-v4l2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-v4l2}"
SRC_URI[x86_64_v2_baresip-v4l2.sha256sum] = "21c452ea4164fd0757f626098dfaeebd7bcfd077e6001e3a585d765134960daa"

URI_x86_64_v2_baresip-vp8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-vp8-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-vp8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-vp8}"
SRC_URI[x86_64_v2_baresip-vp8.sha256sum] = "c95ffc623a8a69ac5ec1fa8afcdb9af2b30e3c67ea40e6c2e8d61a7913acb764"

URI_x86_64_v2_baresip-vp9 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-vp9-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-vp9;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-vp9}"
SRC_URI[x86_64_v2_baresip-vp9.sha256sum] = "f41cbbc8a579000f3d665bdb8f9ca76441781ebab3c05df35425649032a0116f"

URI_x86_64_v2_baresip-x11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-x11-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-x11}"
SRC_URI[x86_64_v2_baresip-x11.sha256sum] = "f264f96804b44493bb9ac622fd9d22987db89c9b6d2ba144bd44d95f2553ef47"

URI_aarch64_baresip = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip}"
SRC_URI[aarch64_baresip.sha256sum] = "a061b5021f88102e7b1d1b89ac5e2cec81fabd4edd9f5589af9b30c0e8646a4d"

URI_aarch64_baresip-aac = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-aac-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-aac;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-aac}"
SRC_URI[aarch64_baresip-aac.sha256sum] = "6f97e04b4608f2a7f0e6053787ac418df2c0cdbda54f2b18a46e486d37189797"

URI_aarch64_baresip-alsa = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-alsa-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-alsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-alsa}"
SRC_URI[aarch64_baresip-alsa.sha256sum] = "af9398a0436b382dc432f4beef476f7282f941169496ac213ca55dae5cd16bef"

URI_aarch64_baresip-av1 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-av1-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-av1;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-av1}"
SRC_URI[aarch64_baresip-av1.sha256sum] = "fe7fd05a9ca2de9f267216338a30f92aaa267cea084b08bca987db61196b17ef"

URI_aarch64_baresip-avcodec = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-avcodec-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-avcodec;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-avcodec}"
SRC_URI[aarch64_baresip-avcodec.sha256sum] = "ddee851f0efcb851b083af1a09bcc76c684b64d977bdb2c72bc25e92b0e34765"

URI_aarch64_baresip-avfilter = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-avfilter-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-avfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-avfilter}"
SRC_URI[aarch64_baresip-avfilter.sha256sum] = "bb165e3e28d4789de41af9cf974e65b7a57a37e2f6c4f8ee81efddfec8a861bb"

URI_aarch64_baresip-avformat = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-avformat-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-avformat;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-avformat}"
SRC_URI[aarch64_baresip-avformat.sha256sum] = "5e1c9cc1ae2720941355edfb028fc7ff5203b3bec615588b8919844754ff9cbf"

URI_aarch64_baresip-codec2 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-codec2-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-codec2;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-codec2}"
SRC_URI[aarch64_baresip-codec2.sha256sum] = "9c7826c08fdf3e0729aaa4bd6e249d9f4c089e61f27b3abc47943bc05f4aee87"

URI_aarch64_baresip-ctrl_dbus = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-ctrl_dbus-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-ctrl_dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-ctrl_dbus}"
SRC_URI[aarch64_baresip-ctrl_dbus.sha256sum] = "e5b974e82dfb39d16e392030f2ef51506d5d61d8b4de2e8419688896e367d51b"

URI_aarch64_baresip-devel = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-devel-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-devel}"
SRC_URI[aarch64_baresip-devel.sha256sum] = "849e4ff07cc5b42f0a21d38eb8687c20c53fbb1524f4e9669558ab4204e417a2"

URI_aarch64_baresip-g722 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-g722-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-g722;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-g722}"
SRC_URI[aarch64_baresip-g722.sha256sum] = "61a7f766cf34d657858bdc0f487cc2ecd7c5475fd62936a401fb7bb52fecb57f"

URI_aarch64_baresip-gst = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-gst-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-gst;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-gst}"
SRC_URI[aarch64_baresip-gst.sha256sum] = "c6cd2daccffdf6fd6e756175aed4510fc85182c08450074ce03d749d70b69b17"

URI_aarch64_baresip-gtk = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-gtk-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-gtk}"
SRC_URI[aarch64_baresip-gtk.sha256sum] = "e231a4fa22ba1ad3cea0a6516c0a46bbb43d6bfb7b5f8047badadb421952a330"

URI_aarch64_baresip-jack = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-jack-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-jack;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-jack}"
SRC_URI[aarch64_baresip-jack.sha256sum] = "7d55fef5f34e6dc8386dfa4a41bc225e4f43ab8fd4bbcbfb9ae8287a51d42deb"

URI_aarch64_baresip-mqtt = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-mqtt-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-mqtt;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-mqtt}"
SRC_URI[aarch64_baresip-mqtt.sha256sum] = "91b89c741ed0d5352bbbc577ac00be49c35bf994c6b4ff5feda81ccec88faac1"

URI_aarch64_baresip-opus = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-opus-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-opus;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-opus}"
SRC_URI[aarch64_baresip-opus.sha256sum] = "c859b9f456b22d6ca69c7b6ca5dadf064ee640bbaaa16e19ecfbebaec3f041e3"

URI_aarch64_baresip-pipewire = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-pipewire-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-pipewire;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-pipewire}"
SRC_URI[aarch64_baresip-pipewire.sha256sum] = "0bed80e76de8bd8ea7d041b626b5c2f93bf7b9589b4990ea304baeb7191f4c18"

URI_aarch64_baresip-plc = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-plc-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-plc;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-plc}"
SRC_URI[aarch64_baresip-plc.sha256sum] = "e7a9f2a887f564f29deb156c76e871812e0c0ed7c5fec2e4091290183487b789"

URI_aarch64_baresip-portaudio = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-portaudio-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-portaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-portaudio}"
SRC_URI[aarch64_baresip-portaudio.sha256sum] = "1f4e30dcfde44b0028f7d02caa7101908f7d4eba257a455c00b8c2f2d2cf8ee7"

URI_aarch64_baresip-pulse = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-pulse-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-pulse;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-pulse}"
SRC_URI[aarch64_baresip-pulse.sha256sum] = "652e39dbc436c20028de5467c9ab15b5ae3494b12b40cf29f810bf6810433edf"

URI_aarch64_baresip-sdl = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-sdl-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-sdl;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-sdl}"
SRC_URI[aarch64_baresip-sdl.sha256sum] = "6f4cabdf263c3060bf5ce64a98a433659ccab87d132c4ea56381887d91048b79"

URI_aarch64_baresip-snapshot = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-snapshot-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-snapshot;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-snapshot}"
SRC_URI[aarch64_baresip-snapshot.sha256sum] = "ca920e96ca52e696359b22616f3075b2017f7f4db2b43b1b418426724839e97e"

URI_aarch64_baresip-sndfile = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-sndfile-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-sndfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-sndfile}"
SRC_URI[aarch64_baresip-sndfile.sha256sum] = "8d06539495f2ac2c726a8cbeabb0d5c4114068683b2d7dba28107f055b1adf7a"

URI_aarch64_baresip-swscale = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-swscale-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-swscale;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-swscale}"
SRC_URI[aarch64_baresip-swscale.sha256sum] = "f8ed26b97a86e75c5522b3cdf2f2634c8dc83c9f15c8d6a08e6678434b768d11"

URI_aarch64_baresip-tools = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-tools-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-tools}"
SRC_URI[aarch64_baresip-tools.sha256sum] = "fd82d8050ecf18cfd2e70e22cecffcaa696c83e2a579e9a4f7e288bf2d596f29"

URI_aarch64_baresip-v4l2 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-v4l2-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-v4l2;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-v4l2}"
SRC_URI[aarch64_baresip-v4l2.sha256sum] = "dfdead51d24ae936e6aac6b717b973217aa35198fe658d0020b662a1b12472e2"

URI_aarch64_baresip-vp8 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-vp8-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-vp8;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-vp8}"
SRC_URI[aarch64_baresip-vp8.sha256sum] = "49906ae7437ed9b17ee26e74966128e07011e3a6d0a7b253d06f72a3462012be"

URI_aarch64_baresip-vp9 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-vp9-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-vp9;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-vp9}"
SRC_URI[aarch64_baresip-vp9.sha256sum] = "ae3f0c926fc8571e52bb51715671337a6ed3e061882352b940d63551905e48e3"

URI_aarch64_baresip-x11 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-x11-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-x11}"
SRC_URI[aarch64_baresip-x11.sha256sum] = "36e4336863859e2f755fbca4d87cd54ecd8bc040ac6a92e36c6e057314c28f68"

RDEPENDS:baresip = " \
 glibc \
 libre \
 "
RDEPENDS:baresip-aac = " \
 baresip \
 fdk-aac-free \
 glibc \
 "
RDEPENDS:baresip-alsa = " \
 alsa-lib \
 baresip \
 glibc \
 "
RDEPENDS:baresip-av1 = " \
 baresip \
 glibc \
 libaom \
 "
RDEPENDS:baresip-avcodec = " \
 baresip \
 glibc \
 libavcodec-free \
 libavutil-free \
 "
RDEPENDS:baresip-avfilter = " \
 baresip \
 glibc \
 libavfilter-free \
 libavutil-free \
 "
RDEPENDS:baresip-avformat = " \
 baresip \
 glibc \
 libavcodec-free \
 libavdevice-free \
 libavformat-free \
 libavutil-free \
 libswresample-free \
 "
RDEPENDS:baresip-codec2 = " \
 baresip \
 codec2 \
 glibc \
 "
RDEPENDS:baresip-ctrl_dbus = " \
 baresip \
 glib2 \
 glibc \
 "
RDEPENDS:baresip-devel = " \
 baresip \
 pkgconf-pkg-config \
 "
RDEPENDS:baresip-g722 = " \
 baresip \
 glibc \
 spandsp \
 "
RDEPENDS:baresip-gst = " \
 baresip \
 glib2 \
 glibc \
 gstreamer1 \
 "
RDEPENDS:baresip-gtk = " \
 adwaita-icon-theme \
 baresip \
 glib2 \
 glibc \
 gnome-shell-extension-appindicator \
 gtk3 \
 "
RDEPENDS:baresip-jack = " \
 baresip \
 glibc \
 pipewire-jack-audio-connection-kit-libs \
 "
RDEPENDS:baresip-mqtt = " \
 baresip \
 glibc \
 mosquitto \
 "
RDEPENDS:baresip-opus = " \
 baresip \
 glibc \
 opus \
 "
RDEPENDS:baresip-pipewire = " \
 baresip \
 glibc \
 pipewire-libs \
 "
RDEPENDS:baresip-plc = " \
 baresip \
 glibc \
 spandsp \
 "
RDEPENDS:baresip-portaudio = " \
 baresip \
 glibc \
 portaudio \
 "
RDEPENDS:baresip-pulse = " \
 baresip \
 glibc \
 pulseaudio-libs \
 "
RDEPENDS:baresip-sdl = " \
 baresip \
 glibc \
 sdl2-compat \
 "
RDEPENDS:baresip-snapshot = " \
 baresip \
 glibc \
 libpng \
 "
RDEPENDS:baresip-sndfile = " \
 baresip \
 glibc \
 libsndfile \
 "
RDEPENDS:baresip-swscale = " \
 baresip \
 glibc \
 libswscale-free \
 "
RDEPENDS:baresip-tools = " \
 baresip \
 python3 \
 "
RDEPENDS:baresip-v4l2 = " \
 baresip \
 glibc \
 "
RDEPENDS:baresip-vp8 = " \
 baresip \
 glibc \
 libvpx \
 "
RDEPENDS:baresip-vp9 = " \
 baresip \
 glibc \
 libvpx \
 "
RDEPENDS:baresip-x11 = " \
 baresip \
 glibc \
 libX11 \
 libXext \
 "
