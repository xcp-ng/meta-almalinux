# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pem-rfc7468"
PV = "0.7.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-pem-rfc7468+alloc-devel \
 rust-pem-rfc7468+default-devel \
 rust-pem-rfc7468+std-devel \
 rust-pem-rfc7468-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pem-rfc7468-0.7.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e028abb752621706c0f23ea58d7f1a7a9d3b8b906e48714c6a9dd113867efd76"

URI_x86_64_v2_rust-pem-rfc7468+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-rfc7468+alloc-devel-0.7.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-rfc7468+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem-rfc7468+alloc-devel}"
SRC_URI[x86_64_v2_rust-pem-rfc7468+alloc-devel.sha256sum] = "72a10706aadfab9aba0554cb867028acafb94831cb0f70a7ac2df7fd31ea7953"

URI_x86_64_v2_rust-pem-rfc7468+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-rfc7468+default-devel-0.7.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-rfc7468+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem-rfc7468+default-devel}"
SRC_URI[x86_64_v2_rust-pem-rfc7468+default-devel.sha256sum] = "3e232318968fe85bdda6bf83dd27ccb311e214f9d6be61a6371efc91229277c4"

URI_x86_64_v2_rust-pem-rfc7468+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-rfc7468+std-devel-0.7.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-rfc7468+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem-rfc7468+std-devel}"
SRC_URI[x86_64_v2_rust-pem-rfc7468+std-devel.sha256sum] = "2cdc3d42903729e7a34df3df0e0b54649b80e9a6f36533cb2f7192b73997f56b"

URI_x86_64_v2_rust-pem-rfc7468-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-rfc7468-devel-0.7.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-rfc7468-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem-rfc7468-devel}"
SRC_URI[x86_64_v2_rust-pem-rfc7468-devel.sha256sum] = "216dba5f06dad1be445a137e6194a3834a00bb4b215515c841eb8cf0b6eddd96"

URI_aarch64_rust-pem-rfc7468+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-rfc7468+alloc-devel-0.7.0-4.el10_0.noarch.rpm;name=aarch64_rust-pem-rfc7468+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem-rfc7468+alloc-devel}"
SRC_URI[aarch64_rust-pem-rfc7468+alloc-devel.sha256sum] = "bfefae15235828f5663aa0542e35de33787988201d42a7021eff235ce60c3619"

URI_aarch64_rust-pem-rfc7468+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-rfc7468+default-devel-0.7.0-4.el10_0.noarch.rpm;name=aarch64_rust-pem-rfc7468+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem-rfc7468+default-devel}"
SRC_URI[aarch64_rust-pem-rfc7468+default-devel.sha256sum] = "ef8232f1c08a7def94caad9a1d0a3a454069f6ac79a58c76bf9003f78b10a42b"

URI_aarch64_rust-pem-rfc7468+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-rfc7468+std-devel-0.7.0-4.el10_0.noarch.rpm;name=aarch64_rust-pem-rfc7468+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem-rfc7468+std-devel}"
SRC_URI[aarch64_rust-pem-rfc7468+std-devel.sha256sum] = "66283cfac74f8aafbf3bcd67a728f2d52ee4dc6848d507488a1f55fea377e059"

URI_aarch64_rust-pem-rfc7468-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-rfc7468-devel-0.7.0-4.el10_0.noarch.rpm;name=aarch64_rust-pem-rfc7468-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem-rfc7468-devel}"
SRC_URI[aarch64_rust-pem-rfc7468-devel.sha256sum] = "1ec48c2e954aa7cc0e8504d7306a9cb2273030b4f6da733e83fc13050fb345d6"

RDEPENDS:rust-pem-rfc7468+alloc-devel = " \
 cargo \
 rust-base64ct+alloc-devel \
 rust-pem-rfc7468-devel \
 "
RDEPENDS:rust-pem-rfc7468+default-devel = " \
 cargo \
 rust-pem-rfc7468-devel \
 "
RDEPENDS:rust-pem-rfc7468+std-devel = " \
 cargo \
 rust-base64ct+std-devel \
 rust-pem-rfc7468+alloc-devel \
 rust-pem-rfc7468-devel \
 "
RDEPENDS:rust-pem-rfc7468-devel = " \
 cargo \
 rust \
 rust-base64ct+default-devel \
 "
