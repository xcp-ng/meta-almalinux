# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Digest-CRC"
PV = "0.24"
PR = "11.el10"
PACKAGES = " \
 perl-Digest-CRC \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Digest-CRC-0.24-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48b0194654e8a414d3abe07b1933ebe224250a01a4fdd3f00b36ea6573482264"

URI_x86_64_v2_perl-Digest-CRC = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Digest-CRC-0.24-11.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Digest-CRC;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Digest-CRC}"
SRC_URI[x86_64_v2_perl-Digest-CRC.sha256sum] = "590f7a3e8aedbc09a36a92eb3988c29c382e56c6398eaff4c0e86ec4770835ed"

URI_aarch64_perl-Digest-CRC = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Digest-CRC-0.24-11.el10.aarch64.rpm;name=aarch64_perl-Digest-CRC;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Digest-CRC}"
SRC_URI[aarch64_perl-Digest-CRC.sha256sum] = "39a35174e107228aea31701205559ef05487a20743d50296359054587ded54fc"

RDEPENDS:perl-Digest-CRC = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-Symbol \
 perl-libs \
 perl-vars \
 "
