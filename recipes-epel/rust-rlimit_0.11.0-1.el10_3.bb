# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rlimit"
PV = "0.11.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-rlimit+default-devel \
 rust-rlimit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rlimit-0.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ae5f4dec2afa6be726c0b2cf96b654482c704d9e0ab48bbe4af250d28206f1a"

URI_x86_64_v2_rust-rlimit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rlimit+default-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rlimit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rlimit+default-devel}"
SRC_URI[x86_64_v2_rust-rlimit+default-devel.sha256sum] = "6f382b90f7405054fbea1c84d91dcd616170f071688f4c910c2dc221384ba788"

URI_x86_64_v2_rust-rlimit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rlimit-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rlimit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rlimit-devel}"
SRC_URI[x86_64_v2_rust-rlimit-devel.sha256sum] = "2efd8ba5308475d7d784b3f26d9445fc32c093aa7ff8f1276dcfffc60e3b1be4"

URI_aarch64_rust-rlimit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rlimit+default-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-rlimit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rlimit+default-devel}"
SRC_URI[aarch64_rust-rlimit+default-devel.sha256sum] = "abcd27d5d3c9f5cce6d6871c6f7bd0de3372f5cf01225c0e013c58c656aafc09"

URI_aarch64_rust-rlimit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rlimit-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-rlimit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rlimit-devel}"
SRC_URI[aarch64_rust-rlimit-devel.sha256sum] = "8f2712cf0bb01ca3ed4649f848d4787cb923fc577b0a7ddf6155624c4082bca8"

RDEPENDS:rust-rlimit+default-devel = " \
 cargo \
 rust-rlimit-devel \
 "
RDEPENDS:rust-rlimit-devel = " \
 bash \
 cargo \
 rust \
 rust-libc+default-devel \
 "
