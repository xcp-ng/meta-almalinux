# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustversion"
PV = "1.0.22"
PR = "1.el10_0"
PACKAGES = " \
 rust-rustversion+default-devel \
 rust-rustversion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustversion-1.0.22-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f63795f3e0e86b56912a217f5610a39aad8c6440f6ee35a03ea6dc1e33b2b24"

URI_x86_64_v2_rust-rustversion+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustversion+default-devel-1.0.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustversion+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustversion+default-devel}"
SRC_URI[x86_64_v2_rust-rustversion+default-devel.sha256sum] = "6a40a49aa1f7e7e78bac3f661793ea567ca857d1055efc6319411d6299fef31e"

URI_x86_64_v2_rust-rustversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustversion-devel-1.0.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustversion-devel}"
SRC_URI[x86_64_v2_rust-rustversion-devel.sha256sum] = "9748662dd7190e8b517ef2aed233155271e4c012268a48d7fa070395997993fd"

URI_aarch64_rust-rustversion+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustversion+default-devel-1.0.22-1.el10_0.noarch.rpm;name=aarch64_rust-rustversion+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustversion+default-devel}"
SRC_URI[aarch64_rust-rustversion+default-devel.sha256sum] = "daaad5d8f9a3e7c6b0c02a701d960c94e110a5697d7e0408cdc6f1c3f77874e4"

URI_aarch64_rust-rustversion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustversion-devel-1.0.22-1.el10_0.noarch.rpm;name=aarch64_rust-rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustversion-devel}"
SRC_URI[aarch64_rust-rustversion-devel.sha256sum] = "718a73984bbe7712a1103baa3efd70d718cfd65249d5ee3c5b1574160b9e440f"

RDEPENDS:rust-rustversion+default-devel = " \
 cargo \
 rust-rustversion-devel \
 "
RDEPENDS:rust-rustversion-devel = " \
 cargo \
 rust \
 "
