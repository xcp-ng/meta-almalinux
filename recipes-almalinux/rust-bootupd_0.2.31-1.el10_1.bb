# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bootupd"
PV = "0.2.31"
PR = "1.el10_1"
PACKAGES = " \
 bootupd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-bootupd-0.2.31-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ee6c106ca16bb3692350e4ae3494be90cfabb8bfabb755ff3ab86a9710d3bec"

URI_x86_64_v2_bootupd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bootupd-0.2.31-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_bootupd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bootupd}"
SRC_URI[x86_64_v2_bootupd.sha256sum] = "4e36f8c0f278336d1148e9ec4df11f5dbb6ff30ba2254e7cfaadfa5289a07a04"

URI_aarch64_bootupd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bootupd-0.2.31-1.el10_1.aarch64.rpm;name=aarch64_bootupd;unpack=0"
SRC_URI:append = " ${URI_aarch64_bootupd}"
SRC_URI[aarch64_bootupd.sha256sum] = "69c38b1155945b10d43594ec7f57c2fead7fc52ef15db8a65497e4bcd04a0787"

RDEPENDS:bootupd = " \
 glibc \
 libgcc \
 openssl-libs \
 systemd \
 "
