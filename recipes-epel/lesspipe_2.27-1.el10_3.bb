# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lesspipe"
PV = "2.27"
PR = "1.el10_3"
PACKAGES = " \
 lesspipe \
 lesspipe-profile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lesspipe-2.27-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76837f94dd60803ab5bf4a306309fb6765784fc0582ffea86230ffbdde4f1928"

URI_x86_64_v2_lesspipe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lesspipe-2.27-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lesspipe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lesspipe}"
SRC_URI[x86_64_v2_lesspipe.sha256sum] = "6609c537c69aec327f1768d6e33f3bde25fcb094041c538e7051ef97197241ba"

URI_x86_64_v2_lesspipe-profile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lesspipe-profile-2.27-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lesspipe-profile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lesspipe-profile}"
SRC_URI[x86_64_v2_lesspipe-profile.sha256sum] = "aea3ff040317bd476704428ec4e66245b280bc1660c4099451c31e55e8fb745f"

URI_aarch64_lesspipe = "${EPEL_MIRROR}/aarch64/Packages/l/lesspipe-2.27-1.el10_3.noarch.rpm;name=aarch64_lesspipe;unpack=0"
SRC_URI:append = " ${URI_aarch64_lesspipe}"
SRC_URI[aarch64_lesspipe.sha256sum] = "e8ec06e9fde659c305c96704e4a04a4db4bb95651abb4902e7371f0f2d43a884"

URI_aarch64_lesspipe-profile = "${EPEL_MIRROR}/aarch64/Packages/l/lesspipe-profile-2.27-1.el10_3.noarch.rpm;name=aarch64_lesspipe-profile;unpack=0"
SRC_URI:append = " ${URI_aarch64_lesspipe-profile}"
SRC_URI[aarch64_lesspipe-profile.sha256sum] = "863fb2dee8cbd5f300926906a1478d875e78dec9528dd780783729f57a81582f"

RDEPENDS:lesspipe = " \
 bash \
 file \
 glibc-common \
 procps-ng \
 virtual//usr/bin/head \
 "
RDEPENDS:lesspipe-profile = " \
 lesspipe \
 setup \
 "
