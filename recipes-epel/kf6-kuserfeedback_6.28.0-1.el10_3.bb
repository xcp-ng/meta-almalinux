# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kuserfeedback"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kuserfeedback \
 kf6-kuserfeedback-console \
 kf6-kuserfeedback-devel \
 kf6-kuserfeedback-doc \
 kf6-kuserfeedback-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kuserfeedback-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21fadf99eaaab20b3de1b15e4048912019c1e5e03399f8febaa4bbf9e33fc537"

URI_x86_64_v2_kf6-kuserfeedback = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kuserfeedback;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback}"
SRC_URI[x86_64_v2_kf6-kuserfeedback.sha256sum] = "2bb8719db153c6013e6f9f995f78652d17cfbfb162e2abfa86634ac30253045b"

URI_x86_64_v2_kf6-kuserfeedback-console = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-console-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kuserfeedback-console;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback-console}"
SRC_URI[x86_64_v2_kf6-kuserfeedback-console.sha256sum] = "c1ba437cd4e8b9f9ffbe4e6c3e17b72121323d2333943f9e3abdf5fbee07facd"

URI_x86_64_v2_kf6-kuserfeedback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kuserfeedback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback-devel}"
SRC_URI[x86_64_v2_kf6-kuserfeedback-devel.sha256sum] = "2f3097091879d70292668be89632ae4c36a9bde5e709a10c0efc53a65515ace2"

URI_x86_64_v2_kf6-kuserfeedback-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kuserfeedback-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback-doc}"
SRC_URI[x86_64_v2_kf6-kuserfeedback-doc.sha256sum] = "caf8b7c45807c467738f987d28df779ba0f0173e9d4c0d7a13aa400247056276"

URI_x86_64_v2_kf6-kuserfeedback-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kuserfeedback-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback-html}"
SRC_URI[x86_64_v2_kf6-kuserfeedback-html.sha256sum] = "a2330746a66e1ae3b3e4aed05f09c5df230efe4569e557bf37f34c0a2f6ae3ff"

URI_aarch64_kf6-kuserfeedback = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kuserfeedback;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback}"
SRC_URI[aarch64_kf6-kuserfeedback.sha256sum] = "6c4c2e662ef302aacc2938d5796ae75f7d5dbe619713f899d4cd61bb653be8a8"

URI_aarch64_kf6-kuserfeedback-console = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-console-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kuserfeedback-console;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback-console}"
SRC_URI[aarch64_kf6-kuserfeedback-console.sha256sum] = "5147d0e130a72de990c6c4d07a59e9cda718ce37078ebbdddfccd41023c237d3"

URI_aarch64_kf6-kuserfeedback-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kuserfeedback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback-devel}"
SRC_URI[aarch64_kf6-kuserfeedback-devel.sha256sum] = "9bbdea18b88e18c4a73e5ba30cf4a10acbdb4e99ee941769128c9e3d468c4ffa"

URI_aarch64_kf6-kuserfeedback-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kuserfeedback-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback-doc}"
SRC_URI[aarch64_kf6-kuserfeedback-doc.sha256sum] = "0ec36ec4b28be672119d9899a049d7500e9324ba004ef1369c72c074b7e34874"

URI_aarch64_kf6-kuserfeedback-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kuserfeedback-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback-html}"
SRC_URI[aarch64_kf6-kuserfeedback-html.sha256sum] = "c7980055e854b005ce0bd0165f54d88f97cfda9bd8ede7b5b5661870a906bf89"

RDEPENDS:kf6-kuserfeedback = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kuserfeedback-console = " \
 glibc \
 kf6-kuserfeedback \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtsvg \
 "
RDEPENDS:kf6-kuserfeedback-devel = " \
 cmake-filesystem \
 kf6-kuserfeedback \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kuserfeedback-doc = " \
 "
RDEPENDS:kf6-kuserfeedback-html = " \
 "
