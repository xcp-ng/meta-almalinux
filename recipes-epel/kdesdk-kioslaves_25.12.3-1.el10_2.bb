# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdesdk-kioslaves"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kdesdk-kioslaves \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdesdk-kioslaves-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbf9faaa4b5f0e82b16e2e008c162bebc08cc3a60983c990a609e607572b16a9"

URI_x86_64_v2_kdesdk-kioslaves = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdesdk-kioslaves-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdesdk-kioslaves;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdesdk-kioslaves}"
SRC_URI[x86_64_v2_kdesdk-kioslaves.sha256sum] = "daec8624177b3509b0dfc1f91f0c9a43938e527d3356246e7fd469d5636730b0"

URI_aarch64_kdesdk-kioslaves = "${EPEL_MIRROR}/aarch64/Packages/k/kdesdk-kioslaves-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdesdk-kioslaves;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdesdk-kioslaves}"
SRC_URI[aarch64_kdesdk-kioslaves.sha256sum] = "80e1b8308441bfa6036697b8476eb7f7fa06fadaf5326df3e283297f0a78c5c2"

RDEPENDS:kdesdk-kioslaves = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 perl-Carp \
 perl-English \
 perl-Pod-Parser \
 perl-base \
 perl-interpreter \
 perl-libs \
 qt6-qtbase \
 "
