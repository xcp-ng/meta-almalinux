# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sysprof"
PV = "47.2"
PR = "1.el10"
PACKAGES = " \
 libsysprof \
 sysprof \
 sysprof-agent \
 sysprof-capture-devel \
 sysprof-cli \
 sysprof-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sysprof-47.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0943f6317dd189dd3a425255cc4c13f9d433d7cc569e815c9975bc7c1590e36"

URI_x86_64_v2_libsysprof = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsysprof-47.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsysprof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsysprof}"
SRC_URI[x86_64_v2_libsysprof.sha256sum] = "b5dd520973b5b219192f2a0ed4185795da7c2091ffc90127cfe8aa10cc7a473e"

URI_x86_64_v2_sysprof = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sysprof-47.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_sysprof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sysprof}"
SRC_URI[x86_64_v2_sysprof.sha256sum] = "fe11b7f2876b9b78ca5875d1c59fbe3724d67529f27b6cf28242b5b15f9569f8"

URI_x86_64_v2_sysprof-agent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sysprof-agent-47.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_sysprof-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sysprof-agent}"
SRC_URI[x86_64_v2_sysprof-agent.sha256sum] = "9cad3ae783e1dc91daea91bb15690473638666c38089dee2f147deedac813e10"

URI_x86_64_v2_sysprof-capture-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sysprof-capture-devel-47.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_sysprof-capture-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sysprof-capture-devel}"
SRC_URI[x86_64_v2_sysprof-capture-devel.sha256sum] = "0f13aa69243619138f64c72756eb104d78b3dd32a8e37275f667d8024683b21b"

URI_x86_64_v2_sysprof-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sysprof-cli-47.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_sysprof-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sysprof-cli}"
SRC_URI[x86_64_v2_sysprof-cli.sha256sum] = "aa7a7e0283321217d460a137ce3bf7ba36cbc3d8f7b13969ff28e50632ffb711"

URI_x86_64_v2_sysprof-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/sysprof-devel-47.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_sysprof-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sysprof-devel}"
SRC_URI[x86_64_v2_sysprof-devel.sha256sum] = "7991abec12748f3effb376268f5a60f53bcf47df1d444ab1414f969d44771dfb"

URI_aarch64_libsysprof = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsysprof-47.2-1.el10.aarch64.rpm;name=aarch64_libsysprof;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsysprof}"
SRC_URI[aarch64_libsysprof.sha256sum] = "8f071b4d7343a9c8e970bc061d23dfaec62bda6fd7d7c2906ac8b110442ca6f9"

URI_aarch64_sysprof = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sysprof-47.2-1.el10.aarch64.rpm;name=aarch64_sysprof;unpack=0"
SRC_URI:append = " ${URI_aarch64_sysprof}"
SRC_URI[aarch64_sysprof.sha256sum] = "747d0e8c17c3891c2ea758ed97858269cca26e83fc428013ec5d1d2be0e83693"

URI_aarch64_sysprof-agent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sysprof-agent-47.2-1.el10.aarch64.rpm;name=aarch64_sysprof-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_sysprof-agent}"
SRC_URI[aarch64_sysprof-agent.sha256sum] = "6a8be4a013758d2a3ec621e234064ccfcc411c807ca57ed7a12725f282bfbe8b"

URI_aarch64_sysprof-capture-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sysprof-capture-devel-47.2-1.el10.aarch64.rpm;name=aarch64_sysprof-capture-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sysprof-capture-devel}"
SRC_URI[aarch64_sysprof-capture-devel.sha256sum] = "1690576d65b2164285e9cbff63941718c64b285763a167b367a91b65fe2268d8"

URI_aarch64_sysprof-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sysprof-cli-47.2-1.el10.aarch64.rpm;name=aarch64_sysprof-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_sysprof-cli}"
SRC_URI[aarch64_sysprof-cli.sha256sum] = "8324fd621340d10b2e46bfdf3542115dda2d1c404bdd49fb6179fafdbe072800"

URI_aarch64_sysprof-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/sysprof-devel-47.2-1.el10.aarch64.rpm;name=aarch64_sysprof-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sysprof-devel}"
SRC_URI[aarch64_sysprof-devel.sha256sum] = "abfc17e668e4eb143d5ed78492b52d0ba87fbda2e08113a6a7739e38eaf3feda"

RDEPENDS:libsysprof = " \
 elfutils-debuginfod-client \
 glib2 \
 glibc \
 json-glib \
 libdex \
 libgcc \
 libstdc++ \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:sysprof = " \
 cairo \
 elfutils-debuginfod-client \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 hicolor-icon-theme \
 json-glib \
 libadwaita \
 libdex \
 libgcc \
 libpanel \
 libstdc++ \
 pango \
 polkit-libs \
 sysprof-cli \
 systemd-libs \
 "
RDEPENDS:sysprof-agent = " \
 elfutils-debuginfod-client \
 glib2 \
 glibc \
 json-glib \
 libdex \
 libgcc \
 libstdc++ \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:sysprof-capture-devel = " \
 pkgconf-pkg-config \
 "
RDEPENDS:sysprof-cli = " \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glib2 \
 glibc \
 json-glib \
 kernel-tools \
 libdex \
 libgcc \
 libstdc++ \
 libsysprof \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:sysprof-devel = " \
 elfutils-debuginfod-client-devel \
 glib2-devel \
 json-glib-devel \
 libdex-devel \
 libsysprof \
 pkgconf-pkg-config \
 polkit-devel \
 sysprof-capture-devel \
 systemd-devel \
 "
