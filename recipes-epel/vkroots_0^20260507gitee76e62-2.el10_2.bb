# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vkroots"
PV = "0^20260507gitee76e62"
PR = "2.el10_2"
PACKAGES = " \
 vkroots-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vkroots-0^20260507gitee76e62-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab1398f2fadbef3a01177baadcf6eb796fc0f789fe5d98ce59ffa3b757c0c877"

URI_x86_64_v2_vkroots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vkroots-devel-0^20260507gitee76e62-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_vkroots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vkroots-devel}"
SRC_URI[x86_64_v2_vkroots-devel.sha256sum] = "9e8e49baca4d19b8f98bf16ae92b212aa4394380f7ec0e8fe942375d36863c0e"

URI_aarch64_vkroots-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vkroots-devel-0^20260507gitee76e62-2.el10_2.noarch.rpm;name=aarch64_vkroots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vkroots-devel}"
SRC_URI[aarch64_vkroots-devel.sha256sum] = "7f1d41414aaaaa14a4d2c876ad49cf42eb36631868029d59f3c2587e10ad51aa"

RDEPENDS:vkroots-devel = " \
 pkgconf-pkg-config \
 "
