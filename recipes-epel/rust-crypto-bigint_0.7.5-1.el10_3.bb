# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crypto-bigint"
PV = "0.7.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-crypto-bigint+alloc-devel \
 rust-crypto-bigint+default-devel \
 rust-crypto-bigint+der-devel \
 rust-crypto-bigint+extra-sizes-devel \
 rust-crypto-bigint+getrandom-devel \
 rust-crypto-bigint+hybrid-array-devel \
 rust-crypto-bigint+rand_core-devel \
 rust-crypto-bigint+serde-devel \
 rust-crypto-bigint+subtle-devel \
 rust-crypto-bigint+zeroize-devel \
 rust-crypto-bigint-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crypto-bigint-0.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aadae759c1563eacbbf475806de3f63f926658a27b8776f655ddd1a3ae8bf9ae"

URI_x86_64_v2_rust-crypto-bigint+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+alloc-devel-0.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+alloc-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+alloc-devel.sha256sum] = "65ccb05821f3268f8ce13e58ab62e884e7688229c0f9f632a34866c5f7ae1035"

URI_x86_64_v2_rust-crypto-bigint+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+default-devel-0.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+default-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+default-devel.sha256sum] = "8dc0eedc02c20c91f798f16e7507c534c684d08697ff81c9b4cb617b2684091c"

URI_x86_64_v2_rust-crypto-bigint+der-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+der-devel-0.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+der-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+der-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+der-devel.sha256sum] = "fd9869561c26be1e81e4b087a0e1392717dfae7ab856b51fdeabe076cf29491e"

URI_x86_64_v2_rust-crypto-bigint+extra-sizes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+extra-sizes-devel-0.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+extra-sizes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+extra-sizes-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+extra-sizes-devel.sha256sum] = "35d5aa057d2795207126098b60fc96c81434d255a7bfac0062ab7aa5bcf8c303"

URI_x86_64_v2_rust-crypto-bigint+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+getrandom-devel-0.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+getrandom-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+getrandom-devel.sha256sum] = "4c5bfb14573a61682d667eb452acaf85375c38f75b2c96ddb47f90f0f63c195b"

URI_x86_64_v2_rust-crypto-bigint+hybrid-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+hybrid-array-devel-0.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+hybrid-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+hybrid-array-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+hybrid-array-devel.sha256sum] = "b1e9a166e63801894444601cceda03c8320f8014ab6449e2aee8612be29b6bcf"

URI_x86_64_v2_rust-crypto-bigint+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+rand_core-devel-0.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+rand_core-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+rand_core-devel.sha256sum] = "fb811d89a26e8dbfd338255f2747e977d90564790d6dc069cb26fce14eb25d10"

URI_x86_64_v2_rust-crypto-bigint+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+serde-devel-0.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+serde-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+serde-devel.sha256sum] = "7b81a7503b9f628206d7775210a4ff4097e52d5d5c28fed1a7faf7563f0d3d7e"

URI_x86_64_v2_rust-crypto-bigint+subtle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+subtle-devel-0.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+subtle-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+subtle-devel.sha256sum] = "d4a73e6766cef1e97ac6f4889719b91bc3741d6cc701f9e50d4014b5410c1301"

URI_x86_64_v2_rust-crypto-bigint+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+zeroize-devel-0.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+zeroize-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+zeroize-devel.sha256sum] = "b934e403828ef8e966f1b170beb44bd850c785bba61861a980f825d93f083006"

URI_x86_64_v2_rust-crypto-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint-devel-0.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint-devel.sha256sum] = "8ee2ec5f650053e44260d031c5dfda8654be0e8a192dcc3bd339e5d496a7f77d"

URI_aarch64_rust-crypto-bigint+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+alloc-devel-0.7.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+alloc-devel}"
SRC_URI[aarch64_rust-crypto-bigint+alloc-devel.sha256sum] = "8caf31a2103d3704cc176d2d3a75da0bba761142bb2bfc4fff4e714a96257af4"

URI_aarch64_rust-crypto-bigint+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+default-devel-0.7.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+default-devel}"
SRC_URI[aarch64_rust-crypto-bigint+default-devel.sha256sum] = "ce5c24ca0f395c0777457a3ffc61512c8d89cac82b83871ea2363f0b3b9fd2c7"

URI_aarch64_rust-crypto-bigint+der-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+der-devel-0.7.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint+der-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+der-devel}"
SRC_URI[aarch64_rust-crypto-bigint+der-devel.sha256sum] = "5a0322691379c422f71a7c4519ce85c54ca16184e2041c14cd9b2c389fd1be1b"

URI_aarch64_rust-crypto-bigint+extra-sizes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+extra-sizes-devel-0.7.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint+extra-sizes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+extra-sizes-devel}"
SRC_URI[aarch64_rust-crypto-bigint+extra-sizes-devel.sha256sum] = "4e08b77299e4fd7f45cd275fc2e2e67bed237c0564c8d0f537ab173cb5a4a86f"

URI_aarch64_rust-crypto-bigint+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+getrandom-devel-0.7.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+getrandom-devel}"
SRC_URI[aarch64_rust-crypto-bigint+getrandom-devel.sha256sum] = "2cd83a62d0fc973ce9c8ca04ff790218e495e1be22a114d9575ee24600f23c26"

URI_aarch64_rust-crypto-bigint+hybrid-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+hybrid-array-devel-0.7.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint+hybrid-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+hybrid-array-devel}"
SRC_URI[aarch64_rust-crypto-bigint+hybrid-array-devel.sha256sum] = "5b1fb72f4c3005fc0d6fb9672f50323ac5876f7003164ae9c799d74883293ba7"

URI_aarch64_rust-crypto-bigint+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+rand_core-devel-0.7.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+rand_core-devel}"
SRC_URI[aarch64_rust-crypto-bigint+rand_core-devel.sha256sum] = "0a9e4cc1eec7530cc49a70c8e5f21f2434e8ea35c8d35e2cfd342662f441a79b"

URI_aarch64_rust-crypto-bigint+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+serde-devel-0.7.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+serde-devel}"
SRC_URI[aarch64_rust-crypto-bigint+serde-devel.sha256sum] = "e629f55a097cf41f4db5dbdae123cfd135f2bf4c5eee67483f9f6c6704417acd"

URI_aarch64_rust-crypto-bigint+subtle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+subtle-devel-0.7.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+subtle-devel}"
SRC_URI[aarch64_rust-crypto-bigint+subtle-devel.sha256sum] = "b02d27bcb8867b4435eab457b39d7e1585a03b8a6122dd6995c1bf01627f6064"

URI_aarch64_rust-crypto-bigint+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+zeroize-devel-0.7.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+zeroize-devel}"
SRC_URI[aarch64_rust-crypto-bigint+zeroize-devel.sha256sum] = "528385536189a9aa525282c835cf5b835057ed67318dea52cd1a017bb6f5d6d1"

URI_aarch64_rust-crypto-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint-devel-0.7.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint-devel}"
SRC_URI[aarch64_rust-crypto-bigint-devel.sha256sum] = "3eacb2ea419d7befc3fa10ed8f1452a7a1e13ccf020d9c23e897e9fa10c26ae9"

RDEPENDS:rust-crypto-bigint+alloc-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-serdect+alloc-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-crypto-bigint+default-devel = " \
 cargo \
 rust-crypto-bigint+rand_core-devel \
 rust-crypto-bigint-devel \
 "
RDEPENDS:rust-crypto-bigint+der-devel = " \
 cargo \
 rust-crypto-bigint+hybrid-array-devel \
 rust-crypto-bigint-devel \
 rust-der-devel \
 "
RDEPENDS:rust-crypto-bigint+extra-sizes-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 "
RDEPENDS:rust-crypto-bigint+getrandom-devel = " \
 cargo \
 rust-crypto-bigint+rand_core-devel \
 rust-crypto-bigint-devel \
 rust-getrandom+default-devel \
 rust-getrandom+sys_rng-devel \
 "
RDEPENDS:rust-crypto-bigint+hybrid-array-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-hybrid-array+default-devel \
 "
RDEPENDS:rust-crypto-bigint+rand_core-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-rand_core-devel \
 "
RDEPENDS:rust-crypto-bigint+serde-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-crypto-bigint+subtle-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-ctutils+subtle-devel \
 rust-hybrid-array+default-devel \
 rust-hybrid-array+subtle-devel \
 rust-subtle-devel \
 "
RDEPENDS:rust-crypto-bigint+zeroize-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-crypto-bigint-devel = " \
 cargo \
 rust \
 rust-cpubits+default-devel \
 rust-ctutils+default-devel \
 rust-num-traits-devel \
 "
