# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-fsnotify"
PV = "0.4.1.0"
PR = "4.el10_0"
PACKAGES = " \
 ghc-fsnotify \
 ghc-fsnotify-devel \
 ghc-fsnotify-doc \
 ghc-fsnotify-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-fsnotify-0.4.1.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f10b4911a9ac20e040377c81d8924a24bf372a52ad2df1e36ff5374508b36d1"

URI_x86_64_v2_ghc-fsnotify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fsnotify-0.4.1.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fsnotify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fsnotify}"
SRC_URI[x86_64_v2_ghc-fsnotify.sha256sum] = "6cbc053625440e551d496889c9f6bd153e9101e4c9c3f226f41b8d4e52d7f381"

URI_x86_64_v2_ghc-fsnotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fsnotify-devel-0.4.1.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fsnotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fsnotify-devel}"
SRC_URI[x86_64_v2_ghc-fsnotify-devel.sha256sum] = "6cac866f7aa49666080fcf565d27c37b1bdcfb8fcfdff1c89ea2b8850ac85733"

URI_x86_64_v2_ghc-fsnotify-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fsnotify-doc-0.4.1.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-fsnotify-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fsnotify-doc}"
SRC_URI[x86_64_v2_ghc-fsnotify-doc.sha256sum] = "e5e4673cda7c63c823e07a7b6634662cc1dc71c09a3cef862ea39ffa1efbb4f0"

URI_x86_64_v2_ghc-fsnotify-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fsnotify-prof-0.4.1.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fsnotify-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fsnotify-prof}"
SRC_URI[x86_64_v2_ghc-fsnotify-prof.sha256sum] = "9bf5e4b1267d1b2faaffdf26463ac56df973c31af43fa3fdda44d94a9c74bd56"

URI_aarch64_ghc-fsnotify = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fsnotify-0.4.1.0-4.el10_0.aarch64.rpm;name=aarch64_ghc-fsnotify;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fsnotify}"
SRC_URI[aarch64_ghc-fsnotify.sha256sum] = "941091615a0c3b3ef9b26708588a3c55cf68d5f96b1e79fb2fbad142f4513698"

URI_aarch64_ghc-fsnotify-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fsnotify-devel-0.4.1.0-4.el10_0.aarch64.rpm;name=aarch64_ghc-fsnotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fsnotify-devel}"
SRC_URI[aarch64_ghc-fsnotify-devel.sha256sum] = "48e3470faa8d397875151b1a0c99bed6e5c5e38e8da9ee49a402a82023f46624"

URI_aarch64_ghc-fsnotify-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fsnotify-doc-0.4.1.0-4.el10_0.noarch.rpm;name=aarch64_ghc-fsnotify-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fsnotify-doc}"
SRC_URI[aarch64_ghc-fsnotify-doc.sha256sum] = "64ffd49d71c1311384c4e18050543ad9a4280a5eb6349a59902214bdd374cc73"

URI_aarch64_ghc-fsnotify-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fsnotify-prof-0.4.1.0-4.el10_0.aarch64.rpm;name=aarch64_ghc-fsnotify-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fsnotify-prof}"
SRC_URI[aarch64_ghc-fsnotify-prof.sha256sum] = "199a913258d9fcb8e2351073ee07bd3a4fc8e1e74b0449088af36e18f7c32d99"

RDEPENDS:ghc-fsnotify = " \
 ghc-array \
 ghc-async \
 ghc-base \
 ghc-base-orphans \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hinotify \
 ghc-monad-control \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-safe-exceptions \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unix-compat \
 glibc \
 gmp \
 "
RDEPENDS:ghc-fsnotify-devel = " \
 ghc-async-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-fsnotify \
 ghc-hinotify-devel \
 ghc-monad-control-devel \
 ghc-safe-exceptions-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-unix-compat-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-fsnotify-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-fsnotify-prof = " \
 ghc-async-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-fsnotify-devel \
 ghc-hinotify-prof \
 ghc-monad-control-prof \
 ghc-safe-exceptions-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-unix-compat-prof \
 ghc-unix-prof \
 "
