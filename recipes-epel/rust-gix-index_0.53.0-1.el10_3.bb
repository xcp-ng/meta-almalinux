# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-index"
PV = "0.53.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-index+default-devel \
 rust-gix-index+document-features-devel \
 rust-gix-index+parallel-devel \
 rust-gix-index+serde-devel \
 rust-gix-index+sha1-devel \
 rust-gix-index+sha256-devel \
 rust-gix-index-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-index-0.53.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43cc17bb872eef880d942e277b51d823594e09bb7135c1726f8a5040edb9526a"

URI_x86_64_v2_rust-gix-index+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-index+default-devel-0.53.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-index+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-index+default-devel}"
SRC_URI[x86_64_v2_rust-gix-index+default-devel.sha256sum] = "da4bcaa480455d7302ed0e6a8e1b9f434f4754958c03bdcfafa0fefa1eaa545a"

URI_x86_64_v2_rust-gix-index+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-index+document-features-devel-0.53.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-index+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-index+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-index+document-features-devel.sha256sum] = "c7d6b4c12d83f5a7361133744e3e34e62638b3873557f96383825b2497174efa"

URI_x86_64_v2_rust-gix-index+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-index+parallel-devel-0.53.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-index+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-index+parallel-devel}"
SRC_URI[x86_64_v2_rust-gix-index+parallel-devel.sha256sum] = "0d73dba03c44128e018d8e2e1971e62726a93adf3dcfa03380af796fca49fc96"

URI_x86_64_v2_rust-gix-index+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-index+serde-devel-0.53.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-index+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-index+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-index+serde-devel.sha256sum] = "823d72036077cf5e165f4f57d5f9a258d98dc1665c26e76ab05c677b120d5721"

URI_x86_64_v2_rust-gix-index+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-index+sha1-devel-0.53.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-index+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-index+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-index+sha1-devel.sha256sum] = "734dd0b6d593bc7be6ac09846b084d7f958a608c4fc0e4c5f1d8519f61914917"

URI_x86_64_v2_rust-gix-index+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-index+sha256-devel-0.53.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-index+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-index+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-index+sha256-devel.sha256sum] = "5d54e8f4578c44f3808cc5b0614cb7cc7616377ab7204ef19276dbc7ec9ff08b"

URI_x86_64_v2_rust-gix-index-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-index-devel-0.53.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-index-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-index-devel}"
SRC_URI[x86_64_v2_rust-gix-index-devel.sha256sum] = "fce189aad0224600472f38caa3e8d84f266e431ebe119ec02bc05b2a23df32fe"

URI_aarch64_rust-gix-index+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-index+default-devel-0.53.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-index+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-index+default-devel}"
SRC_URI[aarch64_rust-gix-index+default-devel.sha256sum] = "5ad52036f37a60eb70fe6f0df86c83d251ae2662d35c94107df12e5268d9e1bb"

URI_aarch64_rust-gix-index+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-index+document-features-devel-0.53.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-index+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-index+document-features-devel}"
SRC_URI[aarch64_rust-gix-index+document-features-devel.sha256sum] = "834ac40a565860658d89505fa47ef61a00bcaf2317b2f3add08d2ffe83f079f6"

URI_aarch64_rust-gix-index+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-index+parallel-devel-0.53.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-index+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-index+parallel-devel}"
SRC_URI[aarch64_rust-gix-index+parallel-devel.sha256sum] = "e3b57f62e8d928161f1d207b018d99e8e32788e4f94a2c6004734023d71f47e7"

URI_aarch64_rust-gix-index+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-index+serde-devel-0.53.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-index+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-index+serde-devel}"
SRC_URI[aarch64_rust-gix-index+serde-devel.sha256sum] = "dcc06ad513ea14601be14743e47a4437a854826ca8c7ecf5a0f3642e62903e1a"

URI_aarch64_rust-gix-index+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-index+sha1-devel-0.53.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-index+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-index+sha1-devel}"
SRC_URI[aarch64_rust-gix-index+sha1-devel.sha256sum] = "f58d445d34be5b3dd9499f1d45ae43e0fb50cce987248d1a83ea250b98e43035"

URI_aarch64_rust-gix-index+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-index+sha256-devel-0.53.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-index+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-index+sha256-devel}"
SRC_URI[aarch64_rust-gix-index+sha256-devel.sha256sum] = "391000c307e648e531d6ac644c7de4cd453d58390234f20c9d51df3ccbe8c707"

URI_aarch64_rust-gix-index-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-index-devel-0.53.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-index-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-index-devel}"
SRC_URI[aarch64_rust-gix-index-devel.sha256sum] = "b9669a98e9e08a9c70a6e20f7af5687331f7a9207d20d9ca653ae39cbb5f48b5"

RDEPENDS:rust-gix-index+default-devel = " \
 cargo \
 rust-gix-index-devel \
 "
RDEPENDS:rust-gix-index+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-index-devel \
 "
RDEPENDS:rust-gix-index+parallel-devel = " \
 cargo \
 rust-gix-features+parallel-devel \
 rust-gix-index-devel \
 "
RDEPENDS:rust-gix-index+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-index-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-smallvec+serde-devel \
 "
RDEPENDS:rust-gix-index+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-index-devel \
 "
RDEPENDS:rust-gix-index+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-index-devel \
 "
RDEPENDS:rust-gix-index-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bstr-devel \
 rust-filetime+default-devel \
 rust-fnv+default-devel \
 rust-gix-bitmap+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-lock+default-devel \
 rust-gix-object+default-devel \
 rust-gix-traverse+default-devel \
 rust-gix-utils+default-devel \
 rust-gix-validate+default-devel \
 rust-hashbrown+default-devel \
 rust-itoa+default-devel \
 rust-libc+default-devel \
 rust-memmap2+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
