# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-server"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 akonadi-server \
 akonadi-server-devel \
 akonadi-server-doc \
 akonadi-server-mysql \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-server-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f06a2c5475364fb119953d4c2c21ab5ffc1ef1901c8f03b1968d4e6f7ba0d939"

URI_x86_64_v2_akonadi-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server}"
SRC_URI[x86_64_v2_akonadi-server.sha256sum] = "25df537ef80e7e29406cef61cd338c079810fa6368f2b1beebb3cc6e0a134e0c"

URI_x86_64_v2_akonadi-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server-devel}"
SRC_URI[x86_64_v2_akonadi-server-devel.sha256sum] = "370af0b292a7ccae29ac531f4ac1e2908381385447de51ae40a95a7c678d5438"

URI_x86_64_v2_akonadi-server-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-server-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server-doc}"
SRC_URI[x86_64_v2_akonadi-server-doc.sha256sum] = "773bdce6b265fef45033f91f054a2db001b8bb748e2af027a739d21638360c5f"

URI_x86_64_v2_akonadi-server-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-mysql-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-server-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server-mysql}"
SRC_URI[x86_64_v2_akonadi-server-mysql.sha256sum] = "55f542a7432f3b0593f8ecfcf5373912d1f9bf1e1086090ed63034241523b382"

URI_aarch64_akonadi-server = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akonadi-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server}"
SRC_URI[aarch64_akonadi-server.sha256sum] = "ae3bf08c4d145fe306244369252513c74eecf6f327181d8aa6d9768081e0d060"

URI_aarch64_akonadi-server-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akonadi-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server-devel}"
SRC_URI[aarch64_akonadi-server-devel.sha256sum] = "a068a50da3f6ca67b692de2fd14a893ab91ea3aafa4474785657665117204f68"

URI_aarch64_akonadi-server-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_akonadi-server-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server-doc}"
SRC_URI[aarch64_akonadi-server-doc.sha256sum] = "96d6692888dfaf48aa4a3dc6895ecb6eb316589fcf3bfa9698ef27cb5eb52dbd"

URI_aarch64_akonadi-server-mysql = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-mysql-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akonadi-server-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server-mysql}"
SRC_URI[aarch64_akonadi-server-mysql.sha256sum] = "953e1d40d6e72b901722d3fc1a0f5679326fb4248d6af9fa922e99f15c84e3bb"

RDEPENDS:akonadi-server = " \
 alternatives \
 bash \
 glibc \
 kaccounts-integration-qt6 \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libaccounts-qt6 \
 libgcc \
 libstdc++ \
 libxml2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xz-libs \
 "
RDEPENDS:akonadi-server-devel = " \
 akonadi-server \
 cmake-filesystem \
 glibc \
 kf6-kconfig \
 kf6-kconfig-devel \
 kf6-kconfigwidgets-devel \
 kf6-kcoreaddons-devel \
 kf6-ki18n \
 kf6-kio-devel \
 kf6-kitemmodels-devel \
 kf6-kxmlgui-devel \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-server-doc = " \
 "
RDEPENDS:akonadi-server-mysql = " \
 akonadi-server \
 alternatives \
 bash \
 mariadb-server \
 qt6-qtbase-mysql \
 "
