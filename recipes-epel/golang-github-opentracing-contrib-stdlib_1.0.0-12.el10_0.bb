# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-opentracing-contrib-stdlib"
PV = "1.0.0"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-opentracing-contrib-stdlib-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-opentracing-contrib-stdlib-1.0.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cde5f5bef481560509884604629aedf8ee94b2c05cf80ca28eb6afd993b146d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-opentracing-contrib-stdlib-devel-1.0.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-opentracing-contrib-stdlib-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-opentracing-contrib-stdlib-devel.sha256sum] = "63ead70f5ce8311e3e9032fb7674992e784090aff3e6e6381f25b7120d65598f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-opentracing-contrib-stdlib-devel-1.0.0-12.el10_0.noarch.rpm;name=aarch64_golang-github-opentracing-contrib-stdlib-devel;unpack=0"
SRC_URI[aarch64_golang-github-opentracing-contrib-stdlib-devel.sha256sum] = "d8fb04a2c16f78824b2162333dea1ce4148b086aadaa6d70481ef5c8a5eb055d"

RDEPENDS:golang-github-opentracing-contrib-stdlib-devel = " \
 go-filesystem \
 golang-github-opentracing-devel \
 "
