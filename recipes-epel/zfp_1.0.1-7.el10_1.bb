# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zfp"
PV = "1.0.1"
PR = "7.el10_1"
PACKAGES = " \
 python3-zfpy \
 zfp \
 zfp-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/z/zfp-1.0.1-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3eb468c8d755d3d938c302823223ba4b4a5655af6dc272f20bce7ffbdc65d77a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zfpy-1.0.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-zfpy;unpack=0"
SRC_URI[x86_64_v2_python3-zfpy.sha256sum] = "e7aa38c8e8958bcf28da2c77f2107ca8a8c36c5fdc399fc76555abd0fbaa00a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zfp-1.0.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zfp;unpack=0"
SRC_URI[x86_64_v2_zfp.sha256sum] = "106567aa01c18c278fba41196aa53ada834bd6e9466ae924df518cec5a92ef01"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zfp-devel-1.0.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zfp-devel;unpack=0"
SRC_URI[x86_64_v2_zfp-devel.sha256sum] = "a02ed6d2e38b46065d11ea1e3c250b527bcf1a5847f6aaa0ca7bbcb8e9ffca0d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-zfpy-1.0.1-7.el10_1.aarch64.rpm;name=aarch64_python3-zfpy;unpack=0"
SRC_URI[aarch64_python3-zfpy.sha256sum] = "3fb176471e08154027d036d1f068df93e980404406d3b1933dbb9a2e704db6e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/z/zfp-1.0.1-7.el10_1.aarch64.rpm;name=aarch64_zfp;unpack=0"
SRC_URI[aarch64_zfp.sha256sum] = "d3975bc1770d3fac1259193ec124e0e6705082fd083f22420702911603f97199"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/z/zfp-devel-1.0.1-7.el10_1.aarch64.rpm;name=aarch64_zfp-devel;unpack=0"
SRC_URI[aarch64_zfp-devel.sha256sum] = "6fccb6b8749c98061dbc086807f7d18090b093f42ffc01f17760adca5f9eaf52"

RDEPENDS:python3-zfpy = " \
 glibc \
 python3 \
 zfp \
 "
RDEPENDS:zfp = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:zfp-devel = " \
 cmake-filesystem \
 zfp \
 "
