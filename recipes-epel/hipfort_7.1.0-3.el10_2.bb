# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipfort"
PV = "7.1.0"
PR = "3.el10_2"
PACKAGES:x86_64_v2 = " \
 hipfort \
 hipfort-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipfort-7.1.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61773c6fe535eb96ceac759b2d7897d738c6bcd460f720bec4a741a35079027b"

URI_x86_64_v2_hipfort = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipfort-7.1.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipfort;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipfort}"
SRC_URI[x86_64_v2_hipfort.sha256sum] = "99bd9072595d7b663cbac6d8fe9e10ddb86db49afde3da30eb811aedb0689e99"

URI_x86_64_v2_hipfort-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipfort-devel-7.1.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipfort-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipfort-devel}"
SRC_URI[x86_64_v2_hipfort-devel.sha256sum] = "634be7ad956c55afce342040a41fb8285ae500b6b80e526ae411384cd823e28d"

RDEPENDS:hipfort = " \
 bash \
 glibc \
 hipblas \
 hipfft \
 hipsolver \
 hipsparse \
 libgcc \
 libgfortran \
 rocminfo \
 "
RDEPENDS:hipfort-devel = " \
 hipfort \
 "
