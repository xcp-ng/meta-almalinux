# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-headers"
PV = "1.4.313.0"
PR = "1.el10"
PACKAGES = " \
 vulkan-headers \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-headers-1.4.313.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e34f663c784def2ac92fcc763aead98e3804162bfecf0509e00ace55060c6077"

URI_x86_64_v2_vulkan-headers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-headers-1.4.313.0-1.el10.noarch.rpm;name=x86_64_v2_vulkan-headers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-headers}"
SRC_URI[x86_64_v2_vulkan-headers.sha256sum] = "b0fdf72f35f67e6a5de6db7498e822a209046d40ce11f24caf7e0d56961cedd2"

URI_aarch64_vulkan-headers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-headers-1.4.313.0-1.el10.noarch.rpm;name=aarch64_vulkan-headers;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-headers}"
SRC_URI[aarch64_vulkan-headers.sha256sum] = "b0fdf72f35f67e6a5de6db7498e822a209046d40ce11f24caf7e0d56961cedd2"

RDEPENDS:vulkan-headers = " \
 cmake-filesystem \
 python3 \
 "
