# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "soci"
PV = "4.1.2"
PR = "1.el10_2"
PACKAGES = " \
 soci \
 soci-devel \
 soci-doc \
 soci-empty \
 soci-empty-devel \
 soci-mysql \
 soci-mysql-devel \
 soci-postgresql \
 soci-postgresql-devel \
 soci-sqlite3 \
 soci-sqlite3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/soci-4.1.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65d7142b3dc2af16e0766feba9a53fbac4f1acf4088d12685277334159deaa8d"

URI_x86_64_v2_soci = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-4.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_soci}"
SRC_URI[x86_64_v2_soci.sha256sum] = "5914f9f82cf2c3ca27dd8cecbf63ca13a6610c73537b76e6f4e9ffe2a5ab6f60"

URI_x86_64_v2_soci-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-devel-4.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_soci-devel}"
SRC_URI[x86_64_v2_soci-devel.sha256sum] = "7bdb43b417015a4dab032e06a044a8468dc778359769e56a2e4e520b4a70d760"

URI_x86_64_v2_soci-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-doc-4.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_soci-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_soci-doc}"
SRC_URI[x86_64_v2_soci-doc.sha256sum] = "313e714241fccd97829d331b3659f4b8013334cc72fbeadc5e40ca6c79501b6a"

URI_x86_64_v2_soci-empty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-empty-4.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-empty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_soci-empty}"
SRC_URI[x86_64_v2_soci-empty.sha256sum] = "1a618cdf9f26b543fbb83d241f28f4af0c6b5c97e587e88c6605fc136a8bdc27"

URI_x86_64_v2_soci-empty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-empty-devel-4.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-empty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_soci-empty-devel}"
SRC_URI[x86_64_v2_soci-empty-devel.sha256sum] = "63d6b65d556f71e78cace23b36ddc3551aa20d0546b3fc7cb0d47fbbf3c73e2e"

URI_x86_64_v2_soci-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-mysql-4.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_soci-mysql}"
SRC_URI[x86_64_v2_soci-mysql.sha256sum] = "f33b1787352f71ede68114f9189bfb559460a13755c8c347e6105563b91f16ef"

URI_x86_64_v2_soci-mysql-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-mysql-devel-4.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-mysql-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_soci-mysql-devel}"
SRC_URI[x86_64_v2_soci-mysql-devel.sha256sum] = "1d94a23daa788ec5091967b2ee9da7a2c1876ce986f1c3101fe674a485c7a080"

URI_x86_64_v2_soci-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-postgresql-4.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_soci-postgresql}"
SRC_URI[x86_64_v2_soci-postgresql.sha256sum] = "4e9fb1811b38ffc015dc2d87eb106bb4b620c1e22aea2384dc48622a1113465f"

URI_x86_64_v2_soci-postgresql-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-postgresql-devel-4.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-postgresql-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_soci-postgresql-devel}"
SRC_URI[x86_64_v2_soci-postgresql-devel.sha256sum] = "3c0e1fa052811285782c215b83771d966d8b4b8bb9d8aa948478946001e3653f"

URI_x86_64_v2_soci-sqlite3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-sqlite3-4.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-sqlite3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_soci-sqlite3}"
SRC_URI[x86_64_v2_soci-sqlite3.sha256sum] = "4ffb84f6f85017f66a92b4f407a261a0d3e9873e259db17193339bca2164615b"

URI_x86_64_v2_soci-sqlite3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-sqlite3-devel-4.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-sqlite3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_soci-sqlite3-devel}"
SRC_URI[x86_64_v2_soci-sqlite3-devel.sha256sum] = "b13cb8dc7e9e81ddc980123b8d040fc235e9ac8344ca1a9ca3be3220b69fb660"

URI_aarch64_soci = "${EPEL_MIRROR}/aarch64/Packages/s/soci-4.1.2-1.el10_2.aarch64.rpm;name=aarch64_soci;unpack=0"
SRC_URI:append = " ${URI_aarch64_soci}"
SRC_URI[aarch64_soci.sha256sum] = "0a470bca2adb93ac90dc3eb66d142833276d77519eabe35a1bb7456f587dbcc0"

URI_aarch64_soci-devel = "${EPEL_MIRROR}/aarch64/Packages/s/soci-devel-4.1.2-1.el10_2.aarch64.rpm;name=aarch64_soci-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_soci-devel}"
SRC_URI[aarch64_soci-devel.sha256sum] = "800fb73c96fae679d07a17b8bae87d0fdfeba3bf5897c95063d1915d081a127a"

URI_aarch64_soci-doc = "${EPEL_MIRROR}/aarch64/Packages/s/soci-doc-4.1.2-1.el10_2.noarch.rpm;name=aarch64_soci-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_soci-doc}"
SRC_URI[aarch64_soci-doc.sha256sum] = "ae62186932652e39a4d506013004796fc49ebeaa5c9c431a4eec240d8a59108c"

URI_aarch64_soci-empty = "${EPEL_MIRROR}/aarch64/Packages/s/soci-empty-4.1.2-1.el10_2.aarch64.rpm;name=aarch64_soci-empty;unpack=0"
SRC_URI:append = " ${URI_aarch64_soci-empty}"
SRC_URI[aarch64_soci-empty.sha256sum] = "0f1bae0e105b706ccf08312ec792089da8523331da6821226749c71382ba4660"

URI_aarch64_soci-empty-devel = "${EPEL_MIRROR}/aarch64/Packages/s/soci-empty-devel-4.1.2-1.el10_2.aarch64.rpm;name=aarch64_soci-empty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_soci-empty-devel}"
SRC_URI[aarch64_soci-empty-devel.sha256sum] = "7efa372b2e8bef56de1b93c48559950fc05229cd022d828b89db2856ce98e4b8"

URI_aarch64_soci-mysql = "${EPEL_MIRROR}/aarch64/Packages/s/soci-mysql-4.1.2-1.el10_2.aarch64.rpm;name=aarch64_soci-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_soci-mysql}"
SRC_URI[aarch64_soci-mysql.sha256sum] = "66f676de167125a43bb3c0c0ea7034b96b41877e10bfb42884a26e8185380f7d"

URI_aarch64_soci-mysql-devel = "${EPEL_MIRROR}/aarch64/Packages/s/soci-mysql-devel-4.1.2-1.el10_2.aarch64.rpm;name=aarch64_soci-mysql-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_soci-mysql-devel}"
SRC_URI[aarch64_soci-mysql-devel.sha256sum] = "ac9269cc37daeccb36a399d42171c3cc8f716e876a7572268e1458a3f1cdbc34"

URI_aarch64_soci-postgresql = "${EPEL_MIRROR}/aarch64/Packages/s/soci-postgresql-4.1.2-1.el10_2.aarch64.rpm;name=aarch64_soci-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_soci-postgresql}"
SRC_URI[aarch64_soci-postgresql.sha256sum] = "a7f83631cd00b7cee02ded09a1095d5008428019ac08caedb40ed45259036c17"

URI_aarch64_soci-postgresql-devel = "${EPEL_MIRROR}/aarch64/Packages/s/soci-postgresql-devel-4.1.2-1.el10_2.aarch64.rpm;name=aarch64_soci-postgresql-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_soci-postgresql-devel}"
SRC_URI[aarch64_soci-postgresql-devel.sha256sum] = "e240297a321fb002297ba770e40556ca4b3ef13f9f3b3992bf36873ff311c5ed"

URI_aarch64_soci-sqlite3 = "${EPEL_MIRROR}/aarch64/Packages/s/soci-sqlite3-4.1.2-1.el10_2.aarch64.rpm;name=aarch64_soci-sqlite3;unpack=0"
SRC_URI:append = " ${URI_aarch64_soci-sqlite3}"
SRC_URI[aarch64_soci-sqlite3.sha256sum] = "88d76b9690260bf6974984a7b7df04aced9b22b0f396f42a6f70d809df0cd9b8"

URI_aarch64_soci-sqlite3-devel = "${EPEL_MIRROR}/aarch64/Packages/s/soci-sqlite3-devel-4.1.2-1.el10_2.aarch64.rpm;name=aarch64_soci-sqlite3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_soci-sqlite3-devel}"
SRC_URI[aarch64_soci-sqlite3-devel.sha256sum] = "0a0451ae7a533a949897218c41872bad11f80a7c48f7a1245eee16d962e340f2"

RDEPENDS:soci = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:soci-devel = " \
 pkgconf-pkg-config \
 soci \
 "
RDEPENDS:soci-doc = " \
 "
RDEPENDS:soci-empty = " \
 glibc \
 libgcc \
 libstdc++ \
 soci \
 "
RDEPENDS:soci-empty-devel = " \
 soci-devel \
 soci-empty \
 "
RDEPENDS:soci-mysql = " \
 glibc \
 libgcc \
 libstdc++ \
 mariadb-connector-c \
 soci \
 "
RDEPENDS:soci-mysql-devel = " \
 mariadb-connector-c-devel \
 soci-devel \
 soci-mysql \
 "
RDEPENDS:soci-postgresql = " \
 glibc \
 libgcc \
 libpq \
 libstdc++ \
 soci \
 "
RDEPENDS:soci-postgresql-devel = " \
 libpq-devel \
 soci-devel \
 soci-postgresql \
 "
RDEPENDS:soci-sqlite3 = " \
 glibc \
 libgcc \
 libstdc++ \
 soci \
 sqlite-libs \
 "
RDEPENDS:soci-sqlite3-devel = " \
 soci-devel \
 soci-sqlite3 \
 sqlite-devel \
 "
