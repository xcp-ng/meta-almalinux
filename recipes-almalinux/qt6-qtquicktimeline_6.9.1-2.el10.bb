# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtquicktimeline"
PV = "6.9.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtquicktimeline \
 qt6-qtquicktimeline-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtquicktimeline-6.9.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25cac2f4d22eb8165646b88a45cfad109b5b12d54a1789eb807adca11d6e210e"

URI_x86_64_v2_qt6-qtquicktimeline = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtquicktimeline-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtquicktimeline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtquicktimeline}"
SRC_URI[x86_64_v2_qt6-qtquicktimeline.sha256sum] = "f41e9c4148d0c1134926f6fd8757d56fef91f892729c8cb82f7c9920eba53bdb"

URI_x86_64_v2_qt6-qtquicktimeline-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtquicktimeline-devel-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtquicktimeline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtquicktimeline-devel}"
SRC_URI[x86_64_v2_qt6-qtquicktimeline-devel.sha256sum] = "6205e59c398585875e00ff96c8f4c55eb36648c769bd8c2e7bbd2edde8b3bc3e"

URI_aarch64_qt6-qtquicktimeline = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtquicktimeline-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtquicktimeline;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtquicktimeline}"
SRC_URI[aarch64_qt6-qtquicktimeline.sha256sum] = "d338c608d7d98b06f2a02aadcb348776195429d3c08cbe9367e826af1888aae4"

URI_aarch64_qt6-qtquicktimeline-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtquicktimeline-devel-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtquicktimeline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtquicktimeline-devel}"
SRC_URI[aarch64_qt6-qtquicktimeline-devel.sha256sum] = "f9602547ee0afc49e3253398793ee1ee506f4bdb2e4444c33df75b61310b1da0"

RDEPENDS:qt6-qtquicktimeline = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtquicktimeline-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtquicktimeline \
 qt6-qtquicktimeline-devel \
 "
