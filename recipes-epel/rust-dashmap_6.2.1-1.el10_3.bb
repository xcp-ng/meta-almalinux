# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dashmap"
PV = "6.2.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-dashmap+arbitrary-devel \
 rust-dashmap+default-devel \
 rust-dashmap+inline-devel \
 rust-dashmap+raw-api-devel \
 rust-dashmap+rayon-devel \
 rust-dashmap+serde-devel \
 rust-dashmap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dashmap-6.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e526e955053105c4cfc51f61cfd674029483696af208707973de45d9de909366"

URI_x86_64_v2_rust-dashmap+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+arbitrary-devel-6.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-dashmap+arbitrary-devel.sha256sum] = "a3ef07cda0f1b87140c673278ff2986f01f51832bfd8e863e7a06a766c21e058"

URI_x86_64_v2_rust-dashmap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+default-devel-6.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+default-devel}"
SRC_URI[x86_64_v2_rust-dashmap+default-devel.sha256sum] = "26769428a2be5ebe40fc95c861228bd9774f38e457459162b1217f7c22010eca"

URI_x86_64_v2_rust-dashmap+inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+inline-devel-6.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+inline-devel}"
SRC_URI[x86_64_v2_rust-dashmap+inline-devel.sha256sum] = "ed4fe00fe96323d1de6ab6e3266fceda2ecdf8f7e950e5aaf9d4bce664687176"

URI_x86_64_v2_rust-dashmap+raw-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+raw-api-devel-6.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+raw-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+raw-api-devel}"
SRC_URI[x86_64_v2_rust-dashmap+raw-api-devel.sha256sum] = "cfa19f51fc577c7ff68e98cedb15475f440beba3121d25a51a642d81521103d7"

URI_x86_64_v2_rust-dashmap+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+rayon-devel-6.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+rayon-devel}"
SRC_URI[x86_64_v2_rust-dashmap+rayon-devel.sha256sum] = "c92b1f80c55e68ca103a42ac6a6bea6fde6594458186b9ef3944cf76e901ad5b"

URI_x86_64_v2_rust-dashmap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+serde-devel-6.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+serde-devel}"
SRC_URI[x86_64_v2_rust-dashmap+serde-devel.sha256sum] = "d413bfcc1ad9d7b74a83ecd0a15a004fa76416a747bf6aaffca523b00b2a1f7b"

URI_x86_64_v2_rust-dashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap-devel-6.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap-devel}"
SRC_URI[x86_64_v2_rust-dashmap-devel.sha256sum] = "9fe5002fa38f935675fc1c199b030c4126c7900aa355e29dd4e762b3ea8b6110"

URI_aarch64_rust-dashmap+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+arbitrary-devel-6.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-dashmap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+arbitrary-devel}"
SRC_URI[aarch64_rust-dashmap+arbitrary-devel.sha256sum] = "4bd98aaeeeb86fa9fe46fa8a7b995363a1787693a2225c86d7df783dcfabb2bb"

URI_aarch64_rust-dashmap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+default-devel-6.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-dashmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+default-devel}"
SRC_URI[aarch64_rust-dashmap+default-devel.sha256sum] = "485bbf2bf3aaec1efdeca6171f42e8416a8cf2f79376331fa36e15f0324a13e8"

URI_aarch64_rust-dashmap+inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+inline-devel-6.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-dashmap+inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+inline-devel}"
SRC_URI[aarch64_rust-dashmap+inline-devel.sha256sum] = "ae7ae6369ab903c4f827e824c98970b0aabfb2a3633269d09aa4370f6f5d2029"

URI_aarch64_rust-dashmap+raw-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+raw-api-devel-6.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-dashmap+raw-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+raw-api-devel}"
SRC_URI[aarch64_rust-dashmap+raw-api-devel.sha256sum] = "fba5361660a59dfc4b4386f6d52de45fe8ed362b2f09e7b7e070792ac29819a1"

URI_aarch64_rust-dashmap+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+rayon-devel-6.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-dashmap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+rayon-devel}"
SRC_URI[aarch64_rust-dashmap+rayon-devel.sha256sum] = "a0ecd8340cc82ef0309ff9099a1da0a654f8abe872801c48fa10d4d804250cb0"

URI_aarch64_rust-dashmap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+serde-devel-6.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-dashmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+serde-devel}"
SRC_URI[aarch64_rust-dashmap+serde-devel.sha256sum] = "bb062164d0d075d54b7a836537c5060faf43089bf7957e462a4794ab92d836c0"

URI_aarch64_rust-dashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap-devel-6.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap-devel}"
SRC_URI[aarch64_rust-dashmap-devel.sha256sum] = "3e77f5e0949dbefaa23530ba95b39e285a375352467afcb9fe64e0c860965732"

RDEPENDS:rust-dashmap+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-dashmap-devel \
 "
RDEPENDS:rust-dashmap+default-devel = " \
 cargo \
 rust-dashmap-devel \
 "
RDEPENDS:rust-dashmap+inline-devel = " \
 cargo \
 rust-dashmap-devel \
 rust-hashbrown0.14+inline-more-devel \
 "
RDEPENDS:rust-dashmap+raw-api-devel = " \
 cargo \
 rust-dashmap-devel \
 "
RDEPENDS:rust-dashmap+rayon-devel = " \
 cargo \
 rust-dashmap-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-dashmap+serde-devel = " \
 cargo \
 rust-dashmap-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-dashmap-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-crossbeam-utils+default-devel \
 rust-hashbrown0.14+raw-devel \
 rust-hashbrown0.14-devel \
 rust-lock_api+default-devel \
 rust-once_cell+default-devel \
 rust-parking_lot_core+default-devel \
 "
