# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "foomatic"
PV = "4.0.13"
PR = "33.el10"
PACKAGES = " \
 foomatic \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/foomatic-4.0.13-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1445313f9c2b3decf82ac9c1c0470204306a62bd65dd7ff0d1f67183c0d73de8"

URI_x86_64_v2_foomatic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/foomatic-4.0.13-33.el10.x86_64_v2.rpm;name=x86_64_v2_foomatic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_foomatic}"
SRC_URI[x86_64_v2_foomatic.sha256sum] = "78676b2660f04cd5811cc036a38a855916ab631a3504d7f631ab5325c953f143"

URI_aarch64_foomatic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/foomatic-4.0.13-33.el10.aarch64.rpm;name=aarch64_foomatic;unpack=0"
SRC_URI:append = " ${URI_aarch64_foomatic}"
SRC_URI[aarch64_foomatic.sha256sum] = "01d47559657fc0e7ae5ec96f353cfbd9add375e08874c2054154a360d7d91908"

RDEPENDS:foomatic = " \
 bash \
 colord \
 cups \
 cups-filters \
 dbus \
 foomatic-db \
 ghostscript \
 glibc \
 libxml2 \
 perl-Data-Dumper \
 perl-Encode \
 perl-Exporter \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-POSIX \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 perl-vars \
 virtual/coreutils \
 "
