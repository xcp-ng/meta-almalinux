# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nltk"
PE = "1"
PV = "3.9.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-nltk \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-nltk-3.9.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "69e81f59811b6bf7b08958e1527cb39678d473e2ec5720d8c59eaba1aa771ac3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nltk-3.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-nltk;unpack=0"
SRC_URI[x86_64_v2_python3-nltk.sha256sum] = "926395e2d3aa147b5862f4914a6b00fa9fdaa3dfefbabefabebb410226313248"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-nltk-3.9.1-1.el10_0.noarch.rpm;name=aarch64_python3-nltk;unpack=0"
SRC_URI[aarch64_python3-nltk.sha256sum] = "7d7dc4d9b6b0235506aec90da4aa5b41fa0093f0d11fbf316d4402ea5b6264ba"

RDEPENDS:python3-nltk = " \
 python3 \
 python3-click \
 python3-joblib \
 python3-matplotlib \
 python3-numpy \
 python3-pyyaml \
 python3-regex \
 python3-tkinter \
 python3-tqdm \
 "
