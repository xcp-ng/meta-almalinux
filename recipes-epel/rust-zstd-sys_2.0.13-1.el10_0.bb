# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zstd-sys"
PV = "2.0.13"
PR = "1.el10_0"
PACKAGES = " \
 rust-zstd-sys+bindgen-devel \
 rust-zstd-sys+debug-devel \
 rust-zstd-sys+default-devel \
 rust-zstd-sys+experimental-devel \
 rust-zstd-sys+fat-lto-devel \
 rust-zstd-sys+legacy-devel \
 rust-zstd-sys+no_asm-devel \
 rust-zstd-sys+non-cargo-devel \
 rust-zstd-sys+pkg-config-devel \
 rust-zstd-sys+std-devel \
 rust-zstd-sys+thin-devel \
 rust-zstd-sys+thin-lto-devel \
 rust-zstd-sys+zdict_builder-devel \
 rust-zstd-sys+zstdmt-devel \
 rust-zstd-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zstd-sys-2.0.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c01986718c66c2656e465935b79b430de7f380cac6cbbc23599ca66588acbac"

URI_x86_64_v2_rust-zstd-sys+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+bindgen-devel-2.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+bindgen-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+bindgen-devel.sha256sum] = "ab87bdd2cc4da09df820609009ef7cc65386dec7a9a881dac2e493056fb4f539"

URI_x86_64_v2_rust-zstd-sys+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+debug-devel-2.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+debug-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+debug-devel.sha256sum] = "8f6cff6dd44265987d3f295b38eeec36f6d7fb812a1d71e6c475ddf246297367"

URI_x86_64_v2_rust-zstd-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+default-devel-2.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+default-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+default-devel.sha256sum] = "891503dd911c49ac2563d9f004e5742a9da8448140b158ea9601b08ac6de04f4"

URI_x86_64_v2_rust-zstd-sys+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+experimental-devel-2.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+experimental-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+experimental-devel.sha256sum] = "38e353d786a0516a969c137a7152b617cf92fe2f5d51de98558729545bcf9e84"

URI_x86_64_v2_rust-zstd-sys+fat-lto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+fat-lto-devel-2.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+fat-lto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+fat-lto-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+fat-lto-devel.sha256sum] = "a6a9de433eed3b4ab8c8f2ee8a0046b99a616a4a3dabf1322ddcb66315d1c462"

URI_x86_64_v2_rust-zstd-sys+legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+legacy-devel-2.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+legacy-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+legacy-devel.sha256sum] = "aab1e16d501e1850a54778e0a52edc3b6b7cab338272ae599ec171a543d5a73e"

URI_x86_64_v2_rust-zstd-sys+no_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+no_asm-devel-2.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+no_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+no_asm-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+no_asm-devel.sha256sum] = "c3bb16ae52ee26c43805e84305a2ca8a63fe5395efc2ad31e0845cd84bbdf030"

URI_x86_64_v2_rust-zstd-sys+non-cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+non-cargo-devel-2.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+non-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+non-cargo-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+non-cargo-devel.sha256sum] = "d5dfd7b546eb893932f1f6e1e989153cd0f39f9a9592db3a361006aeb5760c81"

URI_x86_64_v2_rust-zstd-sys+pkg-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+pkg-config-devel-2.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+pkg-config-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+pkg-config-devel.sha256sum] = "107cd1de24737699c0977757d75b833112555f2d40e3ddc944bb05885eff6ef4"

URI_x86_64_v2_rust-zstd-sys+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+std-devel-2.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+std-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+std-devel.sha256sum] = "0b88db065dc972a11006c42600370f07c33541d4b53a4244f0442db3b768a9b5"

URI_x86_64_v2_rust-zstd-sys+thin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+thin-devel-2.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+thin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+thin-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+thin-devel.sha256sum] = "20b0008a989f77d257dcdf9e71d4914473b7cb10039e0fcdf0738e36ea1937d4"

URI_x86_64_v2_rust-zstd-sys+thin-lto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+thin-lto-devel-2.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+thin-lto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+thin-lto-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+thin-lto-devel.sha256sum] = "4e9a55e58b4b0ebfb040bd9433db45c62b42bdcf4b97fd297712b4f160914f68"

URI_x86_64_v2_rust-zstd-sys+zdict_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+zdict_builder-devel-2.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+zdict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+zdict_builder-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+zdict_builder-devel.sha256sum] = "b45eff5115a570d7f2682cb64c6773d8926c3e9c516f86da6b4ffb392eb786c1"

URI_x86_64_v2_rust-zstd-sys+zstdmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+zstdmt-devel-2.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+zstdmt-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+zstdmt-devel.sha256sum] = "826c05a5f5aea61e3b44a3ce9970bad919b26267f320e7066bd6de56902ab672"

URI_x86_64_v2_rust-zstd-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys-devel-2.0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys-devel.sha256sum] = "b7eddb0885d12931172ef32695c41570f796d5f372a1323e81bddeee51061a70"

URI_aarch64_rust-zstd-sys+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+bindgen-devel-2.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+bindgen-devel}"
SRC_URI[aarch64_rust-zstd-sys+bindgen-devel.sha256sum] = "4c3b28454da439de98a915a009417214e305ac6819feac39f5843b20e35b12df"

URI_aarch64_rust-zstd-sys+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+debug-devel-2.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+debug-devel}"
SRC_URI[aarch64_rust-zstd-sys+debug-devel.sha256sum] = "ce2c4f7c50adc1c6278f08212cc3eec908b3f75a8086252a0b658a037585716b"

URI_aarch64_rust-zstd-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+default-devel-2.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+default-devel}"
SRC_URI[aarch64_rust-zstd-sys+default-devel.sha256sum] = "78d43953b44e7787955c2d6aeecf4a670c0a60f15f69adf8122e34b9172c3904"

URI_aarch64_rust-zstd-sys+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+experimental-devel-2.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-sys+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+experimental-devel}"
SRC_URI[aarch64_rust-zstd-sys+experimental-devel.sha256sum] = "f100fbcf23adb7e4ae6ed167567aae08681c58a9038fc6ba9951d8f22086ad12"

URI_aarch64_rust-zstd-sys+fat-lto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+fat-lto-devel-2.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-sys+fat-lto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+fat-lto-devel}"
SRC_URI[aarch64_rust-zstd-sys+fat-lto-devel.sha256sum] = "e1c86a0a5ac362d5541636c774dfa74b0545a5844a08f818470528a07505ecb7"

URI_aarch64_rust-zstd-sys+legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+legacy-devel-2.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-sys+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+legacy-devel}"
SRC_URI[aarch64_rust-zstd-sys+legacy-devel.sha256sum] = "456fe503935d5809a3fdf19ffd5af04608b1d498e96e47a365b38c0b5fbd1549"

URI_aarch64_rust-zstd-sys+no_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+no_asm-devel-2.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-sys+no_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+no_asm-devel}"
SRC_URI[aarch64_rust-zstd-sys+no_asm-devel.sha256sum] = "693a83e0fad18a23a7a7098853bb5d280f78acde875b252c0ffc02ccbe6ad6e7"

URI_aarch64_rust-zstd-sys+non-cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+non-cargo-devel-2.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-sys+non-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+non-cargo-devel}"
SRC_URI[aarch64_rust-zstd-sys+non-cargo-devel.sha256sum] = "cdb791e509e8b2664a6733c379a0d02cca4b1ec46ee6dbad9231fdd8277448d6"

URI_aarch64_rust-zstd-sys+pkg-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+pkg-config-devel-2.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-sys+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+pkg-config-devel}"
SRC_URI[aarch64_rust-zstd-sys+pkg-config-devel.sha256sum] = "276a61f810d154fe9815e8c250bb0d25a29aa66cb200c3eef289f5b16b15553f"

URI_aarch64_rust-zstd-sys+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+std-devel-2.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+std-devel}"
SRC_URI[aarch64_rust-zstd-sys+std-devel.sha256sum] = "0292eb90d55719e5ee31ecf6bb75f3312f994c77fc5eafc43e66ece9b592cc08"

URI_aarch64_rust-zstd-sys+thin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+thin-devel-2.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-sys+thin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+thin-devel}"
SRC_URI[aarch64_rust-zstd-sys+thin-devel.sha256sum] = "21fe96278458f4cdfe355171e11b982ae27e399d2c47c7ebb901ce6cffd8e668"

URI_aarch64_rust-zstd-sys+thin-lto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+thin-lto-devel-2.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-sys+thin-lto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+thin-lto-devel}"
SRC_URI[aarch64_rust-zstd-sys+thin-lto-devel.sha256sum] = "352c069b739b7160b516dafbf21055aaaedca67038c6f099f4f0c97eb9bb4566"

URI_aarch64_rust-zstd-sys+zdict_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+zdict_builder-devel-2.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-sys+zdict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+zdict_builder-devel}"
SRC_URI[aarch64_rust-zstd-sys+zdict_builder-devel.sha256sum] = "ad40c89b49f346f45b794c647001380094f7a8347a5638056b13dba08332007d"

URI_aarch64_rust-zstd-sys+zstdmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+zstdmt-devel-2.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-sys+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+zstdmt-devel}"
SRC_URI[aarch64_rust-zstd-sys+zstdmt-devel.sha256sum] = "2ef5d6bb42cb34644326f1b205e5665dd9b1c16864815f134445ece6cde89a1f"

URI_aarch64_rust-zstd-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys-devel-2.0.13-1.el10_0.noarch.rpm;name=aarch64_rust-zstd-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys-devel}"
SRC_URI[aarch64_rust-zstd-sys-devel.sha256sum] = "f167948cebcccfdb970c2e789c49e87cd2433c9a91584e143d83e06c87d53bb0"

RDEPENDS:rust-zstd-sys+bindgen-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+debug-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+default-devel = " \
 cargo \
 rust-zstd-sys+legacy-devel \
 rust-zstd-sys+zdict_builder-devel \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+experimental-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+fat-lto-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+legacy-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+no_asm-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+non-cargo-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+pkg-config-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+std-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+thin-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+thin-lto-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+zdict_builder-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+zstdmt-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys-devel = " \
 cargo \
 libzstd-devel \
 rust \
 rust-bindgen+runtime-devel \
 rust-bindgen+which-rustfmt-devel \
 rust-bindgen-devel \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-pkg-config+default-devel \
 "
