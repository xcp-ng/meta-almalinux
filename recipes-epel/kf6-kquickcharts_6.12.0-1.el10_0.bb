# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kquickcharts"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kquickcharts \
 kf6-kquickcharts-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kquickcharts-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02f4c6c08b18610703dd3ffd731ff338e6f33b41042111ee0f2dec36fab7aff6"

URI_x86_64_v2_kf6-kquickcharts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kquickcharts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kquickcharts}"
SRC_URI[x86_64_v2_kf6-kquickcharts.sha256sum] = "0371e212da79c227e3699d0877243df1975912f70d80c053cd70fddd1d0c2d91"

URI_x86_64_v2_kf6-kquickcharts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kquickcharts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kquickcharts-devel}"
SRC_URI[x86_64_v2_kf6-kquickcharts-devel.sha256sum] = "6b9e01f896c01399cc8e9efecf8944a4f4d5d5a23005f9ade92e069f19257371"

URI_aarch64_kf6-kquickcharts = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kquickcharts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kquickcharts}"
SRC_URI[aarch64_kf6-kquickcharts.sha256sum] = "635c44e80d0dd59dd243550ce2368677e1345f7058082f9ba81eb0cae7f2ad3b"

URI_aarch64_kf6-kquickcharts-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kquickcharts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kquickcharts-devel}"
SRC_URI[aarch64_kf6-kquickcharts-devel.sha256sum] = "56935685f89005a83d2ec1f84850d9d38d7e052c1a73388d4ab3c5ad98af8fe0"

RDEPENDS:kf6-kquickcharts = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kquickcharts-devel = " \
 cmake-filesystem \
 kf6-kquickcharts \
 "
