# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tox-current-env"
PV = "0.0.12"
PR = "1.el10_0"
PACKAGES = " \
 python3-tox-current-env \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tox-current-env-0.0.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b99f555178eae3894245a9de9ea1cb60bd7990cc4b6d87d9e98bc9aab4598ab8"

URI_x86_64_v2_python3-tox-current-env = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tox-current-env-0.0.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tox-current-env;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tox-current-env}"
SRC_URI[x86_64_v2_python3-tox-current-env.sha256sum] = "2ad4bf0130d8370928f7e1deb8ea9a1ac4e6564cb7438f5a276b783c804a2d65"

URI_aarch64_python3-tox-current-env = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tox-current-env-0.0.12-1.el10_0.noarch.rpm;name=aarch64_python3-tox-current-env;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tox-current-env}"
SRC_URI[aarch64_python3-tox-current-env.sha256sum] = "9ab2ac008ed3acee02f947cc4482a2e71efeb476254757aa1d21b8b6ffa5a506"

RDEPENDS:python3-tox-current-env = " \
 python3 \
 tox \
 "
