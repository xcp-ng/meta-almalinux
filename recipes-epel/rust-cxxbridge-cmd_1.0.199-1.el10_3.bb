# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxxbridge-cmd"
PV = "1.0.199"
PR = "1.el10_3"
PACKAGES = " \
 cxxbridge \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxxbridge-cmd-1.0.199-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "547d7a035574e530e6e7125e4bebbf91d102c4a46c5167d6aeb9d78b09f27a19"

URI_x86_64_v2_cxxbridge = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cxxbridge-1.0.199-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cxxbridge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cxxbridge}"
SRC_URI[x86_64_v2_cxxbridge.sha256sum] = "1a07637c32d0468b715ac86650990f4f16bd9b7b8688d357b6096f1c3b549a5f"

URI_aarch64_cxxbridge = "${EPEL_MIRROR}/aarch64/Packages/c/cxxbridge-1.0.199-1.el10_3.aarch64.rpm;name=aarch64_cxxbridge;unpack=0"
SRC_URI:append = " ${URI_aarch64_cxxbridge}"
SRC_URI[aarch64_cxxbridge.sha256sum] = "9ba827ef16fdc8a0a084ab74f0ae86b1715fe13f42371338fa8033112d92d2a4"

RDEPENDS:cxxbridge = " \
 glibc \
 libgcc \
 "
