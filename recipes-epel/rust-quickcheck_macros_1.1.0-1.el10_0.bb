# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quickcheck_macros"
PV = "1.1.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-quickcheck_macros+default-devel \
 rust-quickcheck_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quickcheck_macros-1.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b504c7605468488d6698a3de5937ca63463cd497ee444088bcae3204c64c2a47"

URI_x86_64_v2_rust-quickcheck_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck_macros+default-devel-1.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck_macros+default-devel}"
SRC_URI[x86_64_v2_rust-quickcheck_macros+default-devel.sha256sum] = "df60767068a0d419c33dcee760142976a4cd0410cc18c42de6193574b1eb84ce"

URI_x86_64_v2_rust-quickcheck_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck_macros-devel-1.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck_macros-devel}"
SRC_URI[x86_64_v2_rust-quickcheck_macros-devel.sha256sum] = "4ccb06bfdec5ac2f6045b65becfe0bcf852abd0a9d4121c326aff56134e34d0b"

URI_aarch64_rust-quickcheck_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck_macros+default-devel-1.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-quickcheck_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck_macros+default-devel}"
SRC_URI[aarch64_rust-quickcheck_macros+default-devel.sha256sum] = "f06917e674b4371a88f5544071b1a576acd9101cfdb0c088b536f9472305e089"

URI_aarch64_rust-quickcheck_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck_macros-devel-1.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-quickcheck_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck_macros-devel}"
SRC_URI[aarch64_rust-quickcheck_macros-devel.sha256sum] = "f226f56555f78c31f18fdd16ea858a4e6fb71b0af00f2b8e7f0911a40b4df087"

RDEPENDS:rust-quickcheck_macros+default-devel = " \
 cargo \
 rust-quickcheck_macros-devel \
 "
RDEPENDS:rust-quickcheck_macros-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
