# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-test-case-macros"
PV = "3.3.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-test-case-macros+default-devel \
 rust-test-case-macros+with-regex-devel \
 rust-test-case-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-test-case-macros-3.3.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06a88b08b495fb1fd1778e862d32dbeccabe439eda995c5b57e43eeef9d2bcda"

URI_x86_64_v2_rust-test-case-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-case-macros+default-devel-3.3.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-case-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-case-macros+default-devel}"
SRC_URI[x86_64_v2_rust-test-case-macros+default-devel.sha256sum] = "63cc890dc09d64675637612bca283b623c578046400dd0574d637f021e78c8ce"

URI_x86_64_v2_rust-test-case-macros+with-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-case-macros+with-regex-devel-3.3.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-case-macros+with-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-case-macros+with-regex-devel}"
SRC_URI[x86_64_v2_rust-test-case-macros+with-regex-devel.sha256sum] = "268dde8e1269366646c521823cdd433c32c11f4369d20c5a88e1253c7d50b2c3"

URI_x86_64_v2_rust-test-case-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-case-macros-devel-3.3.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-case-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-case-macros-devel}"
SRC_URI[x86_64_v2_rust-test-case-macros-devel.sha256sum] = "22d5dc4f96587e3023e63e273d34ac833d6ef0e77a48ea73f6d6f96c48b0846c"

URI_aarch64_rust-test-case-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-case-macros+default-devel-3.3.1-4.el10_0.noarch.rpm;name=aarch64_rust-test-case-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-case-macros+default-devel}"
SRC_URI[aarch64_rust-test-case-macros+default-devel.sha256sum] = "fa69245c85e1e5790b68e4ae583ba880c612418929fa23a614fa7beb5bade0e1"

URI_aarch64_rust-test-case-macros+with-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-case-macros+with-regex-devel-3.3.1-4.el10_0.noarch.rpm;name=aarch64_rust-test-case-macros+with-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-case-macros+with-regex-devel}"
SRC_URI[aarch64_rust-test-case-macros+with-regex-devel.sha256sum] = "c331030be3ad6f2c0950c16b82b9e45709136e43fc6c752af22f35703e9c7a34"

URI_aarch64_rust-test-case-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-case-macros-devel-3.3.1-4.el10_0.noarch.rpm;name=aarch64_rust-test-case-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-case-macros-devel}"
SRC_URI[aarch64_rust-test-case-macros-devel.sha256sum] = "6d6767bfc6861b37a26c8a46dfa92396ab57c53d6a9fd0058e6f33d9b48b77df"

RDEPENDS:rust-test-case-macros+default-devel = " \
 cargo \
 rust-test-case-macros-devel \
 "
RDEPENDS:rust-test-case-macros+with-regex-devel = " \
 cargo \
 rust-test-case-core+with-regex-devel \
 rust-test-case-macros-devel \
 "
RDEPENDS:rust-test-case-macros-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-test-case-core-devel \
 "
