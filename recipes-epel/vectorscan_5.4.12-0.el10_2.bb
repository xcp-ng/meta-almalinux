# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vectorscan"
PV = "5.4.12"
PR = "0.el10_2"
PACKAGES = " \
 vectorscan \
 vectorscan-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vectorscan-5.4.12-0.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "328b91a49a1c7e7624eedb699647063142a3de0acdb11b8592cf19440494dc74"

URI_x86_64_v2_vectorscan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vectorscan-5.4.12-0.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vectorscan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vectorscan}"
SRC_URI[x86_64_v2_vectorscan.sha256sum] = "f99cb5d54d8dceb5934e4808153eb1894b66c58cb468c342d0a8a83160591591"

URI_x86_64_v2_vectorscan-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vectorscan-devel-5.4.12-0.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vectorscan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vectorscan-devel}"
SRC_URI[x86_64_v2_vectorscan-devel.sha256sum] = "06da06e63d9675651807299e3577f396c74f63a48a2e4ee2a005313aac658ffd"

URI_aarch64_vectorscan = "${EPEL_MIRROR}/aarch64/Packages/v/vectorscan-5.4.12-0.el10_2.aarch64.rpm;name=aarch64_vectorscan;unpack=0"
SRC_URI:append = " ${URI_aarch64_vectorscan}"
SRC_URI[aarch64_vectorscan.sha256sum] = "38ace18c40dc15c569fde806f4a7a8b0b4188491231c8d95114c22e8ccca3b2a"

URI_aarch64_vectorscan-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vectorscan-devel-5.4.12-0.el10_2.aarch64.rpm;name=aarch64_vectorscan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vectorscan-devel}"
SRC_URI[aarch64_vectorscan-devel.sha256sum] = "57e829de0058a234c44d66201d00a2e4221988db2202b3de64369def4d919dc7"

RDEPENDS:vectorscan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:vectorscan-devel = " \
 pkgconf-pkg-config \
 vectorscan \
 "
