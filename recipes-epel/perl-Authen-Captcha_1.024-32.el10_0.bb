# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Authen-Captcha"
PV = "1.024"
PR = "32.el10_0"
PACKAGES = " \
 perl-Authen-Captcha \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Authen-Captcha-1.024-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c82174104661dd893b9fb8f677745b8bbc4c97d9ac531afb2b22dd7cbfd044f"

URI_x86_64_v2_perl-Authen-Captcha = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Authen-Captcha-1.024-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Authen-Captcha;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Authen-Captcha}"
SRC_URI[x86_64_v2_perl-Authen-Captcha.sha256sum] = "7a85b49857d19e96dfdb1a973200560781a11d9c74ebb9e26ea98442d9a2c819"

URI_aarch64_perl-Authen-Captcha = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Authen-Captcha-1.024-32.el10_0.noarch.rpm;name=aarch64_perl-Authen-Captcha;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Authen-Captcha}"
SRC_URI[aarch64_perl-Authen-Captcha.sha256sum] = "b4572d164a2569fd38d726885787b28b988a783cde74bc0f98e63ba312646176"

RDEPENDS:perl-Authen-Captcha = " \
 perl-Carp \
 perl-File-Basename \
 perl-GD \
 perl-PathTools \
 perl-String-Random \
 perl-libs \
 perl-vars \
 "
