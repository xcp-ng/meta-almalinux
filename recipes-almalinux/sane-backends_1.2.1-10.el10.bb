# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sane-backends"
PV = "1.2.1"
PR = "10.el10"
PACKAGES = " \
 sane-backends \
 sane-backends-daemon \
 sane-backends-devel \
 sane-backends-doc \
 sane-backends-drivers-cameras \
 sane-backends-drivers-scanners \
 sane-backends-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sane-backends-1.2.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e102c2b4de8127cf732e52f0dfa7d03c76640a18c033f5d90072c257f2f43c3c"

URI_x86_64_v2_sane-backends = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sane-backends-1.2.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_sane-backends;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sane-backends}"
SRC_URI[x86_64_v2_sane-backends.sha256sum] = "be4744762306c1d2b55df7b0fa287aff29122f03d0d6c4061ada1da1a498426d"

URI_x86_64_v2_sane-backends-daemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sane-backends-daemon-1.2.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_sane-backends-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sane-backends-daemon}"
SRC_URI[x86_64_v2_sane-backends-daemon.sha256sum] = "a572786de8f52dfc7c543669568e8ab5fe05261f6afe42eb6c0eeafaefa61661"

URI_x86_64_v2_sane-backends-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sane-backends-devel-1.2.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_sane-backends-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sane-backends-devel}"
SRC_URI[x86_64_v2_sane-backends-devel.sha256sum] = "bc5742c6850cf28e82c69cd7bc35507e7df78af2fc4da9443561a3d9ff02ddbd"

URI_x86_64_v2_sane-backends-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sane-backends-doc-1.2.1-10.el10.noarch.rpm;name=x86_64_v2_sane-backends-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sane-backends-doc}"
SRC_URI[x86_64_v2_sane-backends-doc.sha256sum] = "a8f719251fa758af5777e58436a7a2e161b6cbf9f8ab2f088e7b1b1876fe1a34"

URI_x86_64_v2_sane-backends-drivers-cameras = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sane-backends-drivers-cameras-1.2.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_sane-backends-drivers-cameras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sane-backends-drivers-cameras}"
SRC_URI[x86_64_v2_sane-backends-drivers-cameras.sha256sum] = "469010851f25b9eac3769854d4ae102e42e496ba77c9df4425fe4e09078f97af"

URI_x86_64_v2_sane-backends-drivers-scanners = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sane-backends-drivers-scanners-1.2.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_sane-backends-drivers-scanners;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sane-backends-drivers-scanners}"
SRC_URI[x86_64_v2_sane-backends-drivers-scanners.sha256sum] = "7612346e886a579e6bf4d655b5bce5a533bdd71538246d32dcf037ba38eb3446"

URI_x86_64_v2_sane-backends-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sane-backends-libs-1.2.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_sane-backends-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sane-backends-libs}"
SRC_URI[x86_64_v2_sane-backends-libs.sha256sum] = "1ee300bfe6b94728487e925674f6deb825a03219f2f6df416cf980511e4c199f"

URI_aarch64_sane-backends = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sane-backends-1.2.1-10.el10.aarch64.rpm;name=aarch64_sane-backends;unpack=0"
SRC_URI:append = " ${URI_aarch64_sane-backends}"
SRC_URI[aarch64_sane-backends.sha256sum] = "434683c4b7018efb07c892ffca4b2be23bef7e5ac66998431f003afd034afe43"

URI_aarch64_sane-backends-daemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sane-backends-daemon-1.2.1-10.el10.aarch64.rpm;name=aarch64_sane-backends-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_sane-backends-daemon}"
SRC_URI[aarch64_sane-backends-daemon.sha256sum] = "973bce02de5519ab51d4d54099e241273810110f0ffb215df6d166c3c70cc2bb"

URI_aarch64_sane-backends-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sane-backends-devel-1.2.1-10.el10.aarch64.rpm;name=aarch64_sane-backends-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sane-backends-devel}"
SRC_URI[aarch64_sane-backends-devel.sha256sum] = "8599339221b5ba745b3f329e1f511717695307b9e7908c668b33547bbf957627"

URI_aarch64_sane-backends-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sane-backends-doc-1.2.1-10.el10.noarch.rpm;name=aarch64_sane-backends-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_sane-backends-doc}"
SRC_URI[aarch64_sane-backends-doc.sha256sum] = "a8f719251fa758af5777e58436a7a2e161b6cbf9f8ab2f088e7b1b1876fe1a34"

URI_aarch64_sane-backends-drivers-cameras = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sane-backends-drivers-cameras-1.2.1-10.el10.aarch64.rpm;name=aarch64_sane-backends-drivers-cameras;unpack=0"
SRC_URI:append = " ${URI_aarch64_sane-backends-drivers-cameras}"
SRC_URI[aarch64_sane-backends-drivers-cameras.sha256sum] = "f1d5eface8402693da60b4d077d3d129ff97457b30ff28ee211c37b0d7fa3cc4"

URI_aarch64_sane-backends-drivers-scanners = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sane-backends-drivers-scanners-1.2.1-10.el10.aarch64.rpm;name=aarch64_sane-backends-drivers-scanners;unpack=0"
SRC_URI:append = " ${URI_aarch64_sane-backends-drivers-scanners}"
SRC_URI[aarch64_sane-backends-drivers-scanners.sha256sum] = "4aae2953fe49f5ba082e403283bcc4eadb23aaccf2bb8f55b445d56631f1ac56"

URI_aarch64_sane-backends-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sane-backends-libs-1.2.1-10.el10.aarch64.rpm;name=aarch64_sane-backends-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_sane-backends-libs}"
SRC_URI[aarch64_sane-backends-libs.sha256sum] = "c885ff8e0c3b9bdbc21876e17395ae48c943db9faebfb043c2226696a3885db2"

RDEPENDS:sane-backends = " \
 bash \
 glibc \
 libieee1284 \
 libjpeg-turbo \
 libpng \
 libusb1 \
 libxml2 \
 sane-airscan \
 sane-backends-libs \
 systemd \
 systemd-udev \
 "
RDEPENDS:sane-backends-daemon = " \
 bash \
 glibc \
 sane-backends \
 sane-backends-libs \
 systemd-libs \
 "
RDEPENDS:sane-backends-devel = " \
 bash \
 libieee1284-devel \
 libjpeg-turbo-devel \
 libtiff-devel \
 libusb1-devel \
 pkgconf-pkg-config \
 sane-backends \
 sane-backends-drivers-cameras \
 sane-backends-drivers-scanners \
 sane-backends-libs \
 "
RDEPENDS:sane-backends-doc = " \
 "
RDEPENDS:sane-backends-drivers-cameras = " \
 glibc \
 libgcc \
 libgphoto2 \
 libieee1284 \
 libjpeg-turbo \
 libstdc++ \
 libtiff \
 libusb1 \
 libv4l \
 libxml2 \
 sane-backends \
 sane-backends-libs \
 "
RDEPENDS:sane-backends-drivers-scanners = " \
 glibc \
 libgcc \
 libieee1284 \
 libjpeg-turbo \
 libstdc++ \
 libtiff \
 libusb1 \
 libxml2 \
 sane-backends \
 sane-backends-libs \
 "
RDEPENDS:sane-backends-libs = " \
 glibc \
 libusb1 \
 libxml2 \
 "
