# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsndfile"
PV = "1.2.2"
PR = "6.el10_2.1"
PACKAGES = " \
 libsndfile \
 libsndfile-devel \
 libsndfile-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libsndfile-1.2.2-6.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61cfa7b2ab8f6fa4eadc5c528c8428bfd5c1b2b4c38489c1691038987107584e"

URI_x86_64_v2_libsndfile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsndfile-1.2.2-6.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libsndfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsndfile}"
SRC_URI[x86_64_v2_libsndfile.sha256sum] = "3638712efe299a65a26b61162ef7f303f1cd3cb5674f1cad951b687c790a797e"

URI_x86_64_v2_libsndfile-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsndfile-devel-1.2.2-6.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libsndfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsndfile-devel}"
SRC_URI[x86_64_v2_libsndfile-devel.sha256sum] = "29a08e2fbbed4d048405fbe0990036855acf885487bbddfe196a8024ec5e7290"

URI_x86_64_v2_libsndfile-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsndfile-utils-1.2.2-6.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libsndfile-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsndfile-utils}"
SRC_URI[x86_64_v2_libsndfile-utils.sha256sum] = "48caea25e912233616f78a5416cea5cb2dc96fb5b8b2a7a9224951920609086b"

URI_aarch64_libsndfile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsndfile-1.2.2-6.el10_2.1.aarch64.rpm;name=aarch64_libsndfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsndfile}"
SRC_URI[aarch64_libsndfile.sha256sum] = "fe8e3a3b9a0763e0c385d7c789f5b1ef615120d434902a8f4d28709ac28d9b71"

URI_aarch64_libsndfile-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsndfile-devel-1.2.2-6.el10_2.1.aarch64.rpm;name=aarch64_libsndfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsndfile-devel}"
SRC_URI[aarch64_libsndfile-devel.sha256sum] = "4e26a11462e8fc06045d9da1afc5aff7b904f6b733306ca0a4beebcb6748de42"

URI_aarch64_libsndfile-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsndfile-utils-1.2.2-6.el10_2.1.aarch64.rpm;name=aarch64_libsndfile-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsndfile-utils}"
SRC_URI[aarch64_libsndfile-utils.sha256sum] = "5a574456d3a8c3c158e28b5aedb7c217b2df2cffd57b1572cf91b8cd92f10a1b"

RDEPENDS:libsndfile = " \
 flac-libs \
 glibc \
 gsm \
 lame-libs \
 libogg \
 libvorbis \
 mpg123-libs \
 opus \
 "
RDEPENDS:libsndfile-devel = " \
 flac-devel \
 libogg-devel \
 libsndfile \
 libvorbis-devel \
 mpg123-devel \
 opus-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libsndfile-utils = " \
 alsa-lib \
 glibc \
 libsndfile \
 "
