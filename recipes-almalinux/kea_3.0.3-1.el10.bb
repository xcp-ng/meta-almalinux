# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kea"
PV = "3.0.3"
PR = "1.el10"
PACKAGES = " \
 kea \
 kea-doc \
 kea-hooks \
 kea-keama \
 kea-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kea-3.0.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44a3bce493f78251319b18686c65d5ee24a01ac61e6e518e4653c8ed34ee2a56"

URI_x86_64_v2_kea = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kea-3.0.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_kea;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea}"
SRC_URI[x86_64_v2_kea.sha256sum] = "9aba5eceb316270bb502dc0cd184e9210ab715e5a968361eb04f7b42ec5752d8"

URI_x86_64_v2_kea-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kea-doc-3.0.3-1.el10.noarch.rpm;name=x86_64_v2_kea-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-doc}"
SRC_URI[x86_64_v2_kea-doc.sha256sum] = "3255a334e16f623c8a39385c07e31a897da415932b39dc9b1eb5c44744f8c629"

URI_x86_64_v2_kea-hooks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kea-hooks-3.0.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_kea-hooks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-hooks}"
SRC_URI[x86_64_v2_kea-hooks.sha256sum] = "a103a400b5fe509b4dbf0a3857e876dc35d590ff037cbeb48800277c577ec3a7"

URI_x86_64_v2_kea-keama = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kea-keama-3.0.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_kea-keama;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-keama}"
SRC_URI[x86_64_v2_kea-keama.sha256sum] = "5444c92548c42d512ee2cfe266545416ffd8c77cc25f1557560132fddeec2d8c"

URI_x86_64_v2_kea-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kea-libs-3.0.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_kea-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-libs}"
SRC_URI[x86_64_v2_kea-libs.sha256sum] = "b2d5bdb7d811533972afe1183cd1ff4a527d174ab0d507d7baacc3d76f4d4ba3"

URI_aarch64_kea = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kea-3.0.3-1.el10.aarch64.rpm;name=aarch64_kea;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea}"
SRC_URI[aarch64_kea.sha256sum] = "0b66ff136df53cd9af1f7e75ec3fb87678c0cf495ff44d2f665979eedde9fc0f"

URI_aarch64_kea-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kea-doc-3.0.3-1.el10.noarch.rpm;name=aarch64_kea-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-doc}"
SRC_URI[aarch64_kea-doc.sha256sum] = "3255a334e16f623c8a39385c07e31a897da415932b39dc9b1eb5c44744f8c629"

URI_aarch64_kea-hooks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kea-hooks-3.0.3-1.el10.aarch64.rpm;name=aarch64_kea-hooks;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-hooks}"
SRC_URI[aarch64_kea-hooks.sha256sum] = "159b99aa9b7afa357beb49687bc240ac806b6650a886da8c2af524e8af715886"

URI_aarch64_kea-keama = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kea-keama-3.0.3-1.el10.aarch64.rpm;name=aarch64_kea-keama;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-keama}"
SRC_URI[aarch64_kea-keama.sha256sum] = "ce58a68048ba11f219be341c31d739b921d6d4d8f82e45bb9fbe3b9cd3aea492"

URI_aarch64_kea-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kea-libs-3.0.3-1.el10.aarch64.rpm;name=aarch64_kea-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-libs}"
SRC_URI[aarch64_kea-libs.sha256sum] = "7dd3e735fc88f2ee4b8c9956e9d83f7cf4725aae216688fb56c6ba89c609e990"

RDEPENDS:kea = " \
 bash \
 glibc \
 kea-libs \
 libgcc \
 libstdc++ \
 openssl-libs \
 python3 \
 shadow-utils \
 systemd \
 systemd-libs \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:kea-doc = " \
 "
RDEPENDS:kea-hooks = " \
 glibc \
 kea-libs \
 krb5-libs \
 libgcc \
 libpq \
 libstdc++ \
 mariadb-connector-c \
 openssl-libs \
 "
RDEPENDS:kea-keama = " \
 glibc \
 "
RDEPENDS:kea-libs = " \
 glibc \
 libgcc \
 libpq \
 libstdc++ \
 log4cplus \
 mariadb-connector-c \
 openssl-libs \
 "
