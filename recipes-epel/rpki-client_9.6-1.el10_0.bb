# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpki-client"
PV = "9.6"
PR = "1.el10_0"
PACKAGES = " \
 rpki-client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rpki-client-9.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f0de212b373cc89a37156b0b1fc5ff29779fd0a7ffbd51b7c4c6d3a0a507850"

URI_x86_64_v2_rpki-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpki-client-9.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rpki-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpki-client}"
SRC_URI[x86_64_v2_rpki-client.sha256sum] = "e1db5680530e751fb292ca18c2c0adedb08b468c113d5db6a7f756ad8c8c029b"

URI_aarch64_rpki-client = "${EPEL_MIRROR}/aarch64/Packages/r/rpki-client-9.6-1.el10_0.aarch64.rpm;name=aarch64_rpki-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpki-client}"
SRC_URI[aarch64_rpki-client.sha256sum] = "0dc20053c21b862036d6ad39adb79c04add8ac09437226541ae146f48a7757f5"

RDEPENDS:rpki-client = " \
 bash \
 expat \
 glibc \
 libretls \
 openssl-libs \
 rsync \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
