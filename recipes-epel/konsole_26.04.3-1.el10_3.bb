# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konsole"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 konsole \
 konsole-part \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/konsole-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8af053ca4bc1d8c1d294ea84254399bde1bb8b0ca4ae74e8d82cb1083138d15"

URI_x86_64_v2_konsole = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konsole-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konsole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konsole}"
SRC_URI[x86_64_v2_konsole.sha256sum] = "ef5b523317fc0ffc69061ad4fef63eb890cc2cc117d1397c44d0ce706e514b7b"

URI_x86_64_v2_konsole-part = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konsole-part-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konsole-part;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konsole-part}"
SRC_URI[x86_64_v2_konsole-part.sha256sum] = "66ef39876e1d090c76d7bb96da142d23604aad470d165046d0d63511d814c9d3"

URI_aarch64_konsole = "${EPEL_MIRROR}/aarch64/Packages/k/konsole-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_konsole;unpack=0"
SRC_URI:append = " ${URI_aarch64_konsole}"
SRC_URI[aarch64_konsole.sha256sum] = "fbc42f126eb398dea658e2399d70a4271b79db49c88a5795bb1cce2a705d5918"

URI_aarch64_konsole-part = "${EPEL_MIRROR}/aarch64/Packages/k/konsole-part-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_konsole-part;unpack=0"
SRC_URI:append = " ${URI_aarch64_konsole-part}"
SRC_URI[aarch64_konsole-part.sha256sum] = "c912fcd7bd57bc5c8ed74460cfce582da67f52b0475db8087eb72f9e4a366c66"

RDEPENDS:konsole = " \
 bash \
 glibc \
 keditbookmarks \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 konsole-part \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:konsole-part = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kpty \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libicu \
 libstdc++ \
 libxkbcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
