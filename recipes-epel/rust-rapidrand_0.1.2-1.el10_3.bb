# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rapidrand"
PV = "0.1.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-rapidrand+default-devel \
 rust-rapidrand+rand-devel \
 rust-rapidrand-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rapidrand-0.1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2e6f39a0149a7b25dfd0fd70aca4bb11fd02800e58138fd56bf01705493eb2b0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rapidrand+default-devel-0.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rapidrand+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rapidrand+default-devel.sha256sum] = "c4830d094cb51cb09e9b4d806c5499dd33473de410391b8375de331a3b1d7989"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rapidrand+rand-devel-0.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rapidrand+rand-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rapidrand+rand-devel.sha256sum] = "238bba70d07309eac388b41cbbac25d3ffb51cd3604da7ffb1acf8cb576d4946"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rapidrand-devel-0.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rapidrand-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rapidrand-devel.sha256sum] = "06e5846294c21a80c9f903123107e8b3e2e778ec6861433d7b47c8f1610036fe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rapidrand+default-devel-0.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-rapidrand+default-devel;unpack=0"
SRC_URI[aarch64_rust-rapidrand+default-devel.sha256sum] = "46c02ef4a1cb9de52778ba402658b6f9cb20759e97fd074823e352d1ef3ac7ea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rapidrand+rand-devel-0.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-rapidrand+rand-devel;unpack=0"
SRC_URI[aarch64_rust-rapidrand+rand-devel.sha256sum] = "25f52b271c10bf6e4087cd594b8b6ca4d03cf3031bf76bb7688bd5ee25fd15c9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rapidrand-devel-0.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-rapidrand-devel;unpack=0"
SRC_URI[aarch64_rust-rapidrand-devel.sha256sum] = "ed997700d9d98dd5785cf90b823647d28a2725edfa2b76bf60673e8a28e118f8"

RDEPENDS:rust-rapidrand+default-devel = " \
 cargo \
 rust-rapidrand+rand-devel \
 rust-rapidrand-devel \
 "
RDEPENDS:rust-rapidrand+rand-devel = " \
 cargo \
 rust-rand_core-devel \
 rust-rapidrand-devel \
 "
RDEPENDS:rust-rapidrand-devel = " \
 cargo \
 rust \
 "
