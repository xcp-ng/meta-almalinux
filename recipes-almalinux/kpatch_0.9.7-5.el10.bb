# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpatch"
PV = "0.9.7"
PR = "5.el10"
PACKAGES = " \
 kpatch \
 kpatch-dnf \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kpatch-0.9.7-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3ca6d7db720fd42a0392606d99c059aba3ee17bf3394c249fb849dd1f005e98"

URI_x86_64_v2_kpatch = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kpatch-0.9.7-5.el10.noarch.rpm;name=x86_64_v2_kpatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpatch}"
SRC_URI[x86_64_v2_kpatch.sha256sum] = "2436baaf64f1cacb221e106c6f72c3980410c3dab013adb5f630481ebadc3e32"

URI_x86_64_v2_kpatch-dnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kpatch-dnf-0.9.7_0.5-5.el10.noarch.rpm;name=x86_64_v2_kpatch-dnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpatch-dnf}"
SRC_URI[x86_64_v2_kpatch-dnf.sha256sum] = "871a1dce26c4ef4199e5bdcd6ac2176763216971d9c6fd23fa65c3053f303213"

URI_aarch64_kpatch = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kpatch-0.9.7-5.el10.noarch.rpm;name=aarch64_kpatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpatch}"
SRC_URI[aarch64_kpatch.sha256sum] = "2436baaf64f1cacb221e106c6f72c3980410c3dab013adb5f630481ebadc3e32"

URI_aarch64_kpatch-dnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kpatch-dnf-0.9.7_0.5-5.el10.noarch.rpm;name=aarch64_kpatch-dnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpatch-dnf}"
SRC_URI[aarch64_kpatch-dnf.sha256sum] = "871a1dce26c4ef4199e5bdcd6ac2176763216971d9c6fd23fa65c3053f303213"

RDEPENDS:kpatch = " \
 bash \
 binutils \
 kmod \
 "
RDEPENDS:kpatch-dnf = " \
 bash \
 python3 \
 python3-dnf \
 python3-hawkey \
 "
