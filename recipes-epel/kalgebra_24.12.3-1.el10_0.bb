# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalgebra"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kalgebra \
 kalgebra-plasma-applet \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kalgebra-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "67153da74385a1e5f47253143adc819f6b77e783ea773cf2ffc2a821c12b9f30"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalgebra-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalgebra;unpack=0"
SRC_URI[x86_64_v2_kalgebra.sha256sum] = "f071cadbb1165867a4a4c17ea15d1244fccde46f0256f4d7d17abcf0567a277a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalgebra-plasma-applet-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalgebra-plasma-applet;unpack=0"
SRC_URI[x86_64_v2_kalgebra-plasma-applet.sha256sum] = "3579c3ba3d475a73c05db0cb56b702238608a3c4f5b1cabf997f85b1fdb0284f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kalgebra-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kalgebra;unpack=0"
SRC_URI[aarch64_kalgebra.sha256sum] = "ad478eaf3c098373f17f2e97b6fad33acbbeb33fb355da2f4c5e247a10adbda2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kalgebra-plasma-applet-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kalgebra-plasma-applet;unpack=0"
SRC_URI[aarch64_kalgebra-plasma-applet.sha256sum] = "4a9d3be1d8f56b1abba358d864076d8b817cdbccbc180257a9a8c176141e6669"

RDEPENDS:kalgebra = " \
 analitza \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 readline \
 "
RDEPENDS:kalgebra-plasma-applet = " \
 kalgebra \
 libplasma \
 "
