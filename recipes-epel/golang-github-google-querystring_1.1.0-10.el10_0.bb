# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-google-querystring"
PV = "1.1.0"
PR = "10.el10_0"
PACKAGES = " \
 golang-github-google-querystring-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-google-querystring-1.1.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48ab7d7b86640cd6c5ba959a09a7b3e1aa5d9e67db60a4d9d6c3da5d6e88ff08"

URI_x86_64_v2_golang-github-google-querystring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-google-querystring-devel-1.1.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-google-querystring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-google-querystring-devel}"
SRC_URI[x86_64_v2_golang-github-google-querystring-devel.sha256sum] = "3ac6614d37e8b3f305417de3e08ac5304196c6ef0e1f1f4dff23f2f5256c003d"

URI_aarch64_golang-github-google-querystring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-google-querystring-devel-1.1.0-10.el10_0.noarch.rpm;name=aarch64_golang-github-google-querystring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-google-querystring-devel}"
SRC_URI[aarch64_golang-github-google-querystring-devel.sha256sum] = "225ce4b1dd7374325ddf0aa617357d093f4da8c35fbbe10474c29ec22877b416"

RDEPENDS:golang-github-google-querystring-devel = " \
 go-filesystem \
 "
