# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trybuild"
PV = "1.0.105"
PR = "1.el10_0"
PACKAGES = " \
 rust-trybuild+default-devel \
 rust-trybuild+diff-devel \
 rust-trybuild-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-trybuild-1.0.105-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d87071b10be87aa6144d430dad2ed38a68be4e9c190526304718f43fa5e807c4"

URI_x86_64_v2_rust-trybuild+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild+default-devel-1.0.105-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild+default-devel}"
SRC_URI[x86_64_v2_rust-trybuild+default-devel.sha256sum] = "f6de401811a697270cac26f07100c6a4d4e3659a413ba0cd162a6675a3ce84d8"

URI_x86_64_v2_rust-trybuild+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild+diff-devel-1.0.105-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild+diff-devel}"
SRC_URI[x86_64_v2_rust-trybuild+diff-devel.sha256sum] = "07389e08566db85b0b305b70a0b01da51dff46113e1650710213920a5c9cd479"

URI_x86_64_v2_rust-trybuild-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild-devel-1.0.105-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild-devel}"
SRC_URI[x86_64_v2_rust-trybuild-devel.sha256sum] = "d64ac7500805c82b1bc2594790507f91e39cd6bde4b9583f89caa7cec127d61d"

URI_aarch64_rust-trybuild+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild+default-devel-1.0.105-1.el10_0.noarch.rpm;name=aarch64_rust-trybuild+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild+default-devel}"
SRC_URI[aarch64_rust-trybuild+default-devel.sha256sum] = "b8f611311643b8b7d1e2ae81c9fec9d52a1a6a395a840c4f6bee45ca1b97e97e"

URI_aarch64_rust-trybuild+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild+diff-devel-1.0.105-1.el10_0.noarch.rpm;name=aarch64_rust-trybuild+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild+diff-devel}"
SRC_URI[aarch64_rust-trybuild+diff-devel.sha256sum] = "656234f70e86cb35683cc5522f389fb2d57d82b7991a682328394ea0c878cd8c"

URI_aarch64_rust-trybuild-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild-devel-1.0.105-1.el10_0.noarch.rpm;name=aarch64_rust-trybuild-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild-devel}"
SRC_URI[aarch64_rust-trybuild-devel.sha256sum] = "156d98adac50b925732052c96f18a8eaad72a953fa5a488c2e365cfb0ff476bb"

RDEPENDS:rust-trybuild+default-devel = " \
 cargo \
 rust-trybuild-devel \
 "
RDEPENDS:rust-trybuild+diff-devel = " \
 cargo \
 rust-dissimilar+default-devel \
 rust-trybuild-devel \
 "
RDEPENDS:rust-trybuild-devel = " \
 cargo \
 rust \
 rust-glob+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 rust-target-triple+default-devel \
 rust-termcolor+default-devel \
 rust-toml+default-devel \
 "
