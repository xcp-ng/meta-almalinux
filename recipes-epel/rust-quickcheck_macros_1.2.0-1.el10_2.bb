# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quickcheck_macros"
PV = "1.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-quickcheck_macros+default-devel \
 rust-quickcheck_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quickcheck_macros-1.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0083f476df3ba8a483f82b8512ad2c1c55151af8a30f69d3882889daecab510"

URI_x86_64_v2_rust-quickcheck_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck_macros+default-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck_macros+default-devel}"
SRC_URI[x86_64_v2_rust-quickcheck_macros+default-devel.sha256sum] = "e141393e84b7128fe879a31a04332264ecaa3dfb08bb28939f6795e03510f905"

URI_x86_64_v2_rust-quickcheck_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck_macros-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck_macros-devel}"
SRC_URI[x86_64_v2_rust-quickcheck_macros-devel.sha256sum] = "0a8665fa7a2cbcb0e9a5f9bab7bebd91a87fdbd78a3e62ce1021a65a81a1e436"

URI_aarch64_rust-quickcheck_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck_macros+default-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-quickcheck_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck_macros+default-devel}"
SRC_URI[aarch64_rust-quickcheck_macros+default-devel.sha256sum] = "6801b5fc3fc85e032531bff2710393f1429d0461abd77003a3a47ce2e33e1eca"

URI_aarch64_rust-quickcheck_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck_macros-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-quickcheck_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck_macros-devel}"
SRC_URI[aarch64_rust-quickcheck_macros-devel.sha256sum] = "97a557ecac3c56e3775df605dd5867cfa33e85e00596b05958f74681f5b7e885"

RDEPENDS:rust-quickcheck_macros+default-devel = " \
 cargo \
 rust-quickcheck_macros-devel \
 "
RDEPENDS:rust-quickcheck_macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
