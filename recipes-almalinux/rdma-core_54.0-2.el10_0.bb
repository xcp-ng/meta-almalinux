# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rdma-core"
PV = "54.0"
PR = "2.el10_0"
PACKAGES = " \
 ibacm \
 infiniband-diags \
 iwpmd \
 libibumad \
 libibverbs \
 libibverbs-utils \
 librdmacm \
 librdmacm-utils \
 python3-pyverbs \
 rdma-core \
 rdma-core-devel \
 srp_daemon \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rdma-core-54.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "114bfac27f103728de906e39331eff517713251065cac672ca653bd712527d72"

URI_x86_64_v2_ibacm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ibacm-54.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_ibacm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibacm}"
SRC_URI[x86_64_v2_ibacm.sha256sum] = "7a793e3321ae17db984440f4c6df8d010818e9f92e6f75b42f30de7ad5fba0e5"

URI_x86_64_v2_infiniband-diags = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/infiniband-diags-54.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_infiniband-diags;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_infiniband-diags}"
SRC_URI[x86_64_v2_infiniband-diags.sha256sum] = "5385b48aff3f536e4b28253697f4df9e3a88d2ca6cb7314cbef444483ce235fa"

URI_x86_64_v2_iwpmd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwpmd-54.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_iwpmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iwpmd}"
SRC_URI[x86_64_v2_iwpmd.sha256sum] = "0554526db8d1f2641260bbbcf303bc9835b3b00c6384f4040ce7a44ad4ee887d"

URI_x86_64_v2_libibumad = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libibumad-54.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_libibumad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libibumad}"
SRC_URI[x86_64_v2_libibumad.sha256sum] = "262b548d7ab7da944d428743fd95a444bed173a345c9d185348e5a208ee91080"

URI_x86_64_v2_libibverbs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libibverbs-54.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_libibverbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libibverbs}"
SRC_URI[x86_64_v2_libibverbs.sha256sum] = "737eda6b1eac51eb915fe3bd8bcbb17e20b45821e0801eadcdba59cab571f5f2"

URI_x86_64_v2_libibverbs-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libibverbs-utils-54.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_libibverbs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libibverbs-utils}"
SRC_URI[x86_64_v2_libibverbs-utils.sha256sum] = "ebf39599116d27beff62fc6541c0f219490f6ee2c492dc4a72f1fa777f6636c5"

URI_x86_64_v2_librdmacm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/librdmacm-54.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_librdmacm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librdmacm}"
SRC_URI[x86_64_v2_librdmacm.sha256sum] = "1b8a7d37c97eee33c78f93369958a43ef95b529a16df1983dee25d01ce9d936e"

URI_x86_64_v2_librdmacm-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/librdmacm-utils-54.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_librdmacm-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librdmacm-utils}"
SRC_URI[x86_64_v2_librdmacm-utils.sha256sum] = "cf03f9fe81ba7e5f3496e1dca8bc9eac5060c63cf0dfad7cbdeeac722446dd73"

URI_x86_64_v2_python3-pyverbs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyverbs-54.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-pyverbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyverbs}"
SRC_URI[x86_64_v2_python3-pyverbs.sha256sum] = "411b87111b32945310206a21fca0d49b3aa320d23c62a3600548ff5ee6bf8763"

URI_x86_64_v2_rdma-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rdma-core-54.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_rdma-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rdma-core}"
SRC_URI[x86_64_v2_rdma-core.sha256sum] = "3bfc64a9709754cb5ee67ff0b135161dc843fffcb32df38a08fd17976bb9416c"

URI_x86_64_v2_rdma-core-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rdma-core-devel-54.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_rdma-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rdma-core-devel}"
SRC_URI[x86_64_v2_rdma-core-devel.sha256sum] = "cb5cec5b26015fe32fb9748863686d8591df67c1e7f810b53fac0dfa0f47338c"

URI_x86_64_v2_srp_daemon = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/srp_daemon-54.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_srp_daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_srp_daemon}"
SRC_URI[x86_64_v2_srp_daemon.sha256sum] = "ea92c92a937505ec905175b612f1c29ac2c0607af9c6ba3c1c72ffdfb22c0542"

URI_aarch64_ibacm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ibacm-54.0-2.el10_0.aarch64.rpm;name=aarch64_ibacm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibacm}"
SRC_URI[aarch64_ibacm.sha256sum] = "6d4b5ccd0c645286b80bd9b8ddd29247ffdb7975f53abd11dc90cefeeca0d099"

URI_aarch64_infiniband-diags = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/infiniband-diags-54.0-2.el10_0.aarch64.rpm;name=aarch64_infiniband-diags;unpack=0"
SRC_URI:append = " ${URI_aarch64_infiniband-diags}"
SRC_URI[aarch64_infiniband-diags.sha256sum] = "e4227e1e60a85238d0283c8d66f104469ee60e7ca11b4c6a9e72c381f774b980"

URI_aarch64_iwpmd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwpmd-54.0-2.el10_0.aarch64.rpm;name=aarch64_iwpmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_iwpmd}"
SRC_URI[aarch64_iwpmd.sha256sum] = "1405ca5433b61a8f55d5d5331f86758fa2e2f2e9e70a8b2fb3951a4870c56460"

URI_aarch64_libibumad = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libibumad-54.0-2.el10_0.aarch64.rpm;name=aarch64_libibumad;unpack=0"
SRC_URI:append = " ${URI_aarch64_libibumad}"
SRC_URI[aarch64_libibumad.sha256sum] = "39d5ab2ddd3343146a6ca433eba581d1181f31702d15ec8c4fa38d7acd6b9bb8"

URI_aarch64_libibverbs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libibverbs-54.0-2.el10_0.aarch64.rpm;name=aarch64_libibverbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libibverbs}"
SRC_URI[aarch64_libibverbs.sha256sum] = "38e96cbfcdc52aaaa6b1034fba227d3d5d9c7a0db0ddf2cf30f534466948db4f"

URI_aarch64_libibverbs-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libibverbs-utils-54.0-2.el10_0.aarch64.rpm;name=aarch64_libibverbs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libibverbs-utils}"
SRC_URI[aarch64_libibverbs-utils.sha256sum] = "1f7e432f491c8bda1b58133bbcda64785415c037b3868eddcc05842c9e0b770c"

URI_aarch64_librdmacm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/librdmacm-54.0-2.el10_0.aarch64.rpm;name=aarch64_librdmacm;unpack=0"
SRC_URI:append = " ${URI_aarch64_librdmacm}"
SRC_URI[aarch64_librdmacm.sha256sum] = "8a1240e8a2b779eb3ca553c0791dcb0ff6878cc031e8e239382b35e6430ebdd1"

URI_aarch64_librdmacm-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/librdmacm-utils-54.0-2.el10_0.aarch64.rpm;name=aarch64_librdmacm-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_librdmacm-utils}"
SRC_URI[aarch64_librdmacm-utils.sha256sum] = "2d7ae2126a9399d5c3f58c94ef8ad60bb3343aea9778872d841906d177ceeb54"

URI_aarch64_python3-pyverbs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyverbs-54.0-2.el10_0.aarch64.rpm;name=aarch64_python3-pyverbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyverbs}"
SRC_URI[aarch64_python3-pyverbs.sha256sum] = "5d464c003394a7ccf372b0047bcccd66287e359efef9d9942e5536e9a328a46c"

URI_aarch64_rdma-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rdma-core-54.0-2.el10_0.aarch64.rpm;name=aarch64_rdma-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_rdma-core}"
SRC_URI[aarch64_rdma-core.sha256sum] = "4a0fd21defa9977d2585fb1c85a6b02868fea10e35d9a2ad9157193038192af7"

URI_aarch64_rdma-core-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rdma-core-devel-54.0-2.el10_0.aarch64.rpm;name=aarch64_rdma-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rdma-core-devel}"
SRC_URI[aarch64_rdma-core-devel.sha256sum] = "39aa673e502533b4678c0fbc3a02f961f9784c87a91691cef9c11e80f4c3289b"

URI_aarch64_srp_daemon = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/srp_daemon-54.0-2.el10_0.aarch64.rpm;name=aarch64_srp_daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_srp_daemon}"
SRC_URI[aarch64_srp_daemon.sha256sum] = "c8de762b7db199d4f9c8f3315df96c9e1d02e0822912d25914dcedcd29594e61"

RDEPENDS:ibacm = " \
 bash \
 glibc \
 libibumad \
 libibverbs \
 libnl3 \
 systemd \
 systemd-libs \
 "
RDEPENDS:infiniband-diags = " \
 bash \
 glibc \
 libibumad \
 perl-Getopt-Std \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:iwpmd = " \
 bash \
 glibc \
 libnl3 \
 systemd \
 systemd-libs \
 "
RDEPENDS:libibumad = " \
 glibc \
 "
RDEPENDS:libibverbs = " \
 glibc \
 libnl3 \
 "
RDEPENDS:libibverbs-utils = " \
 glibc \
 libibverbs \
 "
RDEPENDS:librdmacm = " \
 glibc \
 libibverbs \
 libnl3 \
 "
RDEPENDS:librdmacm-utils = " \
 glibc \
 libibverbs \
 librdmacm \
 "
RDEPENDS:python3-pyverbs = " \
 glibc \
 libibverbs \
 librdmacm \
 python3 \
 python3-libs \
 "
RDEPENDS:rdma-core = " \
 bash \
 glibc \
 libnl3 \
 pciutils \
 systemd-libs \
 "
RDEPENDS:rdma-core-devel = " \
 infiniband-diags \
 libibumad \
 libibverbs \
 librdmacm \
 pkgconf-pkg-config \
 rdma-core-devel \
 "
RDEPENDS:srp_daemon = " \
 bash \
 glibc \
 libibumad \
 libibverbs \
 systemd \
 "
