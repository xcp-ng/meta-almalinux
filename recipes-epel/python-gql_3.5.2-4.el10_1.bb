# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-gql"
PV = "3.5.2"
PR = "4.el10_1"
PACKAGES = " \
 python3-gql \
 python3-gql+aiohttp \
 python3-gql+botocore \
 python3-gql+httpx \
 python3-gql+requests \
 python3-gql+websockets \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-gql-3.5.2-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25df6c96adc746e69daea052cd6bed4fcc90b7d90b0e917c139cf124e4053b14"

URI_x86_64_v2_python3-gql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gql-3.5.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gql}"
SRC_URI[x86_64_v2_python3-gql.sha256sum] = "5058d9af294beed4d9bbe408048f5df22bc39789b7a17e632991da207ff29fbd"

URI_x86_64_v2_python3-gql+aiohttp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gql+aiohttp-3.5.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gql+aiohttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gql+aiohttp}"
SRC_URI[x86_64_v2_python3-gql+aiohttp.sha256sum] = "1fba58edca0b67934337ab3e3c774886755b3a99ea0fef689f230a021c84bf63"

URI_x86_64_v2_python3-gql+botocore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gql+botocore-3.5.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gql+botocore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gql+botocore}"
SRC_URI[x86_64_v2_python3-gql+botocore.sha256sum] = "3506a587ac0929eea54577041e30a36e8c697781a64d15b5a4eb2eac2c32d510"

URI_x86_64_v2_python3-gql+httpx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gql+httpx-3.5.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gql+httpx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gql+httpx}"
SRC_URI[x86_64_v2_python3-gql+httpx.sha256sum] = "6b2c442f9950f51a63aaeade6c73e3b511339e498bf7eaaf8108ef8342543249"

URI_x86_64_v2_python3-gql+requests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gql+requests-3.5.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gql+requests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gql+requests}"
SRC_URI[x86_64_v2_python3-gql+requests.sha256sum] = "951307cfc23c55a2fe85ed638defb8e9a4e1ce877e9cb72fdec49f0765e65795"

URI_x86_64_v2_python3-gql+websockets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gql+websockets-3.5.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gql+websockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gql+websockets}"
SRC_URI[x86_64_v2_python3-gql+websockets.sha256sum] = "fdf022d132be4ffa5e669462dc6f199133702c20e760ade2af767e7b992499ca"

URI_aarch64_python3-gql = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gql-3.5.2-4.el10_1.noarch.rpm;name=aarch64_python3-gql;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gql}"
SRC_URI[aarch64_python3-gql.sha256sum] = "ba8a79d58ff6a07f09cb7da703b91fb0709aa9fa8168f3368d076d54f53c1449"

URI_aarch64_python3-gql+aiohttp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gql+aiohttp-3.5.2-4.el10_1.noarch.rpm;name=aarch64_python3-gql+aiohttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gql+aiohttp}"
SRC_URI[aarch64_python3-gql+aiohttp.sha256sum] = "53e16806053a80ef6ce7ebe19d320fa9282904aadb5a01667a2229e9f3b1efb7"

URI_aarch64_python3-gql+botocore = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gql+botocore-3.5.2-4.el10_1.noarch.rpm;name=aarch64_python3-gql+botocore;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gql+botocore}"
SRC_URI[aarch64_python3-gql+botocore.sha256sum] = "262c5ff3a45f548594869f6fc33bfa14a6059a3c7f71f19c0e41bfde9455f852"

URI_aarch64_python3-gql+httpx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gql+httpx-3.5.2-4.el10_1.noarch.rpm;name=aarch64_python3-gql+httpx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gql+httpx}"
SRC_URI[aarch64_python3-gql+httpx.sha256sum] = "6841390ba127586e68161f4f5ec507f7c6087f3d95478ef2c8c48cfd054b8d16"

URI_aarch64_python3-gql+requests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gql+requests-3.5.2-4.el10_1.noarch.rpm;name=aarch64_python3-gql+requests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gql+requests}"
SRC_URI[aarch64_python3-gql+requests.sha256sum] = "7a54d4e8d7b02fb289ebee6fce5b1c11cc87efc0ffe41e36a9431ffa8368b790"

URI_aarch64_python3-gql+websockets = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gql+websockets-3.5.2-4.el10_1.noarch.rpm;name=aarch64_python3-gql+websockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gql+websockets}"
SRC_URI[aarch64_python3-gql+websockets.sha256sum] = "808ee3f80b1b9659473c039dc9201aea3064ba4c45b529ad720502e957eb58a3"

RDEPENDS:python3-gql = " \
 python3 \
 python3-anyio \
 python3-backoff \
 python3-graphql-core \
 python3-yarl \
 "
RDEPENDS:python3-gql+aiohttp = " \
 python3 \
 python3-aiohttp \
 python3-gql \
 "
RDEPENDS:python3-gql+botocore = " \
 python3 \
 python3-botocore \
 python3-gql \
 "
RDEPENDS:python3-gql+httpx = " \
 python3 \
 python3-gql \
 python3-httpx \
 "
RDEPENDS:python3-gql+requests = " \
 python3 \
 python3-gql \
 python3-requests \
 python3-requests-toolbelt \
 "
RDEPENDS:python3-gql+websockets = " \
 python3 \
 python3-gql \
 python3-websockets \
 "
