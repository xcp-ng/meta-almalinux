# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvirt"
PV = "11.5.0"
PR = "4.8.el10_1.alma.1"
PACKAGES = " \
 libvirt \
 libvirt-client \
 libvirt-client-qemu \
 libvirt-daemon \
 libvirt-daemon-common \
 libvirt-daemon-config-network \
 libvirt-daemon-config-nwfilter \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-daemon-driver-storage-core \
 libvirt-daemon-driver-storage-disk \
 libvirt-daemon-driver-storage-iscsi \
 libvirt-daemon-driver-storage-logical \
 libvirt-daemon-driver-storage-mpath \
 libvirt-daemon-driver-storage-rbd \
 libvirt-daemon-driver-storage-scsi \
 libvirt-daemon-kvm \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-plugin-sanlock \
 libvirt-daemon-proxy \
 libvirt-devel \
 libvirt-docs \
 libvirt-libs \
 libvirt-nss \
 libvirt-ssh-proxy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvirt-11.5.0-4.8.el10_1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30bc1a7ec96ae72f3549aee540cb4ce0654669b3a5f8393895317744e2392fe2"

URI_x86_64_v2_libvirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt}"
SRC_URI[x86_64_v2_libvirt.sha256sum] = "5d5a178164153347ff1451938d14522e7dc209095c585153ee2c56a2b66ab7ff"

URI_x86_64_v2_libvirt-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-client-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-client}"
SRC_URI[x86_64_v2_libvirt-client.sha256sum] = "1fb6f624ac39ade99625c04766166fa71df36539d373335783feeacd0465c42c"

URI_x86_64_v2_libvirt-client-qemu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-client-qemu-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-client-qemu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-client-qemu}"
SRC_URI[x86_64_v2_libvirt-client-qemu.sha256sum] = "c6c114678e48fe58ecc200e607a9d87c91483e3d86b4b18d452a26654c89993d"

URI_x86_64_v2_libvirt-daemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon}"
SRC_URI[x86_64_v2_libvirt-daemon.sha256sum] = "e1934a1f733f3285bfe07b7ce8e07cd85e843713ee6957a6815037d7dce0e0a7"

URI_x86_64_v2_libvirt-daemon-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-common-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-common}"
SRC_URI[x86_64_v2_libvirt-daemon-common.sha256sum] = "b271031dc9d95d87e975ede10424b00e55fdc7b1df41979cc9eae64347133194"

URI_x86_64_v2_libvirt-daemon-config-network = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-config-network-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-config-network;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-config-network}"
SRC_URI[x86_64_v2_libvirt-daemon-config-network.sha256sum] = "3cc5597ae5ae41c4d847951941b4cf474abc54e17b5ab8baa27c73832d449e6d"

URI_x86_64_v2_libvirt-daemon-config-nwfilter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-config-nwfilter-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-config-nwfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-config-nwfilter}"
SRC_URI[x86_64_v2_libvirt-daemon-config-nwfilter.sha256sum] = "df1f99935b92cab2876968264274eab0b83307f4855bfdf452bd5b09a952b381"

URI_x86_64_v2_libvirt-daemon-driver-interface = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-interface-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-interface;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-interface}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-interface.sha256sum] = "bd1196121888b7174af3259ff33bb17e5d696f3d92d23dae1edac7db2071d4c2"

URI_x86_64_v2_libvirt-daemon-driver-network = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-network-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-network;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-network}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-network.sha256sum] = "5a59186b12846ccd887bf4ddbabacb2a0c43b5e0bb484cdbf58ed4cd42026ec6"

URI_x86_64_v2_libvirt-daemon-driver-nodedev = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-nodedev-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-nodedev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-nodedev}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-nodedev.sha256sum] = "d93ac718ee2cd98da83af1c8d46f90f5681ac40af52f72cf5e12c4b5b5709898"

URI_x86_64_v2_libvirt-daemon-driver-nwfilter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-nwfilter-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-nwfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-nwfilter}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-nwfilter.sha256sum] = "306a7d5167b2b0371f9e8c42ff1ebd0d81285970d1abd64451c711621efda80c"

URI_x86_64_v2_libvirt-daemon-driver-qemu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-qemu-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-qemu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-qemu}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-qemu.sha256sum] = "50dffe28ec6a57fdc703c5310eda289a1846fb9ed21a6779530a68bda955f0d7"

URI_x86_64_v2_libvirt-daemon-driver-secret = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-secret-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-secret;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-secret}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-secret.sha256sum] = "57855d23466a1df9ace3569c45bc6b2cacaad8c55582469b50977fc07cc9842e"

URI_x86_64_v2_libvirt-daemon-driver-storage = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage.sha256sum] = "1138c6d80fe3a74bcc97b95f887eeb59f7fed325da592ee92b08b9d6e13c1066"

URI_x86_64_v2_libvirt-daemon-driver-storage-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-core-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-core}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-core.sha256sum] = "6e1aa3d3d279312a4aa4228fd0f20e383ee0068d8d725effc71b42c433c0b360"

URI_x86_64_v2_libvirt-daemon-driver-storage-disk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-disk-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-disk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-disk}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-disk.sha256sum] = "9f797aadbea5cb102a9b4334bbdd5d49e575d62874ee9e36d7edbab5d769385d"

URI_x86_64_v2_libvirt-daemon-driver-storage-iscsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-iscsi-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-iscsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-iscsi}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-iscsi.sha256sum] = "d677691875463ffb782fdfb17b482ae46f54b8d2b1bdffd62c3152932e089816"

URI_x86_64_v2_libvirt-daemon-driver-storage-logical = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-logical-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-logical;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-logical}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-logical.sha256sum] = "3dba26b1ff3b7b3a2afdba8e6e4ea56f43a8ca0b02050785a6586d28ea79ac3f"

URI_x86_64_v2_libvirt-daemon-driver-storage-mpath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-mpath-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-mpath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-mpath}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-mpath.sha256sum] = "7ba314e1465df9b40d06325e5b9ace2e2d890c621cfc4e6eb74c35f063f9d5ee"

URI_x86_64_v2_libvirt-daemon-driver-storage-rbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-rbd-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-rbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-rbd}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-rbd.sha256sum] = "e55e140edcdff60ba0eb7086c685a859fef491072a16ed9798bafb304f99bc80"

URI_x86_64_v2_libvirt-daemon-driver-storage-scsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-scsi-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-scsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-scsi}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-scsi.sha256sum] = "17cb45e99d9e3da61c4ab9e0125777972c6baa291e85c400e1b1e72d7c3ac42a"

URI_x86_64_v2_libvirt-daemon-kvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-kvm-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-kvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-kvm}"
SRC_URI[x86_64_v2_libvirt-daemon-kvm.sha256sum] = "a57c44599368e7b603fa2f3bf801f08ad1ee8dc0cadbf5c3263685f9f597a54e"

URI_x86_64_v2_libvirt-daemon-lock = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-lock-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-lock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-lock}"
SRC_URI[x86_64_v2_libvirt-daemon-lock.sha256sum] = "208f388a29da6835081a3c92277465aceb79a66382beca34698e325bbbfcd9ba"

URI_x86_64_v2_libvirt-daemon-log = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-log-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-log}"
SRC_URI[x86_64_v2_libvirt-daemon-log.sha256sum] = "12b897ea36bafe34100be909fa19c9fe34f602aa2e8c547fed475ffcb8e128cf"

URI_x86_64_v2_libvirt-daemon-plugin-lockd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-plugin-lockd-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-plugin-lockd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-plugin-lockd}"
SRC_URI[x86_64_v2_libvirt-daemon-plugin-lockd.sha256sum] = "ec71f8a6d0178dfbf845b32fd51fec610e1caae0652f32081ba001169e17bd7b"

URI_x86_64_v2_libvirt-daemon-plugin-sanlock = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-daemon-plugin-sanlock-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-plugin-sanlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-plugin-sanlock}"
SRC_URI[x86_64_v2_libvirt-daemon-plugin-sanlock.sha256sum] = "22ff5795927affebac137dd5e49eec2b88c756731659ea69b0e00e4aad9a4889"

URI_x86_64_v2_libvirt-daemon-proxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-proxy-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-proxy}"
SRC_URI[x86_64_v2_libvirt-daemon-proxy.sha256sum] = "4ed0670c73ef82541050fb1b7c59be4d1d8bef83d09216631b73d179febaaaa3"

URI_x86_64_v2_libvirt-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-devel-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-devel}"
SRC_URI[x86_64_v2_libvirt-devel.sha256sum] = "016ee35f4a99a7812721a479f39db9d114274fed1230297849a4e9254a96749a"

URI_x86_64_v2_libvirt-docs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-docs-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-docs}"
SRC_URI[x86_64_v2_libvirt-docs.sha256sum] = "a02e79d82900ca258ab81abc769c2256cc66151402b8b7a2e6b8a805a57c7679"

URI_x86_64_v2_libvirt-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-libs-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-libs}"
SRC_URI[x86_64_v2_libvirt-libs.sha256sum] = "01bd3a56d568c759676af0ba0227b62acd669ae0b540c6166588dbc1b764dc4f"

URI_x86_64_v2_libvirt-nss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-nss-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-nss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-nss}"
SRC_URI[x86_64_v2_libvirt-nss.sha256sum] = "7f01d7ddab8921d15f193f097abe3fa7ff67b6b1bdf1188fe5bf6d546879ff2e"

URI_x86_64_v2_libvirt-ssh-proxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-ssh-proxy-11.5.0-4.8.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-ssh-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-ssh-proxy}"
SRC_URI[x86_64_v2_libvirt-ssh-proxy.sha256sum] = "b1bdb01eeacf878010e67b8d73cfb2be544a04122b3130ae4495ed521788731a"

URI_aarch64_libvirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt}"
SRC_URI[aarch64_libvirt.sha256sum] = "0b50705f533c836c580792910eec8286722cfca48e099577053d4a78487413d1"

URI_aarch64_libvirt-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-client-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-client}"
SRC_URI[aarch64_libvirt-client.sha256sum] = "560c12c5a6ff4c7ce8488d06490f98880c0fb863ab6da02fcf9dafd58a253b0b"

URI_aarch64_libvirt-client-qemu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-client-qemu-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-client-qemu;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-client-qemu}"
SRC_URI[aarch64_libvirt-client-qemu.sha256sum] = "00b4b097892afe9ec604d33bdebf47feaa2acba412fb88528485c3262e97ea00"

URI_aarch64_libvirt-daemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon}"
SRC_URI[aarch64_libvirt-daemon.sha256sum] = "f728a552d943452c7b3a0e8659fdc950f3e84389f6a93647b78e06df71125d6c"

URI_aarch64_libvirt-daemon-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-common-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-common}"
SRC_URI[aarch64_libvirt-daemon-common.sha256sum] = "2b3ba8d25ab1dd36e41bdfc52a57900bb6fd61e053f0a9becbaf0e2f383b7657"

URI_aarch64_libvirt-daemon-config-network = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-config-network-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-config-network;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-config-network}"
SRC_URI[aarch64_libvirt-daemon-config-network.sha256sum] = "68725e543281ed0502ac14c19fb926b8937ea7f354f1a6e6629f50dda240abfa"

URI_aarch64_libvirt-daemon-config-nwfilter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-config-nwfilter-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-config-nwfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-config-nwfilter}"
SRC_URI[aarch64_libvirt-daemon-config-nwfilter.sha256sum] = "892e4e20765f366a766376bd5b6dcf726ea77df35b917bfcd2532394cdb5962d"

URI_aarch64_libvirt-daemon-driver-interface = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-interface-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-interface;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-interface}"
SRC_URI[aarch64_libvirt-daemon-driver-interface.sha256sum] = "b52efb9c1da6d07922b46c46d88a7a56cc8f4daecb95b6ee33b1052870dc9e03"

URI_aarch64_libvirt-daemon-driver-network = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-network-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-network;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-network}"
SRC_URI[aarch64_libvirt-daemon-driver-network.sha256sum] = "41609f3754700d4a0924c131f83beebf00365687f49186df996692621ebc90c6"

URI_aarch64_libvirt-daemon-driver-nodedev = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-nodedev-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-nodedev;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-nodedev}"
SRC_URI[aarch64_libvirt-daemon-driver-nodedev.sha256sum] = "909f67036b10a9ad9aa7ca338c9d4e17d3028d577c1fc68e2b0698b9e8cabb87"

URI_aarch64_libvirt-daemon-driver-nwfilter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-nwfilter-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-nwfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-nwfilter}"
SRC_URI[aarch64_libvirt-daemon-driver-nwfilter.sha256sum] = "55b966be5713f475c80b83a4a1397ebdd23c818be8a11ef7e918abbfdbb406ea"

URI_aarch64_libvirt-daemon-driver-qemu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-qemu-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-qemu;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-qemu}"
SRC_URI[aarch64_libvirt-daemon-driver-qemu.sha256sum] = "2678ea186629d366de6bca9b61c573d26f1e817c1b7066692c2fe78d6038e197"

URI_aarch64_libvirt-daemon-driver-secret = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-secret-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-secret;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-secret}"
SRC_URI[aarch64_libvirt-daemon-driver-secret.sha256sum] = "88d6d14c4629044dc73ac1d488ef929495bab4fc797afc3025bd9784e35693ef"

URI_aarch64_libvirt-daemon-driver-storage = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage}"
SRC_URI[aarch64_libvirt-daemon-driver-storage.sha256sum] = "8203462c9a198afb1926f550fad112970caa0b520ab8f2443f572697d1ce0d04"

URI_aarch64_libvirt-daemon-driver-storage-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-core-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-core}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-core.sha256sum] = "1ac5654742048166ac14623e5db8c4afb52e3f9042a17774af1145a3bff21e44"

URI_aarch64_libvirt-daemon-driver-storage-disk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-disk-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-disk;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-disk}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-disk.sha256sum] = "be4e3f3c4a7991efebbd4526bd38c36a395c1b5778e2203f2165f529b86915c0"

URI_aarch64_libvirt-daemon-driver-storage-iscsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-iscsi-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-iscsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-iscsi}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-iscsi.sha256sum] = "5d8cb2756aaf5b166e75a5653b8af0b0ff7b8abe1f0f10779bfc29aa8bf5b577"

URI_aarch64_libvirt-daemon-driver-storage-logical = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-logical-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-logical;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-logical}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-logical.sha256sum] = "f6a5301b813e1bcfcb2d04de48478c026c22acbaffd37880af9eeb63676673b3"

URI_aarch64_libvirt-daemon-driver-storage-mpath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-mpath-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-mpath;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-mpath}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-mpath.sha256sum] = "8b4762807f2421ff4e9c9e4587a619ca3c95a10dae8f5cca532bd41ae62d702c"

URI_aarch64_libvirt-daemon-driver-storage-rbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-rbd-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-rbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-rbd}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-rbd.sha256sum] = "a1c1e2aab4cec99a551dc6c7c83c11fb708775d94b0d117dd1043342b0932991"

URI_aarch64_libvirt-daemon-driver-storage-scsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-scsi-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-scsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-scsi}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-scsi.sha256sum] = "619449c57a1bcf14565064a6cb9f0c6925121c5c18fc3fce1b00879a769899a5"

URI_aarch64_libvirt-daemon-kvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-kvm-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-kvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-kvm}"
SRC_URI[aarch64_libvirt-daemon-kvm.sha256sum] = "776ce8954b9ecd59d3e2c8bedd3dcd4951a1a97fea951010e2420b53288ae684"

URI_aarch64_libvirt-daemon-lock = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-lock-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-lock;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-lock}"
SRC_URI[aarch64_libvirt-daemon-lock.sha256sum] = "1cf2c1f258e8d590876c72ca9d0d3d3e02d014e5867bc1dbabc58b95905be1e0"

URI_aarch64_libvirt-daemon-log = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-log-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-log;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-log}"
SRC_URI[aarch64_libvirt-daemon-log.sha256sum] = "f81e77326e57f2bc93ad999b361ec66401d3f031cddf513f68a96b3810ca6ff0"

URI_aarch64_libvirt-daemon-plugin-lockd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-plugin-lockd-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-plugin-lockd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-plugin-lockd}"
SRC_URI[aarch64_libvirt-daemon-plugin-lockd.sha256sum] = "1b06727451c37ab33350329f45ad5a417ef69c15ca8fae954db7e7e4f92234e1"

URI_aarch64_libvirt-daemon-plugin-sanlock = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-daemon-plugin-sanlock-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-plugin-sanlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-plugin-sanlock}"
SRC_URI[aarch64_libvirt-daemon-plugin-sanlock.sha256sum] = "d432bab7bd9c683872ff2129e1d6cdce17edd6cac6ad91f3bc424dfb5d4d7857"

URI_aarch64_libvirt-daemon-proxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-proxy-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-proxy}"
SRC_URI[aarch64_libvirt-daemon-proxy.sha256sum] = "ef21628668b8738e9899c7e48a620ead5c61bf447568e0374495d2a792058b97"

URI_aarch64_libvirt-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-devel-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-devel}"
SRC_URI[aarch64_libvirt-devel.sha256sum] = "83f8a5a55feb2be4130dfd8b35798526cd72dcb0975442992360edd18b916396"

URI_aarch64_libvirt-docs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-docs-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-docs}"
SRC_URI[aarch64_libvirt-docs.sha256sum] = "e936a61cdd545cbfab7bf3e6e61be3465710878915580ec82b37fbd5bafa4521"

URI_aarch64_libvirt-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-libs-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-libs}"
SRC_URI[aarch64_libvirt-libs.sha256sum] = "9d7126d4932500ca02a621ae4582124166b5a417aebb78b315a0a70206dbe31e"

URI_aarch64_libvirt-nss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-nss-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-nss;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-nss}"
SRC_URI[aarch64_libvirt-nss.sha256sum] = "a261a9b696defec10fea33014d0f19c355193f588f8ceb7f8c543291894558bf"

URI_aarch64_libvirt-ssh-proxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-ssh-proxy-11.5.0-4.8.el10_1.alma.1.aarch64.rpm;name=aarch64_libvirt-ssh-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-ssh-proxy}"
SRC_URI[aarch64_libvirt-ssh-proxy.sha256sum] = "35e3d17cfb30bcb75963f5ec4f2c444a891a3b8b4cb53dcb064c79ff650cda94"

RDEPENDS:libvirt = " \
 libvirt-client \
 libvirt-client-qemu \
 libvirt-daemon \
 libvirt-daemon-config-network \
 libvirt-daemon-config-nwfilter \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-libs \
 "
RDEPENDS:libvirt-client = " \
 bash \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 libvirt-libs \
 libxml2 \
 readline \
 "
RDEPENDS:libvirt-client-qemu = " \
 libvirt-libs \
 python3 \
 python3-cryptography \
 python3-libvirt \
 python3-lxml \
 "
RDEPENDS:libvirt-daemon = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-proxy \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-common = " \
 bash \
 dbus \
 dmidecode \
 gettext \
 glib2 \
 glibc \
 iproute \
 iproute-tc \
 kmod \
 libacl \
 libgcc \
 libvirt-libs \
 polkit \
 readline \
 shadow-utils \
 systemd \
 "
RDEPENDS:libvirt-daemon-config-network = " \
 bash \
 libvirt-daemon-driver-network \
 "
RDEPENDS:libvirt-daemon-config-nwfilter = " \
 bash \
 libvirt-daemon-driver-nwfilter \
 "
RDEPENDS:libvirt-daemon-driver-interface = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 systemd-libs \
 "
RDEPENDS:libvirt-daemon-driver-network = " \
 bash \
 dnsmasq \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 nftables \
 "
RDEPENDS:libvirt-daemon-driver-nodedev = " \
 bash \
 glib2 \
 glibc \
 kmod \
 libgcc \
 libpciaccess \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 mdevctl \
 systemd \
 systemd-libs \
 "
RDEPENDS:libvirt-daemon-driver-nwfilter = " \
 bash \
 glib2 \
 glibc \
 iptables-nft \
 libgcc \
 libpcap \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-qemu = " \
 bash \
 bzip2 \
 glib2 \
 glibc \
 gnutls \
 gzip \
 libgcc \
 libnbd \
 libselinux \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-log \
 libvirt-libs \
 libxml2 \
 lzop \
 numad \
 qemu-img \
 swtpm-tools \
 systemd-container \
 xz \
 zstd \
 "
RDEPENDS:libvirt-daemon-driver-secret = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage = " \
 libvirt-daemon-driver-storage-core \
 libvirt-daemon-driver-storage-disk \
 libvirt-daemon-driver-storage-iscsi \
 libvirt-daemon-driver-storage-logical \
 libvirt-daemon-driver-storage-mpath \
 libvirt-daemon-driver-storage-rbd \
 libvirt-daemon-driver-storage-scsi \
 "
RDEPENDS:libvirt-daemon-driver-storage-core = " \
 bash \
 glib2 \
 glibc \
 libblkid \
 libgcc \
 libselinux \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 libxml2 \
 parted \
 qemu-img \
 scrub \
 util-linux \
 "
RDEPENDS:libvirt-daemon-driver-storage-disk = " \
 device-mapper \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 parted \
 "
RDEPENDS:libvirt-daemon-driver-storage-iscsi = " \
 glib2 \
 glibc \
 iscsi-initiator-utils \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-logical = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 lvm2 \
 "
RDEPENDS:libvirt-daemon-driver-storage-mpath = " \
 device-mapper \
 device-mapper-libs \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-rbd = " \
 glib2 \
 glibc \
 libgcc \
 librados2 \
 librbd1 \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-scsi = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-kvm = " \
 libvirt-daemon-common \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-proxy \
 libvirt-ssh-proxy \
 qemu-kvm \
 "
RDEPENDS:libvirt-daemon-lock = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-log = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-plugin-lockd = " \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-lock \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-plugin-sanlock = " \
 augeas \
 bash \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-common \
 libvirt-libs \
 sanlock \
 sanlock-lib \
 "
RDEPENDS:libvirt-daemon-proxy = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-devel = " \
 libvirt-devel \
 libvirt-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:libvirt-docs = " \
 "
RDEPENDS:libvirt-libs = " \
 audit-libs \
 cyrus-sasl-gssapi \
 cyrus-sasl-lib \
 glib2 \
 glibc \
 gnutls \
 json-c \
 libacl \
 libcap-ng \
 libgcc \
 libnl3 \
 libselinux \
 libssh \
 libtirpc \
 libxml2 \
 numactl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libvirt-nss = " \
 glibc \
 json-c \
 libgcc \
 libvirt-daemon-driver-network \
 "
RDEPENDS:libvirt-ssh-proxy = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-libs \
 libxml2 \
 "
