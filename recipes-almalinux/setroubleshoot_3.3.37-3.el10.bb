# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setroubleshoot"
PV = "3.3.37"
PR = "3.el10"
PACKAGES = " \
 setroubleshoot \
 setroubleshoot-server \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/setroubleshoot-3.3.37-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6439e7a6eb5af633ee9deedecc91208921df0fe6921d0c5fd77f3e031150d3d0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setroubleshoot-3.3.37-3.el10.x86_64_v2.rpm;name=x86_64_v2_setroubleshoot;unpack=0"
SRC_URI[x86_64_v2_setroubleshoot.sha256sum] = "2e2788e3d1a8ee7d3d31b0c1bba454e7e1f150f15da6188c475c223afb62254b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setroubleshoot-server-3.3.37-3.el10.x86_64_v2.rpm;name=x86_64_v2_setroubleshoot-server;unpack=0"
SRC_URI[x86_64_v2_setroubleshoot-server.sha256sum] = "f8330f238ad19200adb4f46ab1f9348e6947bc018d63325ea3fde9b8428778e8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setroubleshoot-3.3.37-3.el10.aarch64.rpm;name=aarch64_setroubleshoot;unpack=0"
SRC_URI[aarch64_setroubleshoot.sha256sum] = "cb0bb74481e7d2c8cb825bbad2ecc5bfdca48181dc80edb935ce1b670054813c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setroubleshoot-server-3.3.37-3.el10.aarch64.rpm;name=aarch64_setroubleshoot-server;unpack=0"
SRC_URI[aarch64_setroubleshoot-server.sha256sum] = "97470c797cdfe17928f60fd11de65f33a66eec22986c2b32d31f19b65292d228"

RDEPENDS:setroubleshoot = " \
 dbus \
 desktop-file-utils \
 gtk3 \
 libnotify \
 python3 \
 python3-dasbus \
 python3-gobject \
 setroubleshoot-server \
 xdg-utils \
 "
RDEPENDS:setroubleshoot-server = " \
 audit \
 audit-libs \
 bash \
 dbus \
 dbus-libs \
 glibc \
 libcap-ng \
 libselinux \
 policycoreutils-python-utils \
 polkit \
 python3 \
 python3-audit \
 python3-dasbus \
 python3-dbus \
 python3-gobject-base \
 python3-libselinux \
 python3-rpm \
 python3-systemd \
 setroubleshoot-plugins \
 "
