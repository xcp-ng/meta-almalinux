# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyahocorasick"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 python-pyahocorasick-doc \
 python3-pyahocorasick \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyahocorasick-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebbb9b9537a70f35485a432866f1e3282641ca773123a1b45d23256eff809ed2"

URI_x86_64_v2_python-pyahocorasick-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pyahocorasick-doc-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-pyahocorasick-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pyahocorasick-doc}"
SRC_URI[x86_64_v2_python-pyahocorasick-doc.sha256sum] = "b1ad598c975386e13409ab29e8cea4b0b5c979ae0a53e5f9bd85ce9835058deb"

URI_x86_64_v2_python3-pyahocorasick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyahocorasick-2.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyahocorasick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyahocorasick}"
SRC_URI[x86_64_v2_python3-pyahocorasick.sha256sum] = "db10baf3a1dfb7099605c92423fabb90aca24026bc5a0dbb644986252500bbdf"

URI_aarch64_python-pyahocorasick-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-pyahocorasick-doc-2.2.0-1.el10_2.noarch.rpm;name=aarch64_python-pyahocorasick-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pyahocorasick-doc}"
SRC_URI[aarch64_python-pyahocorasick-doc.sha256sum] = "4d5ae6f40e6b716b31b405fa04a7cd5340695e3a410ec598f5216fa9ca06a912"

URI_aarch64_python3-pyahocorasick = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyahocorasick-2.2.0-1.el10_2.aarch64.rpm;name=aarch64_python3-pyahocorasick;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyahocorasick}"
SRC_URI[aarch64_python3-pyahocorasick.sha256sum] = "a47ceb7affa266e3742bc0d397cc4b8052ae8ceec95419ed874c7edce1942051"

RDEPENDS:python-pyahocorasick-doc = " \
 python3-pyahocorasick \
 "
RDEPENDS:python3-pyahocorasick = " \
 glibc \
 python3 \
 "
