# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-copilot-core"
PV = "3.19.1"
PR = "3.el10_0"
PACKAGES = " \
 ghc-copilot-core \
 ghc-copilot-core-devel \
 ghc-copilot-core-doc \
 ghc-copilot-core-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-copilot-core-3.19.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0713ab06b7438404bd3ef4e3110df2cd5386705f1589b9781c21c90c0b5fb2e"

URI_x86_64_v2_ghc-copilot-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-core-3.19.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-core}"
SRC_URI[x86_64_v2_ghc-copilot-core.sha256sum] = "0c9135b244365d6e64b30a881892817392832f5ee1912765311607b5d419d1e0"

URI_x86_64_v2_ghc-copilot-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-core-devel-3.19.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-core-devel}"
SRC_URI[x86_64_v2_ghc-copilot-core-devel.sha256sum] = "8c7f7e1110237b7f6b8855e9cab20863531c1444bb92f9a9a192af8ed4c08a78"

URI_x86_64_v2_ghc-copilot-core-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-core-doc-3.19.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-copilot-core-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-core-doc}"
SRC_URI[x86_64_v2_ghc-copilot-core-doc.sha256sum] = "191f6f3af68a4482e8a5eba448165832cd0b573a6d7314e837db4f702d6c44d0"

URI_x86_64_v2_ghc-copilot-core-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-core-prof-3.19.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-core-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-core-prof}"
SRC_URI[x86_64_v2_ghc-copilot-core-prof.sha256sum] = "50e73acb4f62fcde3d0b9a610238faf3c4f619ce1a5a5c9454cfc277b00e70a5"

URI_aarch64_ghc-copilot-core = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-core-3.19.1-3.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-core}"
SRC_URI[aarch64_ghc-copilot-core.sha256sum] = "394f429dbf3aed412a21fc9314bc2e30473c40876f589a3aa185fee1917ef558"

URI_aarch64_ghc-copilot-core-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-core-devel-3.19.1-3.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-core-devel}"
SRC_URI[aarch64_ghc-copilot-core-devel.sha256sum] = "340eef2a727605dbdd0a3b993f8967f69663cc52d729b0f147680cdd7337c354"

URI_aarch64_ghc-copilot-core-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-core-doc-3.19.1-3.el10_0.noarch.rpm;name=aarch64_ghc-copilot-core-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-core-doc}"
SRC_URI[aarch64_ghc-copilot-core-doc.sha256sum] = "aa2666efa5b0f97ff7cbae68e73d187d065bfba5eb5c6107d8a14454420b1b97"

URI_aarch64_ghc-copilot-core-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-core-prof-3.19.1-3.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-core-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-core-prof}"
SRC_URI[aarch64_ghc-copilot-core-prof.sha256sum] = "9a16849c2ffd354817ec67073f5d089754d11be5f53fbbd010661231976050cc"

RDEPENDS:ghc-copilot-core = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-copilot-core-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-copilot-core \
 "
RDEPENDS:ghc-copilot-core-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-copilot-core-prof = " \
 ghc-base-prof \
 ghc-copilot-core-devel \
 "
