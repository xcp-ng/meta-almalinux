# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "simcrs"
PV = "1.01.11"
PR = "1.el10_2"
PACKAGES = " \
 simcrs \
 simcrs-devel \
 simcrs-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/simcrs-1.01.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "358185c2876724804f91b839b08c99bd3323a4bc743478fb06ccc58d7bb44a49"

URI_x86_64_v2_simcrs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simcrs-1.01.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_simcrs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_simcrs}"
SRC_URI[x86_64_v2_simcrs.sha256sum] = "b6dc92f6f9e56b4bf6754f3e1b05996178a3dab9cd5423f909c64367e781096d"

URI_x86_64_v2_simcrs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simcrs-devel-1.01.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_simcrs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_simcrs-devel}"
SRC_URI[x86_64_v2_simcrs-devel.sha256sum] = "66986a1f59d833bddb3ae2cf98be23b45b541a682a740ec71aac3170fe4613cc"

URI_x86_64_v2_simcrs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simcrs-doc-1.01.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_simcrs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_simcrs-doc}"
SRC_URI[x86_64_v2_simcrs-doc.sha256sum] = "3a1252c322b7503b08994690c245eaad05567493aa47cf8ae6b0a3850a75ced0"

URI_aarch64_simcrs = "${EPEL_MIRROR}/aarch64/Packages/s/simcrs-1.01.11-1.el10_2.aarch64.rpm;name=aarch64_simcrs;unpack=0"
SRC_URI:append = " ${URI_aarch64_simcrs}"
SRC_URI[aarch64_simcrs.sha256sum] = "8fb6776112d329ef04e60f730ae908ecc0cf8ebf1369116e0b70f040076646fd"

URI_aarch64_simcrs-devel = "${EPEL_MIRROR}/aarch64/Packages/s/simcrs-devel-1.01.11-1.el10_2.aarch64.rpm;name=aarch64_simcrs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_simcrs-devel}"
SRC_URI[aarch64_simcrs-devel.sha256sum] = "0b045331f0f5059ebcbddcf35028119d994110ea3fda1817c68985eaf09ff95f"

URI_aarch64_simcrs-doc = "${EPEL_MIRROR}/aarch64/Packages/s/simcrs-doc-1.01.11-1.el10_2.noarch.rpm;name=aarch64_simcrs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_simcrs-doc}"
SRC_URI[aarch64_simcrs-doc.sha256sum] = "8c18e450808785b6755ded04f1f0a7ec582a56d45ad40b6f3c8743bd3246b54d"

RDEPENDS:simcrs = " \
 airinv \
 airtsp \
 boost-program-options \
 glibc \
 libgcc \
 libstdc++ \
 simfqt \
 stdair \
 "
RDEPENDS:simcrs-devel = " \
 bash \
 cmake-filesystem \
 pkgconf-pkg-config \
 simcrs \
 "
RDEPENDS:simcrs-doc = " \
 "
