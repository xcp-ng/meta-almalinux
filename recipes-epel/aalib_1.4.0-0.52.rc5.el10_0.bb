# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aalib"
PV = "1.4.0"
PR = "0.52.rc5.el10_0"
PACKAGES = " \
 aalib \
 aalib-devel \
 aalib-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aalib-1.4.0-0.52.rc5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c47bbe4046bef624d76f655e153cfbbdd04f9da3d96e44387cce0e9fcec830d7"

URI_x86_64_v2_aalib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aalib-1.4.0-0.52.rc5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aalib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aalib}"
SRC_URI[x86_64_v2_aalib.sha256sum] = "876708715c77ac6c776da786df3e0035bb1641e4fb1df20cd0fa0121ee3b1e13"

URI_x86_64_v2_aalib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aalib-devel-1.4.0-0.52.rc5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aalib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aalib-devel}"
SRC_URI[x86_64_v2_aalib-devel.sha256sum] = "79c5868aec1b6c7084f49f4f25807611b2f94ba3701b7f7a3f6afab9afa58db8"

URI_x86_64_v2_aalib-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aalib-libs-1.4.0-0.52.rc5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aalib-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aalib-libs}"
SRC_URI[x86_64_v2_aalib-libs.sha256sum] = "74bd09ee82e0abde4834e1024c6b6c372fb0b3fba2cb38ef5e25d1becf8e555d"

URI_aarch64_aalib = "${EPEL_MIRROR}/aarch64/Packages/a/aalib-1.4.0-0.52.rc5.el10_0.aarch64.rpm;name=aarch64_aalib;unpack=0"
SRC_URI:append = " ${URI_aarch64_aalib}"
SRC_URI[aarch64_aalib.sha256sum] = "c9c717e9f1a47f97baba62ae70dc4d2074708e1bb08dce62070b1d0c45186bc7"

URI_aarch64_aalib-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aalib-devel-1.4.0-0.52.rc5.el10_0.aarch64.rpm;name=aarch64_aalib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aalib-devel}"
SRC_URI[aarch64_aalib-devel.sha256sum] = "9b0cc6df2747e772152401b6f33dad77172d3682380954520a9eb0f93313029b"

URI_aarch64_aalib-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aalib-libs-1.4.0-0.52.rc5.el10_0.aarch64.rpm;name=aarch64_aalib-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aalib-libs}"
SRC_URI[aarch64_aalib-libs.sha256sum] = "63952919bfd4af6f670230bb5d98202506dd5339103cdcb13b23b15fb0d1ebd6"

RDEPENDS:aalib = " \
 aalib-libs \
 glibc \
 "
RDEPENDS:aalib-devel = " \
 aalib-libs \
 bash \
 "
RDEPENDS:aalib-libs = " \
 glibc \
 libX11 \
 ncurses-libs \
 slang \
 "
