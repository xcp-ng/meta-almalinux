# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bitstream-io2"
PV = "2.6.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-bitstream-io2+alloc-devel \
 rust-bitstream-io2+core2-devel \
 rust-bitstream-io2+default-devel \
 rust-bitstream-io2+std-devel \
 rust-bitstream-io2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bitstream-io2-2.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e461e1912e21cb7cc52cfd0c0881c002b97a4cea066b6af44339fc0f909451ab"

URI_x86_64_v2_rust-bitstream-io2+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io2+alloc-devel-2.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io2+alloc-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io2+alloc-devel.sha256sum] = "d602627c257e4106d3448721d47c99a2696c1351bcb0c859a43c8cc0b20d27f6"

URI_x86_64_v2_rust-bitstream-io2+core2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io2+core2-devel-2.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io2+core2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io2+core2-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io2+core2-devel.sha256sum] = "f64681874e7ad70de3f49c4f91e96e8489300706baa336ec83acef69a55c4491"

URI_x86_64_v2_rust-bitstream-io2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io2+default-devel-2.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io2+default-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io2+default-devel.sha256sum] = "550a37b6f7b60fc371cbb4070d69660694ccdafb672bd76ecf376d5c2934f05d"

URI_x86_64_v2_rust-bitstream-io2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io2+std-devel-2.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io2+std-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io2+std-devel.sha256sum] = "7bcc65d74bcaa3bc27752786c72b489e38183533a32cc7c337bdf699188d18d1"

URI_x86_64_v2_rust-bitstream-io2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io2-devel-2.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io2-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io2-devel.sha256sum] = "14807884948da81b38893302fd27b5cfd42286e1b5708b7fb3d05f91316f2140"

URI_aarch64_rust-bitstream-io2+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io2+alloc-devel-2.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitstream-io2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io2+alloc-devel}"
SRC_URI[aarch64_rust-bitstream-io2+alloc-devel.sha256sum] = "5ec9ec090e0e8155e2e6a0180915529b6b66afaf80157e43100330dace0d3873"

URI_aarch64_rust-bitstream-io2+core2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io2+core2-devel-2.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitstream-io2+core2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io2+core2-devel}"
SRC_URI[aarch64_rust-bitstream-io2+core2-devel.sha256sum] = "5a66fcf4111ac9dcda8fe2091f3adcadcfc14e70af725c5894ecaf8d7b064975"

URI_aarch64_rust-bitstream-io2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io2+default-devel-2.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitstream-io2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io2+default-devel}"
SRC_URI[aarch64_rust-bitstream-io2+default-devel.sha256sum] = "82656772d4a0f36e6d494d31e6126da847605e2fdb16560231d69134f34c41fa"

URI_aarch64_rust-bitstream-io2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io2+std-devel-2.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitstream-io2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io2+std-devel}"
SRC_URI[aarch64_rust-bitstream-io2+std-devel.sha256sum] = "4d2f5ed896e1b6e5f118e580c3de97767d3d9beffe6ced57ed5280298350da9b"

URI_aarch64_rust-bitstream-io2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io2-devel-2.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitstream-io2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io2-devel}"
SRC_URI[aarch64_rust-bitstream-io2-devel.sha256sum] = "024c8789d44ca2b5476719d03662ad36694699d67f86294a4134d68da907f581"

RDEPENDS:rust-bitstream-io2+alloc-devel = " \
 cargo \
 rust-bitstream-io2+core2-devel \
 rust-bitstream-io2-devel \
 "
RDEPENDS:rust-bitstream-io2+core2-devel = " \
 cargo \
 rust-bitstream-io2-devel \
 rust-core2+alloc-devel \
 rust-core2-devel \
 "
RDEPENDS:rust-bitstream-io2+default-devel = " \
 cargo \
 rust-bitstream-io2+std-devel \
 rust-bitstream-io2-devel \
 "
RDEPENDS:rust-bitstream-io2+std-devel = " \
 cargo \
 rust-bitstream-io2-devel \
 "
RDEPENDS:rust-bitstream-io2-devel = " \
 cargo \
 rust \
 "
