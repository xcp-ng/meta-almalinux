# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-compilersupport"
PV = "22"
PR = "12.rocm7.2.1.el10_3"
PACKAGES:x86_64_v2 = " \
 hipcc \
 rocm-clang \
 rocm-clang-analyzer \
 rocm-clang-devel \
 rocm-clang-libs \
 rocm-clang-runtime-devel \
 rocm-clang-tools-extra \
 rocm-clang-tools-extra-devel \
 rocm-comgr \
 rocm-comgr-devel \
 rocm-compilersupport-macros \
 rocm-device-libs \
 rocm-lld \
 rocm-llvm \
 rocm-llvm-devel \
 rocm-llvm-filesystem \
 rocm-llvm-libs \
 rocm-llvm-static \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-compilersupport-22-12.rocm7.2.1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bd993c3fdf124817a5a42a95f30d2537e2090387b8b43a3eeced98fafc1707d"

URI_x86_64_v2_hipcc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipcc-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipcc}"
SRC_URI[x86_64_v2_hipcc.sha256sum] = "5c9764d469ca11adb725af59c5910c7e022e37ded8894595317a637f685778a9"

URI_x86_64_v2_rocm-clang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang}"
SRC_URI[x86_64_v2_rocm-clang.sha256sum] = "7f3d227c749b7a3b7a1ce69ab3bdf7dd675a5334ed2b730f6814e919a215c0d0"

URI_x86_64_v2_rocm-clang-analyzer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-analyzer-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-analyzer}"
SRC_URI[x86_64_v2_rocm-clang-analyzer.sha256sum] = "ca7ef5bfa3245517d3d91c92368eb5f38d46bb88ac95c12e6686438b27d6beac"

URI_x86_64_v2_rocm-clang-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-devel-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-devel}"
SRC_URI[x86_64_v2_rocm-clang-devel.sha256sum] = "01c4807f218d8bf874c8236e25b7ae4c2d8ef7ae8546a03ad22ba088cd954b59"

URI_x86_64_v2_rocm-clang-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-libs-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-libs}"
SRC_URI[x86_64_v2_rocm-clang-libs.sha256sum] = "ad95c81444af219c7ef1e5b717175456c662cde5cd02a74ef12d55cc78ae086e"

URI_x86_64_v2_rocm-clang-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-runtime-devel-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-runtime-devel}"
SRC_URI[x86_64_v2_rocm-clang-runtime-devel.sha256sum] = "004f77fc8fb01f1c8c57ba47334594b762c1b66a0532c755215df437155523a3"

URI_x86_64_v2_rocm-clang-tools-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-tools-extra-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-tools-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-tools-extra}"
SRC_URI[x86_64_v2_rocm-clang-tools-extra.sha256sum] = "b626fe7409960f38272bf64b9c56a4d8958c8653713c9c221d4942f8cc88a329"

URI_x86_64_v2_rocm-clang-tools-extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-tools-extra-devel-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-tools-extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-tools-extra-devel}"
SRC_URI[x86_64_v2_rocm-clang-tools-extra-devel.sha256sum] = "6a8bd48fe79483a8153ef7da8a120ff7f50b1a410fff99e4b48b63ab58bd787b"

URI_x86_64_v2_rocm-comgr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-comgr-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-comgr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-comgr}"
SRC_URI[x86_64_v2_rocm-comgr.sha256sum] = "08095d99e8fd10264e7559e7161ee758b16d031a63cc14f4c811294d32435e2a"

URI_x86_64_v2_rocm-comgr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-comgr-devel-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-comgr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-comgr-devel}"
SRC_URI[x86_64_v2_rocm-comgr-devel.sha256sum] = "cda8355ca003a68a58872ac8d2e83d2399e052dd88a7a40ade922be139296f4c"

URI_x86_64_v2_rocm-compilersupport-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-compilersupport-macros-22-12.rocm7.2.1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rocm-compilersupport-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-compilersupport-macros}"
SRC_URI[x86_64_v2_rocm-compilersupport-macros.sha256sum] = "ad66a09e1c88357bf59f98d4d7823ca66cc1edbb7a2fad1bf798bfd4ecdf806d"

URI_x86_64_v2_rocm-device-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-device-libs-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-device-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-device-libs}"
SRC_URI[x86_64_v2_rocm-device-libs.sha256sum] = "5e0061677f912942cc59a006d3463fe7588c3c00f190950da602f93c184cc898"

URI_x86_64_v2_rocm-lld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-lld-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-lld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-lld}"
SRC_URI[x86_64_v2_rocm-lld.sha256sum] = "24d54da1d31a3da798a518e71fcaf59eff9ef24d604e524fbc23e6c41a948f46"

URI_x86_64_v2_rocm-llvm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-llvm-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-llvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-llvm}"
SRC_URI[x86_64_v2_rocm-llvm.sha256sum] = "4ac3a3fea516d62d2b1970cccd4c7f26b1672bc542fc79246d449e6a29d70136"

URI_x86_64_v2_rocm-llvm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-llvm-devel-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-llvm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-llvm-devel}"
SRC_URI[x86_64_v2_rocm-llvm-devel.sha256sum] = "b84436bfe5415e7e38d9334c35a3c1a74d9e71eba5bce2964040bc27cb2b17c9"

URI_x86_64_v2_rocm-llvm-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-llvm-filesystem-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-llvm-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-llvm-filesystem}"
SRC_URI[x86_64_v2_rocm-llvm-filesystem.sha256sum] = "8555bba13a3bd70a73cad19014779431c6f3f8a28cc9751542702540ee67af0f"

URI_x86_64_v2_rocm-llvm-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-llvm-libs-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-llvm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-llvm-libs}"
SRC_URI[x86_64_v2_rocm-llvm-libs.sha256sum] = "0a5ec8d1c7030c7c0da96ef455d9f94f85067aff316c23f24c5cf00b628e6f93"

URI_x86_64_v2_rocm-llvm-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-llvm-static-22-12.rocm7.2.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-llvm-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-llvm-static}"
SRC_URI[x86_64_v2_rocm-llvm-static.sha256sum] = "36c8bf3ff6c98058eb2aa6f4c3c4715253b7fc3cde38082fea20d9fff524b101"

RDEPENDS:hipcc = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-device-libs \
 rocm-filesystem \
 rocminfo \
 "
RDEPENDS:rocm-clang = " \
 git \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 rocm-clang-libs \
 rocm-clang-runtime-devel \
 rocm-llvm-filesystem \
 rocm-llvm-libs \
 "
RDEPENDS:rocm-clang-analyzer = " \
 perl-File-Copy \
 perl-File-Find \
 perl-FindBin \
 perl-Hash-Util \
 perl-Sys-Hostname \
 perl-interpreter \
 python3 \
 rocm-clang \
 rocm-llvm-filesystem \
 "
RDEPENDS:rocm-clang-devel = " \
 rocm-clang \
 rocm-clang-libs \
 rocm-llvm-filesystem \
 "
RDEPENDS:rocm-clang-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-filesystem \
 rocm-llvm-filesystem \
 rocm-llvm-libs \
 "
RDEPENDS:rocm-clang-runtime-devel = " \
 rocm-llvm-filesystem \
 "
RDEPENDS:rocm-clang-tools-extra = " \
 python3 \
 rocm-clang-libs \
 rocm-llvm-filesystem \
 "
RDEPENDS:rocm-clang-tools-extra-devel = " \
 rocm-clang-tools-extra \
 rocm-llvm-filesystem \
 "
RDEPENDS:rocm-comgr = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 rocm-filesystem \
 zlib-ng-compat \
 "
RDEPENDS:rocm-comgr-devel = " \
 cmake-filesystem \
 rocm-comgr \
 rocm-device-libs \
 "
RDEPENDS:rocm-compilersupport-macros = " \
 rpm \
 "
RDEPENDS:rocm-device-libs = " \
 cmake-filesystem \
 rocm-clang-devel \
 rocm-lld \
 rocm-llvm-filesystem \
 rocm-llvm-static \
 "
RDEPENDS:rocm-lld = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 rocm-llvm-filesystem \
 rocm-llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:rocm-llvm = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 rocm-filesystem \
 rocm-llvm-filesystem \
 rocm-llvm-libs \
 "
RDEPENDS:rocm-llvm-devel = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-filesystem \
 rocm-llvm \
 rocm-llvm-filesystem \
 rocm-llvm-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:rocm-llvm-filesystem = " \
 rocm-filesystem \
 "
RDEPENDS:rocm-llvm-libs = " \
 glibc \
 libffi \
 libgcc \
 libstdc++ \
 libzstd \
 rocm-llvm-filesystem \
 zlib-ng-compat \
 "
RDEPENDS:rocm-llvm-static = " \
 rocm-llvm-devel \
 rocm-llvm-filesystem \
 "
