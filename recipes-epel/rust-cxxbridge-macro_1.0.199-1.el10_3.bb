# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxxbridge-macro"
PV = "1.0.199"
PR = "1.el10_3"
PACKAGES = " \
 rust-cxxbridge-macro+default-devel \
 rust-cxxbridge-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxxbridge-macro-1.0.199-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "588c3ea7022f6e3fea50ae668846a74f1755976721c21c9bcb8c2d143591cc7b"

URI_x86_64_v2_rust-cxxbridge-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+default-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro+default-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+default-devel.sha256sum] = "49c04cb339dd0bfb4938ac75cd27042c2986f4738331cd39f13224020701d178"

URI_x86_64_v2_rust-cxxbridge-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro-devel.sha256sum] = "5dab6af17d8f9306fea9f97bb1545b5a3e1b3365a15c91ade3db09eec8e2f825"

URI_aarch64_rust-cxxbridge-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+default-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxxbridge-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro+default-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro+default-devel.sha256sum] = "ded7ffe2d85f2cbe88ae27b58e69f8f4551ecbca5f27fd166dd3f67c60c7043a"

URI_aarch64_rust-cxxbridge-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxxbridge-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro-devel.sha256sum] = "1681cf55836f6984379e0e2685b22892f8113365201b174ec88238af9fafcf25"

RDEPENDS:rust-cxxbridge-macro+default-devel = " \
 cargo \
 rust-cxxbridge-macro-devel \
 "
RDEPENDS:rust-cxxbridge-macro-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
