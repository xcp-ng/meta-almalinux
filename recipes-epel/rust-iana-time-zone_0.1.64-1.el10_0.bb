# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-iana-time-zone"
PV = "0.1.64"
PR = "1.el10_0"
PACKAGES = " \
 rust-iana-time-zone+default-devel \
 rust-iana-time-zone+fallback-devel \
 rust-iana-time-zone-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-iana-time-zone-0.1.64-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43740256546b9911abd6ce6264b8047e9deab5ac15c28eb33e4048542f66283c"

URI_x86_64_v2_rust-iana-time-zone+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iana-time-zone+default-devel-0.1.64-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iana-time-zone+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iana-time-zone+default-devel}"
SRC_URI[x86_64_v2_rust-iana-time-zone+default-devel.sha256sum] = "cc8752a4177dc649e4606a93f7407be2fee1d1199cd23fc0e5fb35769f475898"

URI_x86_64_v2_rust-iana-time-zone+fallback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iana-time-zone+fallback-devel-0.1.64-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iana-time-zone+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iana-time-zone+fallback-devel}"
SRC_URI[x86_64_v2_rust-iana-time-zone+fallback-devel.sha256sum] = "959765c7f2cd44ac9f17dbdc116b2ec2ee900b7dc87bc0f58f184990293f4979"

URI_x86_64_v2_rust-iana-time-zone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iana-time-zone-devel-0.1.64-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iana-time-zone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iana-time-zone-devel}"
SRC_URI[x86_64_v2_rust-iana-time-zone-devel.sha256sum] = "ed111ac00a66fda6cd2d94586c986453301ff328335c239e60cbdd03085f20a7"

URI_aarch64_rust-iana-time-zone+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iana-time-zone+default-devel-0.1.64-1.el10_0.noarch.rpm;name=aarch64_rust-iana-time-zone+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iana-time-zone+default-devel}"
SRC_URI[aarch64_rust-iana-time-zone+default-devel.sha256sum] = "19cbfcb9e2a88bca331c5f72665f105b3adaf2dfcac73013bf82afb223fd16df"

URI_aarch64_rust-iana-time-zone+fallback-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iana-time-zone+fallback-devel-0.1.64-1.el10_0.noarch.rpm;name=aarch64_rust-iana-time-zone+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iana-time-zone+fallback-devel}"
SRC_URI[aarch64_rust-iana-time-zone+fallback-devel.sha256sum] = "6af31e761be1891869599bd8a8b1aae309ce89bb7f85323188c89d5ed139cad8"

URI_aarch64_rust-iana-time-zone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iana-time-zone-devel-0.1.64-1.el10_0.noarch.rpm;name=aarch64_rust-iana-time-zone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iana-time-zone-devel}"
SRC_URI[aarch64_rust-iana-time-zone-devel.sha256sum] = "97a4f841200ef905b10974ed6a44e8c9e14709d6c823ab5144da616bafecf995"

RDEPENDS:rust-iana-time-zone+default-devel = " \
 cargo \
 rust-iana-time-zone-devel \
 "
RDEPENDS:rust-iana-time-zone+fallback-devel = " \
 cargo \
 rust-iana-time-zone-devel \
 "
RDEPENDS:rust-iana-time-zone-devel = " \
 cargo \
 rust \
 "
