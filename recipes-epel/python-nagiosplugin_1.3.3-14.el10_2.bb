# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nagiosplugin"
PV = "1.3.3"
PR = "14.el10_2"
PACKAGES = " \
 python3-nagiosplugin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-nagiosplugin-1.3.3-14.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9719e1aca26a372838489cb778beb7ce98298c4d53af88407a58ef5bee93a439"

URI_x86_64_v2_python3-nagiosplugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nagiosplugin-1.3.3-14.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-nagiosplugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nagiosplugin}"
SRC_URI[x86_64_v2_python3-nagiosplugin.sha256sum] = "3effd47fadeac7c26f5006f8ad77f10c4cfbe5bd059f90eb4e67c331e92e0534"

URI_aarch64_python3-nagiosplugin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nagiosplugin-1.3.3-14.el10_2.noarch.rpm;name=aarch64_python3-nagiosplugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nagiosplugin}"
SRC_URI[aarch64_python3-nagiosplugin.sha256sum] = "8dc9062fe68b5b8c688906e14417ca779ee9fcb19cb57613a192fc993a839770"

RDEPENDS:python3-nagiosplugin = " \
 python3 \
 "
