# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdb"
PV = "17.2"
PR = "4.el10"
PACKAGES = " \
 gdb \
 gdb-doc \
 gdb-gdbserver \
 gdb-headless \
 gdb-minimal \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdb-17.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b41439fbf8be0cf79622d628951e9601c891d63399e63fdb3b350b2dc6941a21"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-17.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_gdb;unpack=0"
SRC_URI[x86_64_v2_gdb.sha256sum] = "ae341e088dce1ee9500d387e63a7fcc8f394898e4932419d46aae1c8202b9768"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-doc-17.2-4.el10.noarch.rpm;name=x86_64_v2_gdb-doc;unpack=0"
SRC_URI[x86_64_v2_gdb-doc.sha256sum] = "1f06495ddcd0526c19e8220ce16c98e0e5c71b34355ec64ca0ce371f4fc4d39b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-gdbserver-17.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_gdb-gdbserver;unpack=0"
SRC_URI[x86_64_v2_gdb-gdbserver.sha256sum] = "ce87eac4ecadc8718394865b66ac1130c675be27070c18d16c1f79385f5d9449"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-headless-17.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_gdb-headless;unpack=0"
SRC_URI[x86_64_v2_gdb-headless.sha256sum] = "d8ca930e3471847ba682d896e3cf5d11178db9986455d2067be971f30fbfb50f"
RPROVIDES:gdb-headless:append:x86_64_v2 = " virtual//usr/bin/gdb-add-index"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-minimal-17.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_gdb-minimal;unpack=0"
SRC_URI[x86_64_v2_gdb-minimal.sha256sum] = "711f68002c5deba9138d4dfba6287d381c65cfae2c3a9d1e6a51a21cf46c6a6a"
RPROVIDES:gdb-minimal:append:x86_64_v2 = " virtual//usr/bin/gdb-add-index"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-17.2-4.el10.aarch64.rpm;name=aarch64_gdb;unpack=0"
SRC_URI[aarch64_gdb.sha256sum] = "d21ef40655106878e4cbe62606b09203eda08b31ed9e4ffc0f6f720e58e57f4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-doc-17.2-4.el10.noarch.rpm;name=aarch64_gdb-doc;unpack=0"
SRC_URI[aarch64_gdb-doc.sha256sum] = "1f06495ddcd0526c19e8220ce16c98e0e5c71b34355ec64ca0ce371f4fc4d39b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-gdbserver-17.2-4.el10.aarch64.rpm;name=aarch64_gdb-gdbserver;unpack=0"
SRC_URI[aarch64_gdb-gdbserver.sha256sum] = "d768857749ab1e8bdef3c907db3897ef7f60ebc54358aceba2a9d1a3ed551540"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-headless-17.2-4.el10.aarch64.rpm;name=aarch64_gdb-headless;unpack=0"
SRC_URI[aarch64_gdb-headless.sha256sum] = "18cc52019ea23e49172d79f83f5ca0e16672ddad2283a333fadb3953cd46d830"
RPROVIDES:gdb-headless:append:aarch64 = " virtual//usr/bin/gdb-add-index"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-minimal-17.2-4.el10.aarch64.rpm;name=aarch64_gdb-minimal;unpack=0"
SRC_URI[aarch64_gdb-minimal.sha256sum] = "33cf420ae311e43f76f2c703b036b93469dffa9fcc2ab3634f70a157f4770e60"
RPROVIDES:gdb-minimal:append:aarch64 = " virtual//usr/bin/gdb-add-index"

RDEPENDS:gdb = " \
 bash \
 gdb-headless \
 "
RDEPENDS:gdb-doc = " \
 "
RDEPENDS:gdb-gdbserver = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gdb-headless:x86_64_v2 = " \
 bash \
 binutils \
 elfutils-debuginfod-client \
 expat \
 glibc \
 gmp \
 libbabeltrace \
 libgcc \
 libipt \
 libstdc++ \
 mpfr \
 ncurses-libs \
 python3-libs \
 readline \
 source-highlight \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:gdb-headless:aarch64 = " \
 bash \
 binutils \
 elfutils-debuginfod-client \
 expat \
 glibc \
 gmp \
 libbabeltrace \
 libgcc \
 libstdc++ \
 mpfr \
 ncurses-libs \
 python3-libs \
 readline \
 source-highlight \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:gdb-minimal = " \
 bash \
 elfutils-debuginfod-client \
 glibc \
 gmp \
 libgcc \
 libstdc++ \
 mpfr \
 ncurses-libs \
 readline \
 xz-libs \
 zlib-ng-compat \
 "
