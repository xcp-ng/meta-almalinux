# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snapper"
PV = "0.13.0"
PR = "3.el10_3"
PACKAGES = " \
 pam_snapper \
 snapper \
 snapper-backup \
 snapper-devel \
 snapper-libs \
 snapper-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/snapper-0.13.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cac00903ffd4e32b1944cf534e9c88942dab800822ca264cb0b7ec4f0026ed32"

URI_x86_64_v2_pam_snapper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_snapper-0.13.0-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_snapper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_snapper}"
SRC_URI[x86_64_v2_pam_snapper.sha256sum] = "b1f0f9d816669a1180e79c07327c65b56fc5a86706b62ae6d52f23ecc200c0f4"

URI_x86_64_v2_snapper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapper-0.13.0-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapper}"
SRC_URI[x86_64_v2_snapper.sha256sum] = "a2c790eb2c122077bcf1c0662db87b878a46d92eac57db195af844e29cf30b4a"

URI_x86_64_v2_snapper-backup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapper-backup-0.13.0-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapper-backup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapper-backup}"
SRC_URI[x86_64_v2_snapper-backup.sha256sum] = "911593ab474078a8a5bc80f5474ae9eac2ec2a8d034f4e054255807648aae62c"

URI_x86_64_v2_snapper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapper-devel-0.13.0-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapper-devel}"
SRC_URI[x86_64_v2_snapper-devel.sha256sum] = "834922a23d715c1a177c0ed37a182cefb61340d412673e985d76d23ad25a820f"

URI_x86_64_v2_snapper-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapper-libs-0.13.0-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapper-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapper-libs}"
SRC_URI[x86_64_v2_snapper-libs.sha256sum] = "f3000576045abbc4af01f261c357baba042f3a6379a6f836e8090025156a12c8"

URI_x86_64_v2_snapper-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapper-tests-0.13.0-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapper-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapper-tests}"
SRC_URI[x86_64_v2_snapper-tests.sha256sum] = "902fc83a20df5a92f84e47559f76bbd7e5b78c65cf843024b8a27f2c5265a6be"

URI_aarch64_pam_snapper = "${EPEL_MIRROR}/aarch64/Packages/p/pam_snapper-0.13.0-3.el10_3.aarch64.rpm;name=aarch64_pam_snapper;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_snapper}"
SRC_URI[aarch64_pam_snapper.sha256sum] = "88aa71cbb1cd8a5b8e45300ca0b11b201ae1f1d9e8d9ddeb3a6484c394fe33e1"

URI_aarch64_snapper = "${EPEL_MIRROR}/aarch64/Packages/s/snapper-0.13.0-3.el10_3.aarch64.rpm;name=aarch64_snapper;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapper}"
SRC_URI[aarch64_snapper.sha256sum] = "7feace997c647beaaa49e7337303193cb3b62e3a2bef4bb9553ac4c2eb7cb91f"

URI_aarch64_snapper-backup = "${EPEL_MIRROR}/aarch64/Packages/s/snapper-backup-0.13.0-3.el10_3.aarch64.rpm;name=aarch64_snapper-backup;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapper-backup}"
SRC_URI[aarch64_snapper-backup.sha256sum] = "40787f28e71fc0f51ec11797d089f9d6983203fb3c3c35bc9cb69a4f8e072423"

URI_aarch64_snapper-devel = "${EPEL_MIRROR}/aarch64/Packages/s/snapper-devel-0.13.0-3.el10_3.aarch64.rpm;name=aarch64_snapper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapper-devel}"
SRC_URI[aarch64_snapper-devel.sha256sum] = "f61420e6e1536c406ef8f85bdbaef123c115c47d9b129192be7afc24894f8e75"

URI_aarch64_snapper-libs = "${EPEL_MIRROR}/aarch64/Packages/s/snapper-libs-0.13.0-3.el10_3.aarch64.rpm;name=aarch64_snapper-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapper-libs}"
SRC_URI[aarch64_snapper-libs.sha256sum] = "37bf87e325c715d7d948f36ccf669c8b41170e40120f290341ab8ee71a26e033"

URI_aarch64_snapper-tests = "${EPEL_MIRROR}/aarch64/Packages/s/snapper-tests-0.13.0-3.el10_3.aarch64.rpm;name=aarch64_snapper-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapper-tests}"
SRC_URI[aarch64_snapper-tests.sha256sum] = "1d80aea31b4e577ca01c28ceeab2133cf18df3ed965ab87ccad2039b18ed8187"

RDEPENDS:pam_snapper = " \
 bash \
 dbus-libs \
 glibc \
 libbtrfs \
 libselinux \
 pam-libs \
 snapper \
 "
RDEPENDS:snapper = " \
 bash \
 boost-thread \
 dbus-libs \
 diffutils \
 glibc \
 json-c \
 libgcc \
 libmount \
 libstdc++ \
 libxml2 \
 ncurses-libs \
 snapper-libs \
 "
RDEPENDS:snapper-backup = " \
 dbus-libs \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 ncurses-libs \
 snapper \
 snapper-libs \
 "
RDEPENDS:snapper-devel = " \
 boost-devel \
 btrfs-progs-devel \
 libacl-devel \
 libmount-devel \
 libstdc++-devel \
 libxml2-devel \
 snapper-libs \
 "
RDEPENDS:snapper-libs = " \
 bash \
 boost-system \
 boost-thread \
 btrfs-progs \
 glibc \
 libacl \
 libbtrfs \
 libbtrfsutil \
 libgcc \
 libmount \
 libselinux \
 libstdc++ \
 libxml2 \
 util-linux \
 zlib-ng-compat \
 "
RDEPENDS:snapper-tests = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 snapper-libs \
 "
