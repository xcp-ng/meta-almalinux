# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lirc"
PV = "0.10.0"
PR = "49.el10_0"
PACKAGES = " \
 lirc-compat \
 lirc-config \
 lirc-core \
 lirc-devel \
 lirc-disable-kernel-rc \
 lirc-doc \
 lirc-drv-ftdi \
 lirc-drv-portaudio \
 lirc-libs \
 lirc-tools-gui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lirc-0.10.0-49.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40aaed81fd98ac09730c857aae44b67afd0115971eab22df08459e69ddefdd37"

URI_x86_64_v2_lirc-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-compat-0.10.0-49.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lirc-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lirc-compat}"
SRC_URI[x86_64_v2_lirc-compat.sha256sum] = "9a50e494250514e01d8f17883b3d381f9fdf7d9aa38b587e19baf92c17f1b2ef"

URI_x86_64_v2_lirc-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-config-0.10.0-49.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lirc-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lirc-config}"
SRC_URI[x86_64_v2_lirc-config.sha256sum] = "1cf6ba84650312b64708e44cd7a6f80d34f20556cca2347f9ee4a51b8886bff6"

URI_x86_64_v2_lirc-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-core-0.10.0-49.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lirc-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lirc-core}"
SRC_URI[x86_64_v2_lirc-core.sha256sum] = "9befa7551b3565c6e29adf04746b5dcfd3c9668edbf6cd8438aac368c9872b92"

URI_x86_64_v2_lirc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-devel-0.10.0-49.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lirc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lirc-devel}"
SRC_URI[x86_64_v2_lirc-devel.sha256sum] = "aa59b14b27dbf0552302fa87388e95b6680b25143d5b28705a6f48f20f35e819"

URI_x86_64_v2_lirc-disable-kernel-rc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-disable-kernel-rc-0.10.0-49.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lirc-disable-kernel-rc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lirc-disable-kernel-rc}"
SRC_URI[x86_64_v2_lirc-disable-kernel-rc.sha256sum] = "445da86474357eff43eef6fb159445aa167c599f170419f3409ae46bd0d97708"

URI_x86_64_v2_lirc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-doc-0.10.0-49.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lirc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lirc-doc}"
SRC_URI[x86_64_v2_lirc-doc.sha256sum] = "b780d1448db2e0a01e14a3d57775cfa46c4de1c5e90f8c98ed862351c7cebfe6"

URI_x86_64_v2_lirc-drv-ftdi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-drv-ftdi-0.10.0-49.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lirc-drv-ftdi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lirc-drv-ftdi}"
SRC_URI[x86_64_v2_lirc-drv-ftdi.sha256sum] = "c4ac25dea7aade96c54c6d7da32919b0e3868507c9ddd2b6e12dbe39f20d8871"

URI_x86_64_v2_lirc-drv-portaudio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-drv-portaudio-0.10.0-49.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lirc-drv-portaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lirc-drv-portaudio}"
SRC_URI[x86_64_v2_lirc-drv-portaudio.sha256sum] = "a7af4b310e85c84d7e861e775718f950227881c5215a99f1259e35e1574c4ca8"

URI_x86_64_v2_lirc-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-libs-0.10.0-49.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lirc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lirc-libs}"
SRC_URI[x86_64_v2_lirc-libs.sha256sum] = "52891bdececcb61060804f31e0cc4f8c7520afee76537d6c5c387abfc09a236c"

URI_x86_64_v2_lirc-tools-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-tools-gui-0.10.0-49.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lirc-tools-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lirc-tools-gui}"
SRC_URI[x86_64_v2_lirc-tools-gui.sha256sum] = "9409417164ec2c41dd75c3804ecb5eb9c761a484b8c2ba6b442ced814429611f"

URI_aarch64_lirc-compat = "${EPEL_MIRROR}/aarch64/Packages/l/lirc-compat-0.10.0-49.el10_0.aarch64.rpm;name=aarch64_lirc-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_lirc-compat}"
SRC_URI[aarch64_lirc-compat.sha256sum] = "b17c43e8e4365318164f5be477d8b0703dc597e21fecdfe97f5e411423ff2b3c"

URI_aarch64_lirc-config = "${EPEL_MIRROR}/aarch64/Packages/l/lirc-config-0.10.0-49.el10_0.noarch.rpm;name=aarch64_lirc-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_lirc-config}"
SRC_URI[aarch64_lirc-config.sha256sum] = "214f6f56dc73d12531f46a2eb6bb0238dbfe2cea8cb4414f874afc73eb07b363"

URI_aarch64_lirc-core = "${EPEL_MIRROR}/aarch64/Packages/l/lirc-core-0.10.0-49.el10_0.aarch64.rpm;name=aarch64_lirc-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_lirc-core}"
SRC_URI[aarch64_lirc-core.sha256sum] = "1741c0cb30b871898ae0080b185c66c2c9e5ff29ababa5bbd1ccf70d75eabb7d"

URI_aarch64_lirc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lirc-devel-0.10.0-49.el10_0.aarch64.rpm;name=aarch64_lirc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lirc-devel}"
SRC_URI[aarch64_lirc-devel.sha256sum] = "7335849ee5736422b5b909b9f2d942bed18c087b402ad21085dee129977c796b"

URI_aarch64_lirc-disable-kernel-rc = "${EPEL_MIRROR}/aarch64/Packages/l/lirc-disable-kernel-rc-0.10.0-49.el10_0.noarch.rpm;name=aarch64_lirc-disable-kernel-rc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lirc-disable-kernel-rc}"
SRC_URI[aarch64_lirc-disable-kernel-rc.sha256sum] = "942533ae7718e4a46ebebf3842ed19112b65b0778972d3e2f3616c16b48dc55d"

URI_aarch64_lirc-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lirc-doc-0.10.0-49.el10_0.noarch.rpm;name=aarch64_lirc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lirc-doc}"
SRC_URI[aarch64_lirc-doc.sha256sum] = "02efe36aa61b54c85bad2b344bc63a3bb148192d83284c76dacba662c56874e2"

URI_aarch64_lirc-drv-ftdi = "${EPEL_MIRROR}/aarch64/Packages/l/lirc-drv-ftdi-0.10.0-49.el10_0.aarch64.rpm;name=aarch64_lirc-drv-ftdi;unpack=0"
SRC_URI:append = " ${URI_aarch64_lirc-drv-ftdi}"
SRC_URI[aarch64_lirc-drv-ftdi.sha256sum] = "36eed6e9f7a90351bf87cc307eebe083cc7d569c59bd0722bc3654971a165aaf"

URI_aarch64_lirc-drv-portaudio = "${EPEL_MIRROR}/aarch64/Packages/l/lirc-drv-portaudio-0.10.0-49.el10_0.aarch64.rpm;name=aarch64_lirc-drv-portaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_lirc-drv-portaudio}"
SRC_URI[aarch64_lirc-drv-portaudio.sha256sum] = "9a93b8d98df96a15484a4f215a7ad1cf090810234f5f1fb8467447bccfface48"

URI_aarch64_lirc-libs = "${EPEL_MIRROR}/aarch64/Packages/l/lirc-libs-0.10.0-49.el10_0.aarch64.rpm;name=aarch64_lirc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lirc-libs}"
SRC_URI[aarch64_lirc-libs.sha256sum] = "1abd816c3069d9af7535cfa232455ee6a1901dd87fa01e090b99113583703017"

URI_aarch64_lirc-tools-gui = "${EPEL_MIRROR}/aarch64/Packages/l/lirc-tools-gui-0.10.0-49.el10_0.aarch64.rpm;name=aarch64_lirc-tools-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_lirc-tools-gui}"
SRC_URI[aarch64_lirc-tools-gui.sha256sum] = "af9688acc70f54aff43ee0c1afc160961aa61aa8f1de88397aac82daf5b41d09"

RDEPENDS:lirc-compat = " \
 lirc-config \
 lirc-core \
 lirc-drv-ftdi \
 lirc-drv-portaudio \
 lirc-tools-gui \
 "
RDEPENDS:lirc-config = " \
 bash \
 gnome-icon-theme \
 lirc-core \
 lirc-doc \
 python3 \
 python3-pyyaml \
 "
RDEPENDS:lirc-core = " \
 alsa-lib \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 libusb-compat-0.1 \
 libusb1 \
 lirc-libs \
 python3 \
 systemd \
 systemd-libs \
 "
RDEPENDS:lirc-devel = " \
 lirc-core \
 lirc-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:lirc-disable-kernel-rc = " \
 lirc-compat \
 "
RDEPENDS:lirc-doc = " \
 "
RDEPENDS:lirc-drv-ftdi = " \
 glibc \
 libftdi \
 libusb-compat-0.1 \
 libusb1 \
 lirc-core \
 lirc-libs \
 systemd-libs \
 "
RDEPENDS:lirc-drv-portaudio = " \
 alsa-lib \
 glibc \
 libusb-compat-0.1 \
 libusb1 \
 lirc-core \
 lirc-libs \
 portaudio \
 systemd-libs \
 "
RDEPENDS:lirc-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libusb-compat-0.1 \
 libusb1 \
 systemd-libs \
 "
RDEPENDS:lirc-tools-gui = " \
 glibc \
 libX11 \
 lirc-core \
 lirc-libs \
 "
