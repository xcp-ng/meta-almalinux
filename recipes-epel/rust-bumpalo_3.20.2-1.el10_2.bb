# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bumpalo"
PV = "3.20.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-bumpalo+allocator-api2-devel \
 rust-bumpalo+allocator_api-devel \
 rust-bumpalo+boxed-devel \
 rust-bumpalo+collections-devel \
 rust-bumpalo+default-devel \
 rust-bumpalo+serde-devel \
 rust-bumpalo+std-devel \
 rust-bumpalo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bumpalo-3.20.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9604c0eb9828983d24bb2b6be3c872591108bb05f9ffd25c97b1198d1c98573c"

URI_x86_64_v2_rust-bumpalo+allocator-api2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+allocator-api2-devel-3.20.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+allocator-api2-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+allocator-api2-devel.sha256sum] = "318efa9ade1f9e7db4c37f85b7912f3f6f584c39ae10419a270c8571feb7d26e"

URI_x86_64_v2_rust-bumpalo+allocator_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+allocator_api-devel-3.20.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+allocator_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+allocator_api-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+allocator_api-devel.sha256sum] = "11f40c55ee08ab4f30da0326465c28ea262ca2602c78e7b669164ac8469fba1b"

URI_x86_64_v2_rust-bumpalo+boxed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+boxed-devel-3.20.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+boxed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+boxed-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+boxed-devel.sha256sum] = "3b773925fd0f9a17e69633802bdea4dc689849d974b8ea598ec2428284224863"

URI_x86_64_v2_rust-bumpalo+collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+collections-devel-3.20.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+collections-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+collections-devel.sha256sum] = "fd11fdc7b418b4230ffac47fe86111e43cb0d6b7174e3198ce22c568c68eec7b"

URI_x86_64_v2_rust-bumpalo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+default-devel-3.20.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+default-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+default-devel.sha256sum] = "a87fad08deb9ab0babb290ec25357a73c4e934f534d57797a6dda544b77a7e42"

URI_x86_64_v2_rust-bumpalo+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+serde-devel-3.20.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+serde-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+serde-devel.sha256sum] = "624ae26febf9d6c90bea07738786aec825dbffda5ef24144743b2de65746347a"

URI_x86_64_v2_rust-bumpalo+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+std-devel-3.20.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+std-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+std-devel.sha256sum] = "3e566023eb6118856b06813f90b0c0273ae356272e36eb4db8eab21553c2a979"

URI_x86_64_v2_rust-bumpalo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo-devel-3.20.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo-devel}"
SRC_URI[x86_64_v2_rust-bumpalo-devel.sha256sum] = "f5374b8117bb215f002e5fe2feb824fe8bd8b625fa4b89dca71603a56df3736e"

URI_aarch64_rust-bumpalo+allocator-api2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+allocator-api2-devel-3.20.2-1.el10_2.noarch.rpm;name=aarch64_rust-bumpalo+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+allocator-api2-devel}"
SRC_URI[aarch64_rust-bumpalo+allocator-api2-devel.sha256sum] = "385056cf8d62a7150b7570fbe0c012a46c85b800f65fea0438a552937a8dbbd5"

URI_aarch64_rust-bumpalo+allocator_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+allocator_api-devel-3.20.2-1.el10_2.noarch.rpm;name=aarch64_rust-bumpalo+allocator_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+allocator_api-devel}"
SRC_URI[aarch64_rust-bumpalo+allocator_api-devel.sha256sum] = "793b23f338d6102a35d6288928c83559ea62fe029304ce2d775e4c3a065e71bb"

URI_aarch64_rust-bumpalo+boxed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+boxed-devel-3.20.2-1.el10_2.noarch.rpm;name=aarch64_rust-bumpalo+boxed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+boxed-devel}"
SRC_URI[aarch64_rust-bumpalo+boxed-devel.sha256sum] = "418ccd60322683195be2cfbdfdec7a12cca847a56b4cdda69091fe2c6d6925b4"

URI_aarch64_rust-bumpalo+collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+collections-devel-3.20.2-1.el10_2.noarch.rpm;name=aarch64_rust-bumpalo+collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+collections-devel}"
SRC_URI[aarch64_rust-bumpalo+collections-devel.sha256sum] = "5a8933aaef3d151141d965c0273ee9c5c93d56e7b31393bfc62256283eb75ddf"

URI_aarch64_rust-bumpalo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+default-devel-3.20.2-1.el10_2.noarch.rpm;name=aarch64_rust-bumpalo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+default-devel}"
SRC_URI[aarch64_rust-bumpalo+default-devel.sha256sum] = "a2055213d465ea8a3754fe568bd287c1836b5d225c6651a1f43ad70a882b7a83"

URI_aarch64_rust-bumpalo+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+serde-devel-3.20.2-1.el10_2.noarch.rpm;name=aarch64_rust-bumpalo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+serde-devel}"
SRC_URI[aarch64_rust-bumpalo+serde-devel.sha256sum] = "367546feb13459cea7bec0a400847213733927b3d0962d3116d27e7065fd3146"

URI_aarch64_rust-bumpalo+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+std-devel-3.20.2-1.el10_2.noarch.rpm;name=aarch64_rust-bumpalo+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+std-devel}"
SRC_URI[aarch64_rust-bumpalo+std-devel.sha256sum] = "73575428f65ad3e22e25a56667d3d14da5c6c23e6626adbd4b3febb5390678b4"

URI_aarch64_rust-bumpalo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo-devel-3.20.2-1.el10_2.noarch.rpm;name=aarch64_rust-bumpalo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo-devel}"
SRC_URI[aarch64_rust-bumpalo-devel.sha256sum] = "c4852b1fa11e1ce680efd99b5b0b627b5aa9124ddef8c16037c3e35aca5a359e"

RDEPENDS:rust-bumpalo+allocator-api2-devel = " \
 cargo \
 rust-allocator-api2-devel \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+allocator_api-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+boxed-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+collections-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+default-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+serde-devel = " \
 cargo \
 rust-bumpalo-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-bumpalo+std-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo-devel = " \
 cargo \
 rust \
 "
