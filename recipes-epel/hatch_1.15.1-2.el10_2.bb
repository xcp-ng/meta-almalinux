# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hatch"
PV = "1.15.1"
PR = "2.el10_2"
PACKAGES = " \
 hatch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hatch-1.15.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1635f83accedacc0f322face091af7a25e3796e8479d40f123d685c7a3080957"

URI_x86_64_v2_hatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hatch-1.15.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_hatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hatch}"
SRC_URI[x86_64_v2_hatch.sha256sum] = "5cd055cd2b21e56348e1fe4ad5d7419df4a4f9ba5de6a1c5e537c722fa87dc97"

URI_aarch64_hatch = "${EPEL_MIRROR}/aarch64/Packages/h/hatch-1.15.1-2.el10_2.noarch.rpm;name=aarch64_hatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_hatch}"
SRC_URI[aarch64_hatch.sha256sum] = "e8a661df679492a4d3b268bc0be10d2444243cbbe863a5d6a3f5704dc9e72d40"

RDEPENDS:hatch = " \
 git-core \
 python3 \
 python3-click \
 python3-hatchling \
 python3-httpx \
 python3-hyperlink \
 python3-keyring \
 python3-packaging \
 python3-pexpect \
 python3-platformdirs \
 python3-rich \
 python3-shellingham \
 python3-tomli-w \
 python3-tomlkit \
 python3-userpath \
 python3-uv \
 python3-virtualenv \
 python3-zstandard \
 "
