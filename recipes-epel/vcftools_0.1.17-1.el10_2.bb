# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vcftools"
PV = "0.1.17"
PR = "1.el10_2"
PACKAGES = " \
 vcftools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vcftools-0.1.17-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a3fee89c386c9f4f602563b47fb5cd1a65c217d83d9a9a48af861ebc245b82c"

URI_x86_64_v2_vcftools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vcftools-0.1.17-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vcftools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vcftools}"
SRC_URI[x86_64_v2_vcftools.sha256sum] = "bdde2ae55e269cee921ac7c9f8be93c84adf1dd81ecc44c5ab77d344923ba893"

URI_aarch64_vcftools = "${EPEL_MIRROR}/aarch64/Packages/v/vcftools-0.1.17-1.el10_2.aarch64.rpm;name=aarch64_vcftools;unpack=0"
SRC_URI:append = " ${URI_aarch64_vcftools}"
SRC_URI[aarch64_vcftools.sha256sum] = "c589898050268c0a2990609eebc918ab46e485af3022faecc3c1c45e46b9936f"

RDEPENDS:vcftools = " \
 glibc \
 libgcc \
 libstdc++ \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-FindBin \
 perl-IO \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 vcftools \
 zlib-ng-compat \
 "
