# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cfg-expr"
PV = "0.20.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-cfg-expr+default-devel \
 rust-cfg-expr+target-lexicon-devel \
 rust-cfg-expr+targets-devel \
 rust-cfg-expr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cfg-expr-0.20.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8275b3b81c9884588f4cb380298b1b8ae79163d9fffaac332fdf0ad78da15630"

URI_x86_64_v2_rust-cfg-expr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr+default-devel-0.20.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr+default-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr+default-devel.sha256sum] = "1c116754e928c08dfa877be91f35f0b96f1c73d3892044684d50669b853f19a6"
RPROVIDES:rust-cfg-expr+default-devel:x86_64_v2 = "virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~"

URI_x86_64_v2_rust-cfg-expr+target-lexicon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr+target-lexicon-devel-0.20.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr+target-lexicon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr+target-lexicon-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr+target-lexicon-devel.sha256sum] = "05bb87a057e1e94fb9023d5337aae185cece1472b8cf8fc939ac72222cf16745"

URI_x86_64_v2_rust-cfg-expr+targets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr+targets-devel-0.20.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr+targets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr+targets-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr+targets-devel.sha256sum] = "cc6f452da7a4f1ba613729edb0341598598fb7ee3bbdc72ba3aa48930b9c08fa"
RPROVIDES:rust-cfg-expr+targets-devel:x86_64_v2 = "virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~"

URI_x86_64_v2_rust-cfg-expr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr-devel-0.20.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr-devel.sha256sum] = "0fe8db2adcd81b5cc364a2c4fa38c5f38f3961d8f9c3bb6de763000d1ccbf8fd"

URI_aarch64_rust-cfg-expr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr+default-devel-0.20.8-1.el10_2.noarch.rpm;name=aarch64_rust-cfg-expr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr+default-devel}"
SRC_URI[aarch64_rust-cfg-expr+default-devel.sha256sum] = "eadb7e0c30e641308d1c3c4bdb0d83fda874caef702b7444b6f7215221a2be6a"
RPROVIDES:rust-cfg-expr+default-devel:aarch64 = "virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~"

URI_aarch64_rust-cfg-expr+target-lexicon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr+target-lexicon-devel-0.20.8-1.el10_2.noarch.rpm;name=aarch64_rust-cfg-expr+target-lexicon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr+target-lexicon-devel}"
SRC_URI[aarch64_rust-cfg-expr+target-lexicon-devel.sha256sum] = "033baf432dd80a8dc7e99f021b5b680ddd6d44eee89908dae0fd3a95bada9569"

URI_aarch64_rust-cfg-expr+targets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr+targets-devel-0.20.8-1.el10_2.noarch.rpm;name=aarch64_rust-cfg-expr+targets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr+targets-devel}"
SRC_URI[aarch64_rust-cfg-expr+targets-devel.sha256sum] = "cc76b35c02c919989ffabadcf03e6d4e6a4c5b0653d8c2dd34f2ac16368db3ee"
RPROVIDES:rust-cfg-expr+targets-devel:aarch64 = "virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~"

URI_aarch64_rust-cfg-expr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr-devel-0.20.8-1.el10_2.noarch.rpm;name=aarch64_rust-cfg-expr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr-devel}"
SRC_URI[aarch64_rust-cfg-expr-devel.sha256sum] = "e7c58b7e7e08bc74497a3f8549c16ad0428c61571740147882e7ae2ad89d12fb"

RDEPENDS:rust-cfg-expr+default-devel = " \
 cargo \
 rust-cfg-expr-devel \
 "
RDEPENDS:rust-cfg-expr+target-lexicon-devel = " \
 cargo \
 rust-cfg-expr-devel \
 rust-target-lexicon+default-devel \
 "
RDEPENDS:rust-cfg-expr+targets-devel = " \
 cargo \
 rust-cfg-expr+target-lexicon-devel \
 rust-cfg-expr-devel \
 "
RDEPENDS:rust-cfg-expr-devel = " \
 cargo \
 rust \
 rust-smallvec+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~ rpm/virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~ rpm/virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~"
