# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-copilot-prettyprinter"
PV = "3.19.1"
PR = "2.el10_0"
PACKAGES = " \
 ghc-copilot-prettyprinter \
 ghc-copilot-prettyprinter-devel \
 ghc-copilot-prettyprinter-doc \
 ghc-copilot-prettyprinter-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-copilot-prettyprinter-3.19.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d7e9e78572c48b56d3964fde8daac19f5bff4b1545da5a0279e103008d547f9"

URI_x86_64_v2_ghc-copilot-prettyprinter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-prettyprinter-3.19.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-prettyprinter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-prettyprinter}"
SRC_URI[x86_64_v2_ghc-copilot-prettyprinter.sha256sum] = "f156308b70520c1bc603f67f0c9832b0ce4ca90838259dbc88b95c4cb9ce71b6"

URI_x86_64_v2_ghc-copilot-prettyprinter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-prettyprinter-devel-3.19.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-prettyprinter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-prettyprinter-devel}"
SRC_URI[x86_64_v2_ghc-copilot-prettyprinter-devel.sha256sum] = "a10559494a3b2e707168b4f22cb325f70d2f1834c652503e591867a21aae5b1e"

URI_x86_64_v2_ghc-copilot-prettyprinter-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-prettyprinter-doc-3.19.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-copilot-prettyprinter-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-prettyprinter-doc}"
SRC_URI[x86_64_v2_ghc-copilot-prettyprinter-doc.sha256sum] = "806af814675323f4a73c7053809adb58c94324dd9ffb286ffdece7a0a25b89ea"

URI_x86_64_v2_ghc-copilot-prettyprinter-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-prettyprinter-prof-3.19.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-prettyprinter-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-prettyprinter-prof}"
SRC_URI[x86_64_v2_ghc-copilot-prettyprinter-prof.sha256sum] = "8ca1b37871b6279b65be301d2e1aff659d1b91086b2cb00aab293b95b078905a"

URI_aarch64_ghc-copilot-prettyprinter = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-prettyprinter-3.19.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-prettyprinter;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-prettyprinter}"
SRC_URI[aarch64_ghc-copilot-prettyprinter.sha256sum] = "4c8722c5b395df1e1c8a8f3447a029a5a0b8d7274a417989cf3fc6c7414a4042"

URI_aarch64_ghc-copilot-prettyprinter-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-prettyprinter-devel-3.19.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-prettyprinter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-prettyprinter-devel}"
SRC_URI[aarch64_ghc-copilot-prettyprinter-devel.sha256sum] = "0d91aa8ccb90f882e260ea25e822f22cd5115de19461f9949ef7e4d20d81b310"

URI_aarch64_ghc-copilot-prettyprinter-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-prettyprinter-doc-3.19.1-2.el10_0.noarch.rpm;name=aarch64_ghc-copilot-prettyprinter-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-prettyprinter-doc}"
SRC_URI[aarch64_ghc-copilot-prettyprinter-doc.sha256sum] = "59f83965b170fdd40ecfd6320ff9556b430d14b2f7f0dac11e86535474e7ced1"

URI_aarch64_ghc-copilot-prettyprinter-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-prettyprinter-prof-3.19.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-prettyprinter-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-prettyprinter-prof}"
SRC_URI[aarch64_ghc-copilot-prettyprinter-prof.sha256sum] = "e57f976c81907cd2cb9c023075a4e39f2488023ba2349e694edb699715fe3735"

RDEPENDS:ghc-copilot-prettyprinter = " \
 ghc-array \
 ghc-base \
 ghc-copilot-core \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc-copilot-prettyprinter-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-copilot-core-devel \
 ghc-copilot-prettyprinter \
 ghc-pretty-devel \
 "
RDEPENDS:ghc-copilot-prettyprinter-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-copilot-prettyprinter-prof = " \
 ghc-base-prof \
 ghc-copilot-core-prof \
 ghc-copilot-prettyprinter-devel \
 ghc-pretty-prof \
 "
