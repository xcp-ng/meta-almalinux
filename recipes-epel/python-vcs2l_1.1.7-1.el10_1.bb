# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-vcs2l"
PV = "1.1.7"
PR = "1.el10_1"
PACKAGES = " \
 python3-vcs2l \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-vcs2l-1.1.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60954cd14b7620f07edf86202112e1dcaf9bc355aaf83a42595440539953f6a4"

URI_x86_64_v2_python3-vcs2l = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-vcs2l-1.1.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-vcs2l;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-vcs2l}"
SRC_URI[x86_64_v2_python3-vcs2l.sha256sum] = "eaff313d28208badfe8a6842b949c6e7760e5cc315d888fbef7aaa8e4895e16b"

URI_aarch64_python3-vcs2l = "${EPEL_MIRROR}/aarch64/Packages/p/python3-vcs2l-1.1.7-1.el10_1.noarch.rpm;name=aarch64_python3-vcs2l;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-vcs2l}"
SRC_URI[aarch64_python3-vcs2l.sha256sum] = "f3b3c0e1af62e114a8abb3e1c81c74674a1d763c1b3472c25f6ee98958f12db9"

RDEPENDS:python3-vcs2l = " \
 python3 \
 python3-pyyaml \
 "
