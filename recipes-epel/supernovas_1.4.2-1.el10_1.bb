# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "supernovas"
PV = "1.4.2"
PR = "1.el10_1"
PACKAGES = " \
 supernovas \
 supernovas-cio-data \
 supernovas-devel \
 supernovas-doc \
 supernovas-solsys-calceph \
 supernovas-solsys1 \
 supernovas-solsys2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/supernovas-1.4.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd62401a526553bde7765ca77350a3ab412053238315ae65a4cfad952a2e4cde"

URI_x86_64_v2_supernovas = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-1.4.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_supernovas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas}"
SRC_URI[x86_64_v2_supernovas.sha256sum] = "ead711ef1733f216b706750caadf3745afeba97e45820f244e80457117fd2b91"

URI_x86_64_v2_supernovas-cio-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-cio-data-1.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_supernovas-cio-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas-cio-data}"
SRC_URI[x86_64_v2_supernovas-cio-data.sha256sum] = "71543729f7c4eb9d05a0d97ed861988888c6ebcc090695a04825e6a8c045efd3"

URI_x86_64_v2_supernovas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-devel-1.4.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_supernovas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas-devel}"
SRC_URI[x86_64_v2_supernovas-devel.sha256sum] = "16a89ad268832f6013c4781285602ceae1a7c9fa09b8c766413e2a42c1749702"

URI_x86_64_v2_supernovas-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-doc-1.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_supernovas-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas-doc}"
SRC_URI[x86_64_v2_supernovas-doc.sha256sum] = "f9353fa7f2c852fc2a618f92c99dad03a9500ffe8155208a4108d2d55c5a3ee5"

URI_x86_64_v2_supernovas-solsys-calceph = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-solsys-calceph-1.4.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_supernovas-solsys-calceph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas-solsys-calceph}"
SRC_URI[x86_64_v2_supernovas-solsys-calceph.sha256sum] = "cbc5ef4050823103e90cf4bb097b686643cf6d5ed6dd14829db6f0a8534e461a"

URI_x86_64_v2_supernovas-solsys1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-solsys1-1.4.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_supernovas-solsys1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas-solsys1}"
SRC_URI[x86_64_v2_supernovas-solsys1.sha256sum] = "cead2616ad58c6d06ab478c86976f642c96047e0ade7ecf001334b3255093b2c"

URI_x86_64_v2_supernovas-solsys2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-solsys2-1.4.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_supernovas-solsys2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas-solsys2}"
SRC_URI[x86_64_v2_supernovas-solsys2.sha256sum] = "2e9fc18ff66a3e12971be2a308ef1de42854e75e0d8e3d17015c4da6e140ccff"

URI_aarch64_supernovas = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-1.4.2-1.el10_1.aarch64.rpm;name=aarch64_supernovas;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas}"
SRC_URI[aarch64_supernovas.sha256sum] = "5c55536e98140d5d7cd7b0d0fb019c3c8fafd3d18ec60bb98e6e69a318cb06d3"

URI_aarch64_supernovas-cio-data = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-cio-data-1.4.2-1.el10_1.noarch.rpm;name=aarch64_supernovas-cio-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas-cio-data}"
SRC_URI[aarch64_supernovas-cio-data.sha256sum] = "78f80d94fa4c33586206b49ca13266d0ffdcb55189f2a04dc4754ef74981e213"

URI_aarch64_supernovas-devel = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-devel-1.4.2-1.el10_1.aarch64.rpm;name=aarch64_supernovas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas-devel}"
SRC_URI[aarch64_supernovas-devel.sha256sum] = "32a708fd63e0b0c85f282aba27c04bc87153e667daf7b75e2792d89a19ea32c7"

URI_aarch64_supernovas-doc = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-doc-1.4.2-1.el10_1.noarch.rpm;name=aarch64_supernovas-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas-doc}"
SRC_URI[aarch64_supernovas-doc.sha256sum] = "e85233403ab548a966ffbaf13cff6e9a9be14642d76981799ee698478d6aead5"

URI_aarch64_supernovas-solsys-calceph = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-solsys-calceph-1.4.2-1.el10_1.aarch64.rpm;name=aarch64_supernovas-solsys-calceph;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas-solsys-calceph}"
SRC_URI[aarch64_supernovas-solsys-calceph.sha256sum] = "49be741f7d5271a8c5d9bc2ddc0337adfd7bfc1656b472da766f9dcd9129e2c6"

URI_aarch64_supernovas-solsys1 = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-solsys1-1.4.2-1.el10_1.aarch64.rpm;name=aarch64_supernovas-solsys1;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas-solsys1}"
SRC_URI[aarch64_supernovas-solsys1.sha256sum] = "9da1da5a48fb5a63d70d27ffe7de81e774534c384a3c5f3cc58da93466a57df0"

URI_aarch64_supernovas-solsys2 = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-solsys2-1.4.2-1.el10_1.aarch64.rpm;name=aarch64_supernovas-solsys2;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas-solsys2}"
SRC_URI[aarch64_supernovas-solsys2.sha256sum] = "0982dfa54fed3eee41ba687d46a27eb53c1baeb02c0848fe70af55f37f454400"

RDEPENDS:supernovas = " \
 glibc \
 "
RDEPENDS:supernovas-cio-data = " \
 "
RDEPENDS:supernovas-devel = " \
 supernovas \
 supernovas-solsys-calceph \
 supernovas-solsys1 \
 supernovas-solsys2 \
 "
RDEPENDS:supernovas-doc = " \
 "
RDEPENDS:supernovas-solsys-calceph = " \
 calceph-libs \
 glibc \
 supernovas \
 "
RDEPENDS:supernovas-solsys1 = " \
 glibc \
 supernovas \
 "
RDEPENDS:supernovas-solsys2 = " \
 glibc \
 supernovas \
 "
