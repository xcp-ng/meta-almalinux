# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktrip"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ktrip \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktrip-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab76222216f334be0ffcd5bd423a69703b3f892dee8cea3ecd4e2363411099fa"

URI_x86_64_v2_ktrip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktrip-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktrip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktrip}"
SRC_URI[x86_64_v2_ktrip.sha256sum] = "1bf459ca7a0bb082b5cf41187dc1f976eec8a068846cb897dd651e5bbcd00239"

URI_aarch64_ktrip = "${EPEL_MIRROR}/aarch64/Packages/k/ktrip-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ktrip;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktrip}"
SRC_URI[aarch64_ktrip.sha256sum] = "c36787787458e1e011c117eb242713359eda719b469700b8224ed38289a6e858"

RDEPENDS:ktrip = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kpublictransport \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
