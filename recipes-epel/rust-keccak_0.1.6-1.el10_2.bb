# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-keccak"
PV = "0.1.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-keccak+asm-devel \
 rust-keccak+default-devel \
 rust-keccak+no_unroll-devel \
 rust-keccak+simd-devel \
 rust-keccak-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-keccak-0.1.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0eaefd70ccffd1cefbd5ccd5139087cf69e7c353c2567a430db0033bec3a7d0b"

URI_x86_64_v2_rust-keccak+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-keccak+asm-devel-0.1.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-keccak+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-keccak+asm-devel}"
SRC_URI[x86_64_v2_rust-keccak+asm-devel.sha256sum] = "83bf98358283264535e66bcb6ad3090b5d071dfaae848f6686dc138d6a2bed82"

URI_x86_64_v2_rust-keccak+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-keccak+default-devel-0.1.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-keccak+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-keccak+default-devel}"
SRC_URI[x86_64_v2_rust-keccak+default-devel.sha256sum] = "e6fcbda88a0246cf6dbbf1f73f48b2b8cf86b102da7d9037924c54caf641f81c"

URI_x86_64_v2_rust-keccak+no_unroll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-keccak+no_unroll-devel-0.1.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-keccak+no_unroll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-keccak+no_unroll-devel}"
SRC_URI[x86_64_v2_rust-keccak+no_unroll-devel.sha256sum] = "0e6fac66a72a6963838fd84349d7545e552a5462ead83afdd91c6f6a15e739f8"

URI_x86_64_v2_rust-keccak+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-keccak+simd-devel-0.1.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-keccak+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-keccak+simd-devel}"
SRC_URI[x86_64_v2_rust-keccak+simd-devel.sha256sum] = "16e9387daf1dd7bd438eb90a690956749c1d3eda8d218e03d251b6fa38d954c2"

URI_x86_64_v2_rust-keccak-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-keccak-devel-0.1.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-keccak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-keccak-devel}"
SRC_URI[x86_64_v2_rust-keccak-devel.sha256sum] = "f955cd2a252df7f5178ea1b03a44f7589dc4e077f45fb6dd29d88b8bb9828fad"

URI_aarch64_rust-keccak+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-keccak+asm-devel-0.1.6-1.el10_2.noarch.rpm;name=aarch64_rust-keccak+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-keccak+asm-devel}"
SRC_URI[aarch64_rust-keccak+asm-devel.sha256sum] = "ded783f55010f89b6c12c27d2e3260acdd7d1fd9d30be974c79c9234bc25c859"

URI_aarch64_rust-keccak+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-keccak+default-devel-0.1.6-1.el10_2.noarch.rpm;name=aarch64_rust-keccak+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-keccak+default-devel}"
SRC_URI[aarch64_rust-keccak+default-devel.sha256sum] = "b92cbeb95838f49a1519f521ffb50dad01d04a31df6c481aeaec22d6ad3f665f"

URI_aarch64_rust-keccak+no_unroll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-keccak+no_unroll-devel-0.1.6-1.el10_2.noarch.rpm;name=aarch64_rust-keccak+no_unroll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-keccak+no_unroll-devel}"
SRC_URI[aarch64_rust-keccak+no_unroll-devel.sha256sum] = "08324059efc8de58e06625e721c00eb4c57e9e8ef006dc111018cc537e1c5720"

URI_aarch64_rust-keccak+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-keccak+simd-devel-0.1.6-1.el10_2.noarch.rpm;name=aarch64_rust-keccak+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-keccak+simd-devel}"
SRC_URI[aarch64_rust-keccak+simd-devel.sha256sum] = "f31d33d82962ba3ed0489c0b4bed3cc2186df9830eb73582dd71268cd581d3df"

URI_aarch64_rust-keccak-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-keccak-devel-0.1.6-1.el10_2.noarch.rpm;name=aarch64_rust-keccak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-keccak-devel}"
SRC_URI[aarch64_rust-keccak-devel.sha256sum] = "71500c32b0bee433dbdb2fa0b21d99869b76a9ae79de9acfce036452bb3610ce"

RDEPENDS:rust-keccak+asm-devel = " \
 cargo \
 rust-keccak-devel \
 "
RDEPENDS:rust-keccak+default-devel = " \
 cargo \
 rust-keccak-devel \
 "
RDEPENDS:rust-keccak+no_unroll-devel = " \
 cargo \
 rust-keccak-devel \
 "
RDEPENDS:rust-keccak+simd-devel = " \
 cargo \
 rust-keccak-devel \
 "
RDEPENDS:rust-keccak-devel = " \
 cargo \
 rust-cpufeatures0.2+default-devel \
 "
