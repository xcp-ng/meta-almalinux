# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "arianna"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 arianna \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/arianna-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81462af52e8e1e918d2e5371a671fb27148abb942474814a51f5e26783486580"

URI_x86_64_v2_arianna = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arianna-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_arianna;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_arianna}"
SRC_URI[x86_64_v2_arianna.sha256sum] = "bad761ee2b49b375bc666b976a01566e0d6192aaf72c510f4d2cbb5b90ace3b8"

URI_aarch64_arianna = "${EPEL_MIRROR}/aarch64/Packages/a/arianna-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_arianna;unpack=0"
SRC_URI:append = " ${URI_aarch64_arianna}"
SRC_URI[aarch64_arianna.sha256sum] = "b9e577504b1128d79a0bac1b5e45d397ab867011cc3c021b5ff559ac5d3b08df"

RDEPENDS:arianna = " \
 glibc \
 kf6-baloo-libs \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kquickcharts \
 kf6-kwindowsystem \
 kf6-qqc2-desktop-style \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qthttpserver \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 "
