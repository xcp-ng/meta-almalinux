# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lunasvg"
PV = "3.5.0"
PR = "1.el10_1"
PACKAGES = " \
 lunasvg \
 lunasvg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lunasvg-3.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ef1986a595274b8d75b5f267501dc11c6eabbd61699c7759ef5a6afe040dd94"

URI_x86_64_v2_lunasvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lunasvg-3.5.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lunasvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lunasvg}"
SRC_URI[x86_64_v2_lunasvg.sha256sum] = "d951d7ef4cc5527b75b146937cb74bf87362c78cc3b6312ca47077ba9ec36291"

URI_x86_64_v2_lunasvg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lunasvg-devel-3.5.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lunasvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lunasvg-devel}"
SRC_URI[x86_64_v2_lunasvg-devel.sha256sum] = "814205275f83998c7fcf294cfda228b35c3fc45895555b2eabd16800c625d06c"

URI_aarch64_lunasvg = "${EPEL_MIRROR}/aarch64/Packages/l/lunasvg-3.5.0-1.el10_1.aarch64.rpm;name=aarch64_lunasvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_lunasvg}"
SRC_URI[aarch64_lunasvg.sha256sum] = "721c96045002870e487a3290f0769ead0e38b9616fdd50cfd81473fece353f06"

URI_aarch64_lunasvg-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lunasvg-devel-3.5.0-1.el10_1.aarch64.rpm;name=aarch64_lunasvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lunasvg-devel}"
SRC_URI[aarch64_lunasvg-devel.sha256sum] = "c38ffe17edab2bd9ed61ff0d12a9561b4b171cef973c7701af826e83a87e9093"

RDEPENDS:lunasvg = " \
 glibc \
 libgcc \
 libstdc++ \
 plutovg \
 "
RDEPENDS:lunasvg-devel = " \
 cmake-filesystem \
 lunasvg \
 pkgconf-pkg-config \
 plutovg-devel \
 "
