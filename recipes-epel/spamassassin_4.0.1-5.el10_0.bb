# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spamassassin"
PV = "4.0.1"
PR = "5.el10_0"
PACKAGES = " \
 spamassassin \
 spamassassin-compile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spamassassin-4.0.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e1b8059e479fa28b87c806c17304d6003b5a7e3cdb066bdfc4e35d4f6e1c6c7"

URI_x86_64_v2_spamassassin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spamassassin-4.0.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spamassassin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spamassassin}"
SRC_URI[x86_64_v2_spamassassin.sha256sum] = "9fd8edb126a6bdb7f8f750e79220cdc4135eb51cad04b06c22ac5f2a2eb38d81"

URI_x86_64_v2_spamassassin-compile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spamassassin-compile-4.0.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spamassassin-compile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spamassassin-compile}"
SRC_URI[x86_64_v2_spamassassin-compile.sha256sum] = "df3121f1bdadefe9c7c90ca0cb8cd2fcbfecb704d1b1e65b19ff9221b9b3d7f1"

URI_aarch64_spamassassin = "${EPEL_MIRROR}/aarch64/Packages/s/spamassassin-4.0.1-5.el10_0.aarch64.rpm;name=aarch64_spamassassin;unpack=0"
SRC_URI:append = " ${URI_aarch64_spamassassin}"
SRC_URI[aarch64_spamassassin.sha256sum] = "a05c71f6c7cb9bdbe24ed4645e7a3bef2e111654fd1005b63c69e889bddd3303"

URI_aarch64_spamassassin-compile = "${EPEL_MIRROR}/aarch64/Packages/s/spamassassin-compile-4.0.1-5.el10_0.aarch64.rpm;name=aarch64_spamassassin-compile;unpack=0"
SRC_URI:append = " ${URI_aarch64_spamassassin-compile}"
SRC_URI[aarch64_spamassassin-compile.sha256sum] = "29c52113bd2f606a955d27200ec6b5ac6b31cdd9fb77673ecdbf4f7a01c7f15b"

RDEPENDS:spamassassin = " \
 bash \
 diffutils \
 glibc \
 gnupg2 \
 openssl-libs \
 perl-Archive-Tar \
 perl-BSD-Resource \
 perl-Carp \
 perl-DBD-Pg \
 perl-DBI \
 perl-DB_File \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Encode \
 perl-Encode-Detect \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Path \
 perl-Getopt-Long \
 perl-HTML-Parser \
 perl-HTTP-Date \
 perl-IO \
 perl-IO-Socket-IP \
 perl-IO-Socket-SSL \
 perl-IO-Zlib \
 perl-Mail-DKIM \
 perl-Mail-SPF \
 perl-Net-CIDR-Lite \
 perl-Net-DNS \
 perl-NetAddr-IP \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Scalar-List-Utils \
 perl-Socket \
 perl-Storable \
 perl-Sys-Syslog \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 perl-version \
 procmail \
 spamassassin \
 systemd \
 "
RDEPENDS:spamassassin-compile = " \
 perl-Data-Dumper \
 perl-Errno \
 perl-ExtUtils-MakeMaker \
 perl-File-Copy \
 perl-File-Path \
 perl-Getopt-Long \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Usage \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 re2c \
 spamassassin \
 "
