# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-haskell-gi-overloading"
PE = "1"
PV = "1.0"
PR = "31.el10_0"
PACKAGES = " \
 ghc-haskell-gi-overloading-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-haskell-gi-overloading-1.0-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fef1b31c345a2457261949c74202f76addaf7b2b48bdc0ddc9fd0f86197d815e"

URI_x86_64_v2_ghc-haskell-gi-overloading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskell-gi-overloading-devel-1.0-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haskell-gi-overloading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskell-gi-overloading-devel}"
SRC_URI[x86_64_v2_ghc-haskell-gi-overloading-devel.sha256sum] = "3bea6322d4bbfeb4552e5b6ca903bdb0315e8e1aa4fce1de45d31c37258496a4"

URI_aarch64_ghc-haskell-gi-overloading-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskell-gi-overloading-devel-1.0-31.el10_0.aarch64.rpm;name=aarch64_ghc-haskell-gi-overloading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskell-gi-overloading-devel}"
SRC_URI[aarch64_ghc-haskell-gi-overloading-devel.sha256sum] = "acfb86d33b52f81348686a835d17aaf8e87e669a9e71fa6fcb27cc66fcb9c5c5"

RDEPENDS:ghc-haskell-gi-overloading-devel = " \
 ghc-compiler \
 "
