# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apriltag"
PV = "3.4.2"
PR = "2.el10_0"
PACKAGES = " \
 apriltag \
 apriltag-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/apriltag-3.4.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06d767a70f8093846639d43f53251b6eca38c06f20e3afef18b82189630f2930"

URI_x86_64_v2_apriltag = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apriltag-3.4.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apriltag;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apriltag}"
SRC_URI[x86_64_v2_apriltag.sha256sum] = "16cb7f57ce630943f9880e46cbe6b4772b34ae12ca84bd678cc86d36fd310e37"

URI_x86_64_v2_apriltag-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apriltag-devel-3.4.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apriltag-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apriltag-devel}"
SRC_URI[x86_64_v2_apriltag-devel.sha256sum] = "030aa0e347514b0e7c2c144ca1e4082cfd42507fa8e247a6acbcd9f7d358ec73"

URI_aarch64_apriltag = "${EPEL_MIRROR}/aarch64/Packages/a/apriltag-3.4.2-2.el10_0.aarch64.rpm;name=aarch64_apriltag;unpack=0"
SRC_URI:append = " ${URI_aarch64_apriltag}"
SRC_URI[aarch64_apriltag.sha256sum] = "6ec6a25416827a483477490a4bddd7b2188ac124235ecc799e1998b1af941d42"

URI_aarch64_apriltag-devel = "${EPEL_MIRROR}/aarch64/Packages/a/apriltag-devel-3.4.2-2.el10_0.aarch64.rpm;name=aarch64_apriltag-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_apriltag-devel}"
SRC_URI[aarch64_apriltag-devel.sha256sum] = "687044f677f8ca3349cc2d0a52fed7b0742cc3fde47b3e07293e73e94b69b177"

RDEPENDS:apriltag = " \
 glibc \
 "
RDEPENDS:apriltag-devel = " \
 apriltag \
 pkgconf-pkg-config \
 "
