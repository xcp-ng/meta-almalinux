# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memmap2"
PV = "0.9.11"
PR = "1.el10_3"
PACKAGES = " \
 rust-memmap2+default-devel \
 rust-memmap2+stable_deref_trait-devel \
 rust-memmap2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memmap2-0.9.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f52f127c511be8bdfeb79c973c6b3585717d947c94056336fdbf3f3df521598"

URI_x86_64_v2_rust-memmap2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2+default-devel-0.9.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2+default-devel}"
SRC_URI[x86_64_v2_rust-memmap2+default-devel.sha256sum] = "c0ebd4e8038c418311385cbcb925c03a5691f7b8b1418d5547ce495a0c5ef665"

URI_x86_64_v2_rust-memmap2+stable_deref_trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2+stable_deref_trait-devel-0.9.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2+stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2+stable_deref_trait-devel}"
SRC_URI[x86_64_v2_rust-memmap2+stable_deref_trait-devel.sha256sum] = "700485cfdb94c2f48fdc39df9d7245bbb55c565c3cb879da27721c3fd28aa064"

URI_x86_64_v2_rust-memmap2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2-devel-0.9.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2-devel}"
SRC_URI[x86_64_v2_rust-memmap2-devel.sha256sum] = "40c88dddfa8ddafa77598bd66956594f192c631a1badbc874f17832403eb73f2"

URI_aarch64_rust-memmap2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2+default-devel-0.9.11-1.el10_3.noarch.rpm;name=aarch64_rust-memmap2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2+default-devel}"
SRC_URI[aarch64_rust-memmap2+default-devel.sha256sum] = "9af26c9d4db9ba7a164668c0be8566b3e7d8b2adb59e6b68ec0ec6f96eefc630"

URI_aarch64_rust-memmap2+stable_deref_trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2+stable_deref_trait-devel-0.9.11-1.el10_3.noarch.rpm;name=aarch64_rust-memmap2+stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2+stable_deref_trait-devel}"
SRC_URI[aarch64_rust-memmap2+stable_deref_trait-devel.sha256sum] = "2697148edf975f8f95fb575e7b3c23917723c687c938b9de329c4eba12ea7ccf"

URI_aarch64_rust-memmap2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2-devel-0.9.11-1.el10_3.noarch.rpm;name=aarch64_rust-memmap2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2-devel}"
SRC_URI[aarch64_rust-memmap2-devel.sha256sum] = "fc04f332299ce4e98df2f8e2c3d107993ea7917e68e7313d4164fd33d641eddd"

RDEPENDS:rust-memmap2+default-devel = " \
 cargo \
 rust-memmap2-devel \
 "
RDEPENDS:rust-memmap2+stable_deref_trait-devel = " \
 cargo \
 rust-memmap2-devel \
 rust-stable_deref_trait+default-devel \
 "
RDEPENDS:rust-memmap2-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
