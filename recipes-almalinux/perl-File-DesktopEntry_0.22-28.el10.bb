# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-DesktopEntry"
PV = "0.22"
PR = "28.el10"
PACKAGES = " \
 perl-File-DesktopEntry \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-File-DesktopEntry-0.22-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8fc22ed46b9aca955abb27f810c358b3e20eea7fb4bb65612719c3b3dfb4e10"

URI_x86_64_v2_perl-File-DesktopEntry = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-File-DesktopEntry-0.22-28.el10.noarch.rpm;name=x86_64_v2_perl-File-DesktopEntry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-DesktopEntry}"
SRC_URI[x86_64_v2_perl-File-DesktopEntry.sha256sum] = "c2e4163d6e70708413b338566ec7b285a15a0d9bca035bd6d407f10ddbf79adf"

URI_aarch64_perl-File-DesktopEntry = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-File-DesktopEntry-0.22-28.el10.noarch.rpm;name=aarch64_perl-File-DesktopEntry;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-DesktopEntry}"
SRC_URI[aarch64_perl-File-DesktopEntry.sha256sum] = "c2e4163d6e70708413b338566ec7b285a15a0d9bca035bd6d407f10ddbf79adf"

RDEPENDS:perl-File-DesktopEntry = " \
 perl-Carp \
 perl-Encode \
 perl-File-BaseDir \
 perl-File-Path \
 perl-PathTools \
 perl-URI \
 perl-libs \
 perl-vars \
 "
