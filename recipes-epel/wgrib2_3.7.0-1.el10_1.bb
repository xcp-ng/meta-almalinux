# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wgrib2"
PV = "3.7.0"
PR = "1.el10_1"
PACKAGES = " \
 wgrib2 \
 wgrib2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wgrib2-3.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f800407dd024e631ebff812fdba24221d1fbd347bc0b29ef5615faf153777dcb"

URI_x86_64_v2_wgrib2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wgrib2-3.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wgrib2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wgrib2}"
SRC_URI[x86_64_v2_wgrib2.sha256sum] = "2d2d7c9f392e8f1bd54734c749bd871dee21da181bd7ecf89e1694dadd028c76"

URI_x86_64_v2_wgrib2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wgrib2-devel-3.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wgrib2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wgrib2-devel}"
SRC_URI[x86_64_v2_wgrib2-devel.sha256sum] = "a7c08c3051f898be6dfe7da7a58e2637597bedad07fa5dee97d81e6768898083"

URI_aarch64_wgrib2 = "${EPEL_MIRROR}/aarch64/Packages/w/wgrib2-3.7.0-1.el10_1.aarch64.rpm;name=aarch64_wgrib2;unpack=0"
SRC_URI:append = " ${URI_aarch64_wgrib2}"
SRC_URI[aarch64_wgrib2.sha256sum] = "717d513d03d976d7328ac4f0011669232385c813f836e3157452c69e86a0f567"

URI_aarch64_wgrib2-devel = "${EPEL_MIRROR}/aarch64/Packages/w/wgrib2-devel-3.7.0-1.el10_1.aarch64.rpm;name=aarch64_wgrib2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wgrib2-devel}"
SRC_URI[aarch64_wgrib2-devel.sha256sum] = "39ba22c9fb322170265f441cd7f0ffed9a8bd5cea1f1da6bc740a87c6ad76ed1"

RDEPENDS:wgrib2 = " \
 glibc \
 libaec \
 libgcc \
 libgomp \
 mariadb-connector-c \
 netcdf \
 "
RDEPENDS:wgrib2-devel = " \
 cmake-filesystem \
 glibc \
 libaec \
 libgcc \
 libgfortran \
 libgomp \
 mariadb-connector-c \
 netcdf \
 "
