# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-akutz-memconn"
PV = "0.1.0"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-akutz-memconn-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-akutz-memconn-0.1.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdabdf3d71779941de6b8c1f5eb8bdc2a7e00747efae83b39cf146e86345a0f5"

URI_x86_64_v2_golang-github-akutz-memconn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-akutz-memconn-devel-0.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-akutz-memconn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-akutz-memconn-devel}"
SRC_URI[x86_64_v2_golang-github-akutz-memconn-devel.sha256sum] = "11159768b2f8c7b9c3109b5ca6b82e09215fcc0f912770bf5855a4159f9dac44"

URI_aarch64_golang-github-akutz-memconn-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-akutz-memconn-devel-0.1.0-6.el10_0.noarch.rpm;name=aarch64_golang-github-akutz-memconn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-akutz-memconn-devel}"
SRC_URI[aarch64_golang-github-akutz-memconn-devel.sha256sum] = "674428270958cfaa0996012c4d882dcc8d1616918bbac7f5e0bc4c7c4ce76eb6"

RDEPENDS:golang-github-akutz-memconn-devel = " \
 go-filesystem \
 "
