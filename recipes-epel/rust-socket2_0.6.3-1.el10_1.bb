# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-socket2"
PV = "0.6.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-socket2+all-devel \
 rust-socket2+default-devel \
 rust-socket2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-socket2-0.6.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a6508fe7e7cebc7b03a8350441c79a98e55cf34a80ebcfbdfa6e4e41ebfaf54"

URI_x86_64_v2_rust-socket2+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2+all-devel-0.6.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socket2+all-devel}"
SRC_URI[x86_64_v2_rust-socket2+all-devel.sha256sum] = "d9ca2142b4727de46bf811cc4de69ca2bf8acdcf0906144dcfd83092e4517232"
RPROVIDES:rust-socket2+all-devel:x86_64_v2 = "virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~"

URI_x86_64_v2_rust-socket2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2+default-devel-0.6.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socket2+default-devel}"
SRC_URI[x86_64_v2_rust-socket2+default-devel.sha256sum] = "af9eed4d5ad06fd528e19957d5d90759273bdbafdad5f69b4952a76f217de800"
RPROVIDES:rust-socket2+default-devel:x86_64_v2 = "virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"

URI_x86_64_v2_rust-socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2-devel-0.6.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socket2-devel}"
SRC_URI[x86_64_v2_rust-socket2-devel.sha256sum] = "ddd3ffcec5afccc69e7fda316a54a7c67c785270b6be3a6035c35b4b25f7cb74"

URI_aarch64_rust-socket2+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2+all-devel-0.6.3-1.el10_1.noarch.rpm;name=aarch64_rust-socket2+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socket2+all-devel}"
SRC_URI[aarch64_rust-socket2+all-devel.sha256sum] = "95ee0c2557944d7840923f9c8a9d5a600453713973b3ba0dd03efd6c300109a7"
RPROVIDES:rust-socket2+all-devel:aarch64 = "virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~"

URI_aarch64_rust-socket2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2+default-devel-0.6.3-1.el10_1.noarch.rpm;name=aarch64_rust-socket2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socket2+default-devel}"
SRC_URI[aarch64_rust-socket2+default-devel.sha256sum] = "d33c8dfd98bbdde8deb8d5ca406670bddf7b6e36cf14d2e92d6a84e78dfb2a0d"
RPROVIDES:rust-socket2+default-devel:aarch64 = "virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"

URI_aarch64_rust-socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2-devel-0.6.3-1.el10_1.noarch.rpm;name=aarch64_rust-socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socket2-devel}"
SRC_URI[aarch64_rust-socket2-devel.sha256sum] = "3b63b5fdca39df56aa1ce873a57f73b1c9a076fd37d81fa10950904f7d2aab4a"

RDEPENDS:rust-socket2+all-devel = " \
 cargo \
 rust-socket2-devel \
 "
RDEPENDS:rust-socket2+default-devel = " \
 cargo \
 rust-socket2-devel \
 "
RDEPENDS:rust-socket2-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~ rpm/virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~ rpm/virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"
