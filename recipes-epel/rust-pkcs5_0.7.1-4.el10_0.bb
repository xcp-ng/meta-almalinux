# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pkcs5"
PV = "0.7.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-pkcs5+3des-devel \
 rust-pkcs5+alloc-devel \
 rust-pkcs5+default-devel \
 rust-pkcs5+des-insecure-devel \
 rust-pkcs5+pbes2-devel \
 rust-pkcs5+sha1-insecure-devel \
 rust-pkcs5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pkcs5-0.7.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25ae4dc406dc35c35ec0afc74b8961cd5a489460c80b1c4533ec0086ede39d47"

URI_x86_64_v2_rust-pkcs5+3des-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs5+3des-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs5+3des-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs5+3des-devel}"
SRC_URI[x86_64_v2_rust-pkcs5+3des-devel.sha256sum] = "cca1443db332e6be3dd35b962bac29fbc0114207f4229b610350a8455bbcb4d2"

URI_x86_64_v2_rust-pkcs5+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs5+alloc-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs5+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs5+alloc-devel}"
SRC_URI[x86_64_v2_rust-pkcs5+alloc-devel.sha256sum] = "877ad438209e9206dbbe6770767d4d4a234d6abff28794cb6704385408e393bb"

URI_x86_64_v2_rust-pkcs5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs5+default-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs5+default-devel}"
SRC_URI[x86_64_v2_rust-pkcs5+default-devel.sha256sum] = "64b76d8730153e75398f94ad57aa6551906f16d70e55fbe92d64c850b1564aec"

URI_x86_64_v2_rust-pkcs5+des-insecure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs5+des-insecure-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs5+des-insecure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs5+des-insecure-devel}"
SRC_URI[x86_64_v2_rust-pkcs5+des-insecure-devel.sha256sum] = "5d53696c227f1a7c00f93587b8d18c2d1bf8837c1bb81367919c75f2a8d57dc4"

URI_x86_64_v2_rust-pkcs5+pbes2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs5+pbes2-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs5+pbes2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs5+pbes2-devel}"
SRC_URI[x86_64_v2_rust-pkcs5+pbes2-devel.sha256sum] = "374f40be759af81003ad5c6f532f8941aea6410a78881059f09c35ee0bcf258d"

URI_x86_64_v2_rust-pkcs5+sha1-insecure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs5+sha1-insecure-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs5+sha1-insecure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs5+sha1-insecure-devel}"
SRC_URI[x86_64_v2_rust-pkcs5+sha1-insecure-devel.sha256sum] = "4f41779171cc4c2eb2d3d0c1ea3f573516c81380ab709402571afe844c20ee27"

URI_x86_64_v2_rust-pkcs5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs5-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs5-devel}"
SRC_URI[x86_64_v2_rust-pkcs5-devel.sha256sum] = "3acb53173cbf2ad76403357032922c6c08d00da1824f17724113d0d9a6dcf1a2"

URI_aarch64_rust-pkcs5+3des-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs5+3des-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs5+3des-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs5+3des-devel}"
SRC_URI[aarch64_rust-pkcs5+3des-devel.sha256sum] = "bfc26bb2f3709578a24471f0130d9d1f6e63ac966d83a9d3bc404bbe74e95b1b"

URI_aarch64_rust-pkcs5+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs5+alloc-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs5+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs5+alloc-devel}"
SRC_URI[aarch64_rust-pkcs5+alloc-devel.sha256sum] = "b771288af8aa815d65112a8fc96b3aa3b1920b0578f6926ce1ec4b95c6bc6e82"

URI_aarch64_rust-pkcs5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs5+default-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs5+default-devel}"
SRC_URI[aarch64_rust-pkcs5+default-devel.sha256sum] = "7008b6c99ea4563808fc9c6f35a032e25cdb5e60506bc554cf235595e95eba29"

URI_aarch64_rust-pkcs5+des-insecure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs5+des-insecure-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs5+des-insecure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs5+des-insecure-devel}"
SRC_URI[aarch64_rust-pkcs5+des-insecure-devel.sha256sum] = "4526e5260dc4faceab98428732858e90796cd87cc176b508b4902a66f3aef75d"

URI_aarch64_rust-pkcs5+pbes2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs5+pbes2-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs5+pbes2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs5+pbes2-devel}"
SRC_URI[aarch64_rust-pkcs5+pbes2-devel.sha256sum] = "2c138a30d64fecc64d039fcb457cdef97341ef89defe97beb719b019cf390259"

URI_aarch64_rust-pkcs5+sha1-insecure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs5+sha1-insecure-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs5+sha1-insecure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs5+sha1-insecure-devel}"
SRC_URI[aarch64_rust-pkcs5+sha1-insecure-devel.sha256sum] = "83bd598e093ab5c2e27c45f64adbc5ca50c840865c65ee3e25821b3ab6ba4b98"

URI_aarch64_rust-pkcs5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs5-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs5-devel}"
SRC_URI[aarch64_rust-pkcs5-devel.sha256sum] = "3eb2408d9ad172af7f163f8d628ac3a0f22f3b904cdccffa259e7ce59c76ef2c"

RDEPENDS:rust-pkcs5+3des-devel = " \
 cargo \
 rust-des-devel \
 rust-pkcs5+pbes2-devel \
 rust-pkcs5-devel \
 "
RDEPENDS:rust-pkcs5+alloc-devel = " \
 cargo \
 rust-pkcs5-devel \
 "
RDEPENDS:rust-pkcs5+default-devel = " \
 cargo \
 rust-pkcs5-devel \
 "
RDEPENDS:rust-pkcs5+des-insecure-devel = " \
 cargo \
 rust-des-devel \
 rust-pkcs5+pbes2-devel \
 rust-pkcs5-devel \
 "
RDEPENDS:rust-pkcs5+pbes2-devel = " \
 cargo \
 rust-aes-devel \
 rust-cbc+default-devel \
 rust-pbkdf2-devel \
 rust-pkcs5-devel \
 rust-scrypt-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-pkcs5+sha1-insecure-devel = " \
 cargo \
 rust-pkcs5+pbes2-devel \
 rust-pkcs5-devel \
 rust-sha1-devel \
 "
RDEPENDS:rust-pkcs5-devel = " \
 bash \
 cargo \
 rust \
 rust-der+default-devel \
 rust-der+oid-devel \
 rust-spki+default-devel \
 "
