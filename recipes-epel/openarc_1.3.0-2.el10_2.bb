# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openarc"
PV = "1.3.0"
PR = "2.el10_2"
PACKAGES = " \
 libopenarc \
 libopenarc-devel \
 openarc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openarc-1.3.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e135b3e1a2e1b39e699b09548a65a2cfecd7fb157f6534b07cd2b3f4e376ca2"

URI_x86_64_v2_libopenarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenarc-1.3.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenarc}"
SRC_URI[x86_64_v2_libopenarc.sha256sum] = "b17a04235dd68f745848498fa1a79c3bc04fcccdaea2f531bc4e1443093706a4"

URI_x86_64_v2_libopenarc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenarc-devel-1.3.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenarc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenarc-devel}"
SRC_URI[x86_64_v2_libopenarc-devel.sha256sum] = "9425e9a16b17401ec5c84ab8e1d81a9f545e9a113d33fd69e8fbbe4f067531e2"

URI_x86_64_v2_openarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openarc-1.3.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openarc}"
SRC_URI[x86_64_v2_openarc.sha256sum] = "a2d2e8faee502c08ee2198645d3a28fc59419f085f7e45ff95044194565d8cdd"

URI_aarch64_libopenarc = "${EPEL_MIRROR}/aarch64/Packages/l/libopenarc-1.3.0-2.el10_2.aarch64.rpm;name=aarch64_libopenarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenarc}"
SRC_URI[aarch64_libopenarc.sha256sum] = "b0b6de6145eb65ea70c11d4d3d8d263b80e3116b9d67b2c4a8820baaa516a458"

URI_aarch64_libopenarc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libopenarc-devel-1.3.0-2.el10_2.aarch64.rpm;name=aarch64_libopenarc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenarc-devel}"
SRC_URI[aarch64_libopenarc-devel.sha256sum] = "b2b01b756a2007f7f6b31d36970d4149ad38e9744aa1fd605a86b0bd85ef05db"

URI_aarch64_openarc = "${EPEL_MIRROR}/aarch64/Packages/o/openarc-1.3.0-2.el10_2.aarch64.rpm;name=aarch64_openarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_openarc}"
SRC_URI[aarch64_openarc.sha256sum] = "0d25f6fddf644db3e0863eab37465a87f7de4e0cfdb3791e2a74f9eda1f2feee"

RDEPENDS:libopenarc = " \
 glibc \
 libidn2 \
 openssl-libs \
 "
RDEPENDS:libopenarc-devel = " \
 libidn2-devel \
 libopenarc \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:openarc = " \
 bash \
 glibc \
 jansson \
 libopenarc \
 openssl-libs \
 python3 \
 sendmail-milter \
 setup \
 shadow-utils \
 systemd \
 "
