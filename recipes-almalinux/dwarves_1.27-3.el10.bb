# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dwarves"
PV = "1.27"
PR = "3.el10"
PACKAGES = " \
 dwarves \
 libdwarves1 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dwarves-1.27-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b1e19230b70245571aae3a19d80821d5c890a1dd8a333a7ab77c07a76ebb35d"

URI_x86_64_v2_dwarves = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dwarves-1.27-3.el10.x86_64_v2.rpm;name=x86_64_v2_dwarves;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dwarves}"
SRC_URI[x86_64_v2_dwarves.sha256sum] = "6613fce4bf8a351d7f12be91110b50894d4507d4362dd22b4c8c1d1f39098a09"

URI_x86_64_v2_libdwarves1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libdwarves1-1.27-3.el10.x86_64_v2.rpm;name=x86_64_v2_libdwarves1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdwarves1}"
SRC_URI[x86_64_v2_libdwarves1.sha256sum] = "2f11d12d538cfdd005306d574741d83ab341a45387ca19b0cc880226bc7e035b"

URI_aarch64_dwarves = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dwarves-1.27-3.el10.aarch64.rpm;name=aarch64_dwarves;unpack=0"
SRC_URI:append = " ${URI_aarch64_dwarves}"
SRC_URI[aarch64_dwarves.sha256sum] = "f0b531c1c9f0c2cd956bd14423b568d8949238831ab43c48f6c34a42c8fdf522"

URI_aarch64_libdwarves1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libdwarves1-1.27-3.el10.aarch64.rpm;name=aarch64_libdwarves1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdwarves1}"
SRC_URI[aarch64_libdwarves1.sha256sum] = "659b7aaaf73b21d618541fa372fdf4f8c9c90fe51a2c86fa06bbf6aedc48a2dd"

RDEPENDS:dwarves = " \
 bash \
 elfutils-libelf \
 glibc \
 libdwarves1 \
 python3 \
 "
RDEPENDS:libdwarves1 = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 zlib-ng-compat \
 "
