# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro-error-attr2"
PV = "2.0.0"
PR = "4.el10_3"
PACKAGES = " \
 rust-proc-macro-error-attr2+default-devel \
 rust-proc-macro-error-attr2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro-error-attr2-2.0.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27a470eae6e05c91eceb8474d11e41d273ef9f46af22f29f20beb632eb256a1c"

URI_x86_64_v2_rust-proc-macro-error-attr2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error-attr2+default-devel-2.0.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error-attr2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-error-attr2+default-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-error-attr2+default-devel.sha256sum] = "4445a3e10d6d5df151654c2db5c6d6524de2f5400c1b3a07b81af99a030f60a1"

URI_x86_64_v2_rust-proc-macro-error-attr2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error-attr2-devel-2.0.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error-attr2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-error-attr2-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-error-attr2-devel.sha256sum] = "239fbb733cddcbfc8f9e6e94abfcb352e404021c1c1b7934d24a5b2092412a20"

URI_aarch64_rust-proc-macro-error-attr2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error-attr2+default-devel-2.0.0-4.el10_3.noarch.rpm;name=aarch64_rust-proc-macro-error-attr2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-error-attr2+default-devel}"
SRC_URI[aarch64_rust-proc-macro-error-attr2+default-devel.sha256sum] = "b6d036745e5dd0e32e1d7f1a9f778235a0ecb9878401eefdb6c0dc6a9a5450d7"

URI_aarch64_rust-proc-macro-error-attr2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error-attr2-devel-2.0.0-4.el10_3.noarch.rpm;name=aarch64_rust-proc-macro-error-attr2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-error-attr2-devel}"
SRC_URI[aarch64_rust-proc-macro-error-attr2-devel.sha256sum] = "0c74d9e6a934295d3587ecccdc206ccc96f94c2a4b1710e54e926a1df4c019d8"

RDEPENDS:rust-proc-macro-error-attr2+default-devel = " \
 cargo \
 rust-proc-macro-error-attr2-devel \
 "
RDEPENDS:rust-proc-macro-error-attr2-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
