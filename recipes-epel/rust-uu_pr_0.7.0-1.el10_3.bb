# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_pr"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_pr+default-devel \
 rust-uu_pr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_pr-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d1515bcd6a0d08623ea8e6dfbb2478c7baaea3a5259a53008c9b5d2ece4d2bd"

URI_x86_64_v2_rust-uu_pr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_pr+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_pr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_pr+default-devel}"
SRC_URI[x86_64_v2_rust-uu_pr+default-devel.sha256sum] = "7ad17adf6e00144f4499811546ebed97e8c6473dec64d03e3f47bd7a62b68ae0"

URI_x86_64_v2_rust-uu_pr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_pr-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_pr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_pr-devel}"
SRC_URI[x86_64_v2_rust-uu_pr-devel.sha256sum] = "65ed466422ace00c3c5805986b7497e47e8cd3884ff6268dd3baca7bab57c335"

URI_aarch64_rust-uu_pr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_pr+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_pr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_pr+default-devel}"
SRC_URI[aarch64_rust-uu_pr+default-devel.sha256sum] = "e64140b694d17115d96886da7b2a65d7bcf7ba0d192c33a6179eb483c037f270"

URI_aarch64_rust-uu_pr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_pr-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_pr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_pr-devel}"
SRC_URI[aarch64_rust-uu_pr-devel.sha256sum] = "b3e39fb5830d568d5178b924672c4e5ecbdf2d8b2204075ed01410b0bd7a4bfc"

RDEPENDS:rust-uu_pr+default-devel = " \
 cargo \
 rust-uu_pr-devel \
 "
RDEPENDS:rust-uu_pr-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-itertools0.14+default-devel \
 rust-memchr+default-devel \
 rust-regex+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+time-devel \
 "
