# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-target-lexicon"
PV = "0.13.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-target-lexicon+arch_z80-devel \
 rust-target-lexicon+arch_zkasm-devel \
 rust-target-lexicon+default-devel \
 rust-target-lexicon+serde-devel \
 rust-target-lexicon+serde_support-devel \
 rust-target-lexicon+std-devel \
 rust-target-lexicon-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-target-lexicon-0.13.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a303c697f73a2594fa223237921fe428e918e9df801173ac14be60fc191b245"

URI_x86_64_v2_rust-target-lexicon+arch_z80-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+arch_z80-devel-0.13.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+arch_z80-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+arch_z80-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+arch_z80-devel.sha256sum] = "272a2cccf886434f019fc452cb5c3e71b090a135687c25396ac153688ca58cdd"

URI_x86_64_v2_rust-target-lexicon+arch_zkasm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+arch_zkasm-devel-0.13.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+arch_zkasm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+arch_zkasm-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+arch_zkasm-devel.sha256sum] = "44632aa67a902c64588bd3f99615ea737e79f0559f7c2561f36da8d88aeb2067"

URI_x86_64_v2_rust-target-lexicon+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+default-devel-0.13.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+default-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+default-devel.sha256sum] = "a89e386a2acdc15b670a5f463e20be221474740e0274a24418c40bb83a8d797b"

URI_x86_64_v2_rust-target-lexicon+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+serde-devel-0.13.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+serde-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+serde-devel.sha256sum] = "1e0e4d243dbbacb2f9131ac202e1d5145bb659ac61ef787dd9101c5801de8663"

URI_x86_64_v2_rust-target-lexicon+serde_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+serde_support-devel-0.13.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+serde_support-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+serde_support-devel.sha256sum] = "af5fb0e83a97bd18e608129bdd3a1206130944d831615fe26ce24ed81bf0f644"

URI_x86_64_v2_rust-target-lexicon+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+std-devel-0.13.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+std-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+std-devel.sha256sum] = "de2290f393f119f10fdd964819790d1631be1794faeecb6d9fa07cf3ed1a9607"

URI_x86_64_v2_rust-target-lexicon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon-devel-0.13.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon-devel.sha256sum] = "08b658376684e222ef890c8ef465930efc0d16a93b0ca912b29829ae062eacd1"

URI_aarch64_rust-target-lexicon+arch_z80-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+arch_z80-devel-0.13.5-1.el10_2.noarch.rpm;name=aarch64_rust-target-lexicon+arch_z80-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+arch_z80-devel}"
SRC_URI[aarch64_rust-target-lexicon+arch_z80-devel.sha256sum] = "5fcbc5542cbb415f1967d0a0569179cae1e210d64c491af798b3fe31bb3bd4c7"

URI_aarch64_rust-target-lexicon+arch_zkasm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+arch_zkasm-devel-0.13.5-1.el10_2.noarch.rpm;name=aarch64_rust-target-lexicon+arch_zkasm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+arch_zkasm-devel}"
SRC_URI[aarch64_rust-target-lexicon+arch_zkasm-devel.sha256sum] = "7d4c72cb95eddaa955d5926205f8aed5ee3aa663d72369ea1b3153780f7fc04e"

URI_aarch64_rust-target-lexicon+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+default-devel-0.13.5-1.el10_2.noarch.rpm;name=aarch64_rust-target-lexicon+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+default-devel}"
SRC_URI[aarch64_rust-target-lexicon+default-devel.sha256sum] = "e87ee8a3933372e21fb8aa3e061160c54da592a9ceee81a8531a6789feaa6718"

URI_aarch64_rust-target-lexicon+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+serde-devel-0.13.5-1.el10_2.noarch.rpm;name=aarch64_rust-target-lexicon+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+serde-devel}"
SRC_URI[aarch64_rust-target-lexicon+serde-devel.sha256sum] = "024a599499442a336f6df0dea86ade3709c16e51da9192b6bb85427bfb6e0f9d"

URI_aarch64_rust-target-lexicon+serde_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+serde_support-devel-0.13.5-1.el10_2.noarch.rpm;name=aarch64_rust-target-lexicon+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+serde_support-devel}"
SRC_URI[aarch64_rust-target-lexicon+serde_support-devel.sha256sum] = "57918a7442822c7631ce11361fc53847f7009cf958ee8de0c37cc542fa95f67c"

URI_aarch64_rust-target-lexicon+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+std-devel-0.13.5-1.el10_2.noarch.rpm;name=aarch64_rust-target-lexicon+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+std-devel}"
SRC_URI[aarch64_rust-target-lexicon+std-devel.sha256sum] = "eca071d1a40f1862056eaa7ddfd62c33299ecba5695e7de6fc1f0282c740a7f6"

URI_aarch64_rust-target-lexicon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon-devel-0.13.5-1.el10_2.noarch.rpm;name=aarch64_rust-target-lexicon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon-devel}"
SRC_URI[aarch64_rust-target-lexicon-devel.sha256sum] = "d00f3b14c10e0493630e7746f0c2065d7902fdf5f1a02f15e1bb5de53ef4bc96"

RDEPENDS:rust-target-lexicon+arch_z80-devel = " \
 cargo \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon+arch_zkasm-devel = " \
 cargo \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon+default-devel = " \
 cargo \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon+serde_support-devel = " \
 cargo \
 rust-target-lexicon+serde-devel \
 rust-target-lexicon+std-devel \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon+std-devel = " \
 cargo \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon-devel = " \
 cargo \
 "
