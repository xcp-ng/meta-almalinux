# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hspell"
PV = "1.4"
PR = "23.el10"
PACKAGES = " \
 hunspell-he \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hspell-1.4-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5daf14c6e1cf74ff6846e4a54a5f68e7f673a8d5c7a7bdd309f82bfe7abade26"

URI_x86_64_v2_hunspell-he = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-he-1.4-23.el10.x86_64_v2.rpm;name=x86_64_v2_hunspell-he;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-he}"
SRC_URI[x86_64_v2_hunspell-he.sha256sum] = "4e646d7fd7a5b6cacaf8115ea413dad8d295e978f025feeda674947d1db6ae50"

URI_aarch64_hunspell-he = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-he-1.4-23.el10.aarch64.rpm;name=aarch64_hunspell-he;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-he}"
SRC_URI[aarch64_hunspell-he.sha256sum] = "41bdcf610b814619b5de3594e2071610e2eccaef62646de9dfcc883167363b45"

RDEPENDS:hunspell-he = " \
 hunspell \
 "
