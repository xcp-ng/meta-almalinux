# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openjpeg2"
PV = "2.5.2"
PR = "4.el10_0.1"
PACKAGES = " \
 openjpeg2 \
 openjpeg2-devel \
 openjpeg2-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openjpeg2-2.5.2-4.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ffa6d29ab5619237487e2695aad828c4b596b050c5cdb7f56fb377c0ba0c88d"

URI_x86_64_v2_openjpeg2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openjpeg2-2.5.2-4.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_openjpeg2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openjpeg2}"
SRC_URI[x86_64_v2_openjpeg2.sha256sum] = "bd4ea67949cb60f74b9e5e919199c431d8e2338133492881120d37f1d547b554"

URI_x86_64_v2_openjpeg2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openjpeg2-devel-2.5.2-4.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_openjpeg2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openjpeg2-devel}"
SRC_URI[x86_64_v2_openjpeg2-devel.sha256sum] = "61cbc71494f3a4d01660a3c7c212d937f477b7ef36d577cb50745bc6e8a9bd75"

URI_x86_64_v2_openjpeg2-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openjpeg2-tools-2.5.2-4.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_openjpeg2-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openjpeg2-tools}"
SRC_URI[x86_64_v2_openjpeg2-tools.sha256sum] = "12b3346b28261d1c929bc4f1607e78a0e203c61f23de0419a9527d52cab60712"

URI_aarch64_openjpeg2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openjpeg2-2.5.2-4.el10_0.1.aarch64.rpm;name=aarch64_openjpeg2;unpack=0"
SRC_URI:append = " ${URI_aarch64_openjpeg2}"
SRC_URI[aarch64_openjpeg2.sha256sum] = "5c0fb6592a3dcbc7c0b860357f28e3c156fb05b40ec741fde3331fdef00c274c"

URI_aarch64_openjpeg2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openjpeg2-devel-2.5.2-4.el10_0.1.aarch64.rpm;name=aarch64_openjpeg2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openjpeg2-devel}"
SRC_URI[aarch64_openjpeg2-devel.sha256sum] = "e5f77e36c4db163be4e41d4827cbf5ae6dcb06d1b0a88be260edf6218d1d5a06"

URI_aarch64_openjpeg2-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openjpeg2-tools-2.5.2-4.el10_0.1.aarch64.rpm;name=aarch64_openjpeg2-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_openjpeg2-tools}"
SRC_URI[aarch64_openjpeg2-tools.sha256sum] = "14d8199b1d81277ef1d462d395b483602ce83c5ef80ce9e55d564314e0296f4f"

RDEPENDS:openjpeg2 = " \
 glibc \
 "
RDEPENDS:openjpeg2-devel = " \
 cmake-filesystem \
 openjpeg2 \
 openjpeg2-tools \
 pkgconf-pkg-config \
 "
RDEPENDS:openjpeg2-tools = " \
 glibc \
 lcms2 \
 libpng \
 libtiff \
 openjpeg2 \
 "
