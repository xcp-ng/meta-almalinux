# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mkdocs-monorepo-plugin"
PV = "1.1.2"
PR = "1.el10_2"
PACKAGES = " \
 python3-mkdocs-monorepo-plugin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mkdocs-monorepo-plugin-1.1.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4124f71c9fe67b9dff06062bbc49b5e446a74f3cccb8ab7d3c3028fab1199c66"

URI_x86_64_v2_python3-mkdocs-monorepo-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-monorepo-plugin-1.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-monorepo-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-monorepo-plugin}"
SRC_URI[x86_64_v2_python3-mkdocs-monorepo-plugin.sha256sum] = "b1c1aa3947fc7d70b23b663c919a2bd8034d5fec51fc558dcc4a0e9477e72fed"

URI_aarch64_python3-mkdocs-monorepo-plugin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-monorepo-plugin-1.1.2-1.el10_2.noarch.rpm;name=aarch64_python3-mkdocs-monorepo-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-monorepo-plugin}"
SRC_URI[aarch64_python3-mkdocs-monorepo-plugin.sha256sum] = "04e0a2f2884b0dfddd8ecb90b88100d53c089fb4b38d12b20ce5f14e1346dbc0"

RDEPENDS:python3-mkdocs-monorepo-plugin = " \
 mkdocs \
 python3 \
 python3-slugify \
 "
