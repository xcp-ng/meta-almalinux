# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_complete_command"
PV = "0.6.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-clap_complete_command+default-devel \
 rust-clap_complete_command+fig-devel \
 rust-clap_complete_command+nushell-devel \
 rust-clap_complete_command-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_complete_command-0.6.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0dd8b30fde4a257533a93448ed579534699977864e4b1db8e2e48436a7547160"

URI_x86_64_v2_rust-clap_complete_command+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete_command+default-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete_command+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete_command+default-devel}"
SRC_URI[x86_64_v2_rust-clap_complete_command+default-devel.sha256sum] = "3128aea6041aab6b01209583d16494f07cfddc4c18f218752158c1b29bd82204"

URI_x86_64_v2_rust-clap_complete_command+fig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete_command+fig-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete_command+fig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete_command+fig-devel}"
SRC_URI[x86_64_v2_rust-clap_complete_command+fig-devel.sha256sum] = "42db126ca020ecef6e1f3cb86267167eb3263fdc751158b11f797145edfabcfd"

URI_x86_64_v2_rust-clap_complete_command+nushell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete_command+nushell-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete_command+nushell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete_command+nushell-devel}"
SRC_URI[x86_64_v2_rust-clap_complete_command+nushell-devel.sha256sum] = "617cb6087f92040160412ed9545866f155a1ca37aa59e3c321bc315174ab2aba"

URI_x86_64_v2_rust-clap_complete_command-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete_command-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete_command-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete_command-devel}"
SRC_URI[x86_64_v2_rust-clap_complete_command-devel.sha256sum] = "4ffc9a106f66b9158b43a81ba7be8fa2d0914418a522d1917ee4a89e42b10ef8"

URI_aarch64_rust-clap_complete_command+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete_command+default-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-clap_complete_command+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete_command+default-devel}"
SRC_URI[aarch64_rust-clap_complete_command+default-devel.sha256sum] = "d41c09dc57aa694a07268bcbb3b3e36d593d3ec2917324c1a346c23172389029"

URI_aarch64_rust-clap_complete_command+fig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete_command+fig-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-clap_complete_command+fig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete_command+fig-devel}"
SRC_URI[aarch64_rust-clap_complete_command+fig-devel.sha256sum] = "6aded7ea7275dbe9b1054d8eebade36377f0b8e31a55462189d158c73adb53b9"

URI_aarch64_rust-clap_complete_command+nushell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete_command+nushell-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-clap_complete_command+nushell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete_command+nushell-devel}"
SRC_URI[aarch64_rust-clap_complete_command+nushell-devel.sha256sum] = "4686d93dbe55825c806b69dfbab8a89cad35c3399dcc4fb8bfc84a47e99ad9a2"

URI_aarch64_rust-clap_complete_command-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete_command-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-clap_complete_command-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete_command-devel}"
SRC_URI[aarch64_rust-clap_complete_command-devel.sha256sum] = "68bebea089d1ea59e14573299f0d212f9f1b18cb70513cae0ea7479fd3c6b4d0"

RDEPENDS:rust-clap_complete_command+default-devel = " \
 cargo \
 rust-clap_complete_command+nushell-devel \
 rust-clap_complete_command-devel \
 "
RDEPENDS:rust-clap_complete_command+fig-devel = " \
 cargo \
 rust-clap_complete_command-devel \
 rust-clap_complete_fig+default-devel \
 "
RDEPENDS:rust-clap_complete_command+nushell-devel = " \
 cargo \
 rust-clap_complete_command-devel \
 rust-clap_complete_nushell+default-devel \
 "
RDEPENDS:rust-clap_complete_command-devel = " \
 cargo \
 rust-clap+default-devel \
 rust-clap_complete+default-devel \
 "
