# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtsvg"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtsvg \
 qt5-qtsvg-devel \
 qt5-qtsvg-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtsvg-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86e87b476aa06c7e95382eb57ce3c5ece2fe447528f82832e24fdad76ea7d038"

URI_x86_64_v2_qt5-qtsvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsvg-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsvg}"
SRC_URI[x86_64_v2_qt5-qtsvg.sha256sum] = "0f655c944e577b9fd05e21de3aa6acbbf9f60a3162370ef9345394e711f59643"

URI_x86_64_v2_qt5-qtsvg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsvg-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsvg-devel}"
SRC_URI[x86_64_v2_qt5-qtsvg-devel.sha256sum] = "84fb2e407d102092a65f16f0dc206191871f45a1c373ab35846cf6bf76bfb1bc"

URI_x86_64_v2_qt5-qtsvg-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsvg-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsvg-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsvg-examples}"
SRC_URI[x86_64_v2_qt5-qtsvg-examples.sha256sum] = "8c16b75103ae4b5e17c3c149793c724b8b52d716eda72ed3e3549eab41ed1254"

URI_aarch64_qt5-qtsvg = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsvg-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtsvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsvg}"
SRC_URI[aarch64_qt5-qtsvg.sha256sum] = "40a7e55bf1fd8353e505511716c13de0bbc89ab82e0e42f8da14a088afde1a8c"

URI_aarch64_qt5-qtsvg-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsvg-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtsvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsvg-devel}"
SRC_URI[aarch64_qt5-qtsvg-devel.sha256sum] = "0736255affb30df5607df274ea04d2346314ecdb3383050591bfc6abc8264546"

URI_aarch64_qt5-qtsvg-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsvg-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtsvg-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsvg-examples}"
SRC_URI[aarch64_qt5-qtsvg-examples.sha256sum] = "c35ad5a0acf51b420d062eb03de521caf59be082458d8931bd825dd9210396b5"

RDEPENDS:qt5-qtsvg = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qtsvg-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtsvg \
 "
RDEPENDS:qt5-qtsvg-examples = " \
 glibc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtsvg \
 "
