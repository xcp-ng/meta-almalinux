# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinxcontrib-qthelp"
PV = "2.0.0"
PR = "3.el10_1"
PACKAGES = " \
 python3-sphinxcontrib-qthelp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinxcontrib-qthelp-2.0.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1001542435026ddf0502e5ccf142327a81049d829ba582a300ddf0b29b96d61d"

URI_x86_64_v2_python3-sphinxcontrib-qthelp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinxcontrib-qthelp-2.0.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinxcontrib-qthelp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinxcontrib-qthelp}"
SRC_URI[x86_64_v2_python3-sphinxcontrib-qthelp.sha256sum] = "1cc1ae8e6b13303bd57bd36af63d1c652d1a8a599bc8174216be244f6405fc35"

URI_aarch64_python3-sphinxcontrib-qthelp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinxcontrib-qthelp-2.0.0-3.el10_1.noarch.rpm;name=aarch64_python3-sphinxcontrib-qthelp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinxcontrib-qthelp}"
SRC_URI[aarch64_python3-sphinxcontrib-qthelp.sha256sum] = "8773ebb78cb69da521b911ad4a6ba17090066330bc73cd18b184b1ed381faec3"

RDEPENDS:python3-sphinxcontrib-qthelp = " \
 python3 \
 "
