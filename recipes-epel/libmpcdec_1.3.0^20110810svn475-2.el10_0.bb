# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmpcdec"
PV = "1.3.0^20110810svn475"
PR = "2.el10_0"
PACKAGES = " \
 libmpcdec \
 libmpcdec-devel \
 musepack-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmpcdec-1.3.0^20110810svn475-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c87b38f3cc140ec94b7a44039db27c0db844b4692028e4ab55b0345c60e546b"

URI_x86_64_v2_libmpcdec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmpcdec-1.3.0^20110810svn475-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmpcdec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmpcdec}"
SRC_URI[x86_64_v2_libmpcdec.sha256sum] = "4573676298072bc20ea6f57bc62bc5f720e0f4b68c958e72f59c99f502ad7284"

URI_x86_64_v2_libmpcdec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmpcdec-devel-1.3.0^20110810svn475-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmpcdec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmpcdec-devel}"
SRC_URI[x86_64_v2_libmpcdec-devel.sha256sum] = "ac9a202ec2686ac7ee1bb0a53957a42c5ed218e6c19efa2947972d85ebcc04d5"

URI_x86_64_v2_musepack-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musepack-tools-1.3.0^20110810svn475-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musepack-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musepack-tools}"
SRC_URI[x86_64_v2_musepack-tools.sha256sum] = "3704bc7bc9b7f974e3a260b0221d5e3a74da794d42a8df902918f43a10d8bdd2"

URI_aarch64_libmpcdec = "${EPEL_MIRROR}/aarch64/Packages/l/libmpcdec-1.3.0^20110810svn475-2.el10_0.aarch64.rpm;name=aarch64_libmpcdec;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmpcdec}"
SRC_URI[aarch64_libmpcdec.sha256sum] = "3e0d6a3c4e129af85313eebbcb34592ee9cc84946115f997342ccaae2ffea02d"

URI_aarch64_libmpcdec-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmpcdec-devel-1.3.0^20110810svn475-2.el10_0.aarch64.rpm;name=aarch64_libmpcdec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmpcdec-devel}"
SRC_URI[aarch64_libmpcdec-devel.sha256sum] = "cabf274a37317a63d12a4677f614137dacc7dd4e3de8ee92f3d86f2e1a884265"

URI_aarch64_musepack-tools = "${EPEL_MIRROR}/aarch64/Packages/m/musepack-tools-1.3.0^20110810svn475-2.el10_0.aarch64.rpm;name=aarch64_musepack-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_musepack-tools}"
SRC_URI[aarch64_musepack-tools.sha256sum] = "2e760af8bd28e5baa5464f42f9e2d98dd9239e0aa44faf4a6bca3fab847de48a"

RDEPENDS:libmpcdec = " \
 glibc \
 "
RDEPENDS:libmpcdec-devel = " \
 libmpcdec \
 "
RDEPENDS:musepack-tools = " \
 glibc \
 libmpcdec \
 libreplaygain \
 "
