# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-PasswdMD5"
PV = "1.4.3"
PR = "1.el10_3"
PACKAGES = " \
 perl-Crypt-PasswdMD5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-PasswdMD5-1.4.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "419d889b0fc63248a269a23313f4c3058a4b73b10f360486b59b4c412d4379dc"

URI_x86_64_v2_perl-Crypt-PasswdMD5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-PasswdMD5-1.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-PasswdMD5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-PasswdMD5}"
SRC_URI[x86_64_v2_perl-Crypt-PasswdMD5.sha256sum] = "0059e6488e1231fb3dec441c8aa3d08680b11acecaf0123758112dbc8359e105"

URI_aarch64_perl-Crypt-PasswdMD5 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-PasswdMD5-1.4.3-1.el10_3.noarch.rpm;name=aarch64_perl-Crypt-PasswdMD5;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-PasswdMD5}"
SRC_URI[aarch64_perl-Crypt-PasswdMD5.sha256sum] = "5b732265424a3e8a2579b14f8b5b6ed9d5ad907dfd95e739f5422d416d005776"

RDEPENDS:perl-Crypt-PasswdMD5 = " \
 perl-Crypt-URandom \
 perl-Digest-MD5 \
 perl-Encode \
 perl-Exporter \
 perl-libs \
 "
