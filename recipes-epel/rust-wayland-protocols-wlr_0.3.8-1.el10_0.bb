# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-protocols-wlr"
PV = "0.3.8"
PR = "1.el10_0"
PACKAGES = " \
 rust-wayland-protocols-wlr+client-devel \
 rust-wayland-protocols-wlr+default-devel \
 rust-wayland-protocols-wlr+server-devel \
 rust-wayland-protocols-wlr+wayland-client-devel \
 rust-wayland-protocols-wlr+wayland-server-devel \
 rust-wayland-protocols-wlr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-protocols-wlr-0.3.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1cc42d96a2e231dbcefe0cb3b4c394756727dd560e1069fd1f5f107ee208ba5c"

URI_x86_64_v2_rust-wayland-protocols-wlr+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+client-devel-0.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+client-devel.sha256sum] = "0a6a0b2c484953cc3441d29b2c896a205db28e392ae0374a3f73d1fe499e1ef9"

URI_x86_64_v2_rust-wayland-protocols-wlr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+default-devel-0.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+default-devel.sha256sum] = "5a7eb57507a5625d4250090fedc5a47078318900500fe0d1ad339e4e50fec887"

URI_x86_64_v2_rust-wayland-protocols-wlr+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+server-devel-0.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+server-devel.sha256sum] = "14997f8708b6a0bc81131e183dbb3fa98a4cdd564ee9abde16acb0c86839cab5"

URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+wayland-client-devel-0.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel.sha256sum] = "9f37d1c1878f69f29ea65856cb87f6b5945a114933ee18bbdf16c0f62fe7f2ee"

URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+wayland-server-devel-0.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel.sha256sum] = "4b7d3f3239b8df0aea07fe119f9753d4ca2fdad067a781679f9561258a87c5ed"

URI_x86_64_v2_rust-wayland-protocols-wlr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr-devel-0.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr-devel.sha256sum] = "27d801731d83a7cf45669544fd0cd560bf6f6fa19054b3028b3a16d726178010"

URI_aarch64_rust-wayland-protocols-wlr+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+client-devel-0.3.8-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+client-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+client-devel.sha256sum] = "daf9136d95a56118b2b2633c38275d01cf9a55a535e384c4ca43344747e46c43"

URI_aarch64_rust-wayland-protocols-wlr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+default-devel-0.3.8-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+default-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+default-devel.sha256sum] = "d0049d7c3da94adb26f01a8a6a52da97011abb1893b995177d8b9177cae45132"

URI_aarch64_rust-wayland-protocols-wlr+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+server-devel-0.3.8-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+server-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+server-devel.sha256sum] = "103336ed5da6b406d5609f0533f0cbb3394177f51e0a3e69e27c124f88d8900b"

URI_aarch64_rust-wayland-protocols-wlr+wayland-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+wayland-client-devel-0.3.8-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+wayland-client-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+wayland-client-devel.sha256sum] = "be4f85f33b3a7c6369c2bf62f191154c9b9ccd3becf4c7d69b4c5d519115d093"

URI_aarch64_rust-wayland-protocols-wlr+wayland-server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+wayland-server-devel-0.3.8-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+wayland-server-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+wayland-server-devel.sha256sum] = "0bd5ebc3ad8cea1473b3f09f4e7606b87bd18c022eed342d7ee74ebc7b5a0282"

URI_aarch64_rust-wayland-protocols-wlr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr-devel-0.3.8-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr-devel.sha256sum] = "3eed35d58f2035b95128d59f140a62895da5ba0a6b2abaca4ad7d323e2368280"

RDEPENDS:rust-wayland-protocols-wlr+client-devel = " \
 cargo \
 rust-wayland-protocols+client-devel \
 rust-wayland-protocols-wlr+wayland-client-devel \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+default-devel = " \
 cargo \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+server-devel = " \
 cargo \
 rust-wayland-protocols+server-devel \
 rust-wayland-protocols-wlr+wayland-server-devel \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+wayland-client-devel = " \
 cargo \
 rust-wayland-client+default-devel \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+wayland-server-devel = " \
 cargo \
 rust-wayland-protocols-wlr-devel \
 rust-wayland-server+default-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-protocols+default-devel \
 rust-wayland-scanner+default-devel \
 "
