# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml"
PV = "1.1.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-toml+debug-devel \
 rust-toml+default-devel \
 rust-toml+display-devel \
 rust-toml+fast_hash-devel \
 rust-toml+parse-devel \
 rust-toml+preserve_order-devel \
 rust-toml+serde-devel \
 rust-toml+std-devel \
 rust-toml+unbounded-devel \
 rust-toml-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-toml-1.1.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "08170da78e5b6a4c413fff77c1509f68edb62eaeedf046fa10a39616f1ef5856"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+debug-devel-1.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml+debug-devel.sha256sum] = "52f7760d393d39c19435b93a695998461fe80ab1f46f798bfdb2abdfd12d572d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+default-devel-1.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml+default-devel.sha256sum] = "687c6e7a53b136f1c2e40853bf72a0d06668d888b075c20c6a76b47eb312c95d"
RPROVIDES:rust-toml+default-devel:append:x86_64_v2 = " virtual/crate_toml/default__ge_0.6.0_with_crate_toml/default__lt_2.0.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+display-devel-1.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+display-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml+display-devel.sha256sum] = "63d72003c1e69a722da2b076872622803da057da62a6d642eb9ed7df9914de9f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+fast_hash-devel-1.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+fast_hash-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml+fast_hash-devel.sha256sum] = "9f4eea834e7ef43070eb06e155a97c36e8a7f203847f3b5289b7e89fff4efbc7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+parse-devel-1.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+parse-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml+parse-devel.sha256sum] = "1edba2bfeddfca01f91c2071a4a5c4312bd6945046c49c4d4ba1cf5894684fe9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+preserve_order-devel-1.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+preserve_order-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml+preserve_order-devel.sha256sum] = "7f0ec90c75fa117fb411f9e37cef3d581bc6b79191b968f11c5769034a3529b8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+serde-devel-1.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml+serde-devel.sha256sum] = "9da13e0c24137af61dca5667972b75858278b6a897132936ac0aa16a67f64ff2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+std-devel-1.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml+std-devel.sha256sum] = "5fcef58e7da4341e8eb89c5975e10682faf7484e951613bd3faf8f1e05131a86"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+unbounded-devel-1.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+unbounded-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml+unbounded-devel.sha256sum] = "6ea2b6165bcc314d8ab2948690f430ca2bf53d99251dcb2b200f9c86594fe0e5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml-devel-1.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml-devel.sha256sum] = "7a0854a105120b4866f9af794f026e0966b0994d95be3a7c691d89204fbeb2f8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+debug-devel-1.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-toml+debug-devel;unpack=0"
SRC_URI[aarch64_rust-toml+debug-devel.sha256sum] = "ac34a3a662ab878760161c5b1964b68c2cafb2be25750f0ea5240fa42dd2e2f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+default-devel-1.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-toml+default-devel;unpack=0"
SRC_URI[aarch64_rust-toml+default-devel.sha256sum] = "566dab17f387edd4bbd73f8ba2608680934963bc3d600863445a75e540883c70"
RPROVIDES:rust-toml+default-devel:append:aarch64 = " virtual/crate_toml/default__ge_0.6.0_with_crate_toml/default__lt_2.0.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+display-devel-1.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-toml+display-devel;unpack=0"
SRC_URI[aarch64_rust-toml+display-devel.sha256sum] = "ca89de81891c705ea13528b9e4c15ff18f05e91e91b3240656b9c5b5857db811"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+fast_hash-devel-1.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-toml+fast_hash-devel;unpack=0"
SRC_URI[aarch64_rust-toml+fast_hash-devel.sha256sum] = "73772e3a2668afc234738eca3044d3a80a1c7bbd36dc1dd4a8980f78c89c90ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+parse-devel-1.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-toml+parse-devel;unpack=0"
SRC_URI[aarch64_rust-toml+parse-devel.sha256sum] = "f7492a943ad564cd3e8d898ff271931f2eed69c8300977329f0cdfc38fd2e1ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+preserve_order-devel-1.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-toml+preserve_order-devel;unpack=0"
SRC_URI[aarch64_rust-toml+preserve_order-devel.sha256sum] = "00df9fa43eac01b43b2585f73e5fc77c9cfc99be3005ece9825d618427f3fe4f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+serde-devel-1.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-toml+serde-devel;unpack=0"
SRC_URI[aarch64_rust-toml+serde-devel.sha256sum] = "1782cbce0b15dd687299ca69a3f8b7c37018d8ebe14232a35a219a4ca0d62fbb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+std-devel-1.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-toml+std-devel;unpack=0"
SRC_URI[aarch64_rust-toml+std-devel.sha256sum] = "04b557c49b44012ce9b035ce7b4a517f46fba6f9e30498734847cb3e309be632"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+unbounded-devel-1.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-toml+unbounded-devel;unpack=0"
SRC_URI[aarch64_rust-toml+unbounded-devel.sha256sum] = "7320d1e19150e94c1345d11eab188ddd71ca5f4e542d5a8f836e08174dedff7b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml-devel-1.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-toml-devel;unpack=0"
SRC_URI[aarch64_rust-toml-devel.sha256sum] = "4ae6afdccf9885413c70305f855563749f7d5faea68d90b950d74e413e3f7879"

RDEPENDS:rust-toml+debug-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 rust-toml_parser+alloc-devel \
 rust-toml_parser+debug-devel \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml+default-devel = " \
 cargo \
 rust-toml+display-devel \
 rust-toml+parse-devel \
 rust-toml+serde-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 "
RDEPENDS:rust-toml+display-devel = " \
 cargo \
 rust-toml-devel \
 rust-toml_writer+alloc-devel \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml+fast_hash-devel = " \
 cargo \
 rust-foldhash-devel \
 rust-toml+preserve_order-devel \
 rust-toml-devel \
 "
RDEPENDS:rust-toml+parse-devel = " \
 cargo \
 rust-toml-devel \
 rust-toml_parser+alloc-devel \
 rust-toml_parser-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-toml+preserve_order-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 "
RDEPENDS:rust-toml+serde-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-serde_spanned+serde-devel \
 rust-toml-devel \
 rust-toml_datetime+serde-devel \
 "
RDEPENDS:rust-toml+std-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-serde_spanned+std-devel \
 rust-toml-devel \
 rust-toml_datetime+std-devel \
 rust-toml_parser+alloc-devel \
 rust-toml_parser+std-devel \
 rust-toml_parser-devel \
 rust-toml_writer+alloc-devel \
 rust-toml_writer+std-devel \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml+unbounded-devel = " \
 cargo \
 rust-toml-devel \
 "
RDEPENDS:rust-toml-devel = " \
 cargo \
 rust \
 rust-serde_spanned+alloc-devel \
 rust-serde_spanned-devel \
 rust-toml_datetime+alloc-devel \
 rust-toml_datetime-devel \
 "
