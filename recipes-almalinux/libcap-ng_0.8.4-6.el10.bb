# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcap-ng"
PV = "0.8.4"
PR = "6.el10"
PACKAGES = " \
 libcap-ng \
 libcap-ng-devel \
 libcap-ng-python3 \
 libcap-ng-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libcap-ng-0.8.4-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5d5ffe9aa35da49583680d4e4167a13412bd949d1229a09e07eda483d7abb28"

URI_x86_64_v2_libcap-ng = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcap-ng-0.8.4-6.el10.x86_64_v2.rpm;name=x86_64_v2_libcap-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap-ng}"
SRC_URI[x86_64_v2_libcap-ng.sha256sum] = "a652a668464ee57a3f71c0fa396c1851c760099362b6066202c747ecc101e0d6"

URI_x86_64_v2_libcap-ng-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcap-ng-devel-0.8.4-6.el10.x86_64_v2.rpm;name=x86_64_v2_libcap-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap-ng-devel}"
SRC_URI[x86_64_v2_libcap-ng-devel.sha256sum] = "ee7853ce21db03ad77ced89a0e06c628e80190fdc5f7a931b6f593e5dffb388a"

URI_x86_64_v2_libcap-ng-python3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcap-ng-python3-0.8.4-6.el10.x86_64_v2.rpm;name=x86_64_v2_libcap-ng-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap-ng-python3}"
SRC_URI[x86_64_v2_libcap-ng-python3.sha256sum] = "a3de8822559117af55410e5860701598b46f33471e8d88e3a0c43d7708c04513"

URI_x86_64_v2_libcap-ng-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcap-ng-utils-0.8.4-6.el10.x86_64_v2.rpm;name=x86_64_v2_libcap-ng-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap-ng-utils}"
SRC_URI[x86_64_v2_libcap-ng-utils.sha256sum] = "94a2f74a042379ec223c729fec7b5339a505182a85ee39e7c06f1343ee426ad3"

URI_aarch64_libcap-ng = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcap-ng-0.8.4-6.el10.aarch64.rpm;name=aarch64_libcap-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcap-ng}"
SRC_URI[aarch64_libcap-ng.sha256sum] = "7104ac4d6754efcee41b6afbf1dc1c38c3654eab4aa2ce221b3f3a754d522f95"

URI_aarch64_libcap-ng-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcap-ng-devel-0.8.4-6.el10.aarch64.rpm;name=aarch64_libcap-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcap-ng-devel}"
SRC_URI[aarch64_libcap-ng-devel.sha256sum] = "281e8aeaa0ee98774e506cc63e31d9e6d20dbf424f9568ff4bf917db29e96d22"

URI_aarch64_libcap-ng-python3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcap-ng-python3-0.8.4-6.el10.aarch64.rpm;name=aarch64_libcap-ng-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcap-ng-python3}"
SRC_URI[aarch64_libcap-ng-python3.sha256sum] = "e625758334729b4982af2713dc0fe33ccd75bb1f460e33f3aa0e8bc1a1e14f98"

URI_aarch64_libcap-ng-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcap-ng-utils-0.8.4-6.el10.aarch64.rpm;name=aarch64_libcap-ng-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcap-ng-utils}"
SRC_URI[aarch64_libcap-ng-utils.sha256sum] = "dacba1c83bc41e66204eacd6374d305211fdb426a6acabf6add57d0f2fcfe32e"

RDEPENDS:libcap-ng = " \
 glibc \
 "
RDEPENDS:libcap-ng-devel = " \
 kernel-headers \
 libcap-ng \
 pkgconf-pkg-config \
 "
RDEPENDS:libcap-ng-python3 = " \
 glibc \
 libcap-ng \
 python3 \
 "
RDEPENDS:libcap-ng-utils = " \
 glibc \
 libcap-ng \
 "
