# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ocserv"
PV = "1.3.0"
PR = "5.el10_0"
PACKAGES = " \
 ocserv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/ocserv-1.3.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8abcd08d70e55b28772e3a39f0ee5af322d2932bd12253994e2f5ce34c32ab5d"

URI_x86_64_v2_ocserv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ocserv-1.3.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ocserv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocserv}"
SRC_URI[x86_64_v2_ocserv.sha256sum] = "3fcc104cbef6646cc1d3b31d8b88a1bdc0052d449f773da16fe4b04fb4b5a9d3"

URI_aarch64_ocserv = "${EPEL_MIRROR}/aarch64/Packages/o/ocserv-1.3.0-5.el10_0.aarch64.rpm;name=aarch64_ocserv;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocserv}"
SRC_URI[aarch64_ocserv.sha256sum] = "0b4a9ffb996ed3fd54f5539bd9ab5c1e78612f6d9458f3c5ed943ccdd8897fd1"

RDEPENDS:ocserv:x86_64_v2 = " \
 bash \
 glibc \
 gnutls \
 krb5-libs \
 libev \
 libmaxminddb \
 libnl3 \
 liboath \
 libseccomp \
 libtalloc \
 libtasn1 \
 libxcrypt \
 llhttp \
 lz4-libs \
 nettle \
 pam-libs \
 protobuf-c \
 radcli \
 readline \
 shadow-utils \
 systemd \
 systemd-libs \
"
RDEPENDS:ocserv:aarch64 = " \
 bash \
 glibc \
 gnutls \
 krb5-libs \
 libev \
 libmaxminddb \
 libnl3 \
 liboath \
 libtalloc \
 libtasn1 \
 libxcrypt \
 llhttp \
 lz4-libs \
 nettle \
 pam-libs \
 protobuf-c \
 radcli \
 readline \
 shadow-utils \
 systemd \
 systemd-libs \
"
