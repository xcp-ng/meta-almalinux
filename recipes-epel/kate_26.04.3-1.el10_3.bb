# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kate"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kate \
 kate-libs \
 kate-plugins \
 kwrite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kate-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a83115b41a10516fbb4e1bc5df049eb0d9101992f99e28c5ea270d24cfb122b1"

URI_x86_64_v2_kate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kate}"
SRC_URI[x86_64_v2_kate.sha256sum] = "6fd948739921de7def9ad6f272915ddc8ebc9e18ebba488418e64e86821f47d0"

URI_x86_64_v2_kate-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kate-libs}"
SRC_URI[x86_64_v2_kate-libs.sha256sum] = "42475e60e6161936cf1809e3cb4e525f4d0c0e240d2c378b090ff22b78adff73"

URI_x86_64_v2_kate-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-plugins-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kate-plugins}"
SRC_URI[x86_64_v2_kate-plugins.sha256sum] = "4edeb49954118dcb8d6824728863c38ce2c351d98c228942c56c7a4242c6badb"

URI_x86_64_v2_kwrite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwrite-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwrite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwrite}"
SRC_URI[x86_64_v2_kwrite.sha256sum] = "14b2fa68b737f1a4dfb860d74f840dcc2cdd2216691e69e5478aab2f5ac881e4"

URI_aarch64_kate = "${EPEL_MIRROR}/aarch64/Packages/k/kate-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kate;unpack=0"
SRC_URI:append = " ${URI_aarch64_kate}"
SRC_URI[aarch64_kate.sha256sum] = "c6be630e80f9911ffdf0f56db48a05aa1b02153c867b9804ad8e6b073f071555"

URI_aarch64_kate-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kate-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kate-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kate-libs}"
SRC_URI[aarch64_kate-libs.sha256sum] = "95763940e36f031d2e715df47815687d04b57ef10f166b488de19c1556c8ee48"

URI_aarch64_kate-plugins = "${EPEL_MIRROR}/aarch64/Packages/k/kate-plugins-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kate-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_kate-plugins}"
SRC_URI[aarch64_kate-plugins.sha256sum] = "8ef18773adea5fff15e513d799e74a1b09a72ab48e319d22a04758041c49c3bb"

URI_aarch64_kwrite = "${EPEL_MIRROR}/aarch64/Packages/k/kwrite-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kwrite;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwrite}"
SRC_URI[aarch64_kwrite.sha256sum] = "b9d597230c1752054d5247f54ceb31d0d05a18be15e3f76e2dcd7bbc397be014"

RDEPENDS:kate = " \
 glibc \
 kate-libs \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kate-libs = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kate-plugins = " \
 bash \
 glibc \
 kate \
 kate-libs \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-kparts \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qtkeychain-qt6 \
 "
RDEPENDS:kwrite = " \
 glibc \
 kate-libs \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
