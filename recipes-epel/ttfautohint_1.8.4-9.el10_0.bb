# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ttfautohint"
PV = "1.8.4"
PR = "9.el10_0"
PACKAGES = " \
 ttfautohint \
 ttfautohint-devel \
 ttfautohint-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/ttfautohint-1.8.4-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "135e8a4bb68a8cc91d6a953acb971c5c3d71505d6b1cb0653f0172b52a89810a"

URI_x86_64_v2_ttfautohint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ttfautohint-1.8.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ttfautohint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ttfautohint}"
SRC_URI[x86_64_v2_ttfautohint.sha256sum] = "67044bda94f965b6afc526ee0dabd60a7655c547c6799909488c65bd9d21dec6"

URI_x86_64_v2_ttfautohint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ttfautohint-devel-1.8.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ttfautohint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ttfautohint-devel}"
SRC_URI[x86_64_v2_ttfautohint-devel.sha256sum] = "b5be5e5d2aa52b5dd6b7a039b0d00fb53fb8e5529b2a26a60a3dbde4aefa13b4"

URI_x86_64_v2_ttfautohint-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ttfautohint-libs-1.8.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ttfautohint-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ttfautohint-libs}"
SRC_URI[x86_64_v2_ttfautohint-libs.sha256sum] = "44b5b64128806daf80c1d592c9007fe84dcf6a151bd87aa35c41bc90ed6e0302"

URI_aarch64_ttfautohint = "${EPEL_MIRROR}/aarch64/Packages/t/ttfautohint-1.8.4-9.el10_0.aarch64.rpm;name=aarch64_ttfautohint;unpack=0"
SRC_URI:append = " ${URI_aarch64_ttfautohint}"
SRC_URI[aarch64_ttfautohint.sha256sum] = "14419519e2904ed8185de8506a30f54c9d9a6c162f55e55d5b0f81f11240c088"

URI_aarch64_ttfautohint-devel = "${EPEL_MIRROR}/aarch64/Packages/t/ttfautohint-devel-1.8.4-9.el10_0.aarch64.rpm;name=aarch64_ttfautohint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ttfautohint-devel}"
SRC_URI[aarch64_ttfautohint-devel.sha256sum] = "041f0f9d918e369b9338e49bac2dcf3cf71bd3ad272db6630e9d59af719cc6fa"

URI_aarch64_ttfautohint-libs = "${EPEL_MIRROR}/aarch64/Packages/t/ttfautohint-libs-1.8.4-9.el10_0.aarch64.rpm;name=aarch64_ttfautohint-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ttfautohint-libs}"
SRC_URI[aarch64_ttfautohint-libs.sha256sum] = "72f5c9c103e94bb834d6a4b5aa28102757752a37e966f29db1fb4f5f57a4fa48"

RDEPENDS:ttfautohint = " \
 freetype \
 glibc \
 libgcc \
 libstdc++ \
 ttfautohint-libs \
 "
RDEPENDS:ttfautohint-devel = " \
 freetype-devel \
 harfbuzz-devel \
 pkgconf-pkg-config \
 ttfautohint-libs \
 "
RDEPENDS:ttfautohint-libs = " \
 freetype \
 glibc \
 harfbuzz \
 "
