# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "autojump"
PV = "22.5.3"
PR = "24.el10_2"
PACKAGES = " \
 autojump \
 autojump-fish \
 autojump-zsh \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/autojump-22.5.3-24.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1eccc8b0b87cfd2caff52436cdcfa3adc8952efa86a1677ae05215113fdf606"

URI_x86_64_v2_autojump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/autojump-22.5.3-24.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_autojump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_autojump}"
SRC_URI[x86_64_v2_autojump.sha256sum] = "60dda5c23238e3e31bb4da58471636fcbd33912afb6247500d33a3ecb11f4bb5"

URI_x86_64_v2_autojump-fish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/autojump-fish-22.5.3-24.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_autojump-fish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_autojump-fish}"
SRC_URI[x86_64_v2_autojump-fish.sha256sum] = "381f57b89a16f7c455ce02d5da647d4a376fe86dfcef944aeaa834d0312ddf9a"

URI_x86_64_v2_autojump-zsh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/autojump-zsh-22.5.3-24.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_autojump-zsh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_autojump-zsh}"
SRC_URI[x86_64_v2_autojump-zsh.sha256sum] = "3e7c4b77f1dda7b05aa84ebbd370ab523daf485667c42bbe143875b3ae184813"

URI_aarch64_autojump = "${EPEL_MIRROR}/aarch64/Packages/a/autojump-22.5.3-24.el10_2.noarch.rpm;name=aarch64_autojump;unpack=0"
SRC_URI:append = " ${URI_aarch64_autojump}"
SRC_URI[aarch64_autojump.sha256sum] = "aca2b44246391b1abdfd0211d695aa58198a65b5e19a2daa4b75cc41b2d284fa"

URI_aarch64_autojump-fish = "${EPEL_MIRROR}/aarch64/Packages/a/autojump-fish-22.5.3-24.el10_2.noarch.rpm;name=aarch64_autojump-fish;unpack=0"
SRC_URI:append = " ${URI_aarch64_autojump-fish}"
SRC_URI[aarch64_autojump-fish.sha256sum] = "7653a44b96a83ec7ea282c782ec920fad5bea9ca322ab1a4951a1b24250e4db0"

URI_aarch64_autojump-zsh = "${EPEL_MIRROR}/aarch64/Packages/a/autojump-zsh-22.5.3-24.el10_2.noarch.rpm;name=aarch64_autojump-zsh;unpack=0"
SRC_URI:append = " ${URI_aarch64_autojump-zsh}"
SRC_URI[aarch64_autojump-zsh.sha256sum] = "cdd0ec62e54a534eff9cdc65940d7afd5496a87c2d6fcb21b3f32a2d6410e5ce"

RDEPENDS:autojump = " \
 python3 \
 "
RDEPENDS:autojump-fish = " \
 autojump \
 "
RDEPENDS:autojump-zsh = " \
 autojump \
 "
