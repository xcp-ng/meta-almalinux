# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-integer"
PV = "0.1.47"
PR = "1.el10_2"
PACKAGES = " \
 rust-num-integer+default-devel \
 rust-num-integer+i128-devel \
 rust-num-integer+std-devel \
 rust-num-integer-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-num-integer-0.1.47-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ceb3e8ce3bf338bc531936dcf43504c2e9cbf9e3adf450af7ede2192b3f37939"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer+default-devel-0.1.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-num-integer+default-devel.sha256sum] = "40f9da8cfce5a214c79cf84f8c69a225418c35cec190a27d26e14d2c7fd6ee3f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer+i128-devel-0.1.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer+i128-devel;unpack=0"
SRC_URI[x86_64_v2_rust-num-integer+i128-devel.sha256sum] = "e2490b618ce68425932446c92b72b84068699441529b65a6ba0aa61cb5672acd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer+std-devel-0.1.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-num-integer+std-devel.sha256sum] = "3fb8fb37ff093cb418f5492242ecee6bacf3546a867779fddd5e2e506bf5564c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer-devel-0.1.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer-devel;unpack=0"
SRC_URI[x86_64_v2_rust-num-integer-devel.sha256sum] = "e97333cb367ab9d2599059e5d63324ab957a115616e203d3b83c0704981af5d2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer+default-devel-0.1.47-1.el10_2.noarch.rpm;name=aarch64_rust-num-integer+default-devel;unpack=0"
SRC_URI[aarch64_rust-num-integer+default-devel.sha256sum] = "c1e3d1a5f71dbae4df461059550d5a8aa9a9269475feb8ccc8efe879c7a1a8f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer+i128-devel-0.1.47-1.el10_2.noarch.rpm;name=aarch64_rust-num-integer+i128-devel;unpack=0"
SRC_URI[aarch64_rust-num-integer+i128-devel.sha256sum] = "ab64857ebc07a598afa71885da31f0657b52cddc69310a582445617b24cc1cb7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer+std-devel-0.1.47-1.el10_2.noarch.rpm;name=aarch64_rust-num-integer+std-devel;unpack=0"
SRC_URI[aarch64_rust-num-integer+std-devel.sha256sum] = "82ce3759389cb0b18633358ecbaf76d02c829d8ef471a4ccf8b9f18c6e614324"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer-devel-0.1.47-1.el10_2.noarch.rpm;name=aarch64_rust-num-integer-devel;unpack=0"
SRC_URI[aarch64_rust-num-integer-devel.sha256sum] = "0483f58ccbf03fc804b87f0caaf29894be8dcf44f76e475068bb89e7e920d1d1"

RDEPENDS:rust-num-integer+default-devel = " \
 cargo \
 rust-num-integer+std-devel \
 rust-num-integer-devel \
 "
RDEPENDS:rust-num-integer+i128-devel = " \
 cargo \
 rust-num-integer-devel \
 "
RDEPENDS:rust-num-integer+std-devel = " \
 cargo \
 rust-num-integer-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-num-integer-devel = " \
 cargo \
 rust \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
