# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-nxadm-tail"
PV = "1.4.11"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-nxadm-tail \
 golang-github-nxadm-tail-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-nxadm-tail-1.4.11-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9405e19f067355fb8cc306b625b3f047686d8f6441931068ea609209acc307a7"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-github-nxadm-tail-devel: golang(gopkg.in/tomb.v1)

URI_x86_64_v2_golang-github-nxadm-tail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-nxadm-tail-1.4.11-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-nxadm-tail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-nxadm-tail}"
SRC_URI[x86_64_v2_golang-github-nxadm-tail.sha256sum] = "99a4a8a607c180f9b704019d024d4b7317408962c0e99ac60b51852c5255f953"

URI_x86_64_v2_golang-github-nxadm-tail-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-nxadm-tail-devel-1.4.11-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-nxadm-tail-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-nxadm-tail-devel}"
SRC_URI[x86_64_v2_golang-github-nxadm-tail-devel.sha256sum] = "12058cee0562f87e89ae25e02e189ffaafe61af043c0230070c410e4f5024df9"

URI_aarch64_golang-github-nxadm-tail = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-nxadm-tail-1.4.11-6.el10_0.aarch64.rpm;name=aarch64_golang-github-nxadm-tail;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-nxadm-tail}"
SRC_URI[aarch64_golang-github-nxadm-tail.sha256sum] = "80ca1d48fee8be17417618159e8fa785718a01ddf65f2f531016adbd6be05bee"

URI_aarch64_golang-github-nxadm-tail-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-nxadm-tail-devel-1.4.11-6.el10_0.noarch.rpm;name=aarch64_golang-github-nxadm-tail-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-nxadm-tail-devel}"
SRC_URI[aarch64_golang-github-nxadm-tail-devel.sha256sum] = "b167a77562d4cc48442a44e94b93ef8beaccaa98e4361541a68e1c6489d939ff"

RDEPENDS:golang-github-nxadm-tail = " \
 glibc \
 "
RDEPENDS:golang-github-nxadm-tail-devel:x86_64_v2 = " \
 go-filesystem \
 golang-github-fsnotify-devel \
"
RDEPENDS:golang-github-nxadm-tail-devel:aarch64 = " \
 go-filesystem \
 golang-github-fsnotify-devel \
 golang-gopkg-tomb-1-devel \
"
