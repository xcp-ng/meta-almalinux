# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derive_arbitrary"
PV = "1.4.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-derive_arbitrary+default-devel \
 rust-derive_arbitrary-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-derive_arbitrary-1.4.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "308a307b9e67b0f8813d48614ef7b0b3cea6de081b94cf9914a63a95a9990fb4"

URI_x86_64_v2_rust-derive_arbitrary+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_arbitrary+default-devel-1.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_arbitrary+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_arbitrary+default-devel}"
SRC_URI[x86_64_v2_rust-derive_arbitrary+default-devel.sha256sum] = "fa36f9baac5d1f8fdcafcabb6fc7996073c10c67a7c5802b36e35942f7fc49aa"

URI_x86_64_v2_rust-derive_arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_arbitrary-devel-1.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_arbitrary-devel}"
SRC_URI[x86_64_v2_rust-derive_arbitrary-devel.sha256sum] = "98fa2fdf1026b94404f0b10fd009f79e9c8a3baf47f8b5e17bf03c208507f381"

URI_aarch64_rust-derive_arbitrary+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_arbitrary+default-devel-1.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-derive_arbitrary+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_arbitrary+default-devel}"
SRC_URI[aarch64_rust-derive_arbitrary+default-devel.sha256sum] = "b953e57b26a932c3e271fae4623ac48bbf3ea34004a198852ebe2640cf73e4e4"

URI_aarch64_rust-derive_arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_arbitrary-devel-1.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-derive_arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_arbitrary-devel}"
SRC_URI[aarch64_rust-derive_arbitrary-devel.sha256sum] = "6c54420c3145b2d5cb9a662b2c142b1dfafeaf6f921d9a3525a5ad798ddd9ce9"

RDEPENDS:rust-derive_arbitrary+default-devel = " \
 cargo \
 rust-derive_arbitrary-devel \
 "
RDEPENDS:rust-derive_arbitrary-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+parsing-devel \
 "
