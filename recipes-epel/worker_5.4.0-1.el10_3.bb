# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "worker"
PV = "5.4.0"
PR = "1.el10_3"
PACKAGES = " \
 worker \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/worker-5.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "53f92434aa3250fb445c95c8f658e72b8d81455856b8fe7111f6561c749cf551"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/worker-5.4.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_worker;unpack=0"
SRC_URI[x86_64_v2_worker.sha256sum] = "6ca39fc4e06ba18c345b4a73c0d6f313d1d7504d130adf72499a7a0890214601"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/worker-5.4.0-1.el10_3.aarch64.rpm;name=aarch64_worker;unpack=0"
SRC_URI[aarch64_worker.sha256sum] = "1cfb92af5dbd6464b8885312cc3fa616a57563a3c8b3a6d9659bdb55625ac6d0"

RDEPENDS:worker = " \
 bash \
 dbus-libs \
 file-libs \
 glibc \
 imlib2 \
 libX11 \
 libXft \
 libXinerama \
 libgcc \
 libstdc++ \
 lua-libs \
 openssl-libs \
 python3 \
 "
