# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xsd"
PV = "4.1.0"
PR = "0.15.a11.el10_0"
PACKAGES = " \
 xsd \
 xsd-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xsd-4.1.0-0.15.a11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d23ee6554ad6a50ee2125e4d1afc893e9dc3368e5b6aa91da3b199d9a92c1d7"

URI_x86_64_v2_xsd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xsd-4.1.0-0.15.a11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xsd}"
SRC_URI[x86_64_v2_xsd.sha256sum] = "75564bcca306495e3d48bb702ce4f00f75baec58d1f29ca4722abb0fef2659df"

URI_x86_64_v2_xsd-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xsd-doc-4.1.0-0.15.a11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_xsd-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xsd-doc}"
SRC_URI[x86_64_v2_xsd-doc.sha256sum] = "aac6121c319079bc816ac0f9a306bd2b4dcc4377679b39f2f1475be3b0ba0513"

URI_aarch64_xsd = "${EPEL_MIRROR}/aarch64/Packages/x/xsd-4.1.0-0.15.a11.el10_0.aarch64.rpm;name=aarch64_xsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_xsd}"
SRC_URI[aarch64_xsd.sha256sum] = "e64af9c10d5c3ed9c3403e889b5a9a4ac5ba5def0689814afd73e09f7b2bef83"

URI_aarch64_xsd-doc = "${EPEL_MIRROR}/aarch64/Packages/x/xsd-doc-4.1.0-0.15.a11.el10_0.noarch.rpm;name=aarch64_xsd-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_xsd-doc}"
SRC_URI[aarch64_xsd-doc.sha256sum] = "ec2555ec4fd1f2a4216ea5cc7362c98c4b990863d5cc4b58afbb3116dae12377"

RDEPENDS:xsd = " \
 glibc \
 libcutl \
 libgcc \
 libstdc++ \
 xerces-c \
 "
RDEPENDS:xsd-doc = " \
 "
