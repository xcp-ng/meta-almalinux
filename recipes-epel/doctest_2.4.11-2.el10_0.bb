# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "doctest"
PV = "2.4.11"
PR = "2.el10_0"
PACKAGES = " \
 doctest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/doctest-2.4.11-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d29b8e23501c0917edf3ded0777b31f02154e5555a4fe3210452c40c559b1022"

URI_x86_64_v2_doctest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/doctest-devel-2.4.11-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_doctest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_doctest-devel}"
SRC_URI[x86_64_v2_doctest-devel.sha256sum] = "532d4328bdaf1f5a50820a8bf4d8aac2458b48e208c5e199526485e0fc3cb1b9"

URI_aarch64_doctest-devel = "${EPEL_MIRROR}/aarch64/Packages/d/doctest-devel-2.4.11-2.el10_0.aarch64.rpm;name=aarch64_doctest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_doctest-devel}"
SRC_URI[aarch64_doctest-devel.sha256sum] = "c966a8e0c7967297ebc889e280ef1956eca93defe5a10ffc7d81b62869e30182"

RDEPENDS:doctest-devel = " \
 cmake-filesystem \
 libstdc++-devel \
 "
