# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros0.28"
PV = "0.28.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-pyo3-macros0.28+default-devel \
 rust-pyo3-macros0.28+experimental-async-devel \
 rust-pyo3-macros0.28+experimental-inspect-devel \
 rust-pyo3-macros0.28+multiple-pymethods-devel \
 rust-pyo3-macros0.28-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros0.28-0.28.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8e536ba8800e24b41b29883dfea3348bbc0a831e2721967a4be9181c500bb44"

URI_x86_64_v2_rust-pyo3-macros0.28+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.28+default-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.28+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.28+default-devel.sha256sum] = "c2de306ca3aa42f4fa1f45aeee2b7ea08ba05d47e0cf1a401a9552078575453e"

URI_x86_64_v2_rust-pyo3-macros0.28+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.28+experimental-async-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.28+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.28+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.28+experimental-async-devel.sha256sum] = "8db6b22c741b6281cb3586377cea614b69607063c2c4b74ad942d693252d3373"

URI_x86_64_v2_rust-pyo3-macros0.28+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.28+experimental-inspect-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.28+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.28+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.28+experimental-inspect-devel.sha256sum] = "db876160e5c54af7fe594a320d65d3c68c9861ce557ef275d9039b1a3d9d5372"

URI_x86_64_v2_rust-pyo3-macros0.28+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.28+multiple-pymethods-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.28+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.28+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.28+multiple-pymethods-devel.sha256sum] = "e321d41cc249576c1e1e3c9472a4808e18d838aa58c9a3817fb92a868fd11983"

URI_x86_64_v2_rust-pyo3-macros0.28-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.28-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.28-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.28-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.28-devel.sha256sum] = "2d3bb5f4c3d9b98974526500ea9d1fee54c6790e75664238c7491f39c9947201"

URI_aarch64_rust-pyo3-macros0.28+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.28+default-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.28+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.28+default-devel.sha256sum] = "6b2fe6f357f8273129c1afb280ac7f4e32b1cfb5762029e3a3900f49890c367d"

URI_aarch64_rust-pyo3-macros0.28+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.28+experimental-async-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros0.28+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.28+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.28+experimental-async-devel.sha256sum] = "46f3be993a738ea300d6da2f64f634a1fc932f73b58bfdbb252544d318ca45bc"

URI_aarch64_rust-pyo3-macros0.28+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.28+experimental-inspect-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros0.28+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.28+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.28+experimental-inspect-devel.sha256sum] = "0d2fe30d782aab664e67e96aad7354d4e3874b0759ec8a05b0420c763602710f"

URI_aarch64_rust-pyo3-macros0.28+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.28+multiple-pymethods-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros0.28+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.28+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.28+multiple-pymethods-devel.sha256sum] = "71a61e2a7929ecaf8428486679e380b394f20ff1e1e7c26ea0191c28b9c5b9c5"

URI_aarch64_rust-pyo3-macros0.28-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.28-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros0.28-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.28-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.28-devel.sha256sum] = "5bd9a41387fa9f69f1fe75740d52f1a17fa5fec7cffc4ef8357aa8ecaeb37e8c"

RDEPENDS:rust-pyo3-macros0.28+default-devel = " \
 cargo \
 rust-pyo3-macros0.28-devel \
 "
RDEPENDS:rust-pyo3-macros0.28+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend0.28+experimental-async-devel \
 rust-pyo3-macros0.28-devel \
 "
RDEPENDS:rust-pyo3-macros0.28+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-macros-backend0.28+experimental-inspect-devel \
 rust-pyo3-macros0.28-devel \
 "
RDEPENDS:rust-pyo3-macros0.28+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros0.28-devel \
 "
RDEPENDS:rust-pyo3-macros0.28-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-pyo3-macros-backend0.28+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 "
