# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plutosvg"
PV = "0.0.7"
PR = "2.el10_0"
PACKAGES = " \
 plutosvg \
 plutosvg-devel \
 plutosvg-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plutosvg-0.0.7-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37ef83af1d74f577e5fc29cdc493da9d59006f7b3af8f43302681acb2e8a4d24"

URI_x86_64_v2_plutosvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutosvg-0.0.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutosvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutosvg}"
SRC_URI[x86_64_v2_plutosvg.sha256sum] = "d92cedfe1a794724c3159b7cbe976efc1ced7352c64ebddcf7821e4d4ba5f3db"

URI_x86_64_v2_plutosvg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutosvg-devel-0.0.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutosvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutosvg-devel}"
SRC_URI[x86_64_v2_plutosvg-devel.sha256sum] = "f7e0c83192a5f8197785178e8e7ba4dd00eb172a25fcecb3c833004af2cdcbdf"

URI_x86_64_v2_plutosvg-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutosvg-samples-0.0.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutosvg-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutosvg-samples}"
SRC_URI[x86_64_v2_plutosvg-samples.sha256sum] = "d40796c185d1d764d2b49e91bbb4982a2eea66361e88cf293b33623196f7f321"

URI_aarch64_plutosvg = "${EPEL_MIRROR}/aarch64/Packages/p/plutosvg-0.0.7-2.el10_0.aarch64.rpm;name=aarch64_plutosvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutosvg}"
SRC_URI[aarch64_plutosvg.sha256sum] = "ed1944a63049b65767a6fe5a11d9479e0d6a2ec19cc77fb411ddf3084fb24d8e"

URI_aarch64_plutosvg-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plutosvg-devel-0.0.7-2.el10_0.aarch64.rpm;name=aarch64_plutosvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutosvg-devel}"
SRC_URI[aarch64_plutosvg-devel.sha256sum] = "68da05615cf53a4380b1e3f814c4879254b6e051f43c95f0739ece968330ac7b"

URI_aarch64_plutosvg-samples = "${EPEL_MIRROR}/aarch64/Packages/p/plutosvg-samples-0.0.7-2.el10_0.aarch64.rpm;name=aarch64_plutosvg-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutosvg-samples}"
SRC_URI[aarch64_plutosvg-samples.sha256sum] = "b37c2c612c8739a3548fd120f6a0d2c96619118af42750bdae108aae637890fc"

RDEPENDS:plutosvg = " \
 freetype \
 glibc \
 plutovg \
 "
RDEPENDS:plutosvg-devel = " \
 cmake-filesystem \
 freetype-devel \
 pkgconf-pkg-config \
 plutosvg \
 plutovg-devel \
 "
RDEPENDS:plutosvg-samples = " \
 freetype \
 glibc \
 plutosvg \
 plutovg \
 "
