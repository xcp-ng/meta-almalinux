# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-glib2"
PV = "2.87.5"
PR = "1.el10"
PACKAGES = " \
 mingw32-glib2 \
 mingw32-glib2-static \
 mingw64-glib2 \
 mingw64-glib2-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mingw-glib2-2.87.5-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80f95b83e4de9bb9d47b708acc28aa9f460a2c61fa71cbb7775c6913fece951c"

URI_x86_64_v2_mingw32-glib2 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-glib2-2.87.5-1.el10.noarch.rpm;name=x86_64_v2_mingw32-glib2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-glib2}"
SRC_URI[x86_64_v2_mingw32-glib2.sha256sum] = "7fbc3814bba9759d9eeb72aed877592bd2d4aa143784ee56410abd50584ee01e"

URI_x86_64_v2_mingw32-glib2-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-glib2-static-2.87.5-1.el10.noarch.rpm;name=x86_64_v2_mingw32-glib2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-glib2-static}"
SRC_URI[x86_64_v2_mingw32-glib2-static.sha256sum] = "e3645f02cdc48462fa80dfe36efb5e26aca7667a358bb84fbf367d092195d728"

URI_x86_64_v2_mingw64-glib2 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-glib2-2.87.5-1.el10.noarch.rpm;name=x86_64_v2_mingw64-glib2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-glib2}"
SRC_URI[x86_64_v2_mingw64-glib2.sha256sum] = "2461399e0577b2a59a979be0db7afa16c69c18fcb2e93b36d78ce7f5b297f61c"

URI_x86_64_v2_mingw64-glib2-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-glib2-static-2.87.5-1.el10.noarch.rpm;name=x86_64_v2_mingw64-glib2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-glib2-static}"
SRC_URI[x86_64_v2_mingw64-glib2-static.sha256sum] = "a52c1f8df1731306c463cc88aa280610b37faaa2e1f32e0c65097f055b34c45a"

URI_aarch64_mingw32-glib2 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-glib2-2.87.5-1.el10.noarch.rpm;name=aarch64_mingw32-glib2;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-glib2}"
SRC_URI[aarch64_mingw32-glib2.sha256sum] = "7fbc3814bba9759d9eeb72aed877592bd2d4aa143784ee56410abd50584ee01e"

URI_aarch64_mingw32-glib2-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-glib2-static-2.87.5-1.el10.noarch.rpm;name=aarch64_mingw32-glib2-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-glib2-static}"
SRC_URI[aarch64_mingw32-glib2-static.sha256sum] = "e3645f02cdc48462fa80dfe36efb5e26aca7667a358bb84fbf367d092195d728"

URI_aarch64_mingw64-glib2 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-glib2-2.87.5-1.el10.noarch.rpm;name=aarch64_mingw64-glib2;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-glib2}"
SRC_URI[aarch64_mingw64-glib2.sha256sum] = "2461399e0577b2a59a979be0db7afa16c69c18fcb2e93b36d78ce7f5b297f61c"

URI_aarch64_mingw64-glib2-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-glib2-static-2.87.5-1.el10.noarch.rpm;name=aarch64_mingw64-glib2-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-glib2-static}"
SRC_URI[aarch64_mingw64-glib2-static.sha256sum] = "a52c1f8df1731306c463cc88aa280610b37faaa2e1f32e0c65097f055b34c45a"

RDEPENDS:mingw32-glib2 = " \
 bash \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-gettext \
 mingw32-libffi \
 mingw32-libgcc \
 mingw32-pcre2 \
 mingw32-zlib \
 python3 \
 "
RDEPENDS:mingw32-glib2-static = " \
 mingw32-gettext-static \
 mingw32-glib2 \
 "
RDEPENDS:mingw64-glib2 = " \
 bash \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-gettext \
 mingw64-libffi \
 mingw64-pcre2 \
 mingw64-zlib \
 python3 \
 "
RDEPENDS:mingw64-glib2-static = " \
 mingw64-gettext-static \
 mingw64-glib2 \
 "
