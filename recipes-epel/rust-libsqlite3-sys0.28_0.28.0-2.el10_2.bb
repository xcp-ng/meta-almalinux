# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libsqlite3-sys0.28"
PV = "0.28.0"
PR = "2.el10_2"
PACKAGES = " \
 rust-libsqlite3-sys0.28+buildtime_bindgen-devel \
 rust-libsqlite3-sys0.28+default-devel \
 rust-libsqlite3-sys0.28+min_sqlite_version_3_14_0-devel \
 rust-libsqlite3-sys0.28+preupdate_hook-devel \
 rust-libsqlite3-sys0.28+session-devel \
 rust-libsqlite3-sys0.28+unlock_notify-devel \
 rust-libsqlite3-sys0.28-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libsqlite3-sys0.28-0.28.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8a7cbdc8091c17b3885cc76a2d83de27b5761f3d370f533ae11e12390582750"

URI_x86_64_v2_rust-libsqlite3-sys0.28+buildtime_bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys0.28+buildtime_bindgen-devel-0.28.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys0.28+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys0.28+buildtime_bindgen-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys0.28+buildtime_bindgen-devel.sha256sum] = "83d0ff22342e2636a5decfdbd2fdafb6b8f5e0b6cd7955e89c16c747f3deeb5e"

URI_x86_64_v2_rust-libsqlite3-sys0.28+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys0.28+default-devel-0.28.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys0.28+default-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys0.28+default-devel.sha256sum] = "dd24bc70d7aba666fc0073d53217b1c77f2fa302691ee367c597d644f97a88db"

URI_x86_64_v2_rust-libsqlite3-sys0.28+min_sqlite_version_3_14_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys0.28+min_sqlite_version_3_14_0-devel-0.28.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys0.28+min_sqlite_version_3_14_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys0.28+min_sqlite_version_3_14_0-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys0.28+min_sqlite_version_3_14_0-devel.sha256sum] = "56fcf2c8c616f2351e2e5419366b3a64155f44d9042b8108ff014205e9f7b207"

URI_x86_64_v2_rust-libsqlite3-sys0.28+preupdate_hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys0.28+preupdate_hook-devel-0.28.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys0.28+preupdate_hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys0.28+preupdate_hook-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys0.28+preupdate_hook-devel.sha256sum] = "0114fad9ad12d2baf7a00f644791ece06bcffbea65f5de53c478b0d08c593168"

URI_x86_64_v2_rust-libsqlite3-sys0.28+session-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys0.28+session-devel-0.28.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys0.28+session-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys0.28+session-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys0.28+session-devel.sha256sum] = "eb39da318e3342b1e320ec51f44b94e0e6588d7cb72c72e8427d33b2bb608a80"

URI_x86_64_v2_rust-libsqlite3-sys0.28+unlock_notify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys0.28+unlock_notify-devel-0.28.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys0.28+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys0.28+unlock_notify-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys0.28+unlock_notify-devel.sha256sum] = "f4c485a573218239ae1df4bb1f47d9bcea1dc56dae06ada64a38db1d89c2e11e"

URI_x86_64_v2_rust-libsqlite3-sys0.28-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys0.28-devel-0.28.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys0.28-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys0.28-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys0.28-devel.sha256sum] = "ae1ec1fdc042195160bb92667fa8700b146eea30094d9f13eb175fade1c76806"

URI_aarch64_rust-libsqlite3-sys0.28+buildtime_bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys0.28+buildtime_bindgen-devel-0.28.0-2.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys0.28+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys0.28+buildtime_bindgen-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys0.28+buildtime_bindgen-devel.sha256sum] = "aad21f65cf8ac3ed41d9270e69228d8d77c2c17a9ee773e5f6dad1c8bd04f217"

URI_aarch64_rust-libsqlite3-sys0.28+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys0.28+default-devel-0.28.0-2.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys0.28+default-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys0.28+default-devel.sha256sum] = "2c191adbcce071d0c08ee617fdef7a47c8cd2479999c835367f0010cd21918bb"

URI_aarch64_rust-libsqlite3-sys0.28+min_sqlite_version_3_14_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys0.28+min_sqlite_version_3_14_0-devel-0.28.0-2.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys0.28+min_sqlite_version_3_14_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys0.28+min_sqlite_version_3_14_0-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys0.28+min_sqlite_version_3_14_0-devel.sha256sum] = "162f7a97514dc01bbf81293037e0b4e3908ef6e40870159ac8ee2e1ba655553c"

URI_aarch64_rust-libsqlite3-sys0.28+preupdate_hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys0.28+preupdate_hook-devel-0.28.0-2.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys0.28+preupdate_hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys0.28+preupdate_hook-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys0.28+preupdate_hook-devel.sha256sum] = "bd420ae342d21c28c6831402f9677eeaa65e8b31c93e79b4810f2b2ab8385660"

URI_aarch64_rust-libsqlite3-sys0.28+session-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys0.28+session-devel-0.28.0-2.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys0.28+session-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys0.28+session-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys0.28+session-devel.sha256sum] = "e7a6d64217dd1ec24273d8dd009b70515f9f1c890857c345b18a11e0596d5f9d"

URI_aarch64_rust-libsqlite3-sys0.28+unlock_notify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys0.28+unlock_notify-devel-0.28.0-2.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys0.28+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys0.28+unlock_notify-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys0.28+unlock_notify-devel.sha256sum] = "acb3a6f7fe2f65922992ebdc9c71cc9a0e1b8fec1c8bb461a154ea5d79274e39"

URI_aarch64_rust-libsqlite3-sys0.28-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys0.28-devel-0.28.0-2.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys0.28-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys0.28-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys0.28-devel.sha256sum] = "640e54d1998d2927440f62a96c89b212f2743879ef1de4374ea69cad0f73e41b"

RDEPENDS:rust-libsqlite3-sys0.28+buildtime_bindgen-devel = " \
 cargo \
 rust-libsqlite3-sys0.28-devel \
 "
RDEPENDS:rust-libsqlite3-sys0.28+default-devel = " \
 cargo \
 rust-libsqlite3-sys0.28+min_sqlite_version_3_14_0-devel \
 rust-libsqlite3-sys0.28-devel \
 "
RDEPENDS:rust-libsqlite3-sys0.28+min_sqlite_version_3_14_0-devel = " \
 cargo \
 rust-libsqlite3-sys0.28-devel \
 "
RDEPENDS:rust-libsqlite3-sys0.28+preupdate_hook-devel = " \
 cargo \
 rust-libsqlite3-sys0.28+buildtime_bindgen-devel \
 rust-libsqlite3-sys0.28-devel \
 "
RDEPENDS:rust-libsqlite3-sys0.28+session-devel = " \
 cargo \
 rust-libsqlite3-sys0.28+buildtime_bindgen-devel \
 rust-libsqlite3-sys0.28+preupdate_hook-devel \
 rust-libsqlite3-sys0.28-devel \
 "
RDEPENDS:rust-libsqlite3-sys0.28+unlock_notify-devel = " \
 cargo \
 rust-libsqlite3-sys0.28-devel \
 "
RDEPENDS:rust-libsqlite3-sys0.28-devel = " \
 cargo \
 rust-bindgen+runtime-devel \
 rust-bindgen-devel \
 rust-pkg-config+default-devel \
 sqlite-devel \
 "
