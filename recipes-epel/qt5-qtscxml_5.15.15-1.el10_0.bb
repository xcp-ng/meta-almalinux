# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtscxml"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtscxml \
 qt5-qtscxml-devel \
 qt5-qtscxml-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtscxml-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b17f2daa5425cc7afb3613338e238b890bf74ec404e0936b83cb304b45e9b56f"

URI_x86_64_v2_qt5-qtscxml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscxml-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtscxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscxml}"
SRC_URI[x86_64_v2_qt5-qtscxml.sha256sum] = "dccdd1f4fbd8c545c9d93fa3f96d8cbd9af20dfef1f94daa97db8d1853f777b6"

URI_x86_64_v2_qt5-qtscxml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscxml-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtscxml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscxml-devel}"
SRC_URI[x86_64_v2_qt5-qtscxml-devel.sha256sum] = "db80ec97a3b671ecac690599756643c72ffa96ee7bea6e62eddd20fdd0ff176c"

URI_x86_64_v2_qt5-qtscxml-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscxml-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtscxml-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscxml-examples}"
SRC_URI[x86_64_v2_qt5-qtscxml-examples.sha256sum] = "517725242d37b53c44d0f76f9aa08d8a3fa995f657e2ad56047b85aae3903bd1"

URI_aarch64_qt5-qtscxml = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscxml-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtscxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscxml}"
SRC_URI[aarch64_qt5-qtscxml.sha256sum] = "b094f4d22fe33a885bf57fee110727537f40a7ba40fde6a873a10a34fe0be8db"

URI_aarch64_qt5-qtscxml-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscxml-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtscxml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscxml-devel}"
SRC_URI[aarch64_qt5-qtscxml-devel.sha256sum] = "65f6c1c617beb59465905159b33c473dd0ba39212be220924ff31a5eda028395"

URI_aarch64_qt5-qtscxml-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscxml-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtscxml-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscxml-examples}"
SRC_URI[aarch64_qt5-qtscxml-examples.sha256sum] = "68c6a1b0443c6bded4fafbf110b93f4463a4f83f769e171634f9da16eaa95e58"

RDEPENDS:qt5-qtscxml = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtscxml-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtscxml \
 "
RDEPENDS:qt5-qtscxml-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtscxml \
 "
