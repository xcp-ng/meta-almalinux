# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "createrepo-agent"
PV = "0.5.1"
PR = "1.el10_2"
PACKAGES = " \
 createrepo-agent \
 python3-createrepo-agent \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/createrepo-agent-0.5.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af037b590354073bb74ed1027819f8ebe113aa99bf671c237dc7eb8580bfa5d1"

URI_x86_64_v2_createrepo-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/createrepo-agent-0.5.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_createrepo-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_createrepo-agent}"
SRC_URI[x86_64_v2_createrepo-agent.sha256sum] = "89b3d6d23b8e8912438cd8aeb5a98618f76fb1bc86418a45cb70a338af3e7c4f"

URI_x86_64_v2_python3-createrepo-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-createrepo-agent-0.5.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-createrepo-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-createrepo-agent}"
SRC_URI[x86_64_v2_python3-createrepo-agent.sha256sum] = "e9f50ab649c77dc9ba51263b148204a623de0fb45bee1bda29f2ea6e0597ab76"

URI_aarch64_createrepo-agent = "${EPEL_MIRROR}/aarch64/Packages/c/createrepo-agent-0.5.1-1.el10_2.aarch64.rpm;name=aarch64_createrepo-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_createrepo-agent}"
SRC_URI[aarch64_createrepo-agent.sha256sum] = "0bf3543344cf5b05e4c546783e820bb875dd61dd3f9352a0fc817a7d1f6f1516"

URI_aarch64_python3-createrepo-agent = "${EPEL_MIRROR}/aarch64/Packages/p/python3-createrepo-agent-0.5.1-1.el10_2.aarch64.rpm;name=aarch64_python3-createrepo-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-createrepo-agent}"
SRC_URI[aarch64_python3-createrepo-agent.sha256sum] = "c9bcf463a4587a1176b8a2789a8174d29da1f7696edf3b0be342d852c69a9c53"

RDEPENDS:createrepo-agent = " \
 createrepo_c-libs \
 glib2 \
 glibc \
 gpgme \
 libassuan \
 libgpg-error \
 "
RDEPENDS:python3-createrepo-agent = " \
 createrepo-agent \
 createrepo_c-libs \
 glib2 \
 glibc \
 gpgme \
 libassuan \
 libgpg-error \
 python3 \
 "
