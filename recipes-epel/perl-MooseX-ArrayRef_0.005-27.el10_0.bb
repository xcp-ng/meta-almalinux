# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MooseX-ArrayRef"
PV = "0.005"
PR = "27.el10_0"
PACKAGES = " \
 perl-MooseX-ArrayRef \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MooseX-ArrayRef-0.005-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c3d8596b4f8537efc2542de6fddb336b6b3c7a3a6525f2cddf6d4fd007ceeb6"

URI_x86_64_v2_perl-MooseX-ArrayRef = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MooseX-ArrayRef-0.005-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MooseX-ArrayRef;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MooseX-ArrayRef}"
SRC_URI[x86_64_v2_perl-MooseX-ArrayRef.sha256sum] = "08ab1b37ff129a8c9ff8334cb9e5d5c7c81c5c9454aadd5321d4f3f3f0b885a8"

URI_aarch64_perl-MooseX-ArrayRef = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MooseX-ArrayRef-0.005-27.el10_0.noarch.rpm;name=aarch64_perl-MooseX-ArrayRef;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MooseX-ArrayRef}"
SRC_URI[aarch64_perl-MooseX-ArrayRef.sha256sum] = "6698b386c8cce9960c6c5df342ce51f0fef584b77117c018351eebfc730681a4"

RDEPENDS:perl-MooseX-ArrayRef = " \
 perl-Moose \
 perl-MooseX-ArrayRef \
 perl-Scalar-List-Utils \
 perl-constant \
 perl-libs \
 "
