# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openssl"
PE = "1"
PV = "3.5.1"
PR = "7.el10_1.alma.1"
PACKAGES = " \
 openssl \
 openssl-devel \
 openssl-fips-provider \
 openssl-libs \
 openssl-perl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openssl-3.5.1-7.el10_1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8855b4a73b88409d3d68dd319f6708965096deaa90414c1d79877d3a49dc5e57"

URI_x86_64_v2_openssl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-3.5.1-7.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl}"
SRC_URI[x86_64_v2_openssl.sha256sum] = "e1f4d6d0227e7a9b385fc32056fa1351159bbcf9bdbd3e8b046b6fd67199eeb7"

URI_x86_64_v2_openssl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssl-devel-3.5.1-7.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-devel}"
SRC_URI[x86_64_v2_openssl-devel.sha256sum] = "efec8233a78c48beed3859e4fdc1988d5abe67b5270241a8ea1943bf047fad5d"

URI_x86_64_v2_openssl-fips-provider = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-fips-provider-3.5.1-7.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-fips-provider;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-fips-provider}"
SRC_URI[x86_64_v2_openssl-fips-provider.sha256sum] = "fc23e9c1b08a268ca9359639a8ac261b807a9515e613a1cbf4c3ea9e9aa56ae2"

URI_x86_64_v2_openssl-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-libs-3.5.1-7.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-libs}"
SRC_URI[x86_64_v2_openssl-libs.sha256sum] = "a52bfa06973e8a6a1a553ea1ef6e5ca3a7dc5317104c23365614f1268ff48677"

URI_x86_64_v2_openssl-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssl-perl-3.5.1-7.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-perl}"
SRC_URI[x86_64_v2_openssl-perl.sha256sum] = "422aa2e6605423d705390bbb677cf4dce053e71c02d1e770532682cd6329b1ad"

URI_aarch64_openssl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-3.5.1-7.el10_1.alma.1.aarch64.rpm;name=aarch64_openssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl}"
SRC_URI[aarch64_openssl.sha256sum] = "5600edd73b876692803321b1a5c4ed7470dbf8e47d5289080081e41f02d0790b"

URI_aarch64_openssl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssl-devel-3.5.1-7.el10_1.alma.1.aarch64.rpm;name=aarch64_openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-devel}"
SRC_URI[aarch64_openssl-devel.sha256sum] = "3523f929691232e0eb1e627d3cf45c6f548ddb5b13a11a64b569d11497a988cf"

URI_aarch64_openssl-fips-provider = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-fips-provider-3.5.1-7.el10_1.alma.1.aarch64.rpm;name=aarch64_openssl-fips-provider;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-fips-provider}"
SRC_URI[aarch64_openssl-fips-provider.sha256sum] = "14446c05497a88d83be393dbe39602435fe002ea4fc9e5d97cf7f08aa586205a"

URI_aarch64_openssl-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-libs-3.5.1-7.el10_1.alma.1.aarch64.rpm;name=aarch64_openssl-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-libs}"
SRC_URI[aarch64_openssl-libs.sha256sum] = "be956851803f7a37188ac52dfdcdcba56b2a2c7806be5a88fcb67619b5132b2e"

URI_aarch64_openssl-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssl-perl-3.5.1-7.el10_1.alma.1.aarch64.rpm;name=aarch64_openssl-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-perl}"
SRC_URI[aarch64_openssl-perl.sha256sum] = "917611d59595fd28bd2bb61c0b4293579baf2e1c6495c00500c005aeeb9403c0"

RDEPENDS:openssl = " \
 bash \
 glibc \
 openssl-libs \
 virtual/coreutils \
 "
RDEPENDS:openssl-devel = " \
 openssl-devel \
 openssl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openssl-fips-provider = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:openssl-libs = " \
 ca-certificates \
 crypto-policies \
 glibc \
 openssl-fips-provider \
 zlib-ng-compat \
 "
RDEPENDS:openssl-perl = " \
 openssl \
 perl-interpreter \
 "
