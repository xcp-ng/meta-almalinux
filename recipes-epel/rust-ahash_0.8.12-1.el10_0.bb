# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ahash"
PV = "0.8.12"
PR = "1.el10_0"
PACKAGES = " \
 rust-ahash+atomic-polyfill-devel \
 rust-ahash+compile-time-rng-devel \
 rust-ahash+const-random-devel \
 rust-ahash+default-devel \
 rust-ahash+getrandom-devel \
 rust-ahash+nightly-arm-aes-devel \
 rust-ahash+no-rng-devel \
 rust-ahash+runtime-rng-devel \
 rust-ahash+serde-devel \
 rust-ahash+std-devel \
 rust-ahash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ahash-0.8.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dda61db99e0d00fb102dc059c5686ae3ceeca16e21e2b66d2bc9246038054de7"

URI_x86_64_v2_rust-ahash+atomic-polyfill-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+atomic-polyfill-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+atomic-polyfill-devel}"
SRC_URI[x86_64_v2_rust-ahash+atomic-polyfill-devel.sha256sum] = "ae4a99ea9fb612a9fefcf58540308fb75dc412ac93f9a577baed1eeda7f246f9"

URI_x86_64_v2_rust-ahash+compile-time-rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+compile-time-rng-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+compile-time-rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+compile-time-rng-devel}"
SRC_URI[x86_64_v2_rust-ahash+compile-time-rng-devel.sha256sum] = "f2d358b43bf8f1120c1ca523fe9794b9fa0ba8a3e5b9687aa1f91d1b30b05935"

URI_x86_64_v2_rust-ahash+const-random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+const-random-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+const-random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+const-random-devel}"
SRC_URI[x86_64_v2_rust-ahash+const-random-devel.sha256sum] = "0c0e5ab0174468265abaa015f76be13f1e216bb11cbaaa5ab86ec9e5df41aaa8"

URI_x86_64_v2_rust-ahash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+default-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+default-devel}"
SRC_URI[x86_64_v2_rust-ahash+default-devel.sha256sum] = "95d5aa2b75fd4741f882e0180e95690524c7214a9bd40ed956edbea357b76de1"

URI_x86_64_v2_rust-ahash+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+getrandom-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+getrandom-devel}"
SRC_URI[x86_64_v2_rust-ahash+getrandom-devel.sha256sum] = "8b46e319cba8a1bfda50f4ec956aea1d67301d0c6210d86a5bcd514caaa07c2e"

URI_x86_64_v2_rust-ahash+nightly-arm-aes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+nightly-arm-aes-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+nightly-arm-aes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+nightly-arm-aes-devel}"
SRC_URI[x86_64_v2_rust-ahash+nightly-arm-aes-devel.sha256sum] = "a965fbff01ced8b11ad4b7ec3f6413dcc1de1c26ee7f29c14670057aacd3013c"

URI_x86_64_v2_rust-ahash+no-rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+no-rng-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+no-rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+no-rng-devel}"
SRC_URI[x86_64_v2_rust-ahash+no-rng-devel.sha256sum] = "e6bfadaf46814e2678d366fc8e5dbf2aa69cf5653ddf53ba8039539632369861"

URI_x86_64_v2_rust-ahash+runtime-rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+runtime-rng-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+runtime-rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+runtime-rng-devel}"
SRC_URI[x86_64_v2_rust-ahash+runtime-rng-devel.sha256sum] = "ff43cb72a8bdc253b0360adfd8b30f7b4592201d574631ff17d7d39120754526"

URI_x86_64_v2_rust-ahash+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+serde-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+serde-devel}"
SRC_URI[x86_64_v2_rust-ahash+serde-devel.sha256sum] = "4a436954ec40432cbfefa1bac5280c2847698d77dfa601e30c253447a29be7a6"

URI_x86_64_v2_rust-ahash+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+std-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+std-devel}"
SRC_URI[x86_64_v2_rust-ahash+std-devel.sha256sum] = "5757a721fcfc14faea09ff3476662f3149f4a5f7a2f7dffe9cc3aa26d2774237"

URI_x86_64_v2_rust-ahash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash-devel}"
SRC_URI[x86_64_v2_rust-ahash-devel.sha256sum] = "34b16f610fc904bdd71b7d6be4e16a8ba41cc214d77a21b19819fb674ceaffc4"

URI_aarch64_rust-ahash+atomic-polyfill-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+atomic-polyfill-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-ahash+atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+atomic-polyfill-devel}"
SRC_URI[aarch64_rust-ahash+atomic-polyfill-devel.sha256sum] = "467f749c783c201f1d5da984822413a39b8930324266c94da9a917a61cf55d71"

URI_aarch64_rust-ahash+compile-time-rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+compile-time-rng-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-ahash+compile-time-rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+compile-time-rng-devel}"
SRC_URI[aarch64_rust-ahash+compile-time-rng-devel.sha256sum] = "730fca4b164f630e9307d2ea6bfd300fec7e4184201bb5d00fcfed3d5314bc6a"

URI_aarch64_rust-ahash+const-random-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+const-random-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-ahash+const-random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+const-random-devel}"
SRC_URI[aarch64_rust-ahash+const-random-devel.sha256sum] = "06da455804f8c27fa5397e362cd4052f5a81227536db51e6c49a479573cdd3f7"

URI_aarch64_rust-ahash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+default-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-ahash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+default-devel}"
SRC_URI[aarch64_rust-ahash+default-devel.sha256sum] = "7d1ae3aebf97ee1945fc4ee154f63987a8b327285f9fa0bec52e8cf92b330ede"

URI_aarch64_rust-ahash+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+getrandom-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-ahash+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+getrandom-devel}"
SRC_URI[aarch64_rust-ahash+getrandom-devel.sha256sum] = "5f284ca349e1812cb9b3b286e96a7bd0e0d1b309af2ebb02770528a899421086"

URI_aarch64_rust-ahash+nightly-arm-aes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+nightly-arm-aes-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-ahash+nightly-arm-aes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+nightly-arm-aes-devel}"
SRC_URI[aarch64_rust-ahash+nightly-arm-aes-devel.sha256sum] = "3e4789a810e6d8283e763d473c2a7f5a53d78f082e2a61cc5c291772d8798959"

URI_aarch64_rust-ahash+no-rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+no-rng-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-ahash+no-rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+no-rng-devel}"
SRC_URI[aarch64_rust-ahash+no-rng-devel.sha256sum] = "b4ce39b16c50d820437af5cd981be884b94e59367a22494ad8424b5cd0e1ca4a"

URI_aarch64_rust-ahash+runtime-rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+runtime-rng-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-ahash+runtime-rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+runtime-rng-devel}"
SRC_URI[aarch64_rust-ahash+runtime-rng-devel.sha256sum] = "f3369fb918a37e6c22b309511745f8eb7417dc21861198d6a9e3540632ba39ff"

URI_aarch64_rust-ahash+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+serde-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-ahash+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+serde-devel}"
SRC_URI[aarch64_rust-ahash+serde-devel.sha256sum] = "278fbfa78e7fe75757ae63fb59ab90149170b5ed6499910bd41276065102d6c9"

URI_aarch64_rust-ahash+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+std-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-ahash+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+std-devel}"
SRC_URI[aarch64_rust-ahash+std-devel.sha256sum] = "5397775cd099ee36436856b8547410670dfa082ace82f6b120f0ab22b2c080b7"

URI_aarch64_rust-ahash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-ahash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash-devel}"
SRC_URI[aarch64_rust-ahash-devel.sha256sum] = "304946b37bc4406bfbecd189a670cea9b5b0549d8a10c34d1b92290c1305043b"

RDEPENDS:rust-ahash+atomic-polyfill-devel = " \
 cargo \
 rust-ahash-devel \
 rust-once_cell+critical-section-devel \
 rust-portable-atomic+default-devel \
 "
RDEPENDS:rust-ahash+compile-time-rng-devel = " \
 cargo \
 rust-ahash+const-random-devel \
 rust-ahash-devel \
 "
RDEPENDS:rust-ahash+const-random-devel = " \
 cargo \
 rust-ahash-devel \
 rust-const-random+default-devel \
 "
RDEPENDS:rust-ahash+default-devel = " \
 cargo \
 rust-ahash+runtime-rng-devel \
 rust-ahash+std-devel \
 rust-ahash-devel \
 "
RDEPENDS:rust-ahash+getrandom-devel = " \
 cargo \
 rust-ahash-devel \
 rust-getrandom+default-devel \
 "
RDEPENDS:rust-ahash+nightly-arm-aes-devel = " \
 cargo \
 rust-ahash-devel \
 "
RDEPENDS:rust-ahash+no-rng-devel = " \
 cargo \
 rust-ahash-devel \
 "
RDEPENDS:rust-ahash+runtime-rng-devel = " \
 cargo \
 rust-ahash+getrandom-devel \
 rust-ahash-devel \
 "
RDEPENDS:rust-ahash+serde-devel = " \
 cargo \
 rust-ahash-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-ahash+std-devel = " \
 cargo \
 rust-ahash-devel \
 "
RDEPENDS:rust-ahash-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-once_cell+alloc-devel \
 rust-once_cell-devel \
 rust-version_check+default-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy-devel \
 "
