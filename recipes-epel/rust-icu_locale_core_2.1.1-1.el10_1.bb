# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_locale_core"
PV = "2.1.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-icu_locale_core+alloc-devel \
 rust-icu_locale_core+databake-devel \
 rust-icu_locale_core+default-devel \
 rust-icu_locale_core+serde-devel \
 rust-icu_locale_core+zerovec-devel \
 rust-icu_locale_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_locale_core-2.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b44607df7cab6f75c092210a7aecd7133fdf81146dfadc9504b35a7e626957c4"

URI_x86_64_v2_rust-icu_locale_core+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core+alloc-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core+alloc-devel.sha256sum] = "5ec73480c5fa5f1e339e6977f341455936c72008644033d0eaf18916ac82d319"

URI_x86_64_v2_rust-icu_locale_core+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core+databake-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core+databake-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core+databake-devel.sha256sum] = "e38f2d01e07a0bbd45efa232b3f96a5780103740b85a6327f18ec668b44a0c29"

URI_x86_64_v2_rust-icu_locale_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core+default-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core+default-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core+default-devel.sha256sum] = "8d8e120c3548a6dd00d4ab4c5a90bce9d4846577f29705edde5249fcfc2fe125"

URI_x86_64_v2_rust-icu_locale_core+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core+serde-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core+serde-devel.sha256sum] = "344b3385cd6c9b5f4b7c4e20908525349fec86eb0c6a0f6f0a825e66e9fcbdfe"

URI_x86_64_v2_rust-icu_locale_core+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core+zerovec-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core+zerovec-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core+zerovec-devel.sha256sum] = "1549daf7cf76a95b7311663e55dd5ed23798ba626f16932e6f8f1e4805965455"

URI_x86_64_v2_rust-icu_locale_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_core-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_core-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_core-devel.sha256sum] = "733529875fc6687e108c9cba56fc633d54b907ba53468fa1c8d7210bd4469d35"

URI_aarch64_rust-icu_locale_core+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core+alloc-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_locale_core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core+alloc-devel}"
SRC_URI[aarch64_rust-icu_locale_core+alloc-devel.sha256sum] = "b5675164e2f5ad158022d9b39ba450988ce71e995663668f5f6b09ca72b0bbd3"

URI_aarch64_rust-icu_locale_core+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core+databake-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_locale_core+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core+databake-devel}"
SRC_URI[aarch64_rust-icu_locale_core+databake-devel.sha256sum] = "af7f0dc1af5c0eac3ffb4170f3940938d5ea23d6d9112a22981599090ca939d3"

URI_aarch64_rust-icu_locale_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core+default-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_locale_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core+default-devel}"
SRC_URI[aarch64_rust-icu_locale_core+default-devel.sha256sum] = "ddc879a00e5f62fbf3d09d8b0ccadac115a9334baca502d8ff6d9b59639e7299"

URI_aarch64_rust-icu_locale_core+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core+serde-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_locale_core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core+serde-devel}"
SRC_URI[aarch64_rust-icu_locale_core+serde-devel.sha256sum] = "9c16de315592388c1f02f61a6ba3b344707d04dbf748378c11061c9d11bc0cf9"

URI_aarch64_rust-icu_locale_core+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core+zerovec-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_locale_core+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core+zerovec-devel}"
SRC_URI[aarch64_rust-icu_locale_core+zerovec-devel.sha256sum] = "18e738561345a4b84943cecd06ddad2d2fe5ccb84e55ce91bff78a138010c524"

URI_aarch64_rust-icu_locale_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_core-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_locale_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_core-devel}"
SRC_URI[aarch64_rust-icu_locale_core-devel.sha256sum] = "aeae5daea94425e9c2a2fbdd0fc1c547aba339f5d4743c1db3fd1a265f132347"

RDEPENDS:rust-icu_locale_core+alloc-devel = " \
 cargo \
 rust-icu_locale_core-devel \
 rust-litemap+alloc-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-tinystr+alloc-devel \
 rust-writeable+alloc-devel \
 "
RDEPENDS:rust-icu_locale_core+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_locale_core+alloc-devel \
 rust-icu_locale_core-devel \
 "
RDEPENDS:rust-icu_locale_core+default-devel = " \
 cargo \
 rust-icu_locale_core-devel \
 "
RDEPENDS:rust-icu_locale_core+serde-devel = " \
 cargo \
 rust-icu_locale_core-devel \
 rust-serde-devel \
 rust-tinystr+serde-devel \
 "
RDEPENDS:rust-icu_locale_core+zerovec-devel = " \
 cargo \
 rust-icu_locale_core-devel \
 rust-tinystr+zerovec-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-icu_locale_core-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-litemap-devel \
 rust-tinystr-devel \
 rust-writeable-devel \
 "
