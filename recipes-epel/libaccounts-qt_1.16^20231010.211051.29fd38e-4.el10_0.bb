# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libaccounts-qt"
PV = "1.16^20231010.211051.29fd38e"
PR = "4.el10_0"
PACKAGES = " \
 libaccounts-qt-doc \
 libaccounts-qt5 \
 libaccounts-qt5-devel \
 libaccounts-qt6 \
 libaccounts-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libaccounts-qt-1.16^20231010.211051.29fd38e-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67438906cb78be4d65780682d73acdac5fd52de789fcacc8d6b98ccf29b86e5f"

URI_x86_64_v2_libaccounts-qt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaccounts-qt-doc-1.16^20231010.211051.29fd38e-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libaccounts-qt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaccounts-qt-doc}"
SRC_URI[x86_64_v2_libaccounts-qt-doc.sha256sum] = "f098f7adcb233dbc141d87cf160e2cf305b7e9c03f494633a1b56671402f4e06"

URI_x86_64_v2_libaccounts-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaccounts-qt5-1.16^20231010.211051.29fd38e-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaccounts-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaccounts-qt5}"
SRC_URI[x86_64_v2_libaccounts-qt5.sha256sum] = "946eb907167744e78744e363362a7a53b6ab5f2fa9023d490ffd398696a67392"

URI_x86_64_v2_libaccounts-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaccounts-qt5-devel-1.16^20231010.211051.29fd38e-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaccounts-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaccounts-qt5-devel}"
SRC_URI[x86_64_v2_libaccounts-qt5-devel.sha256sum] = "80b9257348d62743473948e63b63737ca52d6dee2fac3ddfbbec49bfca01dde4"

URI_x86_64_v2_libaccounts-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaccounts-qt6-1.16^20231010.211051.29fd38e-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaccounts-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaccounts-qt6}"
SRC_URI[x86_64_v2_libaccounts-qt6.sha256sum] = "5bc6e4ab2bde434df55fa6077ffecbfccefe6d3134c12d5475a2eda7008bfa87"

URI_x86_64_v2_libaccounts-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaccounts-qt6-devel-1.16^20231010.211051.29fd38e-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaccounts-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaccounts-qt6-devel}"
SRC_URI[x86_64_v2_libaccounts-qt6-devel.sha256sum] = "090b83eebca1f303941ff3dd048fb51ec028eef91a717738ae1bf1a978c69ecf"

URI_aarch64_libaccounts-qt-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libaccounts-qt-doc-1.16^20231010.211051.29fd38e-4.el10_0.noarch.rpm;name=aarch64_libaccounts-qt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaccounts-qt-doc}"
SRC_URI[aarch64_libaccounts-qt-doc.sha256sum] = "debdd45bec370a5deb59661f606baea61df58372732bddb8b10434cc713a142a"

URI_aarch64_libaccounts-qt5 = "${EPEL_MIRROR}/aarch64/Packages/l/libaccounts-qt5-1.16^20231010.211051.29fd38e-4.el10_0.aarch64.rpm;name=aarch64_libaccounts-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaccounts-qt5}"
SRC_URI[aarch64_libaccounts-qt5.sha256sum] = "6d3c0167c235d7b62265c3095cc91bb05b9326b3e09ebf84b79b81246b433d9a"

URI_aarch64_libaccounts-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libaccounts-qt5-devel-1.16^20231010.211051.29fd38e-4.el10_0.aarch64.rpm;name=aarch64_libaccounts-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaccounts-qt5-devel}"
SRC_URI[aarch64_libaccounts-qt5-devel.sha256sum] = "06873fe8c7b5b5a41567e33d8affe361af1ccd46d904618399d4eadd0578cfb3"

URI_aarch64_libaccounts-qt6 = "${EPEL_MIRROR}/aarch64/Packages/l/libaccounts-qt6-1.16^20231010.211051.29fd38e-4.el10_0.aarch64.rpm;name=aarch64_libaccounts-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaccounts-qt6}"
SRC_URI[aarch64_libaccounts-qt6.sha256sum] = "76f0948019eb4dabcb009ece6855b251fe5e5fc3de478234773e5a61ee3dd69c"

URI_aarch64_libaccounts-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libaccounts-qt6-devel-1.16^20231010.211051.29fd38e-4.el10_0.aarch64.rpm;name=aarch64_libaccounts-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaccounts-qt6-devel}"
SRC_URI[aarch64_libaccounts-qt6-devel.sha256sum] = "742d554b87c23fa7f9935cc1671c60770d0c23088f040a05376869ec231f8e48"

RDEPENDS:libaccounts-qt-doc = " \
 "
RDEPENDS:libaccounts-qt5 = " \
 glib2 \
 glibc \
 libaccounts-glib \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:libaccounts-qt5-devel = " \
 cmake-filesystem \
 libaccounts-qt5 \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 "
RDEPENDS:libaccounts-qt6 = " \
 glib2 \
 glibc \
 libaccounts-glib \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:libaccounts-qt6-devel = " \
 cmake-filesystem \
 libaccounts-qt6 \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
