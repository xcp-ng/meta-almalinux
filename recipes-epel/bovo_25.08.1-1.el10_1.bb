# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bovo"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 bovo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bovo-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8116e7765903d0972e0ae0c6e3393d0f82857e26bba07ccb9d008a8c367212fc"

URI_x86_64_v2_bovo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bovo-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bovo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bovo}"
SRC_URI[x86_64_v2_bovo.sha256sum] = "205ad0d9311323afb8632d98c245e8b54939ac97a9147d0b3d48793991cf4938"

URI_aarch64_bovo = "${EPEL_MIRROR}/aarch64/Packages/b/bovo-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_bovo;unpack=0"
SRC_URI:append = " ${URI_aarch64_bovo}"
SRC_URI[aarch64_bovo.sha256sum] = "d2304606f72a154ab8dcdabd0d24ea5f44e044117597cd3fdc719171b4b85d86"

RDEPENDS:bovo = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
