# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libayatana-appindicator"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 libayatana-appindicator-gtk3 \
 libayatana-appindicator-gtk3-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libayatana-appindicator-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "10d03c8b2bf133958e9c711a881f8224265a8d4948f271849b0394f2dc2c5ab8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-appindicator-gtk3-0.6.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-appindicator-gtk3;unpack=0"
SRC_URI[x86_64_v2_libayatana-appindicator-gtk3.sha256sum] = "32328c29fafd53568560f223e10b2b67f46b988e0f362fbfecfdf8781f23196e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-appindicator-gtk3-devel-0.6.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-appindicator-gtk3-devel;unpack=0"
SRC_URI[x86_64_v2_libayatana-appindicator-gtk3-devel.sha256sum] = "1a323157a5ddd61896887556e9266c66d3f0118e501ffd972f2f3e2d8dd1d86a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libayatana-appindicator-gtk3-0.6.0-1.el10_2.aarch64.rpm;name=aarch64_libayatana-appindicator-gtk3;unpack=0"
SRC_URI[aarch64_libayatana-appindicator-gtk3.sha256sum] = "d90b0235964451602e88ed576e48aa045ebbe113b69d1cd816a1211dcdc26975"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libayatana-appindicator-gtk3-devel-0.6.0-1.el10_2.aarch64.rpm;name=aarch64_libayatana-appindicator-gtk3-devel;unpack=0"
SRC_URI[aarch64_libayatana-appindicator-gtk3-devel.sha256sum] = "e8b75f2c379d74b761d6500c24ebfbce3fdab49ec27c027100b3baa9f3421477"

RDEPENDS:libayatana-appindicator-gtk3 = " \
 glib2 \
 glibc \
 gtk3 \
 libayatana-indicator-gtk3 \
 libdbusmenu \
 libdbusmenu-gtk3 \
 libgcc \
 "
RDEPENDS:libayatana-appindicator-gtk3-devel = " \
 glib2-devel \
 gtk3-devel \
 libayatana-appindicator-gtk3 \
 libayatana-indicator-gtk3-devel \
 libdbusmenu-devel \
 pkgconf-pkg-config \
 "
