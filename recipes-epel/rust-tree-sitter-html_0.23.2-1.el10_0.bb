# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-html"
PV = "0.23.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter-html+default-devel \
 rust-tree-sitter-html-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-html-0.23.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5cee0e4e7fba617e74dd59ea78916b5386e434b5a4bce79d1833a8fa3873b3f"

URI_x86_64_v2_rust-tree-sitter-html+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-html+default-devel-0.23.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-html+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-html+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-html+default-devel.sha256sum] = "81775484deb38b8fc92edba8004a2d0843fc379d7cf93a6ab6fd52dcc25da81b"

URI_x86_64_v2_rust-tree-sitter-html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-html-devel-0.23.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-html-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-html-devel.sha256sum] = "336d70278b7667d4a178831f03c066a70e767267ace962f0edfbaba6c8db3f02"

URI_aarch64_rust-tree-sitter-html+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-html+default-devel-0.23.2-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-html+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-html+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-html+default-devel.sha256sum] = "35cc3f53b725a20818c972af332e64c41a91d2107949515844a4311cc234e077"

URI_aarch64_rust-tree-sitter-html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-html-devel-0.23.2-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-html-devel}"
SRC_URI[aarch64_rust-tree-sitter-html-devel.sha256sum] = "4b20a61774c2245627e54004ba463670cedcc67b10ef1015b95673e7a10b42e3"

RDEPENDS:rust-tree-sitter-html+default-devel = " \
 cargo \
 rust-tree-sitter-html-devel \
 "
RDEPENDS:rust-tree-sitter-html-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
