# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-ucd-normal"
PV = "0.9.0"
PR = "4.el10_1"
PACKAGES = " \
 rust-unic-ucd-normal+default-devel \
 rust-unic-ucd-normal+unic-ucd-category-devel \
 rust-unic-ucd-normal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-ucd-normal-0.9.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "039f87112d768dfdbf4c5b296844a079f5ab54829d208251b279f07f5fc4370d"

URI_x86_64_v2_rust-unic-ucd-normal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-normal+default-devel-0.9.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-normal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-normal+default-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-normal+default-devel.sha256sum] = "ab5a6c56d731cca53fc7db3f77f9f19258aa6e8ae353b15da1dce393041c901a"

URI_x86_64_v2_rust-unic-ucd-normal+unic-ucd-category-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-normal+unic-ucd-category-devel-0.9.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-normal+unic-ucd-category-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-normal+unic-ucd-category-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-normal+unic-ucd-category-devel.sha256sum] = "abb0b14e776ddf69223b68aab126627da65f94f68becec48f3b6a3cc629e0dc1"

URI_x86_64_v2_rust-unic-ucd-normal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-normal-devel-0.9.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-normal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-normal-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-normal-devel.sha256sum] = "142288bcca3b7de7b3f31e974313eba0bcba2ccf456f86f80de088dbb37de4eb"

URI_aarch64_rust-unic-ucd-normal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-normal+default-devel-0.9.0-4.el10_1.noarch.rpm;name=aarch64_rust-unic-ucd-normal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-normal+default-devel}"
SRC_URI[aarch64_rust-unic-ucd-normal+default-devel.sha256sum] = "7897a8a76402bafc9686aadf946291b602151f6fd66e848c2c95f62f20e78c7f"

URI_aarch64_rust-unic-ucd-normal+unic-ucd-category-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-normal+unic-ucd-category-devel-0.9.0-4.el10_1.noarch.rpm;name=aarch64_rust-unic-ucd-normal+unic-ucd-category-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-normal+unic-ucd-category-devel}"
SRC_URI[aarch64_rust-unic-ucd-normal+unic-ucd-category-devel.sha256sum] = "5071e947d7bc7f4d6b74f62f92da9717a46b548babf9ad23d8b0411895f9bb29"

URI_aarch64_rust-unic-ucd-normal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-normal-devel-0.9.0-4.el10_1.noarch.rpm;name=aarch64_rust-unic-ucd-normal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-normal-devel}"
SRC_URI[aarch64_rust-unic-ucd-normal-devel.sha256sum] = "84fa43b37245eacc03ad8f0c31b0681c8ce4d3c9807fdf23d401f01448cd7cbb"

RDEPENDS:rust-unic-ucd-normal+default-devel = " \
 cargo \
 rust-unic-ucd-normal-devel \
 "
RDEPENDS:rust-unic-ucd-normal+unic-ucd-category-devel = " \
 cargo \
 rust-unic-ucd-category+default-devel \
 rust-unic-ucd-normal-devel \
 "
RDEPENDS:rust-unic-ucd-normal-devel = " \
 cargo \
 rust-unic-char-property+default-devel \
 rust-unic-char-range+default-devel \
 rust-unic-ucd-hangul+default-devel \
 rust-unic-ucd-version+default-devel \
 "
