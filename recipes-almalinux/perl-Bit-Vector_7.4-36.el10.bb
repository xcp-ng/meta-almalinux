# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Bit-Vector"
PV = "7.4"
PR = "36.el10"
PACKAGES = " \
 perl-Bit-Vector \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Bit-Vector-7.4-36.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8caa0245eb5246c5586d557bfaf1220ab8da278445a05a4decde8af989d32898"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Bit-Vector-7.4-36.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Bit-Vector;unpack=0"
SRC_URI[x86_64_v2_perl-Bit-Vector.sha256sum] = "23e09e749c9eaa73fcd3e910439f6efe3f78c15cfb7a10f0016614b10597edeb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Bit-Vector-7.4-36.el10.aarch64.rpm;name=aarch64_perl-Bit-Vector;unpack=0"
SRC_URI[aarch64_perl-Bit-Vector.sha256sum] = "9d1749ddc30b50197d6d89c8abbf139f3666969bb8442c952839c0c482b22ca7"

RDEPENDS:perl-Bit-Vector = " \
 glibc \
 perl-Carp-Clan \
 perl-DynaLoader \
 perl-Exporter \
 perl-Storable \
 perl-libs \
 perl-overload \
 perl-vars \
 "
