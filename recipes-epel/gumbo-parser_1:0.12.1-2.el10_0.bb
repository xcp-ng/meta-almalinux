# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gumbo-parser"
PE = "1"
PV = "0.12.1"
PR = "2.el10_0"
PACKAGES = " \
 gumbo-parser \
 gumbo-parser-devel \
 gumbo-parser-python \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gumbo-parser-0.12.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64bb715049c176ad684e126258c85c949ffadb547fd8b454fe30daebabbfadf1"

URI_x86_64_v2_gumbo-parser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gumbo-parser-0.12.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gumbo-parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gumbo-parser}"
SRC_URI[x86_64_v2_gumbo-parser.sha256sum] = "722bd3c04e600a80e6eb023303ca0a3e31abf6b82b326f9dfa9a0b5d25784df3"

URI_x86_64_v2_gumbo-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gumbo-parser-devel-0.12.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gumbo-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gumbo-parser-devel}"
SRC_URI[x86_64_v2_gumbo-parser-devel.sha256sum] = "f3a09dc1833c82f29601874f25be9eab03ba708f1f35131e76e8dbe90bf4b881"

URI_x86_64_v2_gumbo-parser-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gumbo-parser-python-0.12.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gumbo-parser-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gumbo-parser-python}"
SRC_URI[x86_64_v2_gumbo-parser-python.sha256sum] = "398d967c62e4bdb2b99e6649eb54acbdec5d30b4678580dd6d578683a00b22e3"

URI_aarch64_gumbo-parser = "${EPEL_MIRROR}/aarch64/Packages/g/gumbo-parser-0.12.1-2.el10_0.aarch64.rpm;name=aarch64_gumbo-parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_gumbo-parser}"
SRC_URI[aarch64_gumbo-parser.sha256sum] = "8b1a6912c7c32d86837bc04170f75cfe4a8067c1b497d95562dbea9242890306"

URI_aarch64_gumbo-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gumbo-parser-devel-0.12.1-2.el10_0.aarch64.rpm;name=aarch64_gumbo-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gumbo-parser-devel}"
SRC_URI[aarch64_gumbo-parser-devel.sha256sum] = "ab662ba43008663353c1579a07d756d11a0663f1a1546a33a2eff78b8c0e9ccc"

URI_aarch64_gumbo-parser-python = "${EPEL_MIRROR}/aarch64/Packages/g/gumbo-parser-python-0.12.1-2.el10_0.noarch.rpm;name=aarch64_gumbo-parser-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_gumbo-parser-python}"
SRC_URI[aarch64_gumbo-parser-python.sha256sum] = "fbd5ea6a2c54379ef77c6ab87d86a388aa94f9c3372a8b967480a39802e85843"

RDEPENDS:gumbo-parser = " \
 glibc \
 "
RDEPENDS:gumbo-parser-devel = " \
 gumbo-parser \
 pkgconf-pkg-config \
 "
RDEPENDS:gumbo-parser-python = " \
 gumbo-parser \
 python3 \
 "
