# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "acl"
PV = "2.4.0"
PR = "1.el10_2"
PACKAGES = " \
 acl \
 libacl \
 libacl-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/acl-2.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c905da8e019fbc329e55bc3cdaf583fe8752af195c7b79e5871b76e01bab1559"

URI_x86_64_v2_acl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/acl-2.4.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_acl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_acl}"
SRC_URI[x86_64_v2_acl.sha256sum] = "dcdb68523edff95c1de2b18f4d15f2e9c08e7327022710d26dabd6db8948e243"

URI_x86_64_v2_libacl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libacl-2.4.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libacl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libacl}"
SRC_URI[x86_64_v2_libacl.sha256sum] = "8bf96f1f5a7a092acc072010630f5ceaeee7bf5f8e297901ffb1f50f8a3e3caf"

URI_x86_64_v2_libacl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libacl-devel-2.4.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libacl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libacl-devel}"
SRC_URI[x86_64_v2_libacl-devel.sha256sum] = "41f2f7ee3a99cf1b0bd64f61d898b2f0b7e3708e37a94c325848114444509dd3"

URI_aarch64_acl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/acl-2.4.0-1.el10_2.aarch64.rpm;name=aarch64_acl;unpack=0"
SRC_URI:append = " ${URI_aarch64_acl}"
SRC_URI[aarch64_acl.sha256sum] = "146bcab115f8e05f5e0dab0ce0a6ac5e8236d884b7e920cac8ecbebc0fca7821"

URI_aarch64_libacl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libacl-2.4.0-1.el10_2.aarch64.rpm;name=aarch64_libacl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libacl}"
SRC_URI[aarch64_libacl.sha256sum] = "0fdc62b27f40226a86a52bb53ff4665214c634aa2b43da2244203f01026f9ab3"

URI_aarch64_libacl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libacl-devel-2.4.0-1.el10_2.aarch64.rpm;name=aarch64_libacl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libacl-devel}"
SRC_URI[aarch64_libacl-devel.sha256sum] = "61a99902cb231a69ddd2dc532e6b56432e34db886e1035ad4c69af00e07171b7"

RDEPENDS:acl = " \
 glibc \
 libacl \
 "
RDEPENDS:libacl = " \
 glibc \
 "
RDEPENDS:libacl-devel = " \
 libacl \
 libattr-devel \
 pkgconf-pkg-config \
 "
