# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-connect"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kde-connect \
 kde-connect-libs \
 kde-connect-nautilus \
 kdeconnectd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-connect-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64855550ad1d44775046a964b3cab180304b2e0152b8fa4d2b7509bb585e7793"

URI_x86_64_v2_kde-connect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-connect-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-connect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-connect}"
SRC_URI[x86_64_v2_kde-connect.sha256sum] = "de74a537fa40a3a2b7ca4e45cb7018ec6a4974ab43b3be60cf5477f2affaf379"

URI_x86_64_v2_kde-connect-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-connect-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-connect-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-connect-libs}"
SRC_URI[x86_64_v2_kde-connect-libs.sha256sum] = "e48a5bc5b29c320d1816353bce54fd7062808d50c8ac47b6d97fa42694446d94"

URI_x86_64_v2_kde-connect-nautilus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-connect-nautilus-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-connect-nautilus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-connect-nautilus}"
SRC_URI[x86_64_v2_kde-connect-nautilus.sha256sum] = "10aa848bb554a51c90fe5c42442d7180bfff2cdd9344093bd058f442bebff414"

URI_x86_64_v2_kdeconnectd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeconnectd-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdeconnectd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdeconnectd}"
SRC_URI[x86_64_v2_kdeconnectd.sha256sum] = "5efb50fb03fefd75790fb1dcab868ae251abcc36dfe8122f1a7ba524361bf3fc"

URI_aarch64_kde-connect = "${EPEL_MIRROR}/aarch64/Packages/k/kde-connect-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kde-connect;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-connect}"
SRC_URI[aarch64_kde-connect.sha256sum] = "35728f781d593fe1715884308243299d7154c502cc312fee6391215ea64202e1"

URI_aarch64_kde-connect-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kde-connect-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kde-connect-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-connect-libs}"
SRC_URI[aarch64_kde-connect-libs.sha256sum] = "411018fa653b2452a1664f99374d348bf86f97cb0afbb1d49b08b4a7e4159be5"

URI_aarch64_kde-connect-nautilus = "${EPEL_MIRROR}/aarch64/Packages/k/kde-connect-nautilus-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kde-connect-nautilus;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-connect-nautilus}"
SRC_URI[aarch64_kde-connect-nautilus.sha256sum] = "a6e7b1b695c54df5756de29b211f6231d623c5a8e150fc5f7be6221089b4f3e0"

URI_aarch64_kdeconnectd = "${EPEL_MIRROR}/aarch64/Packages/k/kdeconnectd-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdeconnectd;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdeconnectd}"
SRC_URI[aarch64_kdeconnectd.sha256sum] = "20cabe41fe0e2e9989e96a6e49edaee3e14655512b1d6f0ccb3ee818c7a77a92"

RDEPENDS:kde-connect = " \
 fuse-sshfs \
 glibc \
 kde-cli-tools \
 kde-connect-libs \
 kdeconnectd \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kpeople \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kf6-qqc2-desktop-style \
 libstdc++ \
 libwayland-client \
 qca-qt6-ossl \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kde-connect-libs = " \
 dbus-libs \
 glibc \
 kde-connect \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-modemmanager-qt \
 kf6-solid \
 libX11 \
 libXtst \
 libfakekey \
 libstdc++ \
 libxkbcommon \
 openssl-libs \
 pulseaudio-qt-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtconnectivity \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
RDEPENDS:kde-connect-nautilus = " \
 kdeconnectd \
 nautilus-python \
 "
RDEPENDS:kdeconnectd = " \
 glibc \
 kde-connect-libs \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-knotifications \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
