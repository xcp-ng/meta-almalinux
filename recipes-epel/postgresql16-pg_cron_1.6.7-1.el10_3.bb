# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql16-pg_cron"
PV = "1.6.7"
PR = "1.el10_3"
PACKAGES = " \
 postgresql16-pg_cron \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/postgresql16-pg_cron-1.6.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cde342995f1faa4935ee7531ba13ff9d4967465fbf4deea0889e09ce73fbf430"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/postgresql16-pg_cron-1.6.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_postgresql16-pg_cron;unpack=0"
SRC_URI[x86_64_v2_postgresql16-pg_cron.sha256sum] = "059091aa77a5f0a9b35fc090c0267e26535f6f39658af835db1a577583b45516"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/postgresql16-pg_cron-1.6.7-1.el10_3.aarch64.rpm;name=aarch64_postgresql16-pg_cron;unpack=0"
SRC_URI[aarch64_postgresql16-pg_cron.sha256sum] = "540b722dbc02b4a3c1d3ac3a1c811f56880248f663243a3f89b6886eaafa326a"

RDEPENDS:postgresql16-pg_cron = " \
 glibc \
 postgresql-private-libs \
 postgresql-server \
 "
