# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "a52dec"
PV = "0.7.4"
PR = "50.el10"
PACKAGES = " \
 a52dec \
 liba52 \
 liba52-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/a52dec-0.7.4-50.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "461491b5518f254e37c91eb60352ae25430ad526673fa65fa2bdf0cb15a7bc67"

URI_x86_64_v2_a52dec = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/a52dec-0.7.4-50.el10.x86_64_v2.rpm;name=x86_64_v2_a52dec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_a52dec}"
SRC_URI[x86_64_v2_a52dec.sha256sum] = "b637c135d602d85a94f5d55f48668f2aeae04b5ea2837d5d1b0b8625ead808f6"

URI_x86_64_v2_liba52 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liba52-0.7.4-50.el10.x86_64_v2.rpm;name=x86_64_v2_liba52;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liba52}"
SRC_URI[x86_64_v2_liba52.sha256sum] = "b833e35aa67f59187af3abefd5a6d5a24caa1605825942e2b03520c6e01213aa"

URI_x86_64_v2_liba52-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/liba52-devel-0.7.4-50.el10.x86_64_v2.rpm;name=x86_64_v2_liba52-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liba52-devel}"
SRC_URI[x86_64_v2_liba52-devel.sha256sum] = "51389b9b0b417e36ef0c2ed2c6b492ddf5428e680286b407f5829283f452daf6"

URI_aarch64_a52dec = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/a52dec-0.7.4-50.el10.aarch64.rpm;name=aarch64_a52dec;unpack=0"
SRC_URI:append = " ${URI_aarch64_a52dec}"
SRC_URI[aarch64_a52dec.sha256sum] = "0f9f181d3d65359cf7746463815b6f7e9704c4e2a54a3ff1710f98a94f488dc4"

URI_aarch64_liba52 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liba52-0.7.4-50.el10.aarch64.rpm;name=aarch64_liba52;unpack=0"
SRC_URI:append = " ${URI_aarch64_liba52}"
SRC_URI[aarch64_liba52.sha256sum] = "816f64694acf889fd2d14c54e379b15564bb848813914453c37483ceda299e68"

URI_aarch64_liba52-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/liba52-devel-0.7.4-50.el10.aarch64.rpm;name=aarch64_liba52-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liba52-devel}"
SRC_URI[aarch64_liba52-devel.sha256sum] = "a489d63fc87ba17c81a14db9888913c297079954d5699a9088f36e5ec816d777"

RDEPENDS:a52dec = " \
 glibc \
 liba52 \
 "
RDEPENDS:liba52 = " \
 glibc \
 "
RDEPENDS:liba52-devel = " \
 liba52 \
 "
