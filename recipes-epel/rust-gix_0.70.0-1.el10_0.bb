# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix"
PV = "0.70.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix+async-network-client-async-std-devel \
 rust-gix+async-network-client-devel \
 rust-gix+async-std-devel \
 rust-gix+attributes-devel \
 rust-gix+basic-devel \
 rust-gix+blame-devel \
 rust-gix+blob-diff-devel \
 rust-gix+blocking-http-transport-curl-devel \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix+blocking-http-transport-reqwest-native-tls-devel \
 rust-gix+blocking-http-transport-reqwest-rust-tls-devel \
 rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel \
 rust-gix+blocking-network-client-devel \
 rust-gix+cache-efficiency-debug-devel \
 rust-gix+comfort-devel \
 rust-gix+command-devel \
 rust-gix+credentials-devel \
 rust-gix+default-devel \
 rust-gix+dirwalk-devel \
 rust-gix+document-features-devel \
 rust-gix+excludes-devel \
 rust-gix+extras-devel \
 rust-gix+fast-sha1-devel \
 rust-gix+gix-archive-devel \
 rust-gix+gix-status-devel \
 rust-gix+gix-worktree-stream-devel \
 rust-gix+hp-tempfile-registry-devel \
 rust-gix+index-devel \
 rust-gix+interrupt-devel \
 rust-gix+mailmap-devel \
 rust-gix+max-control-devel \
 rust-gix+max-performance-devel \
 rust-gix+max-performance-safe-devel \
 rust-gix+merge-devel \
 rust-gix+need-more-recent-msrv-devel \
 rust-gix+pack-cache-lru-dynamic-devel \
 rust-gix+pack-cache-lru-static-devel \
 rust-gix+parallel-devel \
 rust-gix+parallel-walkdir-devel \
 rust-gix+prodash-devel \
 rust-gix+progress-tree-devel \
 rust-gix+regex-devel \
 rust-gix+revision-devel \
 rust-gix+revparse-regex-devel \
 rust-gix+serde-devel \
 rust-gix+status-devel \
 rust-gix+tracing-detail-devel \
 rust-gix+tracing-devel \
 rust-gix+tree-editor-devel \
 rust-gix+verbose-object-parsing-errors-devel \
 rust-gix+worktree-archive-devel \
 rust-gix+worktree-mutation-devel \
 rust-gix+worktree-stream-devel \
 rust-gix+zlib-ng-devel \
 rust-gix+zlib-stock-devel \
 rust-gix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-0.70.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8d24a6cff4abe24b2a26a63139d1916ee91328e59639755dd0200465b542cac"

URI_x86_64_v2_rust-gix+async-network-client-async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+async-network-client-async-std-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+async-network-client-async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+async-network-client-async-std-devel}"
SRC_URI[x86_64_v2_rust-gix+async-network-client-async-std-devel.sha256sum] = "af20ea4db7496da1cf700cf015f44e5fa69447e79563cbb2098a7cdea5c04b8c"

URI_x86_64_v2_rust-gix+async-network-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+async-network-client-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+async-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+async-network-client-devel}"
SRC_URI[x86_64_v2_rust-gix+async-network-client-devel.sha256sum] = "ff2b6b6d63a790586a5ad2c519f0df9012dd1df3c764cc8e4fe0deba7546a3ed"

URI_x86_64_v2_rust-gix+async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+async-std-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+async-std-devel}"
SRC_URI[x86_64_v2_rust-gix+async-std-devel.sha256sum] = "57feaeae31e377ed583b72d546dcebe879b8e202e8d241a1cd67f00294022e06"

URI_x86_64_v2_rust-gix+attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+attributes-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+attributes-devel}"
SRC_URI[x86_64_v2_rust-gix+attributes-devel.sha256sum] = "6c66ebb9cdfb506b1e0fb43694d1efae29ac0f4f83dbcf86bf482624041c1782"

URI_x86_64_v2_rust-gix+basic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+basic-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+basic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+basic-devel}"
SRC_URI[x86_64_v2_rust-gix+basic-devel.sha256sum] = "836ba022f5650cb9ac804dd5716e30008f1c90e2233634e78a410a89218f0969"

URI_x86_64_v2_rust-gix+blame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blame-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blame-devel}"
SRC_URI[x86_64_v2_rust-gix+blame-devel.sha256sum] = "b2d8611bf794b341a88e835245f2aa1ac2767cd4059b2020ea847d30bbf46e72"

URI_x86_64_v2_rust-gix+blob-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blob-diff-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blob-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blob-diff-devel}"
SRC_URI[x86_64_v2_rust-gix+blob-diff-devel.sha256sum] = "a6cfd88f3ae982e2f3e9b0a9cc8e689a2e0767dae02835825be6cdde535b4d40"

URI_x86_64_v2_rust-gix+blocking-http-transport-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-curl-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-curl-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-curl-devel.sha256sum] = "52f0bd6adb5a6a7cb0cfb64d01956b073917b484f67b3d7142e142237fad626a"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel.sha256sum] = "6436d6d435e32d02d6230abe7c063581fa611a3567292870d7d6050e0a998b81"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-native-tls-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel.sha256sum] = "21ee3bc7143ba27eb38d9502fa7858ce28cb3d6b2ee1e6a26166a1e89adf32f9"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-rust-tls-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel.sha256sum] = "24273d776522db898b6c8df3a25e9c842d310f6dc3fc11900d9c015ddeae0651"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel.sha256sum] = "c611d2d3107b1ba0d4f30061935a47cfe3830283d99ddf7c481775bd21b0c143"

URI_x86_64_v2_rust-gix+blocking-network-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-network-client-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-network-client-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-network-client-devel.sha256sum] = "b91f82682819556b7ad05f4b823892ed0aef4665972b13fcca74a44645bd2460"

URI_x86_64_v2_rust-gix+cache-efficiency-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+cache-efficiency-debug-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+cache-efficiency-debug-devel}"
SRC_URI[x86_64_v2_rust-gix+cache-efficiency-debug-devel.sha256sum] = "0d14a3493a824e622f1ef64a2de8cd9b6ac9d9019d46bd9888cee827e192483b"

URI_x86_64_v2_rust-gix+comfort-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+comfort-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+comfort-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+comfort-devel}"
SRC_URI[x86_64_v2_rust-gix+comfort-devel.sha256sum] = "2eec0b8490d4f631efd8303d8e8beb51ac1bdccbeb6dc58d519e71b9a1ad1864"

URI_x86_64_v2_rust-gix+command-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+command-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+command-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+command-devel}"
SRC_URI[x86_64_v2_rust-gix+command-devel.sha256sum] = "9d565ca7554c984b48c79a5d7e91a17d7fbd711f0eb84da14390ae493657aa58"

URI_x86_64_v2_rust-gix+credentials-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+credentials-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+credentials-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+credentials-devel}"
SRC_URI[x86_64_v2_rust-gix+credentials-devel.sha256sum] = "5c5c1f16071deb7d5b6fe5cf4c8df7232b8f3fc04bbc29b246745d4d4cca94b2"

URI_x86_64_v2_rust-gix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+default-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+default-devel}"
SRC_URI[x86_64_v2_rust-gix+default-devel.sha256sum] = "e5314b7e1503c0bfa8a1121f16b4671bf3d711317e0b3240f30afdd3c81d1121"

URI_x86_64_v2_rust-gix+dirwalk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+dirwalk-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+dirwalk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+dirwalk-devel}"
SRC_URI[x86_64_v2_rust-gix+dirwalk-devel.sha256sum] = "a2a34f77a41537b63dbef38973ec2bc2d948ce81f63cea86d32949ab3f5bdb20"

URI_x86_64_v2_rust-gix+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+document-features-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix+document-features-devel.sha256sum] = "1b880a8e184771e3859098bda82f7de7e6ac5a892d75d9e2fefadee71a2c5515"

URI_x86_64_v2_rust-gix+excludes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+excludes-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+excludes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+excludes-devel}"
SRC_URI[x86_64_v2_rust-gix+excludes-devel.sha256sum] = "603e65bfb15d7684217617bedd756dc79d391f51a0b539ad0508fc60cf51b596"

URI_x86_64_v2_rust-gix+extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+extras-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+extras-devel}"
SRC_URI[x86_64_v2_rust-gix+extras-devel.sha256sum] = "1d7cda3fcdfcb91201514d5b2220db3d4b18684b1e0623953064a9b5a5dff4e2"

URI_x86_64_v2_rust-gix+fast-sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+fast-sha1-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+fast-sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+fast-sha1-devel}"
SRC_URI[x86_64_v2_rust-gix+fast-sha1-devel.sha256sum] = "b936a09b711e0d6683535dea4ba765bf7124f39bd6e75bb7b4c37e2d25cb9867"

URI_x86_64_v2_rust-gix+gix-archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+gix-archive-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+gix-archive-devel}"
SRC_URI[x86_64_v2_rust-gix+gix-archive-devel.sha256sum] = "e544dd2bc67ce91f1298f01a5eb01ea1b1796f9708f2728ddfdc99a7b77e4738"

URI_x86_64_v2_rust-gix+gix-status-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+gix-status-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+gix-status-devel}"
SRC_URI[x86_64_v2_rust-gix+gix-status-devel.sha256sum] = "050027fdd608eb410ffae460d8e4c5f1d09efac3613e615acc934b190a8dc48d"

URI_x86_64_v2_rust-gix+gix-worktree-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+gix-worktree-stream-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+gix-worktree-stream-devel}"
SRC_URI[x86_64_v2_rust-gix+gix-worktree-stream-devel.sha256sum] = "ee5b5ae3b4ac17a12c39d9dfc1f138a119aeec4656762b6b88ec64789c7d883b"

URI_x86_64_v2_rust-gix+hp-tempfile-registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+hp-tempfile-registry-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+hp-tempfile-registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+hp-tempfile-registry-devel}"
SRC_URI[x86_64_v2_rust-gix+hp-tempfile-registry-devel.sha256sum] = "3dc5f9cde388c655e7bfb61e1eeba04cd85c4daa7a93c35ab0f8746a7b1ff50e"

URI_x86_64_v2_rust-gix+index-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+index-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+index-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+index-devel}"
SRC_URI[x86_64_v2_rust-gix+index-devel.sha256sum] = "113e6e09a70da5e1422441da5e34683dc169bf4bcd1fab20d0abdd923a9875d3"

URI_x86_64_v2_rust-gix+interrupt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+interrupt-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+interrupt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+interrupt-devel}"
SRC_URI[x86_64_v2_rust-gix+interrupt-devel.sha256sum] = "0d8253b2516f0d8ee19f9e78e61b67510b4d31dc92d5a882211f097d26c74031"

URI_x86_64_v2_rust-gix+mailmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+mailmap-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+mailmap-devel}"
SRC_URI[x86_64_v2_rust-gix+mailmap-devel.sha256sum] = "ca557579109be5027ea03acb75dc0b28681e9d05d1adb8e083eac2482dad8b4a"

URI_x86_64_v2_rust-gix+max-control-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+max-control-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+max-control-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+max-control-devel}"
SRC_URI[x86_64_v2_rust-gix+max-control-devel.sha256sum] = "f40b572d74fae6b68a1121a59be605f14fca7a4d92e5b46bbbc61441382b8f74"

URI_x86_64_v2_rust-gix+max-performance-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+max-performance-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+max-performance-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+max-performance-devel}"
SRC_URI[x86_64_v2_rust-gix+max-performance-devel.sha256sum] = "3c66287970360ca1d8fcd9708e503eae2860839928a5d868b26176c6b7d32af3"

URI_x86_64_v2_rust-gix+max-performance-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+max-performance-safe-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+max-performance-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+max-performance-safe-devel}"
SRC_URI[x86_64_v2_rust-gix+max-performance-safe-devel.sha256sum] = "8602deb1fc90f554e260be22242d8835c609c8aa28268354b7ef8dc195dd2713"

URI_x86_64_v2_rust-gix+merge-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+merge-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+merge-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+merge-devel}"
SRC_URI[x86_64_v2_rust-gix+merge-devel.sha256sum] = "2e0ecffa9430bc12b99ef73f6b8330b588950e0dc7838d35809978c04a15365f"

URI_x86_64_v2_rust-gix+need-more-recent-msrv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+need-more-recent-msrv-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+need-more-recent-msrv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+need-more-recent-msrv-devel}"
SRC_URI[x86_64_v2_rust-gix+need-more-recent-msrv-devel.sha256sum] = "95c3dd18b470719584f89874ff6feb4206a8592eccd91749e23ae6dc7f2fe01b"

URI_x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+pack-cache-lru-dynamic-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel}"
SRC_URI[x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel.sha256sum] = "3562f463a363e9ab81b8e115fcab99baaaa9a26fbd4bdbca5c7f77cd4e950032"

URI_x86_64_v2_rust-gix+pack-cache-lru-static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+pack-cache-lru-static-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+pack-cache-lru-static-devel}"
SRC_URI[x86_64_v2_rust-gix+pack-cache-lru-static-devel.sha256sum] = "6b86d31e3f011a6935701e9fc4172a3e6c3e49bc965928dce2a58e2a8f507c17"

URI_x86_64_v2_rust-gix+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+parallel-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+parallel-devel}"
SRC_URI[x86_64_v2_rust-gix+parallel-devel.sha256sum] = "2f95717991b62134f2dd313833914685784fc8a810fe9cd95abd58a01da95961"

URI_x86_64_v2_rust-gix+parallel-walkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+parallel-walkdir-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+parallel-walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+parallel-walkdir-devel}"
SRC_URI[x86_64_v2_rust-gix+parallel-walkdir-devel.sha256sum] = "c66ac9fec2f9928a727de511137f16852f698e688c1f0bca71d06bebdb7dc4c9"

URI_x86_64_v2_rust-gix+prodash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+prodash-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+prodash-devel}"
SRC_URI[x86_64_v2_rust-gix+prodash-devel.sha256sum] = "ac425488eee3b8d1d44d3577a1679b9e6ad661ff20d439cb53c28781f5d6c3b4"

URI_x86_64_v2_rust-gix+progress-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+progress-tree-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+progress-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+progress-tree-devel}"
SRC_URI[x86_64_v2_rust-gix+progress-tree-devel.sha256sum] = "8a0748ef53b32953f072901a250627399559583e2f6a66d633ebe687bc3c2b1b"

URI_x86_64_v2_rust-gix+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+regex-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+regex-devel}"
SRC_URI[x86_64_v2_rust-gix+regex-devel.sha256sum] = "72f5de85aad3faa394b68d680427dd1f6d1cf9ade63c92289567921631940068"

URI_x86_64_v2_rust-gix+revision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+revision-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+revision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+revision-devel}"
SRC_URI[x86_64_v2_rust-gix+revision-devel.sha256sum] = "8b78d63e7c33dbd11f55c49bde0f373bd79643a6473af54a922af59bf482f7bb"

URI_x86_64_v2_rust-gix+revparse-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+revparse-regex-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+revparse-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+revparse-regex-devel}"
SRC_URI[x86_64_v2_rust-gix+revparse-regex-devel.sha256sum] = "40218fb74aa1cedc64c52b0dc1914b79e249881d91cf709e91cd6b6c2b8e5d94"

URI_x86_64_v2_rust-gix+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+serde-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+serde-devel}"
SRC_URI[x86_64_v2_rust-gix+serde-devel.sha256sum] = "92e894cc7f324bdcc4dbf8b3991a47ccdd330360ceba32f90af11ed2847c7b43"

URI_x86_64_v2_rust-gix+status-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+status-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+status-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+status-devel}"
SRC_URI[x86_64_v2_rust-gix+status-devel.sha256sum] = "1437497f36720132b77370dcdb3b7affa9a7e80219ce72fdfb5cc007806cf90d"

URI_x86_64_v2_rust-gix+tracing-detail-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+tracing-detail-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+tracing-detail-devel}"
SRC_URI[x86_64_v2_rust-gix+tracing-detail-devel.sha256sum] = "5d1987486a916a64b63ec5af8811ef10b191bdd6658a17218b2be8d04349229c"

URI_x86_64_v2_rust-gix+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+tracing-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+tracing-devel}"
SRC_URI[x86_64_v2_rust-gix+tracing-devel.sha256sum] = "5d5c5f8580ef2a1c6da692a1dc3df904aa1fc5a6c2dfc7c182e9a9f44947daf0"

URI_x86_64_v2_rust-gix+tree-editor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+tree-editor-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+tree-editor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+tree-editor-devel}"
SRC_URI[x86_64_v2_rust-gix+tree-editor-devel.sha256sum] = "0b02b66c7a66a36d36adda494f1b204a338d768e6624d98f407207bb695252ce"

URI_x86_64_v2_rust-gix+verbose-object-parsing-errors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+verbose-object-parsing-errors-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+verbose-object-parsing-errors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+verbose-object-parsing-errors-devel}"
SRC_URI[x86_64_v2_rust-gix+verbose-object-parsing-errors-devel.sha256sum] = "e0e7b9f04ab4aefdcea5bfcb8a51baa3b195807121f7318575d8aa176c464253"

URI_x86_64_v2_rust-gix+worktree-archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+worktree-archive-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+worktree-archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+worktree-archive-devel}"
SRC_URI[x86_64_v2_rust-gix+worktree-archive-devel.sha256sum] = "b97b104393f3e83cf3781e54b36164076a8deac49981ee57d28953f67d134db0"

URI_x86_64_v2_rust-gix+worktree-mutation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+worktree-mutation-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+worktree-mutation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+worktree-mutation-devel}"
SRC_URI[x86_64_v2_rust-gix+worktree-mutation-devel.sha256sum] = "e8e179beebed5f4d3a3870a8bb1f2679f0773b70175ede8dd98ed644ce2515ad"

URI_x86_64_v2_rust-gix+worktree-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+worktree-stream-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+worktree-stream-devel}"
SRC_URI[x86_64_v2_rust-gix+worktree-stream-devel.sha256sum] = "ec6b8f54cf33fb387acbe6a127853c861ad2545de960bf7b60ceef1cfb2faeb8"

URI_x86_64_v2_rust-gix+zlib-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+zlib-ng-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+zlib-ng-devel}"
SRC_URI[x86_64_v2_rust-gix+zlib-ng-devel.sha256sum] = "1e1865d33e9ee0d06532b38af534ef1fcd22804e90610cf7433d70c08e95602c"

URI_x86_64_v2_rust-gix+zlib-stock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+zlib-stock-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+zlib-stock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+zlib-stock-devel}"
SRC_URI[x86_64_v2_rust-gix+zlib-stock-devel.sha256sum] = "36f3872509432046d5e355f32c4f2add31ce5f93c5d05d7fa77d202d31b81e55"

URI_x86_64_v2_rust-gix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-devel-0.70.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-devel}"
SRC_URI[x86_64_v2_rust-gix-devel.sha256sum] = "3cb653a2fa8a0bfa9e10c33f096e272ba6fc1ae6f5929087a51eaa679ea0e1b6"

URI_aarch64_rust-gix+async-network-client-async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+async-network-client-async-std-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+async-network-client-async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+async-network-client-async-std-devel}"
SRC_URI[aarch64_rust-gix+async-network-client-async-std-devel.sha256sum] = "8c09a332054077cdb537c95649104d3b0d4326cf28c5c72d44a721ae02e72fb0"

URI_aarch64_rust-gix+async-network-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+async-network-client-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+async-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+async-network-client-devel}"
SRC_URI[aarch64_rust-gix+async-network-client-devel.sha256sum] = "8da239f8ac62077bf3f3737cbff452a976ff0d0d4657e98a7658b6e00b0a6d43"

URI_aarch64_rust-gix+async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+async-std-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+async-std-devel}"
SRC_URI[aarch64_rust-gix+async-std-devel.sha256sum] = "6a34986fc77d4f385ab107bbb144fda5b029f835758d37ed5f38efaa56462844"

URI_aarch64_rust-gix+attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+attributes-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+attributes-devel}"
SRC_URI[aarch64_rust-gix+attributes-devel.sha256sum] = "bb1968aa000abe2764370478f4bbbc490009b7f00f3876ac7a4c73d419e66dfc"

URI_aarch64_rust-gix+basic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+basic-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+basic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+basic-devel}"
SRC_URI[aarch64_rust-gix+basic-devel.sha256sum] = "55b074de07ccb0e8f20b70eb7bd106130148cc0a9b028bc7bd6d2c95b19cdd92"

URI_aarch64_rust-gix+blame-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blame-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+blame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blame-devel}"
SRC_URI[aarch64_rust-gix+blame-devel.sha256sum] = "4b0a9f3771dcae90bba65bacd693c39f4f1b828c49f02555a13a477435b5e72e"

URI_aarch64_rust-gix+blob-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blob-diff-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+blob-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blob-diff-devel}"
SRC_URI[aarch64_rust-gix+blob-diff-devel.sha256sum] = "9d1a7eb58a175512fed5c7386a08ebe177d24d2a16e85ff8a2e68eb4436653ed"

URI_aarch64_rust-gix+blocking-http-transport-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-curl-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-curl-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-curl-devel.sha256sum] = "805bf1fc2b1d763195da93a34f622d90944f3737587d07ca465deec6c38d344d"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-devel.sha256sum] = "3fbe144596821c5c83fa45973a1f10b7fe741819d9a979a8923f52c84e64362a"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-native-tls-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel.sha256sum] = "cece194f75fb275a01e60a00f00580a4661dd8fb4259187575a042981c56d989"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-rust-tls-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel.sha256sum] = "156b5608a416848e6a9c059c40d5acf323a7581d1e68100bca2091d14288255a"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel.sha256sum] = "a1aca2f556bf71097782232a7e71170e389269d174f8eee625f3db5498a59c51"

URI_aarch64_rust-gix+blocking-network-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-network-client-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+blocking-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-network-client-devel}"
SRC_URI[aarch64_rust-gix+blocking-network-client-devel.sha256sum] = "cbd5aa4f6b86cf17db44aef37b0fcdca787fc218636ad33a2db15e995562171d"

URI_aarch64_rust-gix+cache-efficiency-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+cache-efficiency-debug-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+cache-efficiency-debug-devel}"
SRC_URI[aarch64_rust-gix+cache-efficiency-debug-devel.sha256sum] = "0ad51166803afe7045a1b2481fff9976d54e3d01319456aabc24d9b6cafdf95e"

URI_aarch64_rust-gix+comfort-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+comfort-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+comfort-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+comfort-devel}"
SRC_URI[aarch64_rust-gix+comfort-devel.sha256sum] = "d69e576a4155b5d13d0405e4cbfbd2f3c7a335d45070b386359becf90a4ca8a4"

URI_aarch64_rust-gix+command-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+command-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+command-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+command-devel}"
SRC_URI[aarch64_rust-gix+command-devel.sha256sum] = "121a08d467b67e0f657ab0e14d93a920749c57c0145cfb74b04141468b9957b7"

URI_aarch64_rust-gix+credentials-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+credentials-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+credentials-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+credentials-devel}"
SRC_URI[aarch64_rust-gix+credentials-devel.sha256sum] = "ee0f6a8e638c1eb11f9b5659c0fd953b537d5f8cdd87c25379dd9d7487d082b1"

URI_aarch64_rust-gix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+default-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+default-devel}"
SRC_URI[aarch64_rust-gix+default-devel.sha256sum] = "801576829b1b96e890e659adf622002983648b45d428efc324069fdb3db6bff3"

URI_aarch64_rust-gix+dirwalk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+dirwalk-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+dirwalk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+dirwalk-devel}"
SRC_URI[aarch64_rust-gix+dirwalk-devel.sha256sum] = "4e8e59d14ee3a6d99ffbed6d71387863685df67f412c9ad48e6be9e500fcef0a"

URI_aarch64_rust-gix+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+document-features-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+document-features-devel}"
SRC_URI[aarch64_rust-gix+document-features-devel.sha256sum] = "5e03f722419b8943ddc75639b8900aec1f485d69284c21ab9589b661eeae03bf"

URI_aarch64_rust-gix+excludes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+excludes-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+excludes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+excludes-devel}"
SRC_URI[aarch64_rust-gix+excludes-devel.sha256sum] = "a0b0aaa6920d2cda19ae50fed64b7d83fbeaa432c85e47061a95826e129226ad"

URI_aarch64_rust-gix+extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+extras-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+extras-devel}"
SRC_URI[aarch64_rust-gix+extras-devel.sha256sum] = "ea6d31d25240c1dbb50a8883d6e0a723ad709f55bdb441deaf214693682f4cca"

URI_aarch64_rust-gix+fast-sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+fast-sha1-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+fast-sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+fast-sha1-devel}"
SRC_URI[aarch64_rust-gix+fast-sha1-devel.sha256sum] = "52070f3b61dde32c50c303f7e135e4a795e95570e2959f523c2ecacd76d08a16"

URI_aarch64_rust-gix+gix-archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+gix-archive-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+gix-archive-devel}"
SRC_URI[aarch64_rust-gix+gix-archive-devel.sha256sum] = "741a2c273fdea8611478cb9f429632495c86a9aa249ac2ae6fb46640cc6b5d4a"

URI_aarch64_rust-gix+gix-status-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+gix-status-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+gix-status-devel}"
SRC_URI[aarch64_rust-gix+gix-status-devel.sha256sum] = "62302611f9fed44462aa3d4b8b753fc20f3ff73b1ea983f1269ca84d62c585ea"

URI_aarch64_rust-gix+gix-worktree-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+gix-worktree-stream-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+gix-worktree-stream-devel}"
SRC_URI[aarch64_rust-gix+gix-worktree-stream-devel.sha256sum] = "a45d372eeb73e0a65a18886b8513d9b177c6cb8d51ac48e0c0a88a83a736ae1e"

URI_aarch64_rust-gix+hp-tempfile-registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+hp-tempfile-registry-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+hp-tempfile-registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+hp-tempfile-registry-devel}"
SRC_URI[aarch64_rust-gix+hp-tempfile-registry-devel.sha256sum] = "04eb60531bebf145479694124bbcd5aad19dd10522df0cb5923c3c16648bc794"

URI_aarch64_rust-gix+index-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+index-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+index-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+index-devel}"
SRC_URI[aarch64_rust-gix+index-devel.sha256sum] = "699ef22b6731c81927d0ff7ccbbff8808ed40ea29e6a8e8e1f000fae2003e553"

URI_aarch64_rust-gix+interrupt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+interrupt-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+interrupt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+interrupt-devel}"
SRC_URI[aarch64_rust-gix+interrupt-devel.sha256sum] = "107312ce82a8a79dfc3f84bb50465f4ef5e90fc4cf186ade0ee98e9d2f9de2b2"

URI_aarch64_rust-gix+mailmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+mailmap-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+mailmap-devel}"
SRC_URI[aarch64_rust-gix+mailmap-devel.sha256sum] = "dbd5c6ddeb69113bbdc3ac2f97df25ecaf2864e84f4244d04a054a3d3895b181"

URI_aarch64_rust-gix+max-control-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+max-control-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+max-control-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+max-control-devel}"
SRC_URI[aarch64_rust-gix+max-control-devel.sha256sum] = "929f4cab736254c257f752a076cf058ebe09b6361bccdb4b7063f49ab8d3a153"

URI_aarch64_rust-gix+max-performance-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+max-performance-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+max-performance-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+max-performance-devel}"
SRC_URI[aarch64_rust-gix+max-performance-devel.sha256sum] = "bdc06a958286ee28d8cc0d30e596c52a4b38967cd1fb97e5740031ab21b597ee"

URI_aarch64_rust-gix+max-performance-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+max-performance-safe-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+max-performance-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+max-performance-safe-devel}"
SRC_URI[aarch64_rust-gix+max-performance-safe-devel.sha256sum] = "cd75c18f9934d8b8e741c36843653b65e71d1aa75f3688ca9eedf30b2efa3928"

URI_aarch64_rust-gix+merge-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+merge-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+merge-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+merge-devel}"
SRC_URI[aarch64_rust-gix+merge-devel.sha256sum] = "d6ce84c80f891e12d4e04e955cc3971a11399daecdb8a9d55d15ab7f0ae8d8a7"

URI_aarch64_rust-gix+need-more-recent-msrv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+need-more-recent-msrv-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+need-more-recent-msrv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+need-more-recent-msrv-devel}"
SRC_URI[aarch64_rust-gix+need-more-recent-msrv-devel.sha256sum] = "e1f14ee1089e339fce4b6733106a5df5ecf1044fa2e2d2a9d4cbbcfa132747d3"

URI_aarch64_rust-gix+pack-cache-lru-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+pack-cache-lru-dynamic-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+pack-cache-lru-dynamic-devel}"
SRC_URI[aarch64_rust-gix+pack-cache-lru-dynamic-devel.sha256sum] = "4fdda46caf1057cef9716729a32161053ffce2bd17cc295ec81347a1106f0216"

URI_aarch64_rust-gix+pack-cache-lru-static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+pack-cache-lru-static-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+pack-cache-lru-static-devel}"
SRC_URI[aarch64_rust-gix+pack-cache-lru-static-devel.sha256sum] = "e0341ef5b06736d3c2eadcea912f7cdf36f23b7519407e0c1d114ccbf1a88053"

URI_aarch64_rust-gix+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+parallel-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+parallel-devel}"
SRC_URI[aarch64_rust-gix+parallel-devel.sha256sum] = "74ee4fb7ea379c59a8d96cca42d60a0a9bd26496e25b451b695b4d2a376e8983"

URI_aarch64_rust-gix+parallel-walkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+parallel-walkdir-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+parallel-walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+parallel-walkdir-devel}"
SRC_URI[aarch64_rust-gix+parallel-walkdir-devel.sha256sum] = "fe9fff94658b06fac06676780582564689270bb0c774f80033f67109b7db967b"

URI_aarch64_rust-gix+prodash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+prodash-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+prodash-devel}"
SRC_URI[aarch64_rust-gix+prodash-devel.sha256sum] = "3e8b802cc67b5972afc50f151b46f3d47fca61869a8ff14973b600c80365bc18"

URI_aarch64_rust-gix+progress-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+progress-tree-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+progress-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+progress-tree-devel}"
SRC_URI[aarch64_rust-gix+progress-tree-devel.sha256sum] = "39d08da42d1eb42602409c825eb1d19c78d0a3edae86c2b86771e00eb244eb15"

URI_aarch64_rust-gix+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+regex-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+regex-devel}"
SRC_URI[aarch64_rust-gix+regex-devel.sha256sum] = "bdcf1becd2a75941834ba4e7283e9a8bb39bff09a5f01975fedec609eb1ba450"

URI_aarch64_rust-gix+revision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+revision-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+revision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+revision-devel}"
SRC_URI[aarch64_rust-gix+revision-devel.sha256sum] = "4cf9f598d21de1d6ac9004c9700a52448b398cde382fe200be5872449396def9"

URI_aarch64_rust-gix+revparse-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+revparse-regex-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+revparse-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+revparse-regex-devel}"
SRC_URI[aarch64_rust-gix+revparse-regex-devel.sha256sum] = "598b27e2f3c4fe58993c606b80f6b27b3dbb052b45c742f8906e5884b34fbc7a"

URI_aarch64_rust-gix+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+serde-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+serde-devel}"
SRC_URI[aarch64_rust-gix+serde-devel.sha256sum] = "0c6f93343a87f1d8995f7e1f48d524a004bec72ff0054820d5bd0990df7eb865"

URI_aarch64_rust-gix+status-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+status-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+status-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+status-devel}"
SRC_URI[aarch64_rust-gix+status-devel.sha256sum] = "37aa822202fca579b9138bae29bdd85eca2ebe4de2111be81067fd78dd3036a8"

URI_aarch64_rust-gix+tracing-detail-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+tracing-detail-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+tracing-detail-devel}"
SRC_URI[aarch64_rust-gix+tracing-detail-devel.sha256sum] = "6cc8581c60761e4173b73a9749818d9e476169b1dfff19dc2ce7b62ee30e5269"

URI_aarch64_rust-gix+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+tracing-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+tracing-devel}"
SRC_URI[aarch64_rust-gix+tracing-devel.sha256sum] = "ed801d57a3be0480954d545c0681b0faf69efa9f752f1c111030f514da234184"

URI_aarch64_rust-gix+tree-editor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+tree-editor-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+tree-editor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+tree-editor-devel}"
SRC_URI[aarch64_rust-gix+tree-editor-devel.sha256sum] = "48574195ffda01c9a947b699416b785d944e6fd3accac08c1c82fcb5d89bd0b7"

URI_aarch64_rust-gix+verbose-object-parsing-errors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+verbose-object-parsing-errors-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+verbose-object-parsing-errors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+verbose-object-parsing-errors-devel}"
SRC_URI[aarch64_rust-gix+verbose-object-parsing-errors-devel.sha256sum] = "ca51fec19558ce6c7248839706bf8ad1beaf1caf071278e0279a2451aa16abc5"

URI_aarch64_rust-gix+worktree-archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+worktree-archive-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+worktree-archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+worktree-archive-devel}"
SRC_URI[aarch64_rust-gix+worktree-archive-devel.sha256sum] = "66e81ea428c9fcfd927cfd1b9dc14618fa38aca4d6f96fa1b6410199e7abdc52"

URI_aarch64_rust-gix+worktree-mutation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+worktree-mutation-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+worktree-mutation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+worktree-mutation-devel}"
SRC_URI[aarch64_rust-gix+worktree-mutation-devel.sha256sum] = "6169c6b3c15b1e782a2a29652534a75dada04f8bb551e10ea3e4549fa2c7a0cd"

URI_aarch64_rust-gix+worktree-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+worktree-stream-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+worktree-stream-devel}"
SRC_URI[aarch64_rust-gix+worktree-stream-devel.sha256sum] = "fe586a802cb39111fdc94e9ab3987ff24bf15e2250fdfc6f6a788fdcd0e7e644"

URI_aarch64_rust-gix+zlib-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+zlib-ng-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+zlib-ng-devel}"
SRC_URI[aarch64_rust-gix+zlib-ng-devel.sha256sum] = "f911deddc72cd94f51ee79b1ba7f415c40243de5e985cf146ed89fececc4526c"

URI_aarch64_rust-gix+zlib-stock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+zlib-stock-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix+zlib-stock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+zlib-stock-devel}"
SRC_URI[aarch64_rust-gix+zlib-stock-devel.sha256sum] = "fb9ab96d5afaa02921c751755dcf6124a910d48ba58a1512c5078b7ebc268643"

URI_aarch64_rust-gix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-devel-0.70.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-devel}"
SRC_URI[aarch64_rust-gix-devel.sha256sum] = "7dd8908158b06fc13ecb8fe32465d1c57ef95fbb0b038f3cb447744ddf82fac0"

RDEPENDS:rust-gix+async-network-client-async-std-devel = " \
 cargo \
 rust-gix+async-network-client-devel \
 rust-gix+async-std-devel \
 rust-gix-devel \
 rust-gix-transport+async-std-devel \
 rust-gix-transport+default-devel \
 "
RDEPENDS:rust-gix+async-network-client-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+credentials-devel \
 rust-gix-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-protocol+async-client-devel \
 rust-gix-transport+default-devel \
 "
RDEPENDS:rust-gix+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+attributes-devel = " \
 cargo \
 rust-gix+command-devel \
 rust-gix+excludes-devel \
 rust-gix-attributes+default-devel \
 rust-gix-devel \
 rust-gix-filter+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-submodule+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix+basic-devel = " \
 cargo \
 rust-gix+blob-diff-devel \
 rust-gix+index-devel \
 rust-gix+revision-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+blame-devel = " \
 cargo \
 rust-gix-blame+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+blob-diff-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix-devel \
 rust-gix-diff+blob-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-curl-devel = " \
 cargo \
 rust-gix+blocking-network-client-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-curl-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-devel = " \
 cargo \
 rust-gix+blocking-network-client-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-native-tls-devel = " \
 cargo \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-native-tls-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-rust-tls-devel = " \
 cargo \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel = " \
 cargo \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel \
 "
RDEPENDS:rust-gix+blocking-network-client-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+credentials-devel \
 rust-gix-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-protocol+blocking-client-devel \
 rust-gix-transport+default-devel \
 "
RDEPENDS:rust-gix+cache-efficiency-debug-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+cache-efficiency-debug-devel \
 "
RDEPENDS:rust-gix+comfort-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+progress-unit-bytes-devel \
 rust-gix-features+progress-unit-human-numbers-devel \
 "
RDEPENDS:rust-gix+command-devel = " \
 cargo \
 rust-gix-command+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+credentials-devel = " \
 cargo \
 rust-gix-credentials+default-devel \
 rust-gix-devel \
 rust-gix-negotiate+default-devel \
 rust-gix-prompt+default-devel \
 "
RDEPENDS:rust-gix+default-devel = " \
 cargo \
 rust-gix+basic-devel \
 rust-gix+comfort-devel \
 rust-gix+extras-devel \
 rust-gix+max-performance-safe-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+dirwalk-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+excludes-devel \
 rust-gix-devel \
 rust-gix-dir+default-devel \
 "
RDEPENDS:rust-gix+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+excludes-devel = " \
 cargo \
 rust-gix+index-devel \
 rust-gix-devel \
 rust-gix-ignore+default-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix+extras-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+credentials-devel \
 rust-gix+dirwalk-devel \
 rust-gix+excludes-devel \
 rust-gix+interrupt-devel \
 rust-gix+mailmap-devel \
 rust-gix+revparse-regex-devel \
 rust-gix+status-devel \
 rust-gix+worktree-archive-devel \
 rust-gix+worktree-mutation-devel \
 rust-gix+worktree-stream-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+fast-sha1-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+fast-sha1-devel \
 "
RDEPENDS:rust-gix+gix-archive-devel = " \
 cargo \
 rust-gix-archive-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+gix-status-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-status+default-devel \
 rust-gix-status+worktree-rewrites-devel \
 "
RDEPENDS:rust-gix+gix-worktree-stream-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-worktree-stream+default-devel \
 "
RDEPENDS:rust-gix+hp-tempfile-registry-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-tempfile+hp-hashmap-devel \
 "
RDEPENDS:rust-gix+index-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-index+default-devel \
 "
RDEPENDS:rust-gix+interrupt-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-tempfile+signals-devel \
 rust-parking_lot+default-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-gix+mailmap-devel = " \
 cargo \
 rust-gix+revision-devel \
 rust-gix-devel \
 rust-gix-mailmap+default-devel \
 "
RDEPENDS:rust-gix+max-control-devel = " \
 cargo \
 rust-gix+pack-cache-lru-dynamic-devel \
 rust-gix+pack-cache-lru-static-devel \
 rust-gix+parallel-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+max-performance-devel = " \
 cargo \
 rust-gix+fast-sha1-devel \
 rust-gix+max-performance-safe-devel \
 rust-gix+zlib-ng-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+max-performance-safe-devel = " \
 cargo \
 rust-gix+max-control-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+merge-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+blob-diff-devel \
 rust-gix+tree-editor-devel \
 rust-gix-devel \
 rust-gix-merge-devel \
 "
RDEPENDS:rust-gix+need-more-recent-msrv-devel = " \
 cargo \
 rust-gix+merge-devel \
 rust-gix+tree-editor-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+pack-cache-lru-dynamic-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-pack+pack-cache-lru-dynamic-devel \
 "
RDEPENDS:rust-gix+pack-cache-lru-static-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-pack+pack-cache-lru-static-devel \
 "
RDEPENDS:rust-gix+parallel-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+parallel-devel \
 "
RDEPENDS:rust-gix+parallel-walkdir-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+fs-walkdir-parallel-devel \
 "
RDEPENDS:rust-gix+prodash-devel = " \
 cargo \
 rust-gix-devel \
 rust-prodash+default-devel \
 rust-prodash+progress-tree-devel \
 "
RDEPENDS:rust-gix+progress-tree-devel = " \
 cargo \
 rust-gix-devel \
 rust-prodash+default-devel \
 rust-prodash+progress-tree-devel \
 "
RDEPENDS:rust-gix+regex-devel = " \
 cargo \
 rust-gix-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-gix+revision-devel = " \
 cargo \
 rust-gix+index-devel \
 rust-gix-devel \
 rust-gix-revision+describe-devel \
 rust-gix-revision+merge_base-devel \
 "
RDEPENDS:rust-gix+revparse-regex-devel = " \
 cargo \
 rust-gix+regex-devel \
 rust-gix+revision-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+serde-devel = " \
 cargo \
 rust-gix-attributes+default-devel \
 rust-gix-attributes+serde-devel \
 rust-gix-commitgraph+serde-devel \
 rust-gix-credentials+default-devel \
 rust-gix-credentials+serde-devel \
 rust-gix-devel \
 rust-gix-ignore+default-devel \
 rust-gix-ignore+serde-devel \
 rust-gix-index+default-devel \
 rust-gix-index+serde-devel \
 rust-gix-mailmap+default-devel \
 rust-gix-mailmap+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-odb+serde-devel \
 rust-gix-pack+serde-devel \
 rust-gix-protocol+serde-devel \
 rust-gix-ref+serde-devel \
 rust-gix-revision+serde-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+serde-devel \
 rust-gix-url+serde-devel \
 rust-gix-worktree+serde-devel \
 rust-gix-worktree-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix+status-devel = " \
 cargo \
 rust-gix+blob-diff-devel \
 rust-gix+dirwalk-devel \
 rust-gix+gix-status-devel \
 rust-gix+index-devel \
 rust-gix-devel \
 rust-gix-diff+index-devel \
 "
RDEPENDS:rust-gix+tracing-detail-devel = " \
 cargo \
 rust-gix+tracing-devel \
 rust-gix-devel \
 rust-gix-features+tracing-detail-devel \
 "
RDEPENDS:rust-gix+tracing-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+tracing-devel \
 "
RDEPENDS:rust-gix+tree-editor-devel = " \
 cargo \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+verbose-object-parsing-errors-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-object+verbose-object-parsing-errors-devel \
 "
RDEPENDS:rust-gix+worktree-archive-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+gix-archive-devel \
 rust-gix+worktree-stream-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+worktree-mutation-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix-devel \
 rust-gix-worktree-state+default-devel \
 "
RDEPENDS:rust-gix+worktree-stream-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+gix-worktree-stream-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+zlib-ng-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+zlib-ng-devel \
 "
RDEPENDS:rust-gix+zlib-stock-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+zlib-stock-devel \
 "
RDEPENDS:rust-gix-devel = " \
 bash \
 cargo \
 rust \
 rust-gix-actor+default-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-config+default-devel \
 rust-gix-date+default-devel \
 rust-gix-diff-devel \
 rust-gix-discover+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+once_cell-devel \
 rust-gix-features+progress-devel \
 rust-gix-fs+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-lock+default-devel \
 rust-gix-object+default-devel \
 rust-gix-odb+default-devel \
 rust-gix-pack+object-cache-dynamic-devel \
 rust-gix-pack-devel \
 rust-gix-path+default-devel \
 rust-gix-protocol+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-refspec+default-devel \
 rust-gix-revision-devel \
 rust-gix-revwalk+default-devel \
 rust-gix-sec+default-devel \
 rust-gix-shallow+default-devel \
 rust-gix-tempfile-devel \
 rust-gix-trace+default-devel \
 rust-gix-traverse+default-devel \
 rust-gix-url+default-devel \
 rust-gix-utils+default-devel \
 rust-gix-validate+default-devel \
 rust-once_cell+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
