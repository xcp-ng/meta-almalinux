# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openstep-plist"
PV = "0.5.2"
PR = "1.el10_3"
PACKAGES = " \
 python3-openstep-plist \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openstep-plist-0.5.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "182b28e658c5a0330155c8f49007faedabad2aac98d77e43b40cbca495c5a62a"

URI_x86_64_v2_python3-openstep-plist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openstep-plist-0.5.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-openstep-plist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openstep-plist}"
SRC_URI[x86_64_v2_python3-openstep-plist.sha256sum] = "3b43f8f4d7cafbfcc48308d32fb0387c42649ec58e2823449ddc000e5ccc7ea1"

URI_aarch64_python3-openstep-plist = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openstep-plist-0.5.2-1.el10_3.aarch64.rpm;name=aarch64_python3-openstep-plist;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openstep-plist}"
SRC_URI[aarch64_python3-openstep-plist.sha256sum] = "b8b4484b04425629b973eae21f3dd020f6f894586d68a8d036cd97bef35f834f"

RDEPENDS:python3-openstep-plist = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
