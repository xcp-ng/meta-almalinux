# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-cli"
PV = "0.1.12"
PR = "1.el10_1"
PACKAGES = " \
 rust-grep-cli+default-devel \
 rust-grep-cli-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-cli-0.1.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3e46c2d6c959014d2fc8c88323f0962f4f633f271726f072305222b3cd9d9ad"

URI_x86_64_v2_rust-grep-cli+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-cli+default-devel-0.1.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-cli+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-cli+default-devel}"
SRC_URI[x86_64_v2_rust-grep-cli+default-devel.sha256sum] = "3198e3b28beff97b31e0fc63fd490d4e789605d44d27bec9990e5c896c62802d"

URI_x86_64_v2_rust-grep-cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-cli-devel-0.1.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-cli-devel}"
SRC_URI[x86_64_v2_rust-grep-cli-devel.sha256sum] = "dca1eb0f3be00f91480dc43511c61c8a57b3a6b2e96724275cbc4131983af0e5"

URI_aarch64_rust-grep-cli+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-cli+default-devel-0.1.12-1.el10_1.noarch.rpm;name=aarch64_rust-grep-cli+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-cli+default-devel}"
SRC_URI[aarch64_rust-grep-cli+default-devel.sha256sum] = "dc4d5040430363b0409fd71276099d3fa4d4a83cf4d93bceec9550ad733375b5"

URI_aarch64_rust-grep-cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-cli-devel-0.1.12-1.el10_1.noarch.rpm;name=aarch64_rust-grep-cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-cli-devel}"
SRC_URI[aarch64_rust-grep-cli-devel.sha256sum] = "bade672337a8e0be6a580bfcc5ba21f28c24261acda8e18aaf728610ba75be7b"

RDEPENDS:rust-grep-cli+default-devel = " \
 cargo \
 rust-grep-cli-devel \
 "
RDEPENDS:rust-grep-cli-devel = " \
 cargo \
 rust-bstr+default-devel \
 rust-bstr+std-devel \
 rust-globset+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-termcolor+default-devel \
 "
