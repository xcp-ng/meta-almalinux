# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-slog-async"
PV = "2.8.0"
PR = "4.el10_1"
PACKAGES = " \
 rust-slog-async+default-devel \
 rust-slog-async+dynamic-keys-devel \
 rust-slog-async+nested-values-devel \
 rust-slog-async-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-slog-async-2.8.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a35164b4604855aedc4d553de534c17583eec6b19937b9e5af5feba232f4e205"

URI_x86_64_v2_rust-slog-async+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-async+default-devel-2.8.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-async+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-async+default-devel}"
SRC_URI[x86_64_v2_rust-slog-async+default-devel.sha256sum] = "e66cb139aceee39d88bfa031c3377207a03e2e695c1725f1848668a04e59bc13"

URI_x86_64_v2_rust-slog-async+dynamic-keys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-async+dynamic-keys-devel-2.8.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-async+dynamic-keys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-async+dynamic-keys-devel}"
SRC_URI[x86_64_v2_rust-slog-async+dynamic-keys-devel.sha256sum] = "67390238cc4699564c0e88b4f62042d18ba2b766ff3345b166a00123ef488979"

URI_x86_64_v2_rust-slog-async+nested-values-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-async+nested-values-devel-2.8.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-async+nested-values-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-async+nested-values-devel}"
SRC_URI[x86_64_v2_rust-slog-async+nested-values-devel.sha256sum] = "484de1653df8b6d5decc18609d988dee2f6216c09af0520f67115dfb611844f3"

URI_x86_64_v2_rust-slog-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-async-devel-2.8.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-async-devel}"
SRC_URI[x86_64_v2_rust-slog-async-devel.sha256sum] = "1c5f0d0b3d7d05cf21312d142b1b97ed5354312ecdad192d2eada6794196ef18"

URI_aarch64_rust-slog-async+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-async+default-devel-2.8.0-4.el10_1.noarch.rpm;name=aarch64_rust-slog-async+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-async+default-devel}"
SRC_URI[aarch64_rust-slog-async+default-devel.sha256sum] = "49a1e496ed45bf8a24b162f4ffa2616eec21deee785ff6f8f5a7a2b2a5e7b666"

URI_aarch64_rust-slog-async+dynamic-keys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-async+dynamic-keys-devel-2.8.0-4.el10_1.noarch.rpm;name=aarch64_rust-slog-async+dynamic-keys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-async+dynamic-keys-devel}"
SRC_URI[aarch64_rust-slog-async+dynamic-keys-devel.sha256sum] = "70d8910c38b985c4b2416cd119d347648a4d99dfca79e52279c5b6f0a39a482f"

URI_aarch64_rust-slog-async+nested-values-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-async+nested-values-devel-2.8.0-4.el10_1.noarch.rpm;name=aarch64_rust-slog-async+nested-values-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-async+nested-values-devel}"
SRC_URI[aarch64_rust-slog-async+nested-values-devel.sha256sum] = "d99768806fe8d4bf75dc18bea5179fc3b714fc77ad70b298bf3f9638f58bd20f"

URI_aarch64_rust-slog-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-async-devel-2.8.0-4.el10_1.noarch.rpm;name=aarch64_rust-slog-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-async-devel}"
SRC_URI[aarch64_rust-slog-async-devel.sha256sum] = "5d351290cad0a1c33eff8b3b28f4736988c0a502d5b1d3ce35bcdbfd0118b760"

RDEPENDS:rust-slog-async+default-devel = " \
 cargo \
 rust-slog-async-devel \
 "
RDEPENDS:rust-slog-async+dynamic-keys-devel = " \
 cargo \
 rust-slog+dynamic-keys-devel \
 rust-slog-async-devel \
 "
RDEPENDS:rust-slog-async+nested-values-devel = " \
 cargo \
 rust-slog+nested-values-devel \
 rust-slog-async-devel \
 "
RDEPENDS:rust-slog-async-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-slog+default-devel \
 rust-take_mut+default-devel \
 rust-thread_local+default-devel \
 "
