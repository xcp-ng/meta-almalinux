# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Perl4-CoreLibs"
PV = "0.005"
PR = "7.el10_1"
PACKAGES = " \
 perl-Perl4-CoreLibs \
 perl-Perl4-CoreLibs-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Perl4-CoreLibs-0.005-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1527a71c446d95510c0fa4cf1039b014adc31bc1f9f27443bf9a103b5be255b"

URI_x86_64_v2_perl-Perl4-CoreLibs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Perl4-CoreLibs-0.005-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Perl4-CoreLibs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Perl4-CoreLibs}"
SRC_URI[x86_64_v2_perl-Perl4-CoreLibs.sha256sum] = "b1c89aff566e1ef0290c258b8642201fa3ced84179bca401a12eb0da7f7488a7"

URI_x86_64_v2_perl-Perl4-CoreLibs-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Perl4-CoreLibs-tests-0.005-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Perl4-CoreLibs-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Perl4-CoreLibs-tests}"
SRC_URI[x86_64_v2_perl-Perl4-CoreLibs-tests.sha256sum] = "9e82d247ce57148a58c07f2e057482188cdcf0f180a928fbfe450f1c56506afe"

URI_aarch64_perl-Perl4-CoreLibs = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Perl4-CoreLibs-0.005-7.el10_1.noarch.rpm;name=aarch64_perl-Perl4-CoreLibs;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Perl4-CoreLibs}"
SRC_URI[aarch64_perl-Perl4-CoreLibs.sha256sum] = "2d07cdcadf3afaa26405c8bb58fe2470e0a4127045f2d38856f6d8b0cc06ba7a"

URI_aarch64_perl-Perl4-CoreLibs-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Perl4-CoreLibs-tests-0.005-7.el10_1.noarch.rpm;name=aarch64_perl-Perl4-CoreLibs-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Perl4-CoreLibs-tests}"
SRC_URI[aarch64_perl-Perl4-CoreLibs-tests.sha256sum] = "ef3cedb92716318111fc5190c864e722c797df796175d3baf3c978d15354c051"

RDEPENDS:perl-Perl4-CoreLibs = " \
 hostname \
 perl-File-Find \
 perl-IPC-Open3 \
 perl-Socket \
 perl-Sys-Syslog \
 perl-Text-ParseWords \
 perl-Time-Local \
 perl-libs \
 "
RDEPENDS:perl-Perl4-CoreLibs-tests = " \
 bash \
 perl-IO \
 perl-Perl4-CoreLibs \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
