# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "htslib"
PV = "1.24"
PR = "1.el10_3"
PACKAGES = " \
 htslib \
 htslib-devel \
 htslib-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/htslib-1.24-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bea1361810abb71aeb44c1d50cf477011fff3d171ffc50ee6b6ad8139c84770d"

URI_x86_64_v2_htslib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/htslib-1.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_htslib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_htslib}"
SRC_URI[x86_64_v2_htslib.sha256sum] = "9163493bc978d3b924283d69351f1980bca72488b4e4437ddc2f86042a318a45"

URI_x86_64_v2_htslib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/htslib-devel-1.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_htslib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_htslib-devel}"
SRC_URI[x86_64_v2_htslib-devel.sha256sum] = "9186b88cf89d8316e8bb234e38e976a77933821e022a8ff75428ae440dba35d9"

URI_x86_64_v2_htslib-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/htslib-tools-1.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_htslib-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_htslib-tools}"
SRC_URI[x86_64_v2_htslib-tools.sha256sum] = "ece86d6394c9fbd029a96e26a5a158a597f5ba90dd621ded381111fe3672cd62"

URI_aarch64_htslib = "${EPEL_MIRROR}/aarch64/Packages/h/htslib-1.24-1.el10_3.aarch64.rpm;name=aarch64_htslib;unpack=0"
SRC_URI:append = " ${URI_aarch64_htslib}"
SRC_URI[aarch64_htslib.sha256sum] = "d0b6a3d0991588d65f35cb56f074e9e880195dc09db21c8adbc25690ea58806d"

URI_aarch64_htslib-devel = "${EPEL_MIRROR}/aarch64/Packages/h/htslib-devel-1.24-1.el10_3.aarch64.rpm;name=aarch64_htslib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_htslib-devel}"
SRC_URI[aarch64_htslib-devel.sha256sum] = "1d4720eb51d58fd61e7947eaa6000611473aec0798adcbc9745f52f57cbd7f2f"

URI_aarch64_htslib-tools = "${EPEL_MIRROR}/aarch64/Packages/h/htslib-tools-1.24-1.el10_3.aarch64.rpm;name=aarch64_htslib-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_htslib-tools}"
SRC_URI[aarch64_htslib-tools.sha256sum] = "c2534b1cc2e9bbdcb683be17249003d8e0be1d08c3f17d1e433a2d9c6d01addb"

RDEPENDS:htslib = " \
 bzip2-libs \
 glibc \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:htslib-devel = " \
 htslib \
 pkgconf-pkg-config \
 "
RDEPENDS:htslib-tools = " \
 bzip2-libs \
 glibc \
 htslib \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
