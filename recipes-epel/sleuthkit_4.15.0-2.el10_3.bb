# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sleuthkit"
PV = "4.15.0"
PR = "2.el10_3"
PACKAGES = " \
 sleuthkit \
 sleuthkit-devel \
 sleuthkit-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sleuthkit-4.15.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6d4a84aac5925a8a1b543b0eb91fb838eade4574a88e38716f00ec1a6b799f09"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleuthkit-4.15.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleuthkit;unpack=0"
SRC_URI[x86_64_v2_sleuthkit.sha256sum] = "36b0f2028dbccf2af8a9c682788ed1549d778ca222d40fb6d4d7c223add5f14a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleuthkit-devel-4.15.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleuthkit-devel;unpack=0"
SRC_URI[x86_64_v2_sleuthkit-devel.sha256sum] = "0c251b3a8cbe3c3a7b3281a9b47c88b8733ec8ab030badf2dea98f7752f5df54"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleuthkit-libs-4.15.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleuthkit-libs;unpack=0"
SRC_URI[x86_64_v2_sleuthkit-libs.sha256sum] = "f649c770bc63bf9a05faeaa72aaccb2da4cf350fc76dcb01d6181cfb5e5933de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sleuthkit-4.15.0-2.el10_3.aarch64.rpm;name=aarch64_sleuthkit;unpack=0"
SRC_URI[aarch64_sleuthkit.sha256sum] = "caaa1a28fded91666c5d62d7bda50710cc20736dc71e5eeaeeef200a912a29ee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sleuthkit-devel-4.15.0-2.el10_3.aarch64.rpm;name=aarch64_sleuthkit-devel;unpack=0"
SRC_URI[aarch64_sleuthkit-devel.sha256sum] = "518a5129bea7bdeeffc941111d6363c6e9832882e837063103e5ca198e691b9e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sleuthkit-libs-4.15.0-2.el10_3.aarch64.rpm;name=aarch64_sleuthkit-libs;unpack=0"
SRC_URI[aarch64_sleuthkit-libs.sha256sum] = "1c3dcd537fbd431183cb5b15f723472c6e89bdec8e1477f52f2f160562e52e9e"

RDEPENDS:sleuthkit = " \
 afflib \
 file \
 glibc \
 libewf \
 libgcc \
 libstdc++ \
 mac-robber \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 sleuthkit-libs \
 "
RDEPENDS:sleuthkit-devel = " \
 libewf-devel \
 pkgconf-pkg-config \
 sleuthkit-libs \
 sqlite-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:sleuthkit-libs = " \
 afflib \
 glibc \
 libewf \
 libgcc \
 libstdc++ \
 sqlite-libs \
 zlib-ng-compat \
 "
