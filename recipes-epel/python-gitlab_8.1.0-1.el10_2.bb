# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-gitlab"
PV = "8.1.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-gitlab \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-gitlab-8.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e0a65bb36f24cf164bbdd07516f2b562d23e58463b4b326a91c18893822b3d6"

URI_x86_64_v2_python3-gitlab = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gitlab-8.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gitlab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gitlab}"
SRC_URI[x86_64_v2_python3-gitlab.sha256sum] = "bd40e2115187efbfd2f3c918cf6d468421a7421ae3194023744122ffea72a89b"

URI_aarch64_python3-gitlab = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gitlab-8.1.0-1.el10_2.noarch.rpm;name=aarch64_python3-gitlab;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gitlab}"
SRC_URI[aarch64_python3-gitlab.sha256sum] = "ac0888490d485f66d4f674b8b3508674ecb9c8a023e1671cbf21544d500f1330"

RDEPENDS:python3-gitlab = " \
 python3 \
 python3-requests \
 python3-requests-toolbelt \
 "
