# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Gtk3-SimpleList"
PV = "0.21"
PR = "18.el10_0"
PACKAGES = " \
 perl-Gtk3-SimpleList \
 perl-Gtk3-SimpleList-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Gtk3-SimpleList-0.21-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44a51a924330dcac3af95841653274211e852411f6ebb66577333416f161f6b0"

URI_x86_64_v2_perl-Gtk3-SimpleList = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-SimpleList-0.21-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3-SimpleList;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3-SimpleList}"
SRC_URI[x86_64_v2_perl-Gtk3-SimpleList.sha256sum] = "34fc615e5ccf78bf77df143608686c301d055efdc35e65621633a4237e37e4ca"

URI_x86_64_v2_perl-Gtk3-SimpleList-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-SimpleList-tests-0.21-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3-SimpleList-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3-SimpleList-tests}"
SRC_URI[x86_64_v2_perl-Gtk3-SimpleList-tests.sha256sum] = "9d2b20b078ac43b5ce5514e289c929bafa3a32351abbdb4597988259c48fbd13"

URI_aarch64_perl-Gtk3-SimpleList = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-SimpleList-0.21-18.el10_0.noarch.rpm;name=aarch64_perl-Gtk3-SimpleList;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3-SimpleList}"
SRC_URI[aarch64_perl-Gtk3-SimpleList.sha256sum] = "9834b11ffa780d52ba2042ad9ffb660545dfad01cc651bb81c2dbdb8772fb7fd"

URI_aarch64_perl-Gtk3-SimpleList-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-SimpleList-tests-0.21-18.el10_0.noarch.rpm;name=aarch64_perl-Gtk3-SimpleList-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3-SimpleList-tests}"
SRC_URI[aarch64_perl-Gtk3-SimpleList-tests.sha256sum] = "1201fd6907c762445d88d3384c9abf7a1f3b39a50271295f308e6ed12c8c8dbc"

RDEPENDS:perl-Gtk3-SimpleList = " \
 perl-Carp \
 perl-Gtk3 \
 perl-libs \
 "
RDEPENDS:perl-Gtk3-SimpleList-tests = " \
 bash \
 perl-Gtk3-SimpleList \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 "
