# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "foomuuri"
PV = "0.31"
PR = "1.el10_2"
PACKAGES = " \
 foomuuri \
 foomuuri-firewalld \
 foomuuri_exporter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/foomuuri-0.31-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8479131b1cb5a50486e81e87acdcb9a9c1ef7f72dde4587da3575def1cae8123"

URI_x86_64_v2_foomuuri = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/foomuuri-0.31-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_foomuuri;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_foomuuri}"
SRC_URI[x86_64_v2_foomuuri.sha256sum] = "5e296f049f8d075cc16010c22dbc4ca683614ead1c9a1662e6861c1c5aff9f82"

URI_x86_64_v2_foomuuri-firewalld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/foomuuri-firewalld-0.31-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_foomuuri-firewalld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_foomuuri-firewalld}"
SRC_URI[x86_64_v2_foomuuri-firewalld.sha256sum] = "68025ff0318c68608bef4234c7a07434085457acfcdf51db1f185bfa28d8ac79"

URI_x86_64_v2_foomuuri_exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/foomuuri_exporter-0.31-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_foomuuri_exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_foomuuri_exporter}"
SRC_URI[x86_64_v2_foomuuri_exporter.sha256sum] = "b66415c36da1ab30437466168f3f4e3b138e2de686e7840d88680de7b97e932b"

URI_aarch64_foomuuri = "${EPEL_MIRROR}/aarch64/Packages/f/foomuuri-0.31-1.el10_2.noarch.rpm;name=aarch64_foomuuri;unpack=0"
SRC_URI:append = " ${URI_aarch64_foomuuri}"
SRC_URI[aarch64_foomuuri.sha256sum] = "b3999676b667bd35942369e5de91c3f9b4a362c32778a648fe79217eefb46ae2"

URI_aarch64_foomuuri-firewalld = "${EPEL_MIRROR}/aarch64/Packages/f/foomuuri-firewalld-0.31-1.el10_2.noarch.rpm;name=aarch64_foomuuri-firewalld;unpack=0"
SRC_URI:append = " ${URI_aarch64_foomuuri-firewalld}"
SRC_URI[aarch64_foomuuri-firewalld.sha256sum] = "824930e68f842204fee4b2f6932098a3be4cb6697515d08b0fc4dc1b86846bb9"

URI_aarch64_foomuuri_exporter = "${EPEL_MIRROR}/aarch64/Packages/f/foomuuri_exporter-0.31-1.el10_2.noarch.rpm;name=aarch64_foomuuri_exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_foomuuri_exporter}"
SRC_URI[aarch64_foomuuri_exporter.sha256sum] = "9b5e5a8e14bb15f3e58c6da3319fb5ed0496ebb79640bb909f3e923636b453a7"

RDEPENDS:foomuuri = " \
 bash \
 nftables \
 python3 \
 python3-dbus \
 python3-gobject \
 python3-systemd \
 systemd \
 "
RDEPENDS:foomuuri-firewalld = " \
 foomuuri \
 "
RDEPENDS:foomuuri_exporter = " \
 bash \
 python3 \
 python3-prometheus_client \
 "
