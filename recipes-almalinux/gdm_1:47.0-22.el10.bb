# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdm"
PE = "1"
PV = "47.0"
PR = "22.el10"
PACKAGES = " \
 gdm \
 gdm-devel \
 gdm-pam-extensions-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdm-47.0-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d677ffdcc0c0893093bbe896db9da118fbf097e6061606c6f1e77a73dff071b"

URI_x86_64_v2_gdm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdm-47.0-22.el10.x86_64_v2.rpm;name=x86_64_v2_gdm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdm}"
SRC_URI[x86_64_v2_gdm.sha256sum] = "263a1ad7df62e09616c029c524baa6f1cce8e340ba50b5227c4a3ac466c7a51c"

URI_x86_64_v2_gdm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdm-devel-47.0-22.el10.x86_64_v2.rpm;name=x86_64_v2_gdm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdm-devel}"
SRC_URI[x86_64_v2_gdm-devel.sha256sum] = "bbe5430d60fda74180237a15c68e04f0824ffa1465b7fe5ab2821d89c8c4c4ef"

URI_x86_64_v2_gdm-pam-extensions-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdm-pam-extensions-devel-47.0-22.el10.x86_64_v2.rpm;name=x86_64_v2_gdm-pam-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdm-pam-extensions-devel}"
SRC_URI[x86_64_v2_gdm-pam-extensions-devel.sha256sum] = "bc2ac05d7b07683acbb36cae11d65c033b5a5dce0deacb8e0a55f2595bbee645"

URI_aarch64_gdm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdm-47.0-22.el10.aarch64.rpm;name=aarch64_gdm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdm}"
SRC_URI[aarch64_gdm.sha256sum] = "74cdf6dc6fceafc7fb809ea3e1623e315f68fb3c99df1f523781e4c0e448a6de"

URI_aarch64_gdm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdm-devel-47.0-22.el10.aarch64.rpm;name=aarch64_gdm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdm-devel}"
SRC_URI[aarch64_gdm-devel.sha256sum] = "fd824f43219107ad29233cb9a81259e6aa84477ee7e55e0bba3b1ef10d9e5215"

URI_aarch64_gdm-pam-extensions-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdm-pam-extensions-devel-47.0-22.el10.aarch64.rpm;name=aarch64_gdm-pam-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdm-pam-extensions-devel}"
SRC_URI[aarch64_gdm-pam-extensions-devel.sha256sum] = "0c74ccec9dfb570318318f328fe05c357c910732794220e1bd7d40babc9481f8"

RDEPENDS:gdm = " \
 accountsservice \
 accountsservice-libs \
 almalinux-logos \
 audit-libs \
 bash \
 dbus-daemon \
 dconf \
 glib2 \
 glibc \
 gnome-keyring-pam \
 gnome-session \
 gnome-session-wayland-session \
 gnome-settings-daemon \
 gnome-shell \
 iso-codes \
 json-glib \
 keyutils-libs \
 libXau \
 libgcc \
 libgudev \
 libselinux \
 pam \
 pam-libs \
 polkit-libs \
 python3-pam \
 shadow-utils \
 systemd \
 systemd-libs \
 util-linux \
 "
RDEPENDS:gdm-devel = " \
 gdm \
 gdm-pam-extensions-devel \
 glib2-devel \
 libselinux-devel \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:gdm-pam-extensions-devel = " \
 pam-devel \
 pkgconf-pkg-config \
 "
