# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpwquality"
PV = "1.4.5"
PR = "12.el10"
PACKAGES = " \
 libpwquality \
 libpwquality-devel \
 python3-pwquality \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libpwquality-1.4.5-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0d2708000e62c921872dfc43de8b29f46f8b4f9bc71a958c321b856ef383af4"

URI_x86_64_v2_libpwquality = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpwquality-1.4.5-12.el10.x86_64_v2.rpm;name=x86_64_v2_libpwquality;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpwquality}"
SRC_URI[x86_64_v2_libpwquality.sha256sum] = "7e77b82f9ef9573d2bd290cc7e44cb98535d7bece45680ab485462b691824f92"

URI_x86_64_v2_libpwquality-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libpwquality-devel-1.4.5-12.el10.x86_64_v2.rpm;name=x86_64_v2_libpwquality-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpwquality-devel}"
SRC_URI[x86_64_v2_libpwquality-devel.sha256sum] = "8e12aa24305ecd65d4eea63a527a3ee512aba78d804a5c74207f23e32cee8d72"

URI_x86_64_v2_python3-pwquality = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pwquality-1.4.5-12.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pwquality;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pwquality}"
SRC_URI[x86_64_v2_python3-pwquality.sha256sum] = "7dc4eeaefa3b8eb5c830d49816b2e202870f6d908ace79ff906937ff258b6b44"

URI_aarch64_libpwquality = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpwquality-1.4.5-12.el10.aarch64.rpm;name=aarch64_libpwquality;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpwquality}"
SRC_URI[aarch64_libpwquality.sha256sum] = "6259e1a5a07cfa64a0dad5cd166ac98c0b21745ae9d80d4745d46cfd0b27f5c6"

URI_aarch64_libpwquality-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libpwquality-devel-1.4.5-12.el10.aarch64.rpm;name=aarch64_libpwquality-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpwquality-devel}"
SRC_URI[aarch64_libpwquality-devel.sha256sum] = "29d16b3d9581c3b953a1b756ca61b545d5f5c92ebdc2caf87a1424d40fb8c9bd"

URI_aarch64_python3-pwquality = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pwquality-1.4.5-12.el10.aarch64.rpm;name=aarch64_python3-pwquality;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pwquality}"
SRC_URI[aarch64_python3-pwquality.sha256sum] = "28270bbf5cb84a7ae6946bad0be810307b9b78bbbed8d7b1849fe4b48c8c4adf"

RDEPENDS:libpwquality = " \
 cracklib \
 cracklib-dicts \
 glibc \
 pam-libs \
 "
RDEPENDS:libpwquality-devel = " \
 libpwquality \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-pwquality = " \
 glibc \
 libpwquality \
 python3 \
 "
