# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quickcheck"
PV = "1.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-quickcheck+default-devel \
 rust-quickcheck+env_logger-devel \
 rust-quickcheck+log-devel \
 rust-quickcheck+regex-devel \
 rust-quickcheck+use_logging-devel \
 rust-quickcheck-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quickcheck-1.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f691360c8c2ccfefe060cdbb85245d6a41e34d851de6c84e1a4ac043ad6bdea0"

URI_x86_64_v2_rust-quickcheck+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck+default-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck+default-devel}"
SRC_URI[x86_64_v2_rust-quickcheck+default-devel.sha256sum] = "a273fab0665d61af14aaa974866c9bff7b9362e8e7bc5a7a62d1f48086ce6e9b"

URI_x86_64_v2_rust-quickcheck+env_logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck+env_logger-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck+env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck+env_logger-devel}"
SRC_URI[x86_64_v2_rust-quickcheck+env_logger-devel.sha256sum] = "e401a0b22578773d1fdf654b88d6e20d55f3e4c062795d645fe55c0ca18c45c1"

URI_x86_64_v2_rust-quickcheck+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck+log-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck+log-devel}"
SRC_URI[x86_64_v2_rust-quickcheck+log-devel.sha256sum] = "9593dd853f2ac809b9a651879b28d2d0de248fc0dfc5eac80ed90819d32b65e7"

URI_x86_64_v2_rust-quickcheck+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck+regex-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck+regex-devel}"
SRC_URI[x86_64_v2_rust-quickcheck+regex-devel.sha256sum] = "9718e98eaa1ca167794bfea4b07ae97b198cc543db0305867496780cc28ca3c7"

URI_x86_64_v2_rust-quickcheck+use_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck+use_logging-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck+use_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck+use_logging-devel}"
SRC_URI[x86_64_v2_rust-quickcheck+use_logging-devel.sha256sum] = "c5c7ccdb04ea273ea0b45c364245b6d9a890cde933c25bad4b97500ebda6bb65"

URI_x86_64_v2_rust-quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck-devel}"
SRC_URI[x86_64_v2_rust-quickcheck-devel.sha256sum] = "7fdf5f5acab021e4561605b50a3ddb76f8ec9b2a51e30d42f53dfb74f03c4412"

URI_aarch64_rust-quickcheck+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck+default-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-quickcheck+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck+default-devel}"
SRC_URI[aarch64_rust-quickcheck+default-devel.sha256sum] = "445c218d58d5460a00e7beb2cb71ff9688ad37d84efef6dc7d31e5e0e56f8eaf"

URI_aarch64_rust-quickcheck+env_logger-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck+env_logger-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-quickcheck+env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck+env_logger-devel}"
SRC_URI[aarch64_rust-quickcheck+env_logger-devel.sha256sum] = "a96307f5179655479c6f5d2c0389f3a724e6ed00f18984b73a349da91df026a0"

URI_aarch64_rust-quickcheck+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck+log-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-quickcheck+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck+log-devel}"
SRC_URI[aarch64_rust-quickcheck+log-devel.sha256sum] = "3915005442e1ee65aa30cf6e36dbf0f940552c01dff076002769326548a96912"

URI_aarch64_rust-quickcheck+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck+regex-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-quickcheck+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck+regex-devel}"
SRC_URI[aarch64_rust-quickcheck+regex-devel.sha256sum] = "b68860388f7cbd3c7b12e64966346fbb4822dc7f80cf5a6d83f0b72d4b9ad8aa"

URI_aarch64_rust-quickcheck+use_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck+use_logging-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-quickcheck+use_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck+use_logging-devel}"
SRC_URI[aarch64_rust-quickcheck+use_logging-devel.sha256sum] = "ca6149750e2c81e5b21999f4e56d1a9b7a35e1c09e8e1ab5008d3dad16b5764c"

URI_aarch64_rust-quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck-devel}"
SRC_URI[aarch64_rust-quickcheck-devel.sha256sum] = "2234e1a58dc51fa4b4b81e0a4f9663425369d234dcdb732011d70ab0985ddeb1"

RDEPENDS:rust-quickcheck+default-devel = " \
 cargo \
 rust-quickcheck+regex-devel \
 rust-quickcheck+use_logging-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-quickcheck+env_logger-devel = " \
 cargo \
 rust-env_logger-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-quickcheck+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-quickcheck+regex-devel = " \
 cargo \
 rust-env_logger+regex-devel \
 rust-env_logger-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-quickcheck+use_logging-devel = " \
 cargo \
 rust-quickcheck+env_logger-devel \
 rust-quickcheck+log-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-quickcheck-devel = " \
 cargo \
 rust \
 rust-rand+sys_rng-devel \
 rust-rand-devel \
 "
