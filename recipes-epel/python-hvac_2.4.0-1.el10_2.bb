# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-hvac"
PV = "2.4.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-hvac \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-hvac-2.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7cca2fdaf50aa2c474339da1451e9b23f04398337f0ce77fcf0d3165198b3cc4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hvac-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hvac;unpack=0"
SRC_URI[x86_64_v2_python3-hvac.sha256sum] = "3c3491dd5ce367e32859713bb2152148db50ff25f77f4b896db775906285dc71"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-hvac-2.4.0-1.el10_2.noarch.rpm;name=aarch64_python3-hvac;unpack=0"
SRC_URI[aarch64_python3-hvac.sha256sum] = "9b91c503ad90665e1960bc3ca33b3c92f359b93a925f65eb89ffdf5862efbd70"

RDEPENDS:python3-hvac = " \
 python3 \
 python3-requests \
 "
