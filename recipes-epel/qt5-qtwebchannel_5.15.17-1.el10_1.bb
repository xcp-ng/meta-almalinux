# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtwebchannel"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtwebchannel \
 qt5-qtwebchannel-devel \
 qt5-qtwebchannel-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtwebchannel-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b2b2015b1da534e212e3b4fc3430a02a365d78c8f14be168581aebd5f22a0f3"

URI_x86_64_v2_qt5-qtwebchannel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebchannel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebchannel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebchannel}"
SRC_URI[x86_64_v2_qt5-qtwebchannel.sha256sum] = "fa0c1d64e9cbcb830798dac228624fb21f2a057980bf1c309bb4edff344cc2a4"

URI_x86_64_v2_qt5-qtwebchannel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebchannel-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebchannel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebchannel-devel}"
SRC_URI[x86_64_v2_qt5-qtwebchannel-devel.sha256sum] = "9593498c9e2223c93d5901fe2cbb5cdc69e000591523e72a772e32af00296dc3"

URI_x86_64_v2_qt5-qtwebchannel-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebchannel-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebchannel-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebchannel-examples}"
SRC_URI[x86_64_v2_qt5-qtwebchannel-examples.sha256sum] = "46e2a4cc4efe4fe1b7a4f2103352b07fbc82d1baf7a22b4a98d59306c267125f"

URI_aarch64_qt5-qtwebchannel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebchannel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtwebchannel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebchannel}"
SRC_URI[aarch64_qt5-qtwebchannel.sha256sum] = "d95526d4a39f77ad7365e9ce48a1077e049b7a86926677e3dd958f8bff274d93"

URI_aarch64_qt5-qtwebchannel-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebchannel-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtwebchannel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebchannel-devel}"
SRC_URI[aarch64_qt5-qtwebchannel-devel.sha256sum] = "1754625dfe66617d0403feb16f245775d2af8ceea11256a8d03aa8f9485dc5bd"

URI_aarch64_qt5-qtwebchannel-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebchannel-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtwebchannel-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebchannel-examples}"
SRC_URI[aarch64_qt5-qtwebchannel-examples.sha256sum] = "615f4e42789387f5d5716cf2d76f57d3f0108d52246dac84238f5cce35e6090b"

RDEPENDS:qt5-qtwebchannel = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtwebchannel-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtwebchannel \
 "
RDEPENDS:qt5-qtwebchannel-examples = " \
 glibc \
 libstdc++ \
 nodejs \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtwebchannel \
 qt5-qtwebsockets \
 "
