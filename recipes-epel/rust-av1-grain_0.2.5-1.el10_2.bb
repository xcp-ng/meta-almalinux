# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-av1-grain"
PV = "0.2.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-av1-grain+create-devel \
 rust-av1-grain+default-devel \
 rust-av1-grain+diff-devel \
 rust-av1-grain+estimate-devel \
 rust-av1-grain+nom-devel \
 rust-av1-grain+num-rational-devel \
 rust-av1-grain+parse-devel \
 rust-av1-grain+serde-devel \
 rust-av1-grain+serialize-devel \
 rust-av1-grain+unstable-devel \
 rust-av1-grain+v_frame-devel \
 rust-av1-grain-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-av1-grain-0.2.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75e404971cc351c0bd116b68e996e36942bef32a2f8d77412f45044a258c1a40"

URI_x86_64_v2_rust-av1-grain+create-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+create-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+create-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+create-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+create-devel.sha256sum] = "fd06e25fbc7deeaabd4321b5ab8a2dd39706969cabea8ecd2d59b73fedf27e76"

URI_x86_64_v2_rust-av1-grain+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+default-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+default-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+default-devel.sha256sum] = "79d93dce3d0c13dda532eb38f477ca934f9e95de482f4b95f126db3a65c0c45c"

URI_x86_64_v2_rust-av1-grain+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+diff-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+diff-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+diff-devel.sha256sum] = "1c653f41eb1299f6e73df22f6387d653528b7d61533b0fec881704e4dba430e1"

URI_x86_64_v2_rust-av1-grain+estimate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+estimate-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+estimate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+estimate-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+estimate-devel.sha256sum] = "80f570c5c708204b0ceeab220a69f097cc8e72513702282f8282ee39209e8000"

URI_x86_64_v2_rust-av1-grain+nom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+nom-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+nom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+nom-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+nom-devel.sha256sum] = "cacba66c74d7a326f839f2a946d35e0ff37e9cc60077e653a5efccac60295140"

URI_x86_64_v2_rust-av1-grain+num-rational-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+num-rational-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+num-rational-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+num-rational-devel.sha256sum] = "fd9cc8f8cf1e305fcdb3d902b177fe898debaed91b7b9e707d06e7e5f3f1b631"

URI_x86_64_v2_rust-av1-grain+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+parse-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+parse-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+parse-devel.sha256sum] = "e214534675cd1b72b12010fad6338d4d0cf4bbc7bbb9ea01f21bdc26086c2d11"

URI_x86_64_v2_rust-av1-grain+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+serde-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+serde-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+serde-devel.sha256sum] = "5a162c6b214263ac067fc30e07b59dfa06b9daea44089558fb27d48f90c2572e"

URI_x86_64_v2_rust-av1-grain+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+serialize-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+serialize-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+serialize-devel.sha256sum] = "463f6cd074ccc843beb0afbb8a65150282512a4b8960785b93653053b20c389f"

URI_x86_64_v2_rust-av1-grain+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+unstable-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+unstable-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+unstable-devel.sha256sum] = "11309f96b578cea4357a95aa0a3ee01b775fdfab8e0e23f1c1c436a6e33d36fa"

URI_x86_64_v2_rust-av1-grain+v_frame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+v_frame-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+v_frame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+v_frame-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+v_frame-devel.sha256sum] = "75d87f9e55a2ce0d2dd73fc80dde90af977dbc33caeb9dc2f2d9b9118798ea59"

URI_x86_64_v2_rust-av1-grain-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain-devel}"
SRC_URI[x86_64_v2_rust-av1-grain-devel.sha256sum] = "115bae10484552314a741d20ffaaa260670b0492cde1fa932f1aba1a8fb5a8fe"

URI_aarch64_rust-av1-grain+create-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+create-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-av1-grain+create-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+create-devel}"
SRC_URI[aarch64_rust-av1-grain+create-devel.sha256sum] = "aad52773491ab0283794779113ba76b6e7ea9e298fdfbb35354d6a0a15877c1d"

URI_aarch64_rust-av1-grain+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+default-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-av1-grain+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+default-devel}"
SRC_URI[aarch64_rust-av1-grain+default-devel.sha256sum] = "78da5cadb549579c9c3ae2e1b7cfcb13d692e69b944d5155690758bbc42bde00"

URI_aarch64_rust-av1-grain+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+diff-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-av1-grain+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+diff-devel}"
SRC_URI[aarch64_rust-av1-grain+diff-devel.sha256sum] = "681ca06af7e1f73f255d3fc03b922f6c6a7cc59f98a0e47cc093ddc04b9e5b49"

URI_aarch64_rust-av1-grain+estimate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+estimate-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-av1-grain+estimate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+estimate-devel}"
SRC_URI[aarch64_rust-av1-grain+estimate-devel.sha256sum] = "c9b1a133d015c13d0cfde65e20024b85a5b67339ca80e6f6cc370c03ccd65fec"

URI_aarch64_rust-av1-grain+nom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+nom-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-av1-grain+nom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+nom-devel}"
SRC_URI[aarch64_rust-av1-grain+nom-devel.sha256sum] = "832bac43d6b7baebc2a8484c5e29a6911032640e5070590841772434eef4eb8b"

URI_aarch64_rust-av1-grain+num-rational-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+num-rational-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-av1-grain+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+num-rational-devel}"
SRC_URI[aarch64_rust-av1-grain+num-rational-devel.sha256sum] = "e73a575cac3934c43012d426acbc9c285dd43b1200fa44dcc52428edf998adcb"

URI_aarch64_rust-av1-grain+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+parse-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-av1-grain+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+parse-devel}"
SRC_URI[aarch64_rust-av1-grain+parse-devel.sha256sum] = "1b9e73b4bac28336e30c0f3463fc58d3d122d38bd8ac57dc9700fefd6cc770fd"

URI_aarch64_rust-av1-grain+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+serde-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-av1-grain+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+serde-devel}"
SRC_URI[aarch64_rust-av1-grain+serde-devel.sha256sum] = "c569efe3edd66339a3e00ab883e351216d4471f26ae3cd9b1f575ec3b3a9786e"

URI_aarch64_rust-av1-grain+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+serialize-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-av1-grain+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+serialize-devel}"
SRC_URI[aarch64_rust-av1-grain+serialize-devel.sha256sum] = "0594ac3595f087b076e063fe48e680b88ca6848b44cc06f93e5c2e500e9c811e"

URI_aarch64_rust-av1-grain+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+unstable-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-av1-grain+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+unstable-devel}"
SRC_URI[aarch64_rust-av1-grain+unstable-devel.sha256sum] = "8c83ca284e53ed752fa620cd0bdf28e4bc3956a1b9c856323bf2c8d97e47adf7"

URI_aarch64_rust-av1-grain+v_frame-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+v_frame-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-av1-grain+v_frame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+v_frame-devel}"
SRC_URI[aarch64_rust-av1-grain+v_frame-devel.sha256sum] = "f703e43d93de5091d28bad38df15858af44e2f875ccfbf2d7e1cfd9c8071d7de"

URI_aarch64_rust-av1-grain-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-av1-grain-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain-devel}"
SRC_URI[aarch64_rust-av1-grain-devel.sha256sum] = "0e7c900e875f410b12955664218e3b37b51f77aa9eca9fc245298c70abe88329"

RDEPENDS:rust-av1-grain+create-devel = " \
 cargo \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+default-devel = " \
 cargo \
 rust-av1-grain+create-devel \
 rust-av1-grain+diff-devel \
 rust-av1-grain+estimate-devel \
 rust-av1-grain+parse-devel \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+diff-devel = " \
 cargo \
 rust-av1-grain+num-rational-devel \
 rust-av1-grain+v_frame-devel \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+estimate-devel = " \
 cargo \
 rust-av1-grain+v_frame-devel \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+nom-devel = " \
 cargo \
 rust-av1-grain-devel \
 rust-nom+default-devel \
 "
RDEPENDS:rust-av1-grain+num-rational-devel = " \
 cargo \
 rust-av1-grain-devel \
 rust-num-rational+default-devel \
 "
RDEPENDS:rust-av1-grain+parse-devel = " \
 cargo \
 rust-av1-grain+nom-devel \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+serde-devel = " \
 cargo \
 rust-av1-grain-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-av1-grain+serialize-devel = " \
 cargo \
 rust-arrayvec+serde-devel \
 rust-av1-grain+serde-devel \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+unstable-devel = " \
 cargo \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+v_frame-devel = " \
 cargo \
 rust-av1-grain-devel \
 rust-v_frame0.3+default-devel \
 "
RDEPENDS:rust-av1-grain-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-arrayvec+default-devel \
 rust-log+default-devel \
 "
