# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-CChecker"
PV = "0.12"
PR = "1.el10_0"
PACKAGES = " \
 perl-ExtUtils-CChecker \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-ExtUtils-CChecker-0.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d15b898f22e174506754380deef8753932077c6f646338e9717ca80b98d9a628"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-CChecker-0.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-CChecker;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-CChecker.sha256sum] = "b903de31c55a8e457854d48f34cc32f8f993bfbd1fa6c408323d872d2dcd492e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-CChecker-0.12-1.el10_0.noarch.rpm;name=aarch64_perl-ExtUtils-CChecker;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-CChecker.sha256sum] = "47d02d8c1e229630bd4cdd73877a1f0f8d25d6eee388cfdb6a636b011eea438a"

RDEPENDS:perl-ExtUtils-CChecker = " \
 perl-Carp \
 perl-ExtUtils-CBuilder \
 perl-Module-Build \
 perl-libs \
 "
