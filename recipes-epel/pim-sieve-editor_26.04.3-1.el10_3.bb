# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pim-sieve-editor"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 pim-sieve-editor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pim-sieve-editor-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14ee55422b4b00b2217b2c985621009048d1d5b7996bf5f6ba5b78e85bd6b85d"

URI_x86_64_v2_pim-sieve-editor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pim-sieve-editor-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pim-sieve-editor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pim-sieve-editor}"
SRC_URI[x86_64_v2_pim-sieve-editor.sha256sum] = "a7dc317acec24cb21f132b794ad41fe154ace294d19966f3cb76455ff99382d4"

URI_aarch64_pim-sieve-editor = "${EPEL_MIRROR}/aarch64/Packages/p/pim-sieve-editor-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_pim-sieve-editor;unpack=0"
SRC_URI:append = " ${URI_aarch64_pim-sieve-editor}"
SRC_URI[aarch64_pim-sieve-editor.sha256sum] = "5c67df72e44f3e2378d1109026f1db65e10fae86cc684ca05219aa3699366993"

RDEPENDS:pim-sieve-editor = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kmailtransport \
 ktextaddons-qt6 \
 libksieve \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
