# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bomber"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 bomber \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/bomber-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "528eb93b38f7ba88c7e8192d059bff1056cc821357a0e9385c80ca00e6be9144"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bomber-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bomber;unpack=0"
SRC_URI[x86_64_v2_bomber.sha256sum] = "52c344f4ca87fc0902584122ca3fc95c335db1fcd50b434d08754e876a991e9e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bomber-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_bomber;unpack=0"
SRC_URI[aarch64_bomber.sha256sum] = "73ba2219a98f5151baac6085c10d82027157f6fc2aae36f62a7c6cd47fc6a70c"

RDEPENDS:bomber = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
