# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akregator"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 akregator \
 akregator-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akregator-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea3e8662a95f24a4d8051fa002d3ede588e173466786c39a05450a78c489609f"

URI_x86_64_v2_akregator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akregator-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akregator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akregator}"
SRC_URI[x86_64_v2_akregator.sha256sum] = "3febfe35ce5f12ed93bfbe9ef316559a8340ce82e2fef861f46d7b829e70ee36"

URI_x86_64_v2_akregator-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akregator-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akregator-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akregator-libs}"
SRC_URI[x86_64_v2_akregator-libs.sha256sum] = "d25601697877b42670ee1175b2c0e4ab2763fdaacf90c3649b58e54a9f3565d8"

URI_aarch64_akregator = "${EPEL_MIRROR}/aarch64/Packages/a/akregator-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akregator;unpack=0"
SRC_URI:append = " ${URI_aarch64_akregator}"
SRC_URI[aarch64_akregator.sha256sum] = "0fa138303b2d546e90f5a10a8c67d939835a5a01d72a25c2e14552eea4966c74"

URI_aarch64_akregator-libs = "${EPEL_MIRROR}/aarch64/Packages/a/akregator-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akregator-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_akregator-libs}"
SRC_URI[aarch64_akregator-libs.sha256sum] = "7dca851c9c2166ae4a040241e65006f135beab897c6ac744a61e2d933bef0d4b"

RDEPENDS:akregator = " \
 akregator-libs \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syndication \
 kontactinterface \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akregator-libs = " \
 akregator \
 glibc \
 grantleetheme \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-ktexttemplate \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syndication \
 kontactinterface \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 messagelib \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
