# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plymouth"
PV = "24.004.60"
PR = "17.el10.alma.2"
PACKAGES = " \
 plymouth \
 plymouth-core-libs \
 plymouth-devel \
 plymouth-graphics-libs \
 plymouth-plugin-fade-throbber \
 plymouth-plugin-label \
 plymouth-plugin-script \
 plymouth-plugin-space-flares \
 plymouth-plugin-two-step \
 plymouth-scripts \
 plymouth-system-theme \
 plymouth-theme-fade-in \
 plymouth-theme-script \
 plymouth-theme-solar \
 plymouth-theme-spinfinity \
 plymouth-theme-spinner \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/plymouth-24.004.60-17.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c4a84488cf59038ed7b4538b85470b86e25838dc2855ba6d79771fdc8826b03"

URI_x86_64_v2_plymouth = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth}"
SRC_URI[x86_64_v2_plymouth.sha256sum] = "0bd1af06c42d45d0728f1d58e410f18275e4e809a3142a5bcf1ff21396689810"

URI_x86_64_v2_plymouth-core-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-core-libs-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth-core-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-core-libs}"
SRC_URI[x86_64_v2_plymouth-core-libs.sha256sum] = "4171352c0949e0442b765a9f9ab18d9a59463331706f06bbc7197ddaf32733ce"

URI_x86_64_v2_plymouth-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-devel-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-devel}"
SRC_URI[x86_64_v2_plymouth-devel.sha256sum] = "83b51df518f6f0fc7733aa2bead07f069a5d29f963edf09c55d57f72c1392c52"

URI_x86_64_v2_plymouth-graphics-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-graphics-libs-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth-graphics-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-graphics-libs}"
SRC_URI[x86_64_v2_plymouth-graphics-libs.sha256sum] = "1c1c70db2efda064e60eea05810d4e2d8e4c29531844dbc35d208c17401d82ea"

URI_x86_64_v2_plymouth-plugin-fade-throbber = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-plugin-fade-throbber-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth-plugin-fade-throbber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-plugin-fade-throbber}"
SRC_URI[x86_64_v2_plymouth-plugin-fade-throbber.sha256sum] = "b3357ef12035398a4f36afa28672816a0feab12c2e584fb9919edec6a1bc564d"

URI_x86_64_v2_plymouth-plugin-label = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-plugin-label-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth-plugin-label;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-plugin-label}"
SRC_URI[x86_64_v2_plymouth-plugin-label.sha256sum] = "646ac082ae7215cae5d9a1dff4f6ccda9d3825ac413e6cd4de29bafd3a5c26de"

URI_x86_64_v2_plymouth-plugin-script = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-plugin-script-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth-plugin-script;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-plugin-script}"
SRC_URI[x86_64_v2_plymouth-plugin-script.sha256sum] = "22f2f461f3c561e168900d95ae9354d6976b18468b2e69029900debfc732bdc9"

URI_x86_64_v2_plymouth-plugin-space-flares = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-plugin-space-flares-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth-plugin-space-flares;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-plugin-space-flares}"
SRC_URI[x86_64_v2_plymouth-plugin-space-flares.sha256sum] = "c6de14fa55f82a633368b994f5453641fa7cda46268911b259f21c03a3f97ac5"

URI_x86_64_v2_plymouth-plugin-two-step = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-plugin-two-step-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth-plugin-two-step;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-plugin-two-step}"
SRC_URI[x86_64_v2_plymouth-plugin-two-step.sha256sum] = "ae957ab439401f0fe66cc8d977987860b1d49c2da9793eb6e22e258578ae6778"

URI_x86_64_v2_plymouth-scripts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-scripts-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-scripts}"
SRC_URI[x86_64_v2_plymouth-scripts.sha256sum] = "100558f05d8cc76e5b3311b6998794579c581d7e334767020f7363f55557f72e"

URI_x86_64_v2_plymouth-system-theme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-system-theme-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth-system-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-system-theme}"
SRC_URI[x86_64_v2_plymouth-system-theme.sha256sum] = "093af5ae304ec84a251d13010514c3b375854fab4b2ffec19a6d1d175c2c1cdb"

URI_x86_64_v2_plymouth-theme-fade-in = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-theme-fade-in-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth-theme-fade-in;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-fade-in}"
SRC_URI[x86_64_v2_plymouth-theme-fade-in.sha256sum] = "bc407235f1623b1832b4d43caf09f13d092665d31cf1ae6a77bf6d112c09c455"

URI_x86_64_v2_plymouth-theme-script = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-theme-script-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth-theme-script;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-script}"
SRC_URI[x86_64_v2_plymouth-theme-script.sha256sum] = "aa35cf45b547247762fa1b31c2200dc9e56221de0997027c38347daf6ade5850"

URI_x86_64_v2_plymouth-theme-solar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-theme-solar-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth-theme-solar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-solar}"
SRC_URI[x86_64_v2_plymouth-theme-solar.sha256sum] = "c6be3daf767e3b79922887b0a264be350a85a2c6d556ec67125ad577c5afea83"

URI_x86_64_v2_plymouth-theme-spinfinity = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-theme-spinfinity-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth-theme-spinfinity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-spinfinity}"
SRC_URI[x86_64_v2_plymouth-theme-spinfinity.sha256sum] = "c8e3a8772172b65dc4a55f02061c35624ae3259e2cf1dbeb1ae7a12bdfd0c118"

URI_x86_64_v2_plymouth-theme-spinner = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-theme-spinner-24.004.60-17.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_plymouth-theme-spinner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-spinner}"
SRC_URI[x86_64_v2_plymouth-theme-spinner.sha256sum] = "de894a67ed78d2e6e87c9c83af1cda364beddcf7989ddf7eb8e33327f2c83f78"

URI_aarch64_plymouth = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth}"
SRC_URI[aarch64_plymouth.sha256sum] = "858b4d34c8885d22f2d1ea9be081902ef8cadee0899a0da6aeaa2ab2d2abc6c5"

URI_aarch64_plymouth-core-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-core-libs-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth-core-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-core-libs}"
SRC_URI[aarch64_plymouth-core-libs.sha256sum] = "febfec2e47d408378494086273bba3e47d1546b3756af830a3ba598206a3c391"

URI_aarch64_plymouth-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-devel-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-devel}"
SRC_URI[aarch64_plymouth-devel.sha256sum] = "ab46372a90955eedf804d3cd58b9281c64971eda86c6eb1c04f8f648dd9627df"

URI_aarch64_plymouth-graphics-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-graphics-libs-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth-graphics-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-graphics-libs}"
SRC_URI[aarch64_plymouth-graphics-libs.sha256sum] = "5c2b91979a1538b90a8b9eff634bd6722c3254452c47c49d96f4ab7a188cfb78"

URI_aarch64_plymouth-plugin-fade-throbber = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-plugin-fade-throbber-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth-plugin-fade-throbber;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-plugin-fade-throbber}"
SRC_URI[aarch64_plymouth-plugin-fade-throbber.sha256sum] = "ea56f1fe52a2efc752159912dd4b055dc1887f4971fde71aa88440c0b2119921"

URI_aarch64_plymouth-plugin-label = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-plugin-label-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth-plugin-label;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-plugin-label}"
SRC_URI[aarch64_plymouth-plugin-label.sha256sum] = "08c6499ef49f92eef536adba3f674493e341a53ccc22d4d2a73a0665783ff8b4"

URI_aarch64_plymouth-plugin-script = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-plugin-script-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth-plugin-script;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-plugin-script}"
SRC_URI[aarch64_plymouth-plugin-script.sha256sum] = "47bdc0ec6dbabeffad503934a9f1485fbb41e5f301afa58fb4472b3b3db79e07"

URI_aarch64_plymouth-plugin-space-flares = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-plugin-space-flares-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth-plugin-space-flares;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-plugin-space-flares}"
SRC_URI[aarch64_plymouth-plugin-space-flares.sha256sum] = "8eb99d6f70df5dfa338b76c0c463caa0714483d3b8e9c825fcbb2632ea8a09fa"

URI_aarch64_plymouth-plugin-two-step = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-plugin-two-step-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth-plugin-two-step;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-plugin-two-step}"
SRC_URI[aarch64_plymouth-plugin-two-step.sha256sum] = "8db6807e6051efa689273287b383c5768165473ef09ded9213d8c47d3ed90c1d"

URI_aarch64_plymouth-scripts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-scripts-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-scripts}"
SRC_URI[aarch64_plymouth-scripts.sha256sum] = "cff865cd7248d68aa3ebb976e936aee2773070df2069576ab7dc4457c480d066"

URI_aarch64_plymouth-system-theme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-system-theme-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth-system-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-system-theme}"
SRC_URI[aarch64_plymouth-system-theme.sha256sum] = "f1bc5ee5081f9df586e231f78c5fb193fb5e20d6093c7fd5bbd2325665d6dfa4"

URI_aarch64_plymouth-theme-fade-in = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-theme-fade-in-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth-theme-fade-in;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-fade-in}"
SRC_URI[aarch64_plymouth-theme-fade-in.sha256sum] = "0ba1ccf19888da7e7b0d50f7a26fa2ecf32a793f4e731a2023ea4e3df5a1e384"

URI_aarch64_plymouth-theme-script = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-theme-script-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth-theme-script;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-script}"
SRC_URI[aarch64_plymouth-theme-script.sha256sum] = "649cf32f4af30ea93359a5cf173b15baa549b0ea0e02547b8fb108a9d59c69e5"

URI_aarch64_plymouth-theme-solar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-theme-solar-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth-theme-solar;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-solar}"
SRC_URI[aarch64_plymouth-theme-solar.sha256sum] = "6107f67899c37539d07a52c7cbb56764de7b662864dbf10f849cde4720888589"

URI_aarch64_plymouth-theme-spinfinity = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-theme-spinfinity-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth-theme-spinfinity;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-spinfinity}"
SRC_URI[aarch64_plymouth-theme-spinfinity.sha256sum] = "65ca17f9ee3caf663ffd054267197dfee3cf28b9730d37c4989e72d9227342c5"

URI_aarch64_plymouth-theme-spinner = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-theme-spinner-24.004.60-17.el10.alma.2.aarch64.rpm;name=aarch64_plymouth-theme-spinner;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-spinner}"
SRC_URI[aarch64_plymouth-theme-spinner.sha256sum] = "bed4aa6029f32922fcf706449be82857b1f03e31b9d1404deaf2dd1084a9daaf"

RDEPENDS:plymouth = " \
 glibc \
 plymouth-core-libs \
 plymouth-scripts \
 xkeyboard-config \
 "
RDEPENDS:plymouth-core-libs = " \
 glibc \
 libevdev \
 libxkbcommon \
 systemd-libs \
 "
RDEPENDS:plymouth-devel = " \
 cairo \
 glib2 \
 glibc \
 gtk3 \
 libevdev-devel \
 libpng-devel \
 libxkbcommon-devel \
 pkgconf-pkg-config \
 plymouth \
 plymouth-core-libs \
 plymouth-devel \
 plymouth-graphics-libs \
 systemd-devel \
 xkeyboard-config-devel \
 "
RDEPENDS:plymouth-graphics-libs = " \
 almalinux-logos \
 glibc \
 libdrm \
 libpng \
 plymouth-core-libs \
 "
RDEPENDS:plymouth-plugin-fade-throbber = " \
 glibc \
 plymouth \
 plymouth-core-libs \
 plymouth-graphics-libs \
 "
RDEPENDS:plymouth-plugin-label = " \
 cairo \
 freetype \
 glib2 \
 glibc \
 pango \
 plymouth \
 plymouth-core-libs \
 plymouth-graphics-libs \
 "
RDEPENDS:plymouth-plugin-script = " \
 glibc \
 plymouth \
 plymouth-core-libs \
 plymouth-graphics-libs \
 "
RDEPENDS:plymouth-plugin-space-flares = " \
 glibc \
 plymouth \
 plymouth-core-libs \
 plymouth-graphics-libs \
 plymouth-plugin-label \
 "
RDEPENDS:plymouth-plugin-two-step = " \
 glibc \
 plymouth \
 plymouth-core-libs \
 plymouth-graphics-libs \
 plymouth-plugin-label \
 "
RDEPENDS:plymouth-scripts = " \
 bash \
 cpio \
 dracut \
 findutils \
 gzip \
 plymouth \
 virtual/coreutils \
 xkeyboard-config \
 "
RDEPENDS:plymouth-system-theme = " \
 plymouth-theme-spinner \
 "
RDEPENDS:plymouth-theme-fade-in = " \
 bash \
 plymouth-plugin-fade-throbber \
 plymouth-scripts \
 "
RDEPENDS:plymouth-theme-script = " \
 plymouth-plugin-script \
 plymouth-scripts \
 "
RDEPENDS:plymouth-theme-solar = " \
 bash \
 plymouth-plugin-space-flares \
 plymouth-scripts \
 "
RDEPENDS:plymouth-theme-spinfinity = " \
 bash \
 plymouth-plugin-two-step \
 plymouth-scripts \
 "
RDEPENDS:plymouth-theme-spinner = " \
 bash \
 plymouth-plugin-two-step \
 plymouth-scripts \
 redhat-mono-vf-fonts \
 redhat-text-vf-fonts \
 "
