# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "desktop-backgrounds"
PV = "45.0.0"
PR = "1.el10_3"
PACKAGES = " \
 desktop-backgrounds-basic \
 desktop-backgrounds-budgie \
 desktop-backgrounds-compat \
 desktop-backgrounds-gnome \
 desktop-backgrounds-kde \
 desktop-backgrounds-waves \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/desktop-backgrounds-45.0.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51650a741cb9938e5c61f13bc29aafe19e2555742fd25e38231db642fd099388"

URI_x86_64_v2_desktop-backgrounds-basic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-basic-45.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-basic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-basic}"
SRC_URI[x86_64_v2_desktop-backgrounds-basic.sha256sum] = "d6bd2f6e6a521855996f238f7f35587c42f9106eee5cbcb81ea4da2871dba8bc"

URI_x86_64_v2_desktop-backgrounds-budgie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-budgie-45.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-budgie}"
SRC_URI[x86_64_v2_desktop-backgrounds-budgie.sha256sum] = "bcd1d7a4da388919ab7dd4d92c49aa95c619cbd57fd92ead1d5d6fd2f5f6bd39"

URI_x86_64_v2_desktop-backgrounds-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-compat-45.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-compat}"
SRC_URI[x86_64_v2_desktop-backgrounds-compat.sha256sum] = "116fdda33a82b9249c8005c9afcd956a9c39e6639afaabc7dcc277d5043c4512"
RPROVIDES:desktop-backgrounds-compat:x86_64_v2 = "virtual/desktop-backgrounds-compat"

URI_x86_64_v2_desktop-backgrounds-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-gnome-45.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-gnome}"
SRC_URI[x86_64_v2_desktop-backgrounds-gnome.sha256sum] = "20e9c32b484a967f995602ddf18d2dde0f6a61b0ce420546ee7a53dbc0b22ad6"

URI_x86_64_v2_desktop-backgrounds-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-kde-45.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-kde}"
SRC_URI[x86_64_v2_desktop-backgrounds-kde.sha256sum] = "abb9a475593ae3fa2c338c6d5808384be1ebb351c4e78c7c561ee9b3d38fc557"
RPROVIDES:desktop-backgrounds-kde:x86_64_v2 = "virtual/system-backgrounds-kde"

URI_x86_64_v2_desktop-backgrounds-waves = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-waves-45.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-waves;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-waves}"
SRC_URI[x86_64_v2_desktop-backgrounds-waves.sha256sum] = "e81baace4ac4cfce5eeb5b0a9c0365fc4b007921e979f79f578109ec07cb1628"

URI_aarch64_desktop-backgrounds-basic = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-basic-45.0.0-1.el10_3.noarch.rpm;name=aarch64_desktop-backgrounds-basic;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-basic}"
SRC_URI[aarch64_desktop-backgrounds-basic.sha256sum] = "d41a5fa396ae2997c024f0ff181e7a5608a457b3f273813f10264e1fae74a01c"

URI_aarch64_desktop-backgrounds-budgie = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-budgie-45.0.0-1.el10_3.noarch.rpm;name=aarch64_desktop-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-budgie}"
SRC_URI[aarch64_desktop-backgrounds-budgie.sha256sum] = "f2d9034102aaa3b4907db3c79bccc77fc395f99b18c0aabbccc5accc07f9c1de"

URI_aarch64_desktop-backgrounds-compat = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-compat-45.0.0-1.el10_3.noarch.rpm;name=aarch64_desktop-backgrounds-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-compat}"
SRC_URI[aarch64_desktop-backgrounds-compat.sha256sum] = "e319840ec1b43a194d55d3bdd05c947c684db11b2653025ce81618830f54d4c5"
RPROVIDES:desktop-backgrounds-compat:aarch64 = "virtual/desktop-backgrounds-compat"

URI_aarch64_desktop-backgrounds-gnome = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-gnome-45.0.0-1.el10_3.noarch.rpm;name=aarch64_desktop-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-gnome}"
SRC_URI[aarch64_desktop-backgrounds-gnome.sha256sum] = "adbb7b13b37c05a5c426a35b5834a9043c4110ed279cb8a3fbbdce35ee9aec11"

URI_aarch64_desktop-backgrounds-kde = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-kde-45.0.0-1.el10_3.noarch.rpm;name=aarch64_desktop-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-kde}"
SRC_URI[aarch64_desktop-backgrounds-kde.sha256sum] = "881ad837d12986a7ba962dd3206fbfb79b2fbdde1345891701fe31025a75ce21"
RPROVIDES:desktop-backgrounds-kde:aarch64 = "virtual/system-backgrounds-kde"

URI_aarch64_desktop-backgrounds-waves = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-waves-45.0.0-1.el10_3.noarch.rpm;name=aarch64_desktop-backgrounds-waves;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-waves}"
SRC_URI[aarch64_desktop-backgrounds-waves.sha256sum] = "95ef33111216e1ece059045c114a09f1cba13847ad25f73eeb50e66c7ee92ae9"

RDEPENDS:desktop-backgrounds-basic = " \
 "
RDEPENDS:desktop-backgrounds-budgie = " \
 f45-backgrounds-budgie \
 gsettings-desktop-schemas \
 "
RDEPENDS:desktop-backgrounds-compat = " \
 f45-backgrounds-base \
 "
RDEPENDS:desktop-backgrounds-gnome = " \
 f45-backgrounds-gnome \
 gsettings-desktop-schemas \
 "
RDEPENDS:desktop-backgrounds-kde = " \
 f45-backgrounds-kde \
 "
RDEPENDS:desktop-backgrounds-waves = " \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/desktop-backgrounds-compat rpm/virtual/system-backgrounds-kde"

PROVIDES:append:aarch64 = " rpm/virtual/desktop-backgrounds-compat rpm/virtual/system-backgrounds-kde"
