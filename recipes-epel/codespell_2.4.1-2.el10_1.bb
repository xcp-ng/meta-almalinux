# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "codespell"
PV = "2.4.1"
PR = "2.el10_1"
PACKAGES = " \
 codespell \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/codespell-2.4.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55903cd5814ef5345a0e3557d55f89441a30d06eb3e2e082a7820e98236c4052"

URI_x86_64_v2_codespell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/codespell-2.4.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_codespell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_codespell}"
SRC_URI[x86_64_v2_codespell.sha256sum] = "8687359223c2e29be0f2e4d8d3cd4a7685e4916037d7a36540cffbdb671b89ec"

URI_aarch64_codespell = "${EPEL_MIRROR}/aarch64/Packages/c/codespell-2.4.1-2.el10_1.noarch.rpm;name=aarch64_codespell;unpack=0"
SRC_URI:append = " ${URI_aarch64_codespell}"
SRC_URI[aarch64_codespell.sha256sum] = "5671510dbf9ceb65c01862081f813d6b2b346737998434594609cc1f581c9683"

RDEPENDS:codespell = " \
 python3 \
 "
