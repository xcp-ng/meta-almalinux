# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gedit-plugins"
PV = "48.1"
PR = "1.el10_1"
PACKAGES = " \
 gedit-plugin-bookmarks \
 gedit-plugin-bracketcompletion \
 gedit-plugin-codecomment \
 gedit-plugin-colorpicker \
 gedit-plugin-drawspaces \
 gedit-plugin-joinlines \
 gedit-plugin-multiedit \
 gedit-plugin-sessionsaver \
 gedit-plugin-smartspaces \
 gedit-plugin-terminal \
 gedit-plugin-wordcompletion \
 gedit-plugins \
 gedit-plugins-data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gedit-plugins-48.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1211fc0db26360ed41dce389ae397d1b2d7c88e591f723da0248551e0c98b9d8"

URI_x86_64_v2_gedit-plugin-bookmarks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-bookmarks-48.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-bookmarks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gedit-plugin-bookmarks}"
SRC_URI[x86_64_v2_gedit-plugin-bookmarks.sha256sum] = "fc32a11e0862c47c6d2c9609fb2958cf5f18c07189016b08f61b5fe0e134434d"

URI_x86_64_v2_gedit-plugin-bracketcompletion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-bracketcompletion-48.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-bracketcompletion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gedit-plugin-bracketcompletion}"
SRC_URI[x86_64_v2_gedit-plugin-bracketcompletion.sha256sum] = "facd4c2c3572194452068ecd40ab269753f2aa0fa1ed330fb59d55b7dafc8443"

URI_x86_64_v2_gedit-plugin-codecomment = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-codecomment-48.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-codecomment;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gedit-plugin-codecomment}"
SRC_URI[x86_64_v2_gedit-plugin-codecomment.sha256sum] = "f2927a0aafb39c14ded2edacf1b28ce95dd375e6eafe9ce85360b74746844a3a"

URI_x86_64_v2_gedit-plugin-colorpicker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-colorpicker-48.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-colorpicker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gedit-plugin-colorpicker}"
SRC_URI[x86_64_v2_gedit-plugin-colorpicker.sha256sum] = "c907241b5df0e26380496636582ba221371d0847ab52a1e85508e093250c3ca5"

URI_x86_64_v2_gedit-plugin-drawspaces = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-drawspaces-48.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-drawspaces;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gedit-plugin-drawspaces}"
SRC_URI[x86_64_v2_gedit-plugin-drawspaces.sha256sum] = "b2cdec50e5e02f95d3472ba6b0162fc420ad8f10267c46b0c6e3ab52304813e2"

URI_x86_64_v2_gedit-plugin-joinlines = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-joinlines-48.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-joinlines;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gedit-plugin-joinlines}"
SRC_URI[x86_64_v2_gedit-plugin-joinlines.sha256sum] = "8eb7dd81723c9e2ecd6050796edd51fbdc4af2b835c6ba81ccb865f143757216"

URI_x86_64_v2_gedit-plugin-multiedit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-multiedit-48.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-multiedit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gedit-plugin-multiedit}"
SRC_URI[x86_64_v2_gedit-plugin-multiedit.sha256sum] = "8e15c066eaa66846793d9fab1074a10a989a82a2d52b88c8d138bf16a4d8be89"

URI_x86_64_v2_gedit-plugin-sessionsaver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-sessionsaver-48.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-sessionsaver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gedit-plugin-sessionsaver}"
SRC_URI[x86_64_v2_gedit-plugin-sessionsaver.sha256sum] = "588be9bb95df3dc8e85c44c9fe974e9b4a5b79c3551728f3c9c413226d49f4ef"

URI_x86_64_v2_gedit-plugin-smartspaces = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-smartspaces-48.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-smartspaces;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gedit-plugin-smartspaces}"
SRC_URI[x86_64_v2_gedit-plugin-smartspaces.sha256sum] = "aed6c196639b8114ee8f95cabb337b9c76b3d2b8f7dcd621d1b378c1b734713c"

URI_x86_64_v2_gedit-plugin-terminal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-terminal-48.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-terminal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gedit-plugin-terminal}"
SRC_URI[x86_64_v2_gedit-plugin-terminal.sha256sum] = "89b91686347d7841a1932e7c60e717c3018048c39469bfbcc42a1ac0ccf878c5"

URI_x86_64_v2_gedit-plugin-wordcompletion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-wordcompletion-48.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-wordcompletion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gedit-plugin-wordcompletion}"
SRC_URI[x86_64_v2_gedit-plugin-wordcompletion.sha256sum] = "11e1480a0501e48a721dcb9d3d993473f50544a78e078ff9fec0e66d775c850f"

URI_x86_64_v2_gedit-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugins-48.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gedit-plugins}"
SRC_URI[x86_64_v2_gedit-plugins.sha256sum] = "cffba6e25d466603d41273ff73cd1f2d0d7fa6529c0723ab4ccbac41636eeb88"

URI_x86_64_v2_gedit-plugins-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugins-data-48.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugins-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gedit-plugins-data}"
SRC_URI[x86_64_v2_gedit-plugins-data.sha256sum] = "a5e3f4acaf21ce89f2823d805499dd55ee989bd78b8e443eb450125eebf0f5bb"

URI_aarch64_gedit-plugin-bookmarks = "${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-bookmarks-48.1-1.el10_1.aarch64.rpm;name=aarch64_gedit-plugin-bookmarks;unpack=0"
SRC_URI:append = " ${URI_aarch64_gedit-plugin-bookmarks}"
SRC_URI[aarch64_gedit-plugin-bookmarks.sha256sum] = "6b57d9f4ed8a55ad444151ece99c74255c095bf0db0c236f944f44cbdd32a1df"

URI_aarch64_gedit-plugin-bracketcompletion = "${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-bracketcompletion-48.1-1.el10_1.aarch64.rpm;name=aarch64_gedit-plugin-bracketcompletion;unpack=0"
SRC_URI:append = " ${URI_aarch64_gedit-plugin-bracketcompletion}"
SRC_URI[aarch64_gedit-plugin-bracketcompletion.sha256sum] = "868b36510514e1be7cabcc807351f73e32b14da85a954506e772aae73ce1cb4c"

URI_aarch64_gedit-plugin-codecomment = "${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-codecomment-48.1-1.el10_1.aarch64.rpm;name=aarch64_gedit-plugin-codecomment;unpack=0"
SRC_URI:append = " ${URI_aarch64_gedit-plugin-codecomment}"
SRC_URI[aarch64_gedit-plugin-codecomment.sha256sum] = "d28b100870fce9574c08021a31146120ead61a386a0fa4233df76181414675c7"

URI_aarch64_gedit-plugin-colorpicker = "${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-colorpicker-48.1-1.el10_1.aarch64.rpm;name=aarch64_gedit-plugin-colorpicker;unpack=0"
SRC_URI:append = " ${URI_aarch64_gedit-plugin-colorpicker}"
SRC_URI[aarch64_gedit-plugin-colorpicker.sha256sum] = "ae5ef170661e1b6d4ea1b8e7bee50d398cbe3e4a1dcc8f58b91e59aad9fb47d1"

URI_aarch64_gedit-plugin-drawspaces = "${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-drawspaces-48.1-1.el10_1.aarch64.rpm;name=aarch64_gedit-plugin-drawspaces;unpack=0"
SRC_URI:append = " ${URI_aarch64_gedit-plugin-drawspaces}"
SRC_URI[aarch64_gedit-plugin-drawspaces.sha256sum] = "839595fd25ddb92f6a8ecfada48c1c77cbb1ced1564ab877de175c62f878fa24"

URI_aarch64_gedit-plugin-joinlines = "${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-joinlines-48.1-1.el10_1.aarch64.rpm;name=aarch64_gedit-plugin-joinlines;unpack=0"
SRC_URI:append = " ${URI_aarch64_gedit-plugin-joinlines}"
SRC_URI[aarch64_gedit-plugin-joinlines.sha256sum] = "0b778f58c4922387545283807dbf618166475d3f2013327914deb39eb549ff4b"

URI_aarch64_gedit-plugin-multiedit = "${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-multiedit-48.1-1.el10_1.aarch64.rpm;name=aarch64_gedit-plugin-multiedit;unpack=0"
SRC_URI:append = " ${URI_aarch64_gedit-plugin-multiedit}"
SRC_URI[aarch64_gedit-plugin-multiedit.sha256sum] = "dbc1432b1f53e76963d58a4814737ec62006ee28c253eeae7b212ced4a686e68"

URI_aarch64_gedit-plugin-sessionsaver = "${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-sessionsaver-48.1-1.el10_1.aarch64.rpm;name=aarch64_gedit-plugin-sessionsaver;unpack=0"
SRC_URI:append = " ${URI_aarch64_gedit-plugin-sessionsaver}"
SRC_URI[aarch64_gedit-plugin-sessionsaver.sha256sum] = "4364ef68cb0bc8c066761a2bda01215d1b58d9f62968a93f6bf7d891985a9a95"

URI_aarch64_gedit-plugin-smartspaces = "${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-smartspaces-48.1-1.el10_1.aarch64.rpm;name=aarch64_gedit-plugin-smartspaces;unpack=0"
SRC_URI:append = " ${URI_aarch64_gedit-plugin-smartspaces}"
SRC_URI[aarch64_gedit-plugin-smartspaces.sha256sum] = "31e1717699fd81a3f03189411c39b535276138ac0d5249332221ea1731d6319e"

URI_aarch64_gedit-plugin-terminal = "${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-terminal-48.1-1.el10_1.aarch64.rpm;name=aarch64_gedit-plugin-terminal;unpack=0"
SRC_URI:append = " ${URI_aarch64_gedit-plugin-terminal}"
SRC_URI[aarch64_gedit-plugin-terminal.sha256sum] = "29ec09a2e2a34cc2b6fa7ecd261a265b3c5110f8a360a61778b00ab523ce27a7"

URI_aarch64_gedit-plugin-wordcompletion = "${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-wordcompletion-48.1-1.el10_1.aarch64.rpm;name=aarch64_gedit-plugin-wordcompletion;unpack=0"
SRC_URI:append = " ${URI_aarch64_gedit-plugin-wordcompletion}"
SRC_URI[aarch64_gedit-plugin-wordcompletion.sha256sum] = "184f8f0735cba90398af3bfbd2875db41342e8208b51a47b9ece0c68dcab9b32"

URI_aarch64_gedit-plugins = "${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugins-48.1-1.el10_1.aarch64.rpm;name=aarch64_gedit-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_gedit-plugins}"
SRC_URI[aarch64_gedit-plugins.sha256sum] = "d75371c6fe2db98d43f1799872650ccc30c821e1c3a936f27acea4fdbf5c9838"

URI_aarch64_gedit-plugins-data = "${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugins-data-48.1-1.el10_1.aarch64.rpm;name=aarch64_gedit-plugins-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_gedit-plugins-data}"
SRC_URI[aarch64_gedit-plugins-data.sha256sum] = "c81b8fa2affbee0fb19b81f29b0b9a1b4a30d5c030ac64891215b1103ada30cf"

RDEPENDS:gedit-plugin-bookmarks = " \
 gedit \
 gedit-plugins-data \
 glib2 \
 glibc \
 gtk3 \
 libgedit-gtksourceview \
 libpeas1 \
 "
RDEPENDS:gedit-plugin-bracketcompletion = " \
 gedit-plugins-data \
 libpeas1-loader-python3 \
 "
RDEPENDS:gedit-plugin-codecomment = " \
 gedit-plugins-data \
 libpeas1-loader-python3 \
 "
RDEPENDS:gedit-plugin-colorpicker = " \
 gedit-plugins-data \
 libpeas1-loader-python3 \
 "
RDEPENDS:gedit-plugin-drawspaces = " \
 gedit \
 gedit-plugins-data \
 glib2 \
 glibc \
 libgedit-gtksourceview \
 libgedit-tepl \
 libpeas1 \
 libpeas1-gtk \
 "
RDEPENDS:gedit-plugin-joinlines = " \
 gedit-plugins-data \
 libpeas1-loader-python3 \
 "
RDEPENDS:gedit-plugin-multiedit = " \
 gedit-plugins-data \
 libpeas1-loader-python3 \
 "
RDEPENDS:gedit-plugin-sessionsaver = " \
 gedit-plugins-data \
 libpeas1-loader-python3 \
 "
RDEPENDS:gedit-plugin-smartspaces = " \
 gedit \
 gedit-plugins-data \
 glib2 \
 glibc \
 libgedit-gtksourceview \
 libpeas1 \
 libpeas1-loader-python3 \
 "
RDEPENDS:gedit-plugin-terminal = " \
 gedit-plugins-data \
 libpeas1-loader-python3 \
 vte291 \
 "
RDEPENDS:gedit-plugin-wordcompletion = " \
 gedit \
 gedit-plugins-data \
 glib2 \
 glibc \
 gtk3 \
 libgedit-gtksourceview \
 libpeas1 \
 libpeas1-gtk \
 "
RDEPENDS:gedit-plugins = " \
 gedit-plugin-bookmarks \
 gedit-plugin-bracketcompletion \
 gedit-plugin-codecomment \
 gedit-plugin-colorpicker \
 gedit-plugin-drawspaces \
 gedit-plugin-joinlines \
 gedit-plugin-multiedit \
 gedit-plugin-sessionsaver \
 gedit-plugin-smartspaces \
 gedit-plugin-terminal \
 gedit-plugin-wordcompletion \
 "
RDEPENDS:gedit-plugins-data = " \
 gedit \
 python3-gobject \
 "
