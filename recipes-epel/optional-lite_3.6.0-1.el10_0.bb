# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "optional-lite"
PV = "3.6.0"
PR = "1.el10_0"
PACKAGES = " \
 optional-lite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/optional-lite-3.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30abfe303afad3af6fba940b4fcc7b247b1e051d6ae429b241638081fa5f7b62"

URI_x86_64_v2_optional-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/optional-lite-devel-3.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_optional-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_optional-lite-devel}"
SRC_URI[x86_64_v2_optional-lite-devel.sha256sum] = "9cc4d88ff192441935b2f34f7edc5588d4d9df0118ae320a693ae68af14f9144"

URI_aarch64_optional-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/o/optional-lite-devel-3.6.0-1.el10_0.aarch64.rpm;name=aarch64_optional-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_optional-lite-devel}"
SRC_URI[aarch64_optional-lite-devel.sha256sum] = "a9c5294c66cd5ec46f0cc361a32c3a43f408947c34d281393ea59c4f17ad0833"

RDEPENDS:optional-lite-devel = " \
 cmake-filesystem \
 "
