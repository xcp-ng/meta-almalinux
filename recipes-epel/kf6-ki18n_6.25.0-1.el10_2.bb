# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ki18n"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-ki18n \
 kf6-ki18n-devel \
 kf6-ki18n-doc \
 kf6-ki18n-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ki18n-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff2e4217c1ff8d4f173ab2ec8ce8461291d3be62b8b370c8d519eaaca26ec628"

URI_x86_64_v2_kf6-ki18n = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ki18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ki18n}"
SRC_URI[x86_64_v2_kf6-ki18n.sha256sum] = "a7327714edb4a436b755d12eaafc7f6fc4a765906c4f3ccda756c79d539d8e05"

URI_x86_64_v2_kf6-ki18n-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ki18n-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ki18n-devel}"
SRC_URI[x86_64_v2_kf6-ki18n-devel.sha256sum] = "6093273417f0af1abc90869ba1b617a9cd2d8882062d60c8c377c38ced178dac"

URI_x86_64_v2_kf6-ki18n-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ki18n-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ki18n-doc}"
SRC_URI[x86_64_v2_kf6-ki18n-doc.sha256sum] = "313828ddff9e8260dcc49ac67aa7b2f81d3f0f1b3218059013d7272bd2ab4653"

URI_x86_64_v2_kf6-ki18n-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ki18n-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ki18n-html}"
SRC_URI[x86_64_v2_kf6-ki18n-html.sha256sum] = "8d22cd54e20119f1a5e049ca81940d71f30470f377b0e374082e11689f30e41e"

URI_aarch64_kf6-ki18n = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-ki18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ki18n}"
SRC_URI[aarch64_kf6-ki18n.sha256sum] = "1c78ca9ae755ca78f5a2993a48778fec6755bc8105d3bdb2fa0cd9d6031d3a84"

URI_aarch64_kf6-ki18n-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-ki18n-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ki18n-devel}"
SRC_URI[aarch64_kf6-ki18n-devel.sha256sum] = "0a318acd6de0da7277ff462dd15f6292f53c91021f15e99952af8cc9174403b5"

URI_aarch64_kf6-ki18n-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-ki18n-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ki18n-doc}"
SRC_URI[aarch64_kf6-ki18n-doc.sha256sum] = "8bba0c5bec804dd0f6fa97919823d3f4f05f7c333ad6f116e3665f65c850af59"

URI_aarch64_kf6-ki18n-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-ki18n-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ki18n-html}"
SRC_URI[aarch64_kf6-ki18n-html.sha256sum] = "f0c686df124ce8405b2a19227544ee1906a79fd522a089399790fa929557225c"

RDEPENDS:kf6-ki18n = " \
 glibc \
 iso-codes \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-ki18n-devel = " \
 cmake-filesystem \
 gettext \
 kf6-ki18n \
 python3 \
 "
RDEPENDS:kf6-ki18n-doc = " \
 "
RDEPENDS:kf6-ki18n-html = " \
 "
