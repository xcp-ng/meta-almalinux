# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "logrotate"
PV = "3.22.0"
PR = "4.el10"
PACKAGES = " \
 logrotate \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/logrotate-3.22.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b89738208cf8b853f7da113c1b17b952166f5be4bcb6bc9b9b45491e0aa6cdf"

URI_x86_64_v2_logrotate = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/logrotate-3.22.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_logrotate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_logrotate}"
SRC_URI[x86_64_v2_logrotate.sha256sum] = "f320191aae7ddf020394629bb003b2e86ed9394b329b32a05d92f666d9aa925a"

URI_aarch64_logrotate = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/logrotate-3.22.0-4.el10.aarch64.rpm;name=aarch64_logrotate;unpack=0"
SRC_URI:append = " ${URI_aarch64_logrotate}"
SRC_URI[aarch64_logrotate.sha256sum] = "6eac3dac5fb9cdcda5bad32a728e151da6e00e016f37ce57997fdd5c0f476a1a"

RDEPENDS:logrotate = " \
 bash \
 glibc \
 libacl \
 libselinux \
 popt \
 systemd \
 virtual/coreutils \
 "
