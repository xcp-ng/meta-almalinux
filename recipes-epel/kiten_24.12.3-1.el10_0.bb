# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiten"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kiten \
 kiten-devel \
 kiten-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kiten-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6aa130b0103ccb25616bf4ab5966bff0a16756a04f0b070079bc3aee474bd023"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiten-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiten;unpack=0"
SRC_URI[x86_64_v2_kiten.sha256sum] = "476cdffa4a1a242befd50e7fed769f9a915105bc545042fed21c6aa2c9598ac7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiten-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiten-devel;unpack=0"
SRC_URI[x86_64_v2_kiten-devel.sha256sum] = "8f2314feed0361176c09abc030b0d70707be59ef6a20899bbb85bbab696b3104"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiten-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiten-libs;unpack=0"
SRC_URI[x86_64_v2_kiten-libs.sha256sum] = "b686047898259a85d82ae5af12237aa05e9ec414d6b7eb655c3b42b004f50ee8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiten-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kiten;unpack=0"
SRC_URI[aarch64_kiten.sha256sum] = "67b54f12ee1a8cef77c10f351cf01af16b33001dd87095e077ddd6731889e5fc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiten-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kiten-devel;unpack=0"
SRC_URI[aarch64_kiten-devel.sha256sum] = "e0fa5dbf38f0e952679f5770546a314efff4a0d9df9659dbf2b84ac6bb3f2d81"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiten-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kiten-libs;unpack=0"
SRC_URI[aarch64_kiten-libs.sha256sum] = "3078b8c53b219f23234508445cd24e25f760f093f60ebf61ff59f434d133d707"

RDEPENDS:kiten = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kiten-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kiten-devel = " \
 kiten-libs \
 "
RDEPENDS:kiten-libs = " \
 glibc \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kiten \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
