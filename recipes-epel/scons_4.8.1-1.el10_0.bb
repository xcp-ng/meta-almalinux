# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scons"
PV = "4.8.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-scons \
 scons-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scons-4.8.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a956444ffaae299b891ecd094456efc7afadf424f7f4548e4add081dde6f4e7"

URI_x86_64_v2_python3-scons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-scons-4.8.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-scons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-scons}"
SRC_URI[x86_64_v2_python3-scons.sha256sum] = "19dbb158a8d7442b1f5fa290a7f8ffa31eff993d5104408fb0ac7a6b95e96c7f"

URI_x86_64_v2_scons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scons-doc-4.8.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_scons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scons-doc}"
SRC_URI[x86_64_v2_scons-doc.sha256sum] = "e65100fc89e225e52cc4b150e32332e4875e3931508318caf24262e502e66447"

URI_aarch64_python3-scons = "${EPEL_MIRROR}/aarch64/Packages/p/python3-scons-4.8.1-1.el10_0.noarch.rpm;name=aarch64_python3-scons;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-scons}"
SRC_URI[aarch64_python3-scons.sha256sum] = "6b1f34e8db8e5040b3868bd3fe53aa6ce02d8bfe2ba1b9b2866fb1a6f37e1292"

URI_aarch64_scons-doc = "${EPEL_MIRROR}/aarch64/Packages/s/scons-doc-4.8.1-1.el10_0.noarch.rpm;name=aarch64_scons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_scons-doc}"
SRC_URI[aarch64_scons-doc.sha256sum] = "ec03263510def96eac0561c2d85bcea9ac1797345691261415b73aa4fab01a21"

RDEPENDS:python3-scons = " \
 python3 \
 "
RDEPENDS:scons-doc = " \
 "
