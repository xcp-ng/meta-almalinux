# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnf-repo"
PV = "0.6.4"
PR = "1.el10_3"
PACKAGES = " \
 dnf-repo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dnf-repo-0.6.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e71d3aa6b4701c3d65a49debd20fb00d4d85c56bcc5f1c9490741d4c4fbedde"

URI_x86_64_v2_dnf-repo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnf-repo-0.6.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dnf-repo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf-repo}"
SRC_URI[x86_64_v2_dnf-repo.sha256sum] = "8e62a5f7406d0cc2d21a9dc9ebe1bf9633dca15f0da9116c48f64310367124bf"

URI_aarch64_dnf-repo = "${EPEL_MIRROR}/aarch64/Packages/d/dnf-repo-0.6.4-1.el10_3.aarch64.rpm;name=aarch64_dnf-repo;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf-repo}"
SRC_URI[aarch64_dnf-repo.sha256sum] = "292fce2a203d44e7653ca36203b2da34d2afa83a4bbe6f1b8db29e7bce1cf978"

RDEPENDS:dnf-repo = " \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
