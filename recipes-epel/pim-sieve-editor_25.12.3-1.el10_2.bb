# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pim-sieve-editor"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 pim-sieve-editor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pim-sieve-editor-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ca722bfa4157004eaba025e690516e5df481942c94f52b60ff93df86b7f2329"

URI_x86_64_v2_pim-sieve-editor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pim-sieve-editor-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pim-sieve-editor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pim-sieve-editor}"
SRC_URI[x86_64_v2_pim-sieve-editor.sha256sum] = "22b85364c2aab172143e495db814a299a7814bc07c9659623ac0ebd386c7f88b"

URI_aarch64_pim-sieve-editor = "${EPEL_MIRROR}/aarch64/Packages/p/pim-sieve-editor-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_pim-sieve-editor;unpack=0"
SRC_URI:append = " ${URI_aarch64_pim-sieve-editor}"
SRC_URI[aarch64_pim-sieve-editor.sha256sum] = "9725b81a14c5be244d6826064b4815f029b34257ca1842d9201e5b9c6bf3a4ba"

RDEPENDS:pim-sieve-editor = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kmailtransport \
 libksieve \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
