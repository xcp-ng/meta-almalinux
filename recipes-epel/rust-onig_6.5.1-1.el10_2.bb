# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onig"
PV = "6.5.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-onig+default-devel \
 rust-onig+generate-devel \
 rust-onig+posix-api-devel \
 rust-onig+print-debug-devel \
 rust-onig+std-pattern-devel \
 rust-onig-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onig-6.5.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17a0fd8c56043e2ad16fd124f683e3717edccca409046196dd110dac1c2b6a09"

URI_x86_64_v2_rust-onig+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig+default-devel-6.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig+default-devel}"
SRC_URI[x86_64_v2_rust-onig+default-devel.sha256sum] = "b851bafe72c29bed61661c6b3dc61dd8428e0950211fda861ccd6f9ab03d3064"

URI_x86_64_v2_rust-onig+generate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig+generate-devel-6.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig+generate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig+generate-devel}"
SRC_URI[x86_64_v2_rust-onig+generate-devel.sha256sum] = "be788bd0874efffbd303a9245c45136199d0871093ca490fc2ac3c54aca07423"

URI_x86_64_v2_rust-onig+posix-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig+posix-api-devel-6.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig+posix-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig+posix-api-devel}"
SRC_URI[x86_64_v2_rust-onig+posix-api-devel.sha256sum] = "617d49f24ab80bfaf0c2617d8738dd9dfddd99463813839251ffe8646e985b9b"

URI_x86_64_v2_rust-onig+print-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig+print-debug-devel-6.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig+print-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig+print-debug-devel}"
SRC_URI[x86_64_v2_rust-onig+print-debug-devel.sha256sum] = "012be72bb986427536d51394a626885e06c67d4de12922dce5faec8ea1f722b9"

URI_x86_64_v2_rust-onig+std-pattern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig+std-pattern-devel-6.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig+std-pattern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig+std-pattern-devel}"
SRC_URI[x86_64_v2_rust-onig+std-pattern-devel.sha256sum] = "5289b0bfcfdb6a747a005b13043c214d25cb9564bdf6d8e3019b981019f05780"

URI_x86_64_v2_rust-onig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig-devel-6.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig-devel}"
SRC_URI[x86_64_v2_rust-onig-devel.sha256sum] = "9e1adf88d7279d8a61917a88fc2f483bba2aeddc0d984f25eff99c9ab652e44b"

URI_aarch64_rust-onig+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig+default-devel-6.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-onig+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig+default-devel}"
SRC_URI[aarch64_rust-onig+default-devel.sha256sum] = "4d9c73a1833c507f50df4716e5fea532280e04cac4514b4580b5a6dbdf60b5c9"

URI_aarch64_rust-onig+generate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig+generate-devel-6.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-onig+generate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig+generate-devel}"
SRC_URI[aarch64_rust-onig+generate-devel.sha256sum] = "300dccc8d04880a0cf4d0b29a8739b19a59ef62fc963d618fd914877fd6a967d"

URI_aarch64_rust-onig+posix-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig+posix-api-devel-6.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-onig+posix-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig+posix-api-devel}"
SRC_URI[aarch64_rust-onig+posix-api-devel.sha256sum] = "225931d43960d9c11549976cc5cd7ead3e680b1b3ad65882837d1a4172c11654"

URI_aarch64_rust-onig+print-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig+print-debug-devel-6.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-onig+print-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig+print-debug-devel}"
SRC_URI[aarch64_rust-onig+print-debug-devel.sha256sum] = "3f38abc5faef3b46ca06b3c1555237c9b112135e4a5b3f1c37ac236c1af5e279"

URI_aarch64_rust-onig+std-pattern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig+std-pattern-devel-6.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-onig+std-pattern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig+std-pattern-devel}"
SRC_URI[aarch64_rust-onig+std-pattern-devel.sha256sum] = "383d1cadfd68d1e3a82f12bd00c1eb85319b5f730aaccf514a364486ce154ac8"

URI_aarch64_rust-onig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig-devel-6.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-onig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig-devel}"
SRC_URI[aarch64_rust-onig-devel.sha256sum] = "de21d9a855f1ca1f72b7c3a4f37e46abc63398cfe706c8825893be511a83f2c1"

RDEPENDS:rust-onig+default-devel = " \
 cargo \
 rust-onig+generate-devel \
 rust-onig-devel \
 "
RDEPENDS:rust-onig+generate-devel = " \
 cargo \
 rust-onig-devel \
 rust-onig_sys+generate-devel \
 "
RDEPENDS:rust-onig+posix-api-devel = " \
 cargo \
 rust-onig-devel \
 rust-onig_sys+posix-api-devel \
 "
RDEPENDS:rust-onig+print-debug-devel = " \
 cargo \
 rust-onig-devel \
 rust-onig_sys+print-debug-devel \
 "
RDEPENDS:rust-onig+std-pattern-devel = " \
 cargo \
 rust-onig-devel \
 "
RDEPENDS:rust-onig-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-once_cell+default-devel \
 rust-onig_sys-devel \
 "
