# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lasso"
PV = "2.8.2"
PR = "17.el10_0"
PACKAGES = " \
 lasso \
 lasso-devel \
 perl-lasso \
 python3-lasso \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lasso-2.8.2-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7dc8f65ea96621ce93d2dba044a3001dccb5fe55d7b8b496c96257b2a0de4ee"

URI_x86_64_v2_lasso = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lasso-2.8.2-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lasso;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lasso}"
SRC_URI[x86_64_v2_lasso.sha256sum] = "d5775873ddaf800c83ede33fb150240958526a480719188fbc7722b81a578a55"

URI_x86_64_v2_lasso-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lasso-devel-2.8.2-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lasso-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lasso-devel}"
SRC_URI[x86_64_v2_lasso-devel.sha256sum] = "f31dd491c431c2e28cd5de93281e0477c2e91f8e30bdf6c5406d537f4435524e"

URI_x86_64_v2_perl-lasso = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-lasso-2.8.2-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-lasso;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-lasso}"
SRC_URI[x86_64_v2_perl-lasso.sha256sum] = "c1b2fd7b2d0c06349ddf64dd37ad6b102056dda8ba6be7af345ac36658e0cdad"

URI_x86_64_v2_python3-lasso = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lasso-2.8.2-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lasso;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lasso}"
SRC_URI[x86_64_v2_python3-lasso.sha256sum] = "313f45b3a7f338c88b713f921a9d8267a1d7fa42bcba3b576611b2d25f7dbab8"

URI_aarch64_lasso = "${EPEL_MIRROR}/aarch64/Packages/l/lasso-2.8.2-17.el10_0.aarch64.rpm;name=aarch64_lasso;unpack=0"
SRC_URI:append = " ${URI_aarch64_lasso}"
SRC_URI[aarch64_lasso.sha256sum] = "5e414627c13c57cff619147624e1d89242470d4179082d3a61a83433b767faa8"

URI_aarch64_lasso-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lasso-devel-2.8.2-17.el10_0.aarch64.rpm;name=aarch64_lasso-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lasso-devel}"
SRC_URI[aarch64_lasso-devel.sha256sum] = "daf5100ee54279b1672cd824d773ef1a0ae39c942e2ee52336cc5411f5d2da35"

URI_aarch64_perl-lasso = "${EPEL_MIRROR}/aarch64/Packages/p/perl-lasso-2.8.2-17.el10_0.aarch64.rpm;name=aarch64_perl-lasso;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-lasso}"
SRC_URI[aarch64_perl-lasso.sha256sum] = "7d75f8232435cabb45685b964d2a83001043548d58253342040819f7fd451fce"

URI_aarch64_python3-lasso = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lasso-2.8.2-17.el10_0.aarch64.rpm;name=aarch64_python3-lasso;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lasso}"
SRC_URI[aarch64_python3-lasso.sha256sum] = "9eba3fe591f12bd28fa48d8d5120e450b389bd2f364067acb9f184457264fa52"

RDEPENDS:lasso = " \
 glib2 \
 glibc \
 libtool-ltdl \
 libxml2 \
 libxslt \
 openssl-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:lasso-devel = " \
 glib2-devel \
 lasso \
 libxml2-devel \
 libxslt-devel \
 pkgconf-pkg-config \
 xmlsec1-devel \
 "
RDEPENDS:perl-lasso = " \
 glib2 \
 glibc \
 lasso \
 libxml2 \
 perl-libs \
 "
RDEPENDS:python3-lasso = " \
 glib2 \
 glibc \
 lasso \
 libtool-ltdl \
 libxml2 \
 libxslt \
 openssl-libs \
 python3 \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
