# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-dvsekhvalnov-jose2go"
PV = "1.7.0"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-dvsekhvalnov-jose2go-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-dvsekhvalnov-jose2go-1.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65eec0149945f40672265639ef41a302fa83f12cf394bf4f51496a5dcd13b4d3"

URI_x86_64_v2_golang-github-dvsekhvalnov-jose2go-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-dvsekhvalnov-jose2go-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-dvsekhvalnov-jose2go-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-dvsekhvalnov-jose2go-devel}"
SRC_URI[x86_64_v2_golang-github-dvsekhvalnov-jose2go-devel.sha256sum] = "1a1dc85d525b99ed508adae338db3262c8aa011ae7b0bfa3f29bce0eb4df916c"

URI_aarch64_golang-github-dvsekhvalnov-jose2go-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-dvsekhvalnov-jose2go-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_golang-github-dvsekhvalnov-jose2go-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-dvsekhvalnov-jose2go-devel}"
SRC_URI[aarch64_golang-github-dvsekhvalnov-jose2go-devel.sha256sum] = "70aa98e5a4efe7ae99a39369be68b020a4802ae6c6a38ea08b568a233c0c9765"

RDEPENDS:golang-github-dvsekhvalnov-jose2go-devel = " \
 go-filesystem \
 "
