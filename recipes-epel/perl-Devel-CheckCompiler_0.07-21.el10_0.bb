# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-CheckCompiler"
PV = "0.07"
PR = "21.el10_0"
PACKAGES = " \
 perl-Devel-CheckCompiler \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-CheckCompiler-0.07-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1cd741ed633aaeacea52b876aadace3d801e5305c37bb01dd8292df6ab16e54e"

URI_x86_64_v2_perl-Devel-CheckCompiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-CheckCompiler-0.07-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Devel-CheckCompiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-CheckCompiler}"
SRC_URI[x86_64_v2_perl-Devel-CheckCompiler.sha256sum] = "86bbf4ddb51d4008c4c3da6b1fad7d6122de046ccc2868cb6155bf7482825c29"

URI_aarch64_perl-Devel-CheckCompiler = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-CheckCompiler-0.07-21.el10_0.noarch.rpm;name=aarch64_perl-Devel-CheckCompiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-CheckCompiler}"
SRC_URI[aarch64_perl-Devel-CheckCompiler.sha256sum] = "6a9b1367f36e5414fe2ed3313785206f1c509cdf0e1a2b3f50ae33d21598f99e"

RDEPENDS:perl-Devel-CheckCompiler = " \
 perl-Devel-CheckCompiler \
 perl-Exporter \
 perl-ExtUtils-CBuilder \
 perl-File-Temp \
 perl-libs \
 perl-parent \
 "
