# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ladspa-autotalent-plugins"
PV = "0.2"
PR = "48.el10_0"
PACKAGES = " \
 ladspa-autotalent-plugins \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/ladspa-autotalent-plugins-0.2-48.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9a2d352d300619fe6bbc67c1439e56709b30c2e17bb16701d55f31039b4240a"

URI_x86_64_v2_ladspa-autotalent-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ladspa-autotalent-plugins-0.2-48.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ladspa-autotalent-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ladspa-autotalent-plugins}"
SRC_URI[x86_64_v2_ladspa-autotalent-plugins.sha256sum] = "bfc12f1c0607f5347102df61a64ba8ce39119b9c3e024b531477a8942e31f497"

URI_aarch64_ladspa-autotalent-plugins = "${EPEL_MIRROR}/aarch64/Packages/l/ladspa-autotalent-plugins-0.2-48.el10_0.aarch64.rpm;name=aarch64_ladspa-autotalent-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_ladspa-autotalent-plugins}"
SRC_URI[aarch64_ladspa-autotalent-plugins.sha256sum] = "3eb8a43a4a801cc1c12293a0466a95fad879b0cfbe18d160504945bf3bd46bda"

RDEPENDS:ladspa-autotalent-plugins = " \
 glibc \
 ladspa \
 "
