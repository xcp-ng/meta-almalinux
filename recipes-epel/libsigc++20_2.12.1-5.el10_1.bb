# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsigc++20"
PV = "2.12.1"
PR = "5.el10_1"
PACKAGES = " \
 libsigc++20 \
 libsigc++20-devel \
 libsigc++20-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libsigc++20-2.12.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24a34361c3e9d94868ccacdfe4d32437ec486faa52fecd929a98775c0342e50f"

URI_x86_64_v2_libsigc++20 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsigc++20-2.12.1-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsigc++20;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsigc++20}"
SRC_URI[x86_64_v2_libsigc++20.sha256sum] = "b056909c4fcf6ecfc91f4e0a9a827c176fe85be48a303443b1c231195ae2952a"

URI_x86_64_v2_libsigc++20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsigc++20-devel-2.12.1-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsigc++20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsigc++20-devel}"
SRC_URI[x86_64_v2_libsigc++20-devel.sha256sum] = "43ecc6a214cfc2e6ef25eaf41f104f8aeb3afa71413ee739df1fbfc48773ac3d"

URI_x86_64_v2_libsigc++20-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsigc++20-doc-2.12.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libsigc++20-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsigc++20-doc}"
SRC_URI[x86_64_v2_libsigc++20-doc.sha256sum] = "faf93e9ed0d09845843101612094233322417c997ce32b9dca990b5de029695b"

URI_aarch64_libsigc++20 = "${EPEL_MIRROR}/aarch64/Packages/l/libsigc++20-2.12.1-5.el10_1.aarch64.rpm;name=aarch64_libsigc++20;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsigc++20}"
SRC_URI[aarch64_libsigc++20.sha256sum] = "03e53d8aa4dce52206785d4ddeccf0af0e5ca5cdbe88d5a7704f7fe673c4eb2f"

URI_aarch64_libsigc++20-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libsigc++20-devel-2.12.1-5.el10_1.aarch64.rpm;name=aarch64_libsigc++20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsigc++20-devel}"
SRC_URI[aarch64_libsigc++20-devel.sha256sum] = "d4e6184e1cb13ac5b7b902d406ec6980c9b1d89cb70b760d35e5f9cdd42472fb"

URI_aarch64_libsigc++20-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libsigc++20-doc-2.12.1-5.el10_1.noarch.rpm;name=aarch64_libsigc++20-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsigc++20-doc}"
SRC_URI[aarch64_libsigc++20-doc.sha256sum] = "34f88b704d1c3638111663feee3beda43a37a27e07274a3cc903e40525e27f59"

RDEPENDS:libsigc++20 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libsigc++20-devel = " \
 libsigc++20 \
 pkgconf-pkg-config \
 "
RDEPENDS:libsigc++20-doc = " \
 libsigc++20 \
 "
