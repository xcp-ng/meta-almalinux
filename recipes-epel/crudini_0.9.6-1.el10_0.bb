# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crudini"
PV = "0.9.6"
PR = "1.el10_0"
PACKAGES = " \
 crudini \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/crudini-0.9.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e9b2475dcc40c958b36dc782df04573f977b914a7ad2dc6bbdce12c6de0e603"

URI_x86_64_v2_crudini = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/crudini-0.9.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_crudini;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crudini}"
SRC_URI[x86_64_v2_crudini.sha256sum] = "16f698eeaa5089e2b31669ba0cb30206433f3e0ab8e1f9812beb8ca9040eac85"

URI_aarch64_crudini = "${EPEL_MIRROR}/aarch64/Packages/c/crudini-0.9.6-1.el10_0.noarch.rpm;name=aarch64_crudini;unpack=0"
SRC_URI:append = " ${URI_aarch64_crudini}"
SRC_URI[aarch64_crudini.sha256sum] = "1e1c96de66d367ff84864a5234f29a8f8702ce74cd72f925387007545ecf37ae"

RDEPENDS:crudini = " \
 python3 \
 python3-iniparse \
 "
