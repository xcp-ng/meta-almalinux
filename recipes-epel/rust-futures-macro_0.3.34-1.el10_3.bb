# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-macro"
PV = "0.3.34"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-macro+default-devel \
 rust-futures-macro-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-futures-macro-0.3.34-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0bda492ba7ee8cabb2ad594ea6938454e498d33fa1edc41548ebb58a7f75692c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-macro+default-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-macro+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-macro+default-devel.sha256sum] = "cf327bc394e95e74cba1c0046dbe0560be7430cf9e2246ef703fbf68222247fb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-macro-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-macro-devel.sha256sum] = "f13d493db51d28cff9bc954523821587de5da4b4f01331a0c466258b94213722"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-macro+default-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-macro+default-devel;unpack=0"
SRC_URI[aarch64_rust-futures-macro+default-devel.sha256sum] = "15278214b0dfe710d8fd2f06e5f238482b8f1e8115887bda6d41f03d279c8320"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-macro-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-macro-devel;unpack=0"
SRC_URI[aarch64_rust-futures-macro-devel.sha256sum] = "0253bbb605199dc580519f6f8068098f878ba4d3c627f20b91594404f1f686a4"

RDEPENDS:rust-futures-macro+default-devel = " \
 cargo \
 rust-futures-macro-devel \
 "
RDEPENDS:rust-futures-macro-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
