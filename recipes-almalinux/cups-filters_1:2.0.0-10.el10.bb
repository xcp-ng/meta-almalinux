# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cups-filters"
PE = "1"
PV = "2.0.0"
PR = "10.el10"
PACKAGES = " \
 cups-filters \
 cups-filters-driverless \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cups-filters-2.0.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33a7ede5449dd363d556f91df5df071d01a017c37c9f19a750996cb0157c36d4"

URI_x86_64_v2_cups-filters = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-filters-2.0.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_cups-filters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-filters}"
SRC_URI[x86_64_v2_cups-filters.sha256sum] = "deca1226d5734a9e774c8db2dd86f8a1924d8baf5ad9a609562074ddb41cbf88"

URI_x86_64_v2_cups-filters-driverless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-filters-driverless-2.0.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_cups-filters-driverless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-filters-driverless}"
SRC_URI[x86_64_v2_cups-filters-driverless.sha256sum] = "e2ab80049929d9c3b281d2d196d20adcd46ca91d98866eb8f2406efd8053f3c9"

URI_aarch64_cups-filters = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-filters-2.0.0-10.el10.aarch64.rpm;name=aarch64_cups-filters;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-filters}"
SRC_URI[aarch64_cups-filters.sha256sum] = "b89f75f4efa5e30c3bd1f77fab0f209d7c0f1633eb092b58775313ed1c042c7e"

URI_aarch64_cups-filters-driverless = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-filters-driverless-2.0.0-10.el10.aarch64.rpm;name=aarch64_cups-filters-driverless;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-filters-driverless}"
SRC_URI[aarch64_cups-filters-driverless.sha256sum] = "99b8cab0dffd116d918ca5d0da00e550b6b948ef54b1c561cd109c8df4ac4663"

RDEPENDS:cups-filters = " \
 bash \
 cups-filesystem \
 cups-libs \
 glibc \
 libcupsfilters \
 libppd \
 "
RDEPENDS:cups-filters-driverless = " \
 avahi \
 bash \
 cups-filesystem \
 cups-ipptool \
 cups-libs \
 glibc \
 libcupsfilters \
 libppd \
 "
