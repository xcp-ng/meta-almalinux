# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sys-Statistics-Linux"
PV = "0.66"
PR = "39.el10_3"
PACKAGES = " \
 perl-Sys-Statistics-Linux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sys-Statistics-Linux-0.66-39.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab2adf2068b0654f07723136bbaec760bafa577789e8fb763fdaa63980f8f662"

URI_x86_64_v2_perl-Sys-Statistics-Linux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-Statistics-Linux-0.66-39.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sys-Statistics-Linux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-Statistics-Linux}"
SRC_URI[x86_64_v2_perl-Sys-Statistics-Linux.sha256sum] = "8326d9aae9dbbb4c91d2f947afadedfe75c5812c5021a5c373679362ebda8398"

URI_aarch64_perl-Sys-Statistics-Linux = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-Statistics-Linux-0.66-39.el10_3.noarch.rpm;name=aarch64_perl-Sys-Statistics-Linux;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-Statistics-Linux}"
SRC_URI[aarch64_perl-Sys-Statistics-Linux.sha256sum] = "83c377f70fd8c48842b7d64a7028cae4814401e0ed0303af6628744372e74ed9"

RDEPENDS:perl-Sys-Statistics-Linux = " \
 perl-Carp \
 perl-POSIX \
 perl-Sys-Statistics-Linux \
 perl-Time-HiRes \
 perl-constant \
 perl-libs \
 "
