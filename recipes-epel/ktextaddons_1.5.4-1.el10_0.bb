# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktextaddons"
PV = "1.5.4"
PR = "1.el10_0"
PACKAGES = " \
 ktextaddons-common \
 ktextaddons-qt6 \
 ktextaddons-qt6-devel \
 ktextaddons-qt6-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktextaddons-1.5.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59b272894dcf979cb5ad3dac9227615dc77e78192058e6ec94d059b9d61375d0"

URI_x86_64_v2_ktextaddons-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-common-1.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ktextaddons-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-common}"
SRC_URI[x86_64_v2_ktextaddons-common.sha256sum] = "185391b882b42245531e6b7d1c3a2a0d01ed062ee08dda1eb83f0239c7002d71"

URI_x86_64_v2_ktextaddons-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-qt6-1.5.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktextaddons-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-qt6}"
SRC_URI[x86_64_v2_ktextaddons-qt6.sha256sum] = "c80d6e5c9a3971bdea0726aec7ca3be94231790ddb1f70fdda53d293b02e66de"

URI_x86_64_v2_ktextaddons-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-qt6-devel-1.5.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktextaddons-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-qt6-devel}"
SRC_URI[x86_64_v2_ktextaddons-qt6-devel.sha256sum] = "9d4b9e73bb7d1dbf768bd96d742d3bcc3445c94af98d2f5a86b4e1cb16a85aab"

URI_x86_64_v2_ktextaddons-qt6-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-qt6-doc-1.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ktextaddons-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-qt6-doc}"
SRC_URI[x86_64_v2_ktextaddons-qt6-doc.sha256sum] = "8768291d4b2748a5a05dfc33a6d2ad0dd28bf68a171f2207f114c0948483ef55"

URI_aarch64_ktextaddons-common = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-common-1.5.4-1.el10_0.noarch.rpm;name=aarch64_ktextaddons-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-common}"
SRC_URI[aarch64_ktextaddons-common.sha256sum] = "85f646db894105c50ad76d91919ec487e9c0f2465895d959242b193f0b5169b5"

URI_aarch64_ktextaddons-qt6 = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-qt6-1.5.4-1.el10_0.aarch64.rpm;name=aarch64_ktextaddons-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-qt6}"
SRC_URI[aarch64_ktextaddons-qt6.sha256sum] = "e6f6afe533a656cd6004a44bf517124dca4271628bce4c2abb34d0a3dbf1b955"

URI_aarch64_ktextaddons-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-qt6-devel-1.5.4-1.el10_0.aarch64.rpm;name=aarch64_ktextaddons-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-qt6-devel}"
SRC_URI[aarch64_ktextaddons-qt6-devel.sha256sum] = "4a652d071c7dbaffb12694bcbc8ae415aeea9b065b8be0ab99d06c926b1e6d2e"

URI_aarch64_ktextaddons-qt6-doc = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-qt6-doc-1.5.4-1.el10_0.noarch.rpm;name=aarch64_ktextaddons-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-qt6-doc}"
SRC_URI[aarch64_ktextaddons-qt6-doc.sha256sum] = "42a69424042cfbda572b83793cbd275d6161bdf4398838f57f53fdc072e91fc8"

RDEPENDS:ktextaddons-common = " \
 "
RDEPENDS:ktextaddons-qt6 = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-sonnet \
 kf6-syntax-highlighting \
 ktextaddons-common \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 qtkeychain-qt6 \
 "
RDEPENDS:ktextaddons-qt6-devel = " \
 cmake-filesystem \
 glibc \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:ktextaddons-qt6-doc = " \
 "
