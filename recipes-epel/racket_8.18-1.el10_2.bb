# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "racket"
PV = "8.18"
PR = "1.el10_2"
PACKAGES = " \
 racket \
 racket-collects \
 racket-devel \
 racket-doc \
 racket-minimal \
 racket-pkgs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/racket-8.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c855e7cccd454c904e179aec0eea2ee14fa507adf95f2d01c799cd73d55c9b76"

URI_x86_64_v2_racket = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-8.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_racket;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket}"
SRC_URI[x86_64_v2_racket.sha256sum] = "64136895f25c7b361b2f490068ca516512b4e9bd0b42f46c1a7bf29f19c316b2"

URI_x86_64_v2_racket-collects = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-collects-8.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_racket-collects;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket-collects}"
SRC_URI[x86_64_v2_racket-collects.sha256sum] = "b704a1a9f9509d9e01b9fc149bf289139adada41624694f274393c5d0b2b0d14"

URI_x86_64_v2_racket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-devel-8.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_racket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket-devel}"
SRC_URI[x86_64_v2_racket-devel.sha256sum] = "f545c07372bed13390401c727cebe9c1e69a3fba9e934bc8773ec14cd9820f8a"

URI_x86_64_v2_racket-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-doc-8.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_racket-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket-doc}"
SRC_URI[x86_64_v2_racket-doc.sha256sum] = "7f0d262ca9a3a09b991ce8d409fc6ce5980a71cf9b1315cda3ea8f7aea830e7d"

URI_x86_64_v2_racket-minimal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-minimal-8.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_racket-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket-minimal}"
SRC_URI[x86_64_v2_racket-minimal.sha256sum] = "35307da603f0fafe3ed7941442b54947ee9310ded92e652e2dec62b3caa5c90e"

URI_x86_64_v2_racket-pkgs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-pkgs-8.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_racket-pkgs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket-pkgs}"
SRC_URI[x86_64_v2_racket-pkgs.sha256sum] = "7c541156aed881edc9158eca85d87cc05999debbad909c112c7f234627075a13"

URI_aarch64_racket = "${EPEL_MIRROR}/aarch64/Packages/r/racket-8.18-1.el10_2.aarch64.rpm;name=aarch64_racket;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket}"
SRC_URI[aarch64_racket.sha256sum] = "dfa738a666d40593ee4c6143783d0370d1d5bbdee8180c428e94fb6349009529"

URI_aarch64_racket-collects = "${EPEL_MIRROR}/aarch64/Packages/r/racket-collects-8.18-1.el10_2.noarch.rpm;name=aarch64_racket-collects;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket-collects}"
SRC_URI[aarch64_racket-collects.sha256sum] = "1aea334aac378940fcea24f6b7a74b4fd4e51df26157e72929e49144750b3524"

URI_aarch64_racket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/racket-devel-8.18-1.el10_2.aarch64.rpm;name=aarch64_racket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket-devel}"
SRC_URI[aarch64_racket-devel.sha256sum] = "d899fd47643a6def6a98ae18f87587cb07c48c8f06db1a9344a6f8c8607364ff"

URI_aarch64_racket-doc = "${EPEL_MIRROR}/aarch64/Packages/r/racket-doc-8.18-1.el10_2.noarch.rpm;name=aarch64_racket-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket-doc}"
SRC_URI[aarch64_racket-doc.sha256sum] = "ae69a6646c63fb5ce660b7141b42b0989d20efa520b2b6b30d29ccc474684bc3"

URI_aarch64_racket-minimal = "${EPEL_MIRROR}/aarch64/Packages/r/racket-minimal-8.18-1.el10_2.aarch64.rpm;name=aarch64_racket-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket-minimal}"
SRC_URI[aarch64_racket-minimal.sha256sum] = "3967fd71e3de442be0e38bca9e91b979b448f06eb11d130272c397dcd41a59ac"

URI_aarch64_racket-pkgs = "${EPEL_MIRROR}/aarch64/Packages/r/racket-pkgs-8.18-1.el10_2.noarch.rpm;name=aarch64_racket-pkgs;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket-pkgs}"
SRC_URI[aarch64_racket-pkgs.sha256sum] = "e1327e0b0f6671d629e200463902154fc48f8595977b2d915c5ed1bd1d5d389d"

RDEPENDS:racket = " \
 bash \
 glibc \
 racket-minimal \
 racket-pkgs \
 "
RDEPENDS:racket-collects = " \
 "
RDEPENDS:racket-devel = " \
 racket-minimal \
 "
RDEPENDS:racket-doc = " \
 "
RDEPENDS:racket-minimal = " \
 bash \
 glibc \
 libgcc \
 racket-collects \
 "
RDEPENDS:racket-pkgs = " \
 bash \
 cairo \
 glib2 \
 gtk3 \
 libjpeg-turbo \
 libpng \
 pango \
 racket-minimal \
 "
