# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf_shared"
PV = "0.11.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-phf_shared+default-devel \
 rust-phf_shared+std-devel \
 rust-phf_shared+uncased-devel \
 rust-phf_shared+unicase-devel \
 rust-phf_shared-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf_shared-0.11.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31c76cafa31bab43d39c9104d7cfd8dedc9c1c35e7e9a91ccf64cdaa2103e74c"

URI_x86_64_v2_rust-phf_shared+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared+default-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared+default-devel}"
SRC_URI[x86_64_v2_rust-phf_shared+default-devel.sha256sum] = "543dee045b3cde3cdfd51518bdad2106935da38d8fc0481b54f9bacd9132e254"

URI_x86_64_v2_rust-phf_shared+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared+std-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared+std-devel}"
SRC_URI[x86_64_v2_rust-phf_shared+std-devel.sha256sum] = "04dd5131ce21e8b1cdcd80bf120af154d1b2d759350283d2c95d09cc88d21ab3"

URI_x86_64_v2_rust-phf_shared+uncased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared+uncased-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared+uncased-devel}"
SRC_URI[x86_64_v2_rust-phf_shared+uncased-devel.sha256sum] = "25e2f6af6a8cce4de722ab8ee50d2b6a5e3f8aff9fc1322b4ab6863a8de9db96"

URI_x86_64_v2_rust-phf_shared+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared+unicase-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared+unicase-devel}"
SRC_URI[x86_64_v2_rust-phf_shared+unicase-devel.sha256sum] = "27b8bbdca4b5598e93d25fd5c28f9795168f6c1dfa7553f82636a3aab397fbce"

URI_x86_64_v2_rust-phf_shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared-devel}"
SRC_URI[x86_64_v2_rust-phf_shared-devel.sha256sum] = "bf683f37f3d392cda1871cec796e9aad0af6ef31f1b3c2e70492ed33e10f43ba"

URI_aarch64_rust-phf_shared+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared+default-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf_shared+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared+default-devel}"
SRC_URI[aarch64_rust-phf_shared+default-devel.sha256sum] = "458a4f5371c5482415721d600f38fbbcf3d1d795ed1173e5fcc6e08190fcd808"

URI_aarch64_rust-phf_shared+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared+std-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf_shared+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared+std-devel}"
SRC_URI[aarch64_rust-phf_shared+std-devel.sha256sum] = "b180edc19f8a460e09c8ec0586fd8ae80e83deeb1fd7f64eef34a5cd4e2038f8"

URI_aarch64_rust-phf_shared+uncased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared+uncased-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf_shared+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared+uncased-devel}"
SRC_URI[aarch64_rust-phf_shared+uncased-devel.sha256sum] = "b341aa2d8da2663ee7e055bbcc64d88e5ec0fcde54c70582dfd1a4c1838088c9"

URI_aarch64_rust-phf_shared+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared+unicase-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf_shared+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared+unicase-devel}"
SRC_URI[aarch64_rust-phf_shared+unicase-devel.sha256sum] = "248e897fb26b7e73a3bf35c8f0b24cab0e40cd3f8089702980ac298266635588"

URI_aarch64_rust-phf_shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf_shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared-devel}"
SRC_URI[aarch64_rust-phf_shared-devel.sha256sum] = "fef570f3113599b584cd6d47985d49a6ea21bb957872d71472f66fa65b434d3b"

RDEPENDS:rust-phf_shared+default-devel = " \
 cargo \
 rust-phf_shared+std-devel \
 rust-phf_shared-devel \
 "
RDEPENDS:rust-phf_shared+std-devel = " \
 cargo \
 rust-phf_shared-devel \
 "
RDEPENDS:rust-phf_shared+uncased-devel = " \
 cargo \
 rust-phf_shared-devel \
 rust-uncased-devel \
 "
RDEPENDS:rust-phf_shared+unicase-devel = " \
 cargo \
 rust-phf_shared-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-phf_shared-devel = " \
 cargo \
 rust \
 rust-siphasher+default-devel \
 "
