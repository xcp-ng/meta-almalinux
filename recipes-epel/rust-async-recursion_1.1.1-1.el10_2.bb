# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-recursion"
PV = "1.1.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-async-recursion+default-devel \
 rust-async-recursion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-recursion-1.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7c2f4ecd551d81a915083f04e6b05540446a48f718528d5050952ad314b97d3"

URI_x86_64_v2_rust-async-recursion+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-recursion+default-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-recursion+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-recursion+default-devel}"
SRC_URI[x86_64_v2_rust-async-recursion+default-devel.sha256sum] = "3a0b4e9e8f2b1fab84d3a3ab74f472d4ecbad2c2f79f5df501f24b7df983478d"

URI_x86_64_v2_rust-async-recursion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-recursion-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-recursion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-recursion-devel}"
SRC_URI[x86_64_v2_rust-async-recursion-devel.sha256sum] = "2c7d40c8bdd5a791de02a69c5086a19241889c03d447e1f570a2a01cdba3af86"

URI_aarch64_rust-async-recursion+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-recursion+default-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-async-recursion+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-recursion+default-devel}"
SRC_URI[aarch64_rust-async-recursion+default-devel.sha256sum] = "0294cbd3a749d3d8ffee71452529c2288cf191db105552c881339d1f080c25a0"

URI_aarch64_rust-async-recursion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-recursion-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-async-recursion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-recursion-devel}"
SRC_URI[aarch64_rust-async-recursion-devel.sha256sum] = "2cafd0ee94abb12e380827b7b652f9ce57888e03b676a3b49bdd61c4c28e0175"

RDEPENDS:rust-async-recursion+default-devel = " \
 cargo \
 rust-async-recursion-devel \
 "
RDEPENDS:rust-async-recursion-devel = " \
 cargo \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "
