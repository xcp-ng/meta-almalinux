# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tryfn"
PV = "0.2.3"
PR = "2.el10_1"
PACKAGES = " \
 rust-tryfn+color-auto-devel \
 rust-tryfn+color-devel \
 rust-tryfn+default-devel \
 rust-tryfn+diff-devel \
 rust-tryfn-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tryfn-0.2.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d72179035f22daab340923cad3c475a244f1332ea26b31b4dda8754d7727e4ae"

URI_x86_64_v2_rust-tryfn+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn+color-auto-devel-0.2.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn+color-auto-devel}"
SRC_URI[x86_64_v2_rust-tryfn+color-auto-devel.sha256sum] = "33873dc6e737331332b17f2f3db10247c9d5c2e7bdc14d4f8a633ab7757c7dec"

URI_x86_64_v2_rust-tryfn+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn+color-devel-0.2.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn+color-devel}"
SRC_URI[x86_64_v2_rust-tryfn+color-devel.sha256sum] = "799926a9f71af2d688bb38abb557b904acaf51d8bc1b2ce7eb1acc1812bb6909"

URI_x86_64_v2_rust-tryfn+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn+default-devel-0.2.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn+default-devel}"
SRC_URI[x86_64_v2_rust-tryfn+default-devel.sha256sum] = "6437098386a547035704e87656ea7b1aed6b38239749407e0dfa2ce8ce17be98"

URI_x86_64_v2_rust-tryfn+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn+diff-devel-0.2.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn+diff-devel}"
SRC_URI[x86_64_v2_rust-tryfn+diff-devel.sha256sum] = "5b92ae3f9595ccf0ef549282df71509269afc80b465114bc5d61b3c151e38fad"

URI_x86_64_v2_rust-tryfn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn-devel-0.2.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn-devel}"
SRC_URI[x86_64_v2_rust-tryfn-devel.sha256sum] = "9e600f628e9604d5e7bac2931aafb50ef355b20ba110aeef8d6197dc5ed62e29"

URI_aarch64_rust-tryfn+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn+color-auto-devel-0.2.3-2.el10_1.noarch.rpm;name=aarch64_rust-tryfn+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn+color-auto-devel}"
SRC_URI[aarch64_rust-tryfn+color-auto-devel.sha256sum] = "d66af0fc1df88550c45eb5ef9f812dd8ef5772dcd2093cf4af00d6aa11f8d858"

URI_aarch64_rust-tryfn+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn+color-devel-0.2.3-2.el10_1.noarch.rpm;name=aarch64_rust-tryfn+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn+color-devel}"
SRC_URI[aarch64_rust-tryfn+color-devel.sha256sum] = "09952f47c7712321fcb91d4acd916e65ee36763848b868d237d48586120919de"

URI_aarch64_rust-tryfn+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn+default-devel-0.2.3-2.el10_1.noarch.rpm;name=aarch64_rust-tryfn+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn+default-devel}"
SRC_URI[aarch64_rust-tryfn+default-devel.sha256sum] = "e6db8e8f7ebbfcbd6cd65b5bbed2c03759a5497383b0c9ed157ae0e021a9ef99"

URI_aarch64_rust-tryfn+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn+diff-devel-0.2.3-2.el10_1.noarch.rpm;name=aarch64_rust-tryfn+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn+diff-devel}"
SRC_URI[aarch64_rust-tryfn+diff-devel.sha256sum] = "113ed1d2cefb714824f395e5028ecda1000556fd04b757b8f46e77f11b2bd27f"

URI_aarch64_rust-tryfn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn-devel-0.2.3-2.el10_1.noarch.rpm;name=aarch64_rust-tryfn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn-devel}"
SRC_URI[aarch64_rust-tryfn-devel.sha256sum] = "bb021e57b14758c102031bab1471d612e3396fe0c798de1c4f339fab7a6b3d22"

RDEPENDS:rust-tryfn+color-auto-devel = " \
 cargo \
 rust-snapbox+color-auto-devel \
 rust-tryfn-devel \
 "
RDEPENDS:rust-tryfn+color-devel = " \
 cargo \
 rust-snapbox+color-devel \
 rust-tryfn-devel \
 "
RDEPENDS:rust-tryfn+default-devel = " \
 cargo \
 rust-tryfn+color-auto-devel \
 rust-tryfn+diff-devel \
 rust-tryfn-devel \
 "
RDEPENDS:rust-tryfn+diff-devel = " \
 cargo \
 rust-snapbox+diff-devel \
 rust-tryfn-devel \
 "
RDEPENDS:rust-tryfn-devel = " \
 cargo \
 rust \
 rust-ignore+default-devel \
 rust-libtest-mimic+default-devel \
 rust-snapbox-devel \
 "
