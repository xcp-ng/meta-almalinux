# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-markupsafe"
PV = "2.1.3"
PR = "6.el10"
PACKAGES = " \
 python3-markupsafe \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-markupsafe-2.1.3-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e8ef149f912bff952a88880cb1dd9073efa66506a3d3469975b9c7a86b12ebe"

URI_x86_64_v2_python3-markupsafe = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-markupsafe-2.1.3-6.el10.x86_64_v2.rpm;name=x86_64_v2_python3-markupsafe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-markupsafe}"
SRC_URI[x86_64_v2_python3-markupsafe.sha256sum] = "6178f98d1c88888f9d9ac9f125c3a80b2f8f9997ef4c56a6560f5ed35e93d54e"

URI_aarch64_python3-markupsafe = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-markupsafe-2.1.3-6.el10.aarch64.rpm;name=aarch64_python3-markupsafe;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-markupsafe}"
SRC_URI[aarch64_python3-markupsafe.sha256sum] = "d29da31630d0bf79442ce8b92124c213c1ebf3ba0cbc8a7039480e78d92a55c9"

RDEPENDS:python3-markupsafe = " \
 glibc \
 python3 \
 "
