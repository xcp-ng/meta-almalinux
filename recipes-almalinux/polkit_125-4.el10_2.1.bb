# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "polkit"
PV = "125"
PR = "4.el10_2.1"
PACKAGES = " \
 polkit \
 polkit-devel \
 polkit-docs \
 polkit-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/polkit-125-4.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bd99ca231199ef0036e1af8a622b9bc16c862fb51c79c9b3f8fd3fb7a8c9c0bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/polkit-125-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_polkit;unpack=0"
SRC_URI[x86_64_v2_polkit.sha256sum] = "f8caedc1dd62b3e4c4ccf93b27bef0d405b109ab9e4804e85d4a5ef4847143d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/polkit-devel-125-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_polkit-devel;unpack=0"
SRC_URI[x86_64_v2_polkit-devel.sha256sum] = "6b12a96c5a56e6ef4c101659bc7fa530e55866c18a59afe183df355fb8f7545f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/polkit-docs-125-4.el10_2.1.noarch.rpm;name=x86_64_v2_polkit-docs;unpack=0"
SRC_URI[x86_64_v2_polkit-docs.sha256sum] = "305e34938bffb0db90d5a6ec9e239162450d0c39bf641873dcc7b0598bf2930e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/polkit-libs-125-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_polkit-libs;unpack=0"
SRC_URI[x86_64_v2_polkit-libs.sha256sum] = "6e1bd8fbeb58fb5c611f6b1c418bf79e38928ff70b6ec4bc738567801dd2a2da"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/polkit-125-4.el10_2.1.aarch64.rpm;name=aarch64_polkit;unpack=0"
SRC_URI[aarch64_polkit.sha256sum] = "109a6a28ea7cad2413c0f7d5e712bf128735e748a09b50cb606ec0f1d245e83a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/polkit-devel-125-4.el10_2.1.aarch64.rpm;name=aarch64_polkit-devel;unpack=0"
SRC_URI[aarch64_polkit-devel.sha256sum] = "925b97fa2631fb243243606d743ab1f9711feddd76b86d96ef10dc0ac68ff689"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/polkit-docs-125-4.el10_2.1.noarch.rpm;name=aarch64_polkit-docs;unpack=0"
SRC_URI[aarch64_polkit-docs.sha256sum] = "305e34938bffb0db90d5a6ec9e239162450d0c39bf641873dcc7b0598bf2930e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/polkit-libs-125-4.el10_2.1.aarch64.rpm;name=aarch64_polkit-libs;unpack=0"
SRC_URI[aarch64_polkit-libs.sha256sum] = "733ae1c3d0db2c751912710a1b7ba8ac5600344c10b801396ef6195801b593b0"

RDEPENDS:polkit = " \
 bash \
 dbus \
 duktape \
 expat \
 glib2 \
 glibc \
 pam-libs \
 polkit-libs \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:polkit-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 polkit-devel \
 polkit-docs \
 polkit-libs \
 "
RDEPENDS:polkit-docs = " \
 polkit-devel \
 "
RDEPENDS:polkit-libs = " \
 glib2 \
 glibc \
 systemd-libs \
 "
