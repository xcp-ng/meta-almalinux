# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-cert-store"
PV = "0.7.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-sequoia-cert-store+default-devel \
 rust-sequoia-cert-store+keyserver-devel \
 rust-sequoia-cert-store-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-sequoia-cert-store-0.7.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c3123d42f31f2cddc32718ce7fe1c927fc7be4a77ef9c6d9f8f8747878d9c284"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-cert-store+default-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-cert-store+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-cert-store+default-devel.sha256sum] = "27fbc05898a48f983ccb6d99c9664365621d642cc1271622d983cf8f41f1f610"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-cert-store+keyserver-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-cert-store+keyserver-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-cert-store+keyserver-devel.sha256sum] = "ee6c5fdfaeca04b0d813b774047a68409ef24728ac6669d14eb84b7b3956d6fb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-cert-store-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-cert-store-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-cert-store-devel.sha256sum] = "b302c6b3121b9d5cac327123eae1bc874b61d89bc297751ee581705f7dd211b1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-cert-store+default-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-cert-store+default-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-cert-store+default-devel.sha256sum] = "46140e8d2997176f52ebfd56ee8aebbb0fb776352cb0ff7655a96df04b5c5af6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-cert-store+keyserver-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-cert-store+keyserver-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-cert-store+keyserver-devel.sha256sum] = "ffd36cf1d9c0d2e0b7e184165f9ada2c25fef0a27b206416b15a63a4ef2d7dc0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-cert-store-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-cert-store-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-cert-store-devel.sha256sum] = "0931d25ce0942005a649f8ad0b42458aa008a981a46ddf19ffb19ed4d8459dc7"

RDEPENDS:rust-sequoia-cert-store+default-devel = " \
 cargo \
 rust-sequoia-cert-store+keyserver-devel \
 rust-sequoia-cert-store-devel \
 "
RDEPENDS:rust-sequoia-cert-store+keyserver-devel = " \
 cargo \
 rust-sequoia-cert-store-devel \
 rust-sequoia-net-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 "
RDEPENDS:rust-sequoia-cert-store-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-crossbeam+default-devel \
 rust-dirs+default-devel \
 rust-gethostname+default-devel \
 rust-num_cpus+default-devel \
 rust-openpgp-cert-d-devel \
 rust-rayon+default-devel \
 rust-sequoia-openpgp-devel \
 rust-smallvec+default-devel \
 rust-url+default-devel \
 virtual/crate_rusqlite/blob__ge_0.29.0_with_crate_rusqlite/blob__lt_0.41.0~ \
 virtual/crate_rusqlite/collation__ge_0.29.0_with_crate_rusqlite/collation__lt_0.41.0~ \
 virtual/crate_rusqlite/default__ge_0.29.0_with_crate_rusqlite/default__lt_0.41.0~ \
 virtual/crate_rusqlite/trace__ge_0.29.0_with_crate_rusqlite/trace__lt_0.41.0~ \
 virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~ \
 "
