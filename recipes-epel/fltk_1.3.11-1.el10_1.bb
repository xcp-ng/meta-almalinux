# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fltk"
PV = "1.3.11"
PR = "1.el10_1"
PACKAGES = " \
 fltk \
 fltk-devel \
 fltk-fluid \
 fltk-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fltk-1.3.11-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2544a5cbdf0b73b312662f8b54f17180602ab406e13ae1fc7051fff98baa4fbb"

URI_x86_64_v2_fltk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fltk-1.3.11-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fltk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fltk}"
SRC_URI[x86_64_v2_fltk.sha256sum] = "f1ce659c0d6c8dc76053be1bce8326eac4fe369a57053f5be11251d39a346035"

URI_x86_64_v2_fltk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fltk-devel-1.3.11-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fltk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fltk-devel}"
SRC_URI[x86_64_v2_fltk-devel.sha256sum] = "e348d1a59fb7746d065e8da1a52e3cdc706d1ba0deb063fda3ceb41a48ce51f9"

URI_x86_64_v2_fltk-fluid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fltk-fluid-1.3.11-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fltk-fluid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fltk-fluid}"
SRC_URI[x86_64_v2_fltk-fluid.sha256sum] = "054939f1974d44237ed9a6a0891aa171eace151563f53143be38ba6dcabe4857"

URI_x86_64_v2_fltk-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fltk-static-1.3.11-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fltk-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fltk-static}"
SRC_URI[x86_64_v2_fltk-static.sha256sum] = "d80e5df6d7f359e4a2aa7a98d79430c14bf370a55f8355c2efcc0a6a573ce9dd"

URI_aarch64_fltk = "${EPEL_MIRROR}/aarch64/Packages/f/fltk-1.3.11-1.el10_1.aarch64.rpm;name=aarch64_fltk;unpack=0"
SRC_URI:append = " ${URI_aarch64_fltk}"
SRC_URI[aarch64_fltk.sha256sum] = "58b7891af69f5bcda39ad5c43d678678572095a476bf9e9fcafd5f1c4c9b06d6"

URI_aarch64_fltk-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fltk-devel-1.3.11-1.el10_1.aarch64.rpm;name=aarch64_fltk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fltk-devel}"
SRC_URI[aarch64_fltk-devel.sha256sum] = "c109eee04a1b0c727780dbf2af806afdacf84465e5fa2506612af3e117394baf"

URI_aarch64_fltk-fluid = "${EPEL_MIRROR}/aarch64/Packages/f/fltk-fluid-1.3.11-1.el10_1.aarch64.rpm;name=aarch64_fltk-fluid;unpack=0"
SRC_URI:append = " ${URI_aarch64_fltk-fluid}"
SRC_URI[aarch64_fltk-fluid.sha256sum] = "d3f183171d388ffec9a977c3c4a38e15dd7f45d7ca134b4c748c2bb25636e2c2"

URI_aarch64_fltk-static = "${EPEL_MIRROR}/aarch64/Packages/f/fltk-static-1.3.11-1.el10_1.aarch64.rpm;name=aarch64_fltk-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_fltk-static}"
SRC_URI[aarch64_fltk-static.sha256sum] = "ce8c063985c587b7e920905e4dbd39a01b6f5408c55a9728e04688807323bf37"

RDEPENDS:fltk = " \
 fontconfig \
 glibc \
 libX11 \
 libXcursor \
 libXext \
 libXfixes \
 libXft \
 libXinerama \
 libXrender \
 libgcc \
 libglvnd-glx \
 libglvnd-opengl \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 "
RDEPENDS:fltk-devel = " \
 bash \
 cmake-filesystem \
 fltk \
 fontconfig-devel \
 libICE-devel \
 libSM-devel \
 libX11-devel \
 libXft-devel \
 libXt-devel \
 libglvnd-devel \
 libjpeg-turbo-devel \
 libpng-devel \
 libstdc++-devel \
 mesa-libGLU-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:fltk-fluid = " \
 fltk \
 fltk-devel \
 fontconfig \
 glibc \
 libX11 \
 libXcursor \
 libXext \
 libXfixes \
 libXft \
 libXinerama \
 libXrender \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 "
RDEPENDS:fltk-static = " \
 fltk-devel \
 "
