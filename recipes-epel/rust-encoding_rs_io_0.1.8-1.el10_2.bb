# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-encoding_rs_io"
PV = "0.1.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-encoding_rs_io+default-devel \
 rust-encoding_rs_io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-encoding_rs_io-0.1.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b3d1366e373283ecc3ffec32e50fb6ec4735807425afbb16f12d50f9bd552ed"

URI_x86_64_v2_rust-encoding_rs_io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs_io+default-devel-0.1.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs_io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs_io+default-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs_io+default-devel.sha256sum] = "6cecb81e26612b4d0e8d994166b66738a37a4e5a5aa9f2d71610c9c028184a1e"

URI_x86_64_v2_rust-encoding_rs_io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs_io-devel-0.1.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs_io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs_io-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs_io-devel.sha256sum] = "e2cff73c1d493e88b1ceb3251d104c960bf56c6c99f38ef672a8882ec831b807"

URI_aarch64_rust-encoding_rs_io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs_io+default-devel-0.1.8-1.el10_2.noarch.rpm;name=aarch64_rust-encoding_rs_io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs_io+default-devel}"
SRC_URI[aarch64_rust-encoding_rs_io+default-devel.sha256sum] = "9ceccfecb1a41c0b8886f1642fd8cdbbb2174802913347e791cd3f45902efb5a"

URI_aarch64_rust-encoding_rs_io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs_io-devel-0.1.8-1.el10_2.noarch.rpm;name=aarch64_rust-encoding_rs_io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs_io-devel}"
SRC_URI[aarch64_rust-encoding_rs_io-devel.sha256sum] = "9867aaa9bb615118f07a57a63b0d889583c8b3d3b887c6858ef68a3784f88497"

RDEPENDS:rust-encoding_rs_io+default-devel = " \
 cargo \
 rust-encoding_rs_io-devel \
 "
RDEPENDS:rust-encoding_rs_io-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 "
