# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-rsl"
PV = "11.4"
PR = "1.el10_0"
PACKAGES = " \
 globus-rsl \
 globus-rsl-devel \
 globus-rsl-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-rsl-11.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "177d5c19cef0e35cf1a0f659896b28fbbc887c51ae58acbb9bde86e02c5102ff"

URI_x86_64_v2_globus-rsl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-rsl-11.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-rsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-rsl}"
SRC_URI[x86_64_v2_globus-rsl.sha256sum] = "1028c8d7b935a42711d0650b5d07e6e8b34b6d22a04ddcbd610cae59edb5de8f"

URI_x86_64_v2_globus-rsl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-rsl-devel-11.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-rsl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-rsl-devel}"
SRC_URI[x86_64_v2_globus-rsl-devel.sha256sum] = "97b359a4c2c6c46ed547399250bfafc56bdccbbb4f734d59f34bc5e57a5c8bb1"

URI_x86_64_v2_globus-rsl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-rsl-doc-11.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-rsl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-rsl-doc}"
SRC_URI[x86_64_v2_globus-rsl-doc.sha256sum] = "4c87657495c8d0fcd2c58e88fdd36660436b3b691375f3814a6a09d1e031478f"

URI_aarch64_globus-rsl = "${EPEL_MIRROR}/aarch64/Packages/g/globus-rsl-11.4-1.el10_0.aarch64.rpm;name=aarch64_globus-rsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-rsl}"
SRC_URI[aarch64_globus-rsl.sha256sum] = "134c3caafe03462b487989bca1e9cd10a793c7648fe3ec2d756bab0e6477cc07"

URI_aarch64_globus-rsl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-rsl-devel-11.4-1.el10_0.aarch64.rpm;name=aarch64_globus-rsl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-rsl-devel}"
SRC_URI[aarch64_globus-rsl-devel.sha256sum] = "d58cf6dd45ba8868bc511ef0858401a38e57ce078a18cddde76e592292778ba3"

URI_aarch64_globus-rsl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-rsl-doc-11.4-1.el10_0.noarch.rpm;name=aarch64_globus-rsl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-rsl-doc}"
SRC_URI[aarch64_globus-rsl-doc.sha256sum] = "a7f1b3c60dabc9e3d406ba1bd04d3c6df4299c21a775e8a5b247e0470481b638"

RDEPENDS:globus-rsl = " \
 glibc \
 globus-common \
 "
RDEPENDS:globus-rsl-devel = " \
 globus-common-devel \
 globus-rsl \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-rsl-doc = " \
 "
