# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpimtextedit"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kpimtextedit \
 kpimtextedit-devel \
 kpimtextedit-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpimtextedit-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3add099db09562109551e6b31f5abfeac9dc02101d4fd4adea685695843e3aec"

URI_x86_64_v2_kpimtextedit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpimtextedit-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpimtextedit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpimtextedit}"
SRC_URI[x86_64_v2_kpimtextedit.sha256sum] = "fc674d3fe6fe93e28f22f4eff193f2288fcfd75e5c08c0c4f0c0302a5b524497"

URI_x86_64_v2_kpimtextedit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpimtextedit-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpimtextedit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpimtextedit-devel}"
SRC_URI[x86_64_v2_kpimtextedit-devel.sha256sum] = "1ddb655429abdf64d5354b0594c92f6a5f542969996238cd7321c018b8fbc0d4"

URI_x86_64_v2_kpimtextedit-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpimtextedit-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kpimtextedit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpimtextedit-doc}"
SRC_URI[x86_64_v2_kpimtextedit-doc.sha256sum] = "ce1309d29b557deba7f54a1fb9a7d48b0569eacc76b985c64dc129b81faa388b"

URI_aarch64_kpimtextedit = "${EPEL_MIRROR}/aarch64/Packages/k/kpimtextedit-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kpimtextedit;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpimtextedit}"
SRC_URI[aarch64_kpimtextedit.sha256sum] = "40ac4b4527f10067254a18bb7d716892f25c07464fa6e3feb8ba1488525ed018"

URI_aarch64_kpimtextedit-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpimtextedit-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kpimtextedit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpimtextedit-devel}"
SRC_URI[aarch64_kpimtextedit-devel.sha256sum] = "ea5826f8be38aaa2bae8f848638495f7ecaedb3d4c0af4016249a7a3d82e9208"

URI_aarch64_kpimtextedit-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kpimtextedit-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kpimtextedit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpimtextedit-doc}"
SRC_URI[aarch64_kpimtextedit-doc.sha256sum] = "e7203865f87a74314294db923e93cb3da0d48ce8658b3135725d190654f8afb7"

RDEPENDS:kpimtextedit = " \
 glibc \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 kf6-syntax-highlighting \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kpimtextedit-devel = " \
 cmake-filesystem \
 kf6-ktextwidgets-devel \
 kpimtextedit \
 "
RDEPENDS:kpimtextedit-doc = " \
 "
