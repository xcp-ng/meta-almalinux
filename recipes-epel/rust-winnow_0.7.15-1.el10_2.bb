# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-winnow"
PV = "0.7.15"
PR = "1.el10_2"
PACKAGES = " \
 rust-winnow+alloc-devel \
 rust-winnow+debug-devel \
 rust-winnow+default-devel \
 rust-winnow+simd-devel \
 rust-winnow+std-devel \
 rust-winnow+unstable-doc-devel \
 rust-winnow+unstable-recover-devel \
 rust-winnow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-winnow-0.7.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c01a31a699c46e3c32e6231c8e19cdaa32858b209b74f91384cdaadbc6dfd29"

URI_x86_64_v2_rust-winnow+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+alloc-devel-0.7.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+alloc-devel}"
SRC_URI[x86_64_v2_rust-winnow+alloc-devel.sha256sum] = "9781c44d618274ecda2b76eb12beea9426c70f03ae6c67b0ec9f50a3328773cd"

URI_x86_64_v2_rust-winnow+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+debug-devel-0.7.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+debug-devel}"
SRC_URI[x86_64_v2_rust-winnow+debug-devel.sha256sum] = "092d2846df26ad7380aff82480ce9eb5f7fcbc75351cda63968ffb15137b0e46"

URI_x86_64_v2_rust-winnow+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+default-devel-0.7.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+default-devel}"
SRC_URI[x86_64_v2_rust-winnow+default-devel.sha256sum] = "6ab58e68fc08c0627ce6fff74fede2756904415fefa310bcefce002bf1f72a98"

URI_x86_64_v2_rust-winnow+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+simd-devel-0.7.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+simd-devel}"
SRC_URI[x86_64_v2_rust-winnow+simd-devel.sha256sum] = "a8d143c18f6ede2097792f0c5e07249a4456174a63151133230c15ebcee51937"

URI_x86_64_v2_rust-winnow+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+std-devel-0.7.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+std-devel}"
SRC_URI[x86_64_v2_rust-winnow+std-devel.sha256sum] = "ffca0dd8fcbbf167a6bd3604e3f45b1b20428b17d1ae2a54a37ce35edece2cb1"

URI_x86_64_v2_rust-winnow+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+unstable-doc-devel-0.7.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-winnow+unstable-doc-devel.sha256sum] = "0af402984814befe2cadb72f95b3be749cd6b35e2fd25709435e4fe7a7162d80"

URI_x86_64_v2_rust-winnow+unstable-recover-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+unstable-recover-devel-0.7.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+unstable-recover-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+unstable-recover-devel}"
SRC_URI[x86_64_v2_rust-winnow+unstable-recover-devel.sha256sum] = "1a60ba085754b2b231f852ae0bc6403c78c589751d296e775f4eac708b5cc028"

URI_x86_64_v2_rust-winnow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow-devel-0.7.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow-devel}"
SRC_URI[x86_64_v2_rust-winnow-devel.sha256sum] = "59497c1aebe9314b27932e17becc616951d8c0db3607ffe3fbc1f08b841f3f4f"

URI_aarch64_rust-winnow+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+alloc-devel-0.7.15-1.el10_2.noarch.rpm;name=aarch64_rust-winnow+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+alloc-devel}"
SRC_URI[aarch64_rust-winnow+alloc-devel.sha256sum] = "86c92c9b677c058c630162c051b3e82c80a9687fe3f24b8200bcac9a70318204"

URI_aarch64_rust-winnow+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+debug-devel-0.7.15-1.el10_2.noarch.rpm;name=aarch64_rust-winnow+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+debug-devel}"
SRC_URI[aarch64_rust-winnow+debug-devel.sha256sum] = "bd7142cc290801044fad3e48112efb4c529ef0c6f9ce7b7cb72774c1885d5b50"

URI_aarch64_rust-winnow+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+default-devel-0.7.15-1.el10_2.noarch.rpm;name=aarch64_rust-winnow+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+default-devel}"
SRC_URI[aarch64_rust-winnow+default-devel.sha256sum] = "879d2d47613207c9bc3cced2ea0c150076f7fd96cf1f7b248ac58f50026a0dc1"

URI_aarch64_rust-winnow+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+simd-devel-0.7.15-1.el10_2.noarch.rpm;name=aarch64_rust-winnow+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+simd-devel}"
SRC_URI[aarch64_rust-winnow+simd-devel.sha256sum] = "90fc648f080f5b7883910b586caf42ebc576a5a846bb785a987066f3c125ad5e"

URI_aarch64_rust-winnow+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+std-devel-0.7.15-1.el10_2.noarch.rpm;name=aarch64_rust-winnow+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+std-devel}"
SRC_URI[aarch64_rust-winnow+std-devel.sha256sum] = "35851a84c03b6184eb2acd77044f48314c5f6c075db9ffe37ef11ce8f48c15e9"

URI_aarch64_rust-winnow+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+unstable-doc-devel-0.7.15-1.el10_2.noarch.rpm;name=aarch64_rust-winnow+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+unstable-doc-devel}"
SRC_URI[aarch64_rust-winnow+unstable-doc-devel.sha256sum] = "017b8692abca2cb5b06fa81d6781e7d394e4efe3742bbe4ac04ee2dbd7115873"

URI_aarch64_rust-winnow+unstable-recover-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+unstable-recover-devel-0.7.15-1.el10_2.noarch.rpm;name=aarch64_rust-winnow+unstable-recover-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+unstable-recover-devel}"
SRC_URI[aarch64_rust-winnow+unstable-recover-devel.sha256sum] = "a958361448657fba854584eba41d8eec69566c1437825b776d99b3391c0eccdf"

URI_aarch64_rust-winnow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow-devel-0.7.15-1.el10_2.noarch.rpm;name=aarch64_rust-winnow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow-devel}"
SRC_URI[aarch64_rust-winnow-devel.sha256sum] = "a3f24f890e96e59eeaaf580724d3d11c334de8b422576a904c182b657c2a0fd1"

RDEPENDS:rust-winnow+alloc-devel = " \
 cargo \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+debug-devel = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-anstyle+default-devel \
 rust-terminal_size+default-devel \
 rust-winnow+std-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+default-devel = " \
 cargo \
 rust-winnow+std-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+simd-devel = " \
 cargo \
 rust-memchr-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-winnow+alloc-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+unstable-doc-devel = " \
 cargo \
 rust-winnow+alloc-devel \
 rust-winnow+simd-devel \
 rust-winnow+std-devel \
 rust-winnow+unstable-recover-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+unstable-recover-devel = " \
 cargo \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow-devel = " \
 cargo \
 rust \
 "
