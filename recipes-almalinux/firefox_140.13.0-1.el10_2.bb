# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firefox"
PV = "140.13.0"
PR = "1.el10_2"
PACKAGES = " \
 firefox \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/firefox-140.13.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee25c09fef062fae2e34c0ba517611acbd0d9c11315a5d281b93357c1bf19661"

URI_x86_64_v2_firefox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/firefox-140.13.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_firefox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firefox}"
SRC_URI[x86_64_v2_firefox.sha256sum] = "a2123ce62f11938c126f55c64e824bd1a9deb822421c3cd352a8f475a2f18299"

URI_aarch64_firefox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/firefox-140.13.0-1.el10_2.aarch64.rpm;name=aarch64_firefox;unpack=0"
SRC_URI:append = " ${URI_aarch64_firefox}"
SRC_URI[aarch64_firefox.sha256sum] = "afc643d2176d11e5d3c81014321fc49a4683a4b1240db8c3bf1a0c61dbb0d8cc"

RDEPENDS:firefox = " \
 almalinux-indexhtml \
 alsa-lib \
 atk \
 bash \
 cairo \
 cairo-gobject \
 dbus-libs \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libX11 \
 libX11-xcb \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXrandr \
 libXrender \
 libffi \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 libxcb \
 mozilla-filesystem \
 nspr \
 nss \
 nss-util \
 p11-kit-trust \
 pango \
 pciutils-libs \
 zlib-ng-compat \
 "
