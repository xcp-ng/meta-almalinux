# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fastfetch"
PV = "2.66.0"
PR = "1.el10_2"
PACKAGES = " \
 fastfetch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fastfetch-2.66.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37f38799f8c0d9a6c3be085c47fa71cdfd832830efc024ce4aa24916f6b3aa94"

URI_x86_64_v2_fastfetch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fastfetch-2.66.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fastfetch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fastfetch}"
SRC_URI[x86_64_v2_fastfetch.sha256sum] = "333729716908e530fc04ba0552da55eea6687355dd883a3904e2455374088589"

URI_aarch64_fastfetch = "${EPEL_MIRROR}/aarch64/Packages/f/fastfetch-2.66.0-1.el10_2.aarch64.rpm;name=aarch64_fastfetch;unpack=0"
SRC_URI:append = " ${URI_aarch64_fastfetch}"
SRC_URI[aarch64_fastfetch.sha256sum] = "b6c6e50dd2274028744800a6dab12356930d1102c3f3783aa3c7fcf33beb9034"

RDEPENDS:fastfetch = " \
 glibc \
 libgcc \
 yyjson \
 "
