# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-DNS-Resolver-Programmable"
PV = "0.009"
PR = "17.el10_0"
PACKAGES = " \
 perl-Net-DNS-Resolver-Programmable \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-DNS-Resolver-Programmable-0.009-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e47214985bd2fb656f2e87da882ccbb55e6070764e99656f3ea6f3802293fa6"

URI_x86_64_v2_perl-Net-DNS-Resolver-Programmable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-DNS-Resolver-Programmable-0.009-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-DNS-Resolver-Programmable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-DNS-Resolver-Programmable}"
SRC_URI[x86_64_v2_perl-Net-DNS-Resolver-Programmable.sha256sum] = "19ddeeded5266e500b3a0056c0b0b35d6d41d8e5842e9938a2e7fb07942f91de"

URI_aarch64_perl-Net-DNS-Resolver-Programmable = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-DNS-Resolver-Programmable-0.009-17.el10_0.noarch.rpm;name=aarch64_perl-Net-DNS-Resolver-Programmable;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-DNS-Resolver-Programmable}"
SRC_URI[aarch64_perl-Net-DNS-Resolver-Programmable.sha256sum] = "c8abf3f290335d39551c8341111a344e94e0a50a3e8ded36242b796f431c012e"

RDEPENDS:perl-Net-DNS-Resolver-Programmable = " \
 perl-Net-DNS \
 perl-base \
 perl-constant \
 perl-libs \
 "
