# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knavalbattle"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 knavalbattle \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/knavalbattle-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6ed49be846ee209d5410067cec71ff77d155a86aa964590053ec226ba04be4e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knavalbattle-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knavalbattle;unpack=0"
SRC_URI[x86_64_v2_knavalbattle.sha256sum] = "44a447c84090f03a5ad0811329d66544062a687bd8458da24aa975c13e74a437"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/knavalbattle-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_knavalbattle;unpack=0"
SRC_URI[aarch64_knavalbattle.sha256sum] = "858c4cb3432bdb3b9b3e5bf43923fa18ca296c124af85c69a7ed168918e2bb92"

RDEPENDS:knavalbattle = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
