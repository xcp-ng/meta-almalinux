# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-ros-domain-id-coordinator"
PV = "0.2.4"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-ros-domain-id-coordinator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-ros-domain-id-coordinator-0.2.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e6e6407988acd65e012225cb28f26b06a8bac0580e3379b63d131a505f713aa"

URI_x86_64_v2_python3-colcon-ros-domain-id-coordinator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-ros-domain-id-coordinator-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-ros-domain-id-coordinator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-ros-domain-id-coordinator}"
SRC_URI[x86_64_v2_python3-colcon-ros-domain-id-coordinator.sha256sum] = "4546d1bf68dbd13dd04bc2ec76023e14150877c0e606eb2bd14f5bca128479d2"

URI_aarch64_python3-colcon-ros-domain-id-coordinator = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-ros-domain-id-coordinator-0.2.4-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-ros-domain-id-coordinator;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-ros-domain-id-coordinator}"
SRC_URI[aarch64_python3-colcon-ros-domain-id-coordinator.sha256sum] = "4399a39c71a82af22f3bd35ebd5bbdc70f09e65f5581dd1026f2dc4f7f9b724b"

RDEPENDS:python3-colcon-ros-domain-id-coordinator = " \
 python3 \
 python3-colcon-core \
 "
