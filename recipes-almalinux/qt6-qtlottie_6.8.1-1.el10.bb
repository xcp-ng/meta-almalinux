# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtlottie"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtlottie \
 qt6-qtlottie-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtlottie-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f1dc8dd3ddea498ad3179892923956c198016d302569cf1b4fc4a278837f6ec"

URI_x86_64_v2_qt6-qtlottie = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtlottie-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlottie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtlottie}"
SRC_URI[x86_64_v2_qt6-qtlottie.sha256sum] = "692becbddb2662a184b02cdc9c272d74aa496561367c43422b10f93f43b2a311"

URI_x86_64_v2_qt6-qtlottie-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtlottie-devel-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlottie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtlottie-devel}"
SRC_URI[x86_64_v2_qt6-qtlottie-devel.sha256sum] = "13e495d6baa7fa1bbfdd2c30d679765d5262c2614b938bf9851cd8aac39b81c3"

URI_aarch64_qt6-qtlottie = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtlottie-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtlottie;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtlottie}"
SRC_URI[aarch64_qt6-qtlottie.sha256sum] = "cadf562b4d4faa9d7c8f50d986c06714dcb7893434cd68a1504def5f5366295e"

URI_aarch64_qt6-qtlottie-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtlottie-devel-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtlottie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtlottie-devel}"
SRC_URI[aarch64_qt6-qtlottie-devel.sha256sum] = "6ad5b2cbf1be6e171bdbb76bf90a55dc34b984108ec6ddd4764e081e892d6572"

RDEPENDS:qt6-qtlottie = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtlottie-devel = " \
 cmake-filesystem \
 qt6-qtbase-devel \
 qt6-qtlottie \
 "
