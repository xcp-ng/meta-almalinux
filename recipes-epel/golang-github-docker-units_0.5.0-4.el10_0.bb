# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-docker-units"
PV = "0.5.0"
PR = "4.el10_0"
PACKAGES = " \
 golang-github-docker-units-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-docker-units-0.5.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2912add7d42c67036f11762ffe7331cfa234440e64054587695894b58b9ccab"

URI_x86_64_v2_golang-github-docker-units-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-docker-units-devel-0.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-docker-units-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-docker-units-devel}"
SRC_URI[x86_64_v2_golang-github-docker-units-devel.sha256sum] = "9416645a8eeed6d48f69fdd2e3d07861de7ecd54dceaaedcc106e025dbb25bf4"

URI_aarch64_golang-github-docker-units-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-docker-units-devel-0.5.0-4.el10_0.noarch.rpm;name=aarch64_golang-github-docker-units-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-docker-units-devel}"
SRC_URI[aarch64_golang-github-docker-units-devel.sha256sum] = "f5a984510336e009e9e797024acbd07d9bab353a2865b822ce10fc952a7fbc2c"

RDEPENDS:golang-github-docker-units-devel = " \
 go-filesystem \
 "
