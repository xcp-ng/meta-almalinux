# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "baresip"
PV = "4.7.0"
PR = "1.el10_1"
PACKAGES = " \
 baresip \
 baresip-aac \
 baresip-alsa \
 baresip-av1 \
 baresip-avcodec \
 baresip-avfilter \
 baresip-avformat \
 baresip-codec2 \
 baresip-ctrl_dbus \
 baresip-devel \
 baresip-g722 \
 baresip-g726 \
 baresip-gst \
 baresip-gtk \
 baresip-jack \
 baresip-mqtt \
 baresip-opus \
 baresip-pipewire \
 baresip-plc \
 baresip-portaudio \
 baresip-pulse \
 baresip-sdl \
 baresip-snapshot \
 baresip-sndfile \
 baresip-swscale \
 baresip-tools \
 baresip-v4l2 \
 baresip-vp8 \
 baresip-vp9 \
 baresip-x11 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/baresip-4.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a58445ed1bdd7c32289fb5485f1fb36be857837178f7b9234c47c2530262eba"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - baresip-avcodec: libavcodec.so.61()(64bit)
# - baresip-avcodec: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - baresip-avcodec: libavutil.so.59()(64bit)
# - baresip-avcodec: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - baresip-avfilter: libavfilter.so.10()(64bit)
# - baresip-avfilter: libavfilter.so.10(LIBAVFILTER_10)(64bit)
# - baresip-avfilter: libavutil.so.59()(64bit)
# - baresip-avfilter: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - baresip-avformat: libavcodec.so.61()(64bit)
# - baresip-avformat: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - baresip-avformat: libavdevice.so.61()(64bit)
# - baresip-avformat: libavdevice.so.61(LIBAVDEVICE_61)(64bit)
# - baresip-avformat: libavformat.so.61()(64bit)
# - baresip-avformat: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - baresip-avformat: libavutil.so.59()(64bit)
# - baresip-avformat: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - baresip-avformat: libswresample.so.5()(64bit)
# - baresip-avformat: libswresample.so.5(LIBSWRESAMPLE_5)(64bit)
# - baresip-swscale: libswscale.so.8()(64bit)
# - baresip-swscale: libswscale.so.8(LIBSWSCALE_8)(64bit)

URI_x86_64_v2_baresip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip}"
SRC_URI[x86_64_v2_baresip.sha256sum] = "be20d6dc6dc3b58597d212db4650a01887bacfde85423ee43d9ba813de805eb7"

URI_x86_64_v2_baresip-aac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-aac-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-aac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-aac}"
SRC_URI[x86_64_v2_baresip-aac.sha256sum] = "528c1622ee0b12f2e7b3fdafcb3c7cc990adafce29e5cca83dca9d9797f0eb8e"

URI_x86_64_v2_baresip-alsa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-alsa-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-alsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-alsa}"
SRC_URI[x86_64_v2_baresip-alsa.sha256sum] = "5f582718841c5677b94f7b91b23e33188a9e0bbd9e1d0ea178270a8b592487b2"

URI_x86_64_v2_baresip-av1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-av1-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-av1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-av1}"
SRC_URI[x86_64_v2_baresip-av1.sha256sum] = "1f74d223b3c19ce032494bf25a0046f2fabb6d7f12881df8449acd705619e857"

URI_x86_64_v2_baresip-avcodec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avcodec-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avcodec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-avcodec}"
SRC_URI[x86_64_v2_baresip-avcodec.sha256sum] = "339ccd4d393de88f247348eb90da82db6e0191f00b1686d46316c7206f8e06f0"

URI_x86_64_v2_baresip-avfilter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avfilter-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-avfilter}"
SRC_URI[x86_64_v2_baresip-avfilter.sha256sum] = "20dbd8cea133ccd33aecd11ca18906d59da2c0c0de86e8447153eea8b4cf676d"

URI_x86_64_v2_baresip-avformat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avformat-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avformat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-avformat}"
SRC_URI[x86_64_v2_baresip-avformat.sha256sum] = "5fc8674c8f0f67d3ac8db6c870e4bf02aeb50f59bfe7e6812d61ec8939f5dfa8"

URI_x86_64_v2_baresip-codec2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-codec2-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-codec2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-codec2}"
SRC_URI[x86_64_v2_baresip-codec2.sha256sum] = "51994380bfaf601a0e0833dce69b899a66ddc1163fac3299e7623da7a6cf54a1"

URI_x86_64_v2_baresip-ctrl_dbus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-ctrl_dbus-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-ctrl_dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-ctrl_dbus}"
SRC_URI[x86_64_v2_baresip-ctrl_dbus.sha256sum] = "60dffe3119673c0cd87bb785bcb6f2ad9e6ac96c62dbb157c95b6db1716bbabb"

URI_x86_64_v2_baresip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-devel-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-devel}"
SRC_URI[x86_64_v2_baresip-devel.sha256sum] = "e8346aec592fe148d0ba33f226b410d793e0eb0c294526a86fcfe5f270a5690d"

URI_x86_64_v2_baresip-g722 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-g722-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-g722;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-g722}"
SRC_URI[x86_64_v2_baresip-g722.sha256sum] = "53a04ce45f7348f087e311d0fd8173e865528c197573654afba659e29508d6fd"

URI_x86_64_v2_baresip-g726 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-g726-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-g726;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-g726}"
SRC_URI[x86_64_v2_baresip-g726.sha256sum] = "6d9fd2c8cda7ea48b89258425456fcbb6132edf18a533d3af7d6fe16343348d0"

URI_x86_64_v2_baresip-gst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-gst-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-gst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-gst}"
SRC_URI[x86_64_v2_baresip-gst.sha256sum] = "f47659fc7863ba31b291472f0367f0fb5c11bbf71edb5519e7400dcbc11be979"

URI_x86_64_v2_baresip-gtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-gtk-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-gtk}"
SRC_URI[x86_64_v2_baresip-gtk.sha256sum] = "69208032f56d28268c333fec271b891ffcc40d1e13b019351a38bd1190c25d36"

URI_x86_64_v2_baresip-jack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-jack-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-jack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-jack}"
SRC_URI[x86_64_v2_baresip-jack.sha256sum] = "81c5d29689777c495d0dc950755e8aa5eb5dcbb1d7ecd1bdf8d21ffe87164f38"

URI_x86_64_v2_baresip-mqtt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-mqtt-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-mqtt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-mqtt}"
SRC_URI[x86_64_v2_baresip-mqtt.sha256sum] = "0b180af6e7ad785639a27ae6dd87f47abcca836eb4e4179c597dc875caae0687"

URI_x86_64_v2_baresip-opus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-opus-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-opus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-opus}"
SRC_URI[x86_64_v2_baresip-opus.sha256sum] = "9a6614952bcdbe6fb51c7f9bf58ac19bd45cb0b495fdab918effa277f4c399d6"

URI_x86_64_v2_baresip-pipewire = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-pipewire-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-pipewire;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-pipewire}"
SRC_URI[x86_64_v2_baresip-pipewire.sha256sum] = "abe9c30ab2a74d4eacb6b88b22d80fc5ba78e6f3962ff037dcf3579be313d752"

URI_x86_64_v2_baresip-plc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-plc-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-plc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-plc}"
SRC_URI[x86_64_v2_baresip-plc.sha256sum] = "e95212be2905e89d40561b9b4cb9556097eda4caca1a7105ed54bc0316944ea9"

URI_x86_64_v2_baresip-portaudio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-portaudio-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-portaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-portaudio}"
SRC_URI[x86_64_v2_baresip-portaudio.sha256sum] = "3260760df547b32e7d2aa0519f55eec74717e5e4cab518216177250df3ac526d"

URI_x86_64_v2_baresip-pulse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-pulse-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-pulse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-pulse}"
SRC_URI[x86_64_v2_baresip-pulse.sha256sum] = "18c062d1802779594c84242c602357270d67d0e132b4954164f70a7a4e05327a"

URI_x86_64_v2_baresip-sdl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-sdl-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-sdl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-sdl}"
SRC_URI[x86_64_v2_baresip-sdl.sha256sum] = "2aac02d75e2cb90a1442f2e84135e4159410d9091c640877bf5f16429666641f"

URI_x86_64_v2_baresip-snapshot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-snapshot-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-snapshot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-snapshot}"
SRC_URI[x86_64_v2_baresip-snapshot.sha256sum] = "7baa3549c4da498abdff57daeb2f6a30bb189854afa993d446b74ca0204dae0f"

URI_x86_64_v2_baresip-sndfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-sndfile-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-sndfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-sndfile}"
SRC_URI[x86_64_v2_baresip-sndfile.sha256sum] = "813317b07601c182e487fba0c893ade718ceb44bf45c399a801729ebc40ad975"

URI_x86_64_v2_baresip-swscale = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-swscale-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-swscale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-swscale}"
SRC_URI[x86_64_v2_baresip-swscale.sha256sum] = "f44a01a8d16c51405a4efcc5520561a33d87cc46e0d9ec9fe24ff8ed1225b6ef"

URI_x86_64_v2_baresip-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-tools-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-tools}"
SRC_URI[x86_64_v2_baresip-tools.sha256sum] = "5f698dc8252b6f31865802e7bd03e515fe4e204655f8321cf188f32e7ce76f23"

URI_x86_64_v2_baresip-v4l2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-v4l2-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-v4l2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-v4l2}"
SRC_URI[x86_64_v2_baresip-v4l2.sha256sum] = "357d977a528fdf84c70cfc97cbbbe90d3a07256112a09bb2ba9c291bdf517459"

URI_x86_64_v2_baresip-vp8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-vp8-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-vp8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-vp8}"
SRC_URI[x86_64_v2_baresip-vp8.sha256sum] = "ddbba8ff29032fa3ff12648132aa605b2389eb0237062ee7d7f17c2e1837012f"

URI_x86_64_v2_baresip-vp9 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-vp9-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-vp9;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-vp9}"
SRC_URI[x86_64_v2_baresip-vp9.sha256sum] = "743c923362e9f5bfd7cfad363393d5b53c39c7167f6008740e77c48e3d7a95b3"

URI_x86_64_v2_baresip-x11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-x11-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-x11}"
SRC_URI[x86_64_v2_baresip-x11.sha256sum] = "6bd8582dc0242ba6fe714d9c74277f746681df4ddbc39f2174a9b6703b7c1f62"

URI_aarch64_baresip = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip}"
SRC_URI[aarch64_baresip.sha256sum] = "19314ee5a6d5d145627298dae020d403d4a09d3750bdab1af4e9180f6547b49f"

URI_aarch64_baresip-aac = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-aac-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-aac;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-aac}"
SRC_URI[aarch64_baresip-aac.sha256sum] = "e9ee420b1ce33ca469957abee485c8ecb32c3f491550df6579084e1fb9736c13"

URI_aarch64_baresip-alsa = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-alsa-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-alsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-alsa}"
SRC_URI[aarch64_baresip-alsa.sha256sum] = "67c34339874227d8cae72e314e5b49e40449e603bc4e4471bd15fd77c2cf490e"

URI_aarch64_baresip-av1 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-av1-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-av1;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-av1}"
SRC_URI[aarch64_baresip-av1.sha256sum] = "8421aadb943e117ba8a1cbe0b4e533096aa41bb8e84eb8e1898e99938317c1cf"

URI_aarch64_baresip-avcodec = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-avcodec-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-avcodec;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-avcodec}"
SRC_URI[aarch64_baresip-avcodec.sha256sum] = "b9c4f96310678be1b5d7d9c75984659344aada7eff9ff1e82d0fcce8bb531ff2"

URI_aarch64_baresip-avfilter = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-avfilter-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-avfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-avfilter}"
SRC_URI[aarch64_baresip-avfilter.sha256sum] = "e0aa40f8b960dae1b529e65176cf35d040ee82e189632fd85477be6921bfcbe3"

URI_aarch64_baresip-avformat = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-avformat-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-avformat;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-avformat}"
SRC_URI[aarch64_baresip-avformat.sha256sum] = "483fc88093da1423b845fb48d111f3b1a21e3312fd430c4296856ab43535de29"

URI_aarch64_baresip-codec2 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-codec2-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-codec2;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-codec2}"
SRC_URI[aarch64_baresip-codec2.sha256sum] = "40ceae768321e666e10f57ae7ef17aad3183338894c4dffbf9732586fb553997"

URI_aarch64_baresip-ctrl_dbus = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-ctrl_dbus-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-ctrl_dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-ctrl_dbus}"
SRC_URI[aarch64_baresip-ctrl_dbus.sha256sum] = "3b384d9d75d1f09c17dacb521379abac91def8721148cdc8ef0a11151e735005"

URI_aarch64_baresip-devel = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-devel-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-devel}"
SRC_URI[aarch64_baresip-devel.sha256sum] = "21f876b60be7f4de3f576087278fd7e6ba72878756242869c69fcc666771205c"

URI_aarch64_baresip-g722 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-g722-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-g722;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-g722}"
SRC_URI[aarch64_baresip-g722.sha256sum] = "59d2e3882f6adb1482c6dfd0380e24830e05e959d5ec6a91d9be3e2ede1aa6fb"

URI_aarch64_baresip-g726 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-g726-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-g726;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-g726}"
SRC_URI[aarch64_baresip-g726.sha256sum] = "9f4489ea1c1443bcad1d0a1019c549f7915e8007b60a3f3b3dc997ba160688d4"

URI_aarch64_baresip-gst = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-gst-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-gst;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-gst}"
SRC_URI[aarch64_baresip-gst.sha256sum] = "aa1f5724ac83b3e0b78d6848ca2acc868ebbd6ba799b0a2fe973e3dc43b40ec3"

URI_aarch64_baresip-gtk = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-gtk-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-gtk}"
SRC_URI[aarch64_baresip-gtk.sha256sum] = "8127284c04d694a6a4fe3d7bae8974f5e499c960cb6cd7c426a3d250e0b83198"

URI_aarch64_baresip-jack = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-jack-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-jack;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-jack}"
SRC_URI[aarch64_baresip-jack.sha256sum] = "b0c600f9b5a49304d8b41b553d30cf206fe1f9fc3f99fafe2a9af769fbd97a9a"

URI_aarch64_baresip-mqtt = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-mqtt-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-mqtt;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-mqtt}"
SRC_URI[aarch64_baresip-mqtt.sha256sum] = "0ec64bfde67d580d77336468d1b28d05f23f93237ca5cb7ea125142aadb7ebac"

URI_aarch64_baresip-opus = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-opus-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-opus;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-opus}"
SRC_URI[aarch64_baresip-opus.sha256sum] = "14dd06fe55b2252bb20ab78a20d6dbda3ece568e5d5396b1a4d0b1a4e97aabb5"

URI_aarch64_baresip-pipewire = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-pipewire-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-pipewire;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-pipewire}"
SRC_URI[aarch64_baresip-pipewire.sha256sum] = "2cc0386499f16b4c8e7fe39449d9242dc71318461c9947f054e26d57a530a567"

URI_aarch64_baresip-plc = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-plc-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-plc;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-plc}"
SRC_URI[aarch64_baresip-plc.sha256sum] = "e8ed77d094cada12fe6605736c0749dd5111d24146544160b0f5b11e6ffe7a21"

URI_aarch64_baresip-portaudio = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-portaudio-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-portaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-portaudio}"
SRC_URI[aarch64_baresip-portaudio.sha256sum] = "dbb5b3a311ef373857b2d9092a84bcd601be878a6885a08cc1ce6c1d6d27e244"

URI_aarch64_baresip-pulse = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-pulse-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-pulse;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-pulse}"
SRC_URI[aarch64_baresip-pulse.sha256sum] = "da102f940620d948f2b8a74c51eff8bd3c7906a1a4b5f00902fe97491370712e"

URI_aarch64_baresip-sdl = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-sdl-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-sdl;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-sdl}"
SRC_URI[aarch64_baresip-sdl.sha256sum] = "da0c4815338d9c9c4d9e7893e34b59f7909214dae6606a1291c8777a8c1826cd"

URI_aarch64_baresip-snapshot = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-snapshot-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-snapshot;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-snapshot}"
SRC_URI[aarch64_baresip-snapshot.sha256sum] = "cc21112e49c41737e5f69e565c4d0a5adcf21a34dffa10e793bf0aba3fda8385"

URI_aarch64_baresip-sndfile = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-sndfile-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-sndfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-sndfile}"
SRC_URI[aarch64_baresip-sndfile.sha256sum] = "a406a59559e98c9c1572407bdd309dcad26332b7a577c5103550bb21d9a74ea5"

URI_aarch64_baresip-swscale = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-swscale-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-swscale;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-swscale}"
SRC_URI[aarch64_baresip-swscale.sha256sum] = "b1ee1aff4efde53cec532b0b911becc3fa5207cf022f4836d0453a8cc6eb1435"

URI_aarch64_baresip-tools = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-tools-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-tools}"
SRC_URI[aarch64_baresip-tools.sha256sum] = "c43cfeb163d098b360ed2aeddd0e35c057ad6657120d96ab9e2c38343cbe5e15"

URI_aarch64_baresip-v4l2 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-v4l2-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-v4l2;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-v4l2}"
SRC_URI[aarch64_baresip-v4l2.sha256sum] = "8277c5b54c97b7eca6b07ddf5595129d7e2d730182d2114d9643e94cd91bd8cd"

URI_aarch64_baresip-vp8 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-vp8-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-vp8;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-vp8}"
SRC_URI[aarch64_baresip-vp8.sha256sum] = "d525053bdf5e52a75476bb76ee9d183065859f4c17633d42719fa26a94b10db4"

URI_aarch64_baresip-vp9 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-vp9-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-vp9;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-vp9}"
SRC_URI[aarch64_baresip-vp9.sha256sum] = "aff001cb35153b2c6356c45a76c5db18018b5b5ab6a875f42c802db3712d546e"

URI_aarch64_baresip-x11 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-x11-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_baresip-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-x11}"
SRC_URI[aarch64_baresip-x11.sha256sum] = "977d431920b94f3ce938d67c0fd388661d4dba411fb5676bd297b6e969449cd9"

RDEPENDS:baresip = " \
 glibc \
 libre \
 "
RDEPENDS:baresip-aac = " \
 baresip \
 fdk-aac-free \
 glibc \
 "
RDEPENDS:baresip-alsa = " \
 alsa-lib \
 baresip \
 glibc \
 "
RDEPENDS:baresip-av1 = " \
 baresip \
 glibc \
 libaom \
 "
RDEPENDS:baresip-avcodec:x86_64_v2 = " \
 baresip \
 glibc \
"
RDEPENDS:baresip-avcodec:aarch64 = " \
 baresip \
 glibc \
 libavcodec-free \
 libavutil-free \
"
RDEPENDS:baresip-avfilter:x86_64_v2 = " \
 baresip \
 glibc \
"
RDEPENDS:baresip-avfilter:aarch64 = " \
 baresip \
 glibc \
 libavfilter-free \
 libavutil-free \
"
RDEPENDS:baresip-avformat:x86_64_v2 = " \
 baresip \
 glibc \
"
RDEPENDS:baresip-avformat:aarch64 = " \
 baresip \
 glibc \
 libavcodec-free \
 libavdevice-free \
 libavformat-free \
 libavutil-free \
 libswresample-free \
"
RDEPENDS:baresip-codec2 = " \
 baresip \
 codec2 \
 glibc \
 "
RDEPENDS:baresip-ctrl_dbus = " \
 baresip \
 glib2 \
 glibc \
 "
RDEPENDS:baresip-devel = " \
 baresip \
 pkgconf-pkg-config \
 "
RDEPENDS:baresip-g722 = " \
 baresip \
 glibc \
 spandsp \
 "
RDEPENDS:baresip-g726 = " \
 baresip \
 glibc \
 spandsp \
 "
RDEPENDS:baresip-gst = " \
 baresip \
 glib2 \
 glibc \
 gstreamer1 \
 "
RDEPENDS:baresip-gtk = " \
 adwaita-icon-theme \
 baresip \
 glib2 \
 glibc \
 gnome-shell-extension-appindicator \
 gtk3 \
 "
RDEPENDS:baresip-jack = " \
 baresip \
 glibc \
 pipewire-jack-audio-connection-kit-libs \
 "
RDEPENDS:baresip-mqtt = " \
 baresip \
 glibc \
 mosquitto \
 "
RDEPENDS:baresip-opus = " \
 baresip \
 glibc \
 opus \
 "
RDEPENDS:baresip-pipewire = " \
 baresip \
 glibc \
 pipewire-libs \
 "
RDEPENDS:baresip-plc = " \
 baresip \
 glibc \
 spandsp \
 "
RDEPENDS:baresip-portaudio = " \
 baresip \
 glibc \
 portaudio \
 "
RDEPENDS:baresip-pulse = " \
 baresip \
 glibc \
 pulseaudio-libs \
 "
RDEPENDS:baresip-sdl = " \
 baresip \
 glibc \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
RDEPENDS:baresip-snapshot = " \
 baresip \
 glibc \
 libpng \
 "
RDEPENDS:baresip-sndfile = " \
 baresip \
 glibc \
 libsndfile \
 "
RDEPENDS:baresip-swscale:x86_64_v2 = " \
 baresip \
 glibc \
"
RDEPENDS:baresip-swscale:aarch64 = " \
 baresip \
 glibc \
 libswscale-free \
"
RDEPENDS:baresip-tools = " \
 baresip \
 python3 \
 "
RDEPENDS:baresip-v4l2 = " \
 baresip \
 glibc \
 "
RDEPENDS:baresip-vp8 = " \
 baresip \
 glibc \
 libvpx \
 "
RDEPENDS:baresip-vp9 = " \
 baresip \
 glibc \
 libvpx \
 "
RDEPENDS:baresip-x11 = " \
 baresip \
 glibc \
 libX11 \
 libXext \
 "
