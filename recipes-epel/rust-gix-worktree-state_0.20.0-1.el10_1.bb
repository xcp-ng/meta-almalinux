# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-worktree-state"
PV = "0.20.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-worktree-state+default-devel \
 rust-gix-worktree-state-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-worktree-state-0.20.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05f089e4e86d78015dc4252221e48550f0c7a3d1ee9c401e2363fd1a3903d8d3"

URI_x86_64_v2_rust-gix-worktree-state+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-state+default-devel-0.20.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-state+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-state+default-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-state+default-devel.sha256sum] = "9b83a774500b3f3d9876b25aabc044ba8eea7e670eb08eb066d457f1b04bd025"

URI_x86_64_v2_rust-gix-worktree-state-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-state-devel-0.20.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-state-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-state-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-state-devel.sha256sum] = "0b6c0c83c962c8dcb0faf4eafd3c8549105f5a04d5bb05f6600fe37464a3c44e"

URI_aarch64_rust-gix-worktree-state+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-state+default-devel-0.20.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-worktree-state+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-state+default-devel}"
SRC_URI[aarch64_rust-gix-worktree-state+default-devel.sha256sum] = "8e3d5cd30b24abfd73898e2689d92a263f1036997bb7861c4147407d218ddf3b"

URI_aarch64_rust-gix-worktree-state-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-state-devel-0.20.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-worktree-state-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-state-devel}"
SRC_URI[aarch64_rust-gix-worktree-state-devel.sha256sum] = "5778463df2fd7ec6aae824befa703495f2f66f4cc0cf422612b4986e983db25e"

RDEPENDS:rust-gix-worktree-state+default-devel = " \
 cargo \
 rust-gix-worktree-state-devel \
 "
RDEPENDS:rust-gix-worktree-state-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-features+default-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-io-close+default-devel \
 rust-thiserror+default-devel \
 "
