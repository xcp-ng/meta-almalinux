# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cron-converter"
PV = "1.3.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-cron-converter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cron-converter-1.3.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0204f16e44d93fab33eea0e42f0a712936f243ae2ef111adab8deba341c0eaf4"

URI_x86_64_v2_python3-cron-converter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cron-converter-1.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cron-converter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cron-converter}"
SRC_URI[x86_64_v2_python3-cron-converter.sha256sum] = "5404e416953d9be6f1d81f466143cefd06a905bac21371ad874b7880fd77064c"

URI_aarch64_python3-cron-converter = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cron-converter-1.3.1-1.el10_2.noarch.rpm;name=aarch64_python3-cron-converter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cron-converter}"
SRC_URI[aarch64_python3-cron-converter.sha256sum] = "80d63fc520c08bd12387e36f2d8459e94bf552225ee34341bd38af0b6d6dd2ff"

RDEPENDS:python3-cron-converter = " \
 python3 \
 python3-dateutil \
 "
