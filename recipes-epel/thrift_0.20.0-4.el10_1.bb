# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "thrift"
PV = "0.20.0"
PR = "4.el10_1"
PACKAGES = " \
 perl-thrift \
 python3-thrift \
 thrift \
 thrift-devel \
 thrift-glib \
 thrift-qt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/thrift-0.20.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db3bfc7d81d5aea8b909007f645bb6fcda71ea9439985a07c4a4a5acb9e59152"

URI_x86_64_v2_perl-thrift = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-thrift-0.20.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-thrift;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-thrift}"
SRC_URI[x86_64_v2_perl-thrift.sha256sum] = "26a39e007cb080af54afc67f61fac8eee3a4e4b6a3f8233fb69ecb72f0f7c0ae"

URI_x86_64_v2_python3-thrift = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-thrift-0.20.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-thrift;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-thrift}"
SRC_URI[x86_64_v2_python3-thrift.sha256sum] = "e0b1a7e024449f01571e6bc98e1f500f0684283154028b552cd6303d3de0d3cd"

URI_x86_64_v2_thrift = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/thrift-0.20.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_thrift;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_thrift}"
SRC_URI[x86_64_v2_thrift.sha256sum] = "5e936180eb711fe34d39babe2dec655f664513814bdd6d7bead280312d978b3f"

URI_x86_64_v2_thrift-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/thrift-devel-0.20.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_thrift-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_thrift-devel}"
SRC_URI[x86_64_v2_thrift-devel.sha256sum] = "092d03b9d17f55923e8a7c741b2dea8722c63fb9de6028602675425f384e656f"

URI_x86_64_v2_thrift-glib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/thrift-glib-0.20.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_thrift-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_thrift-glib}"
SRC_URI[x86_64_v2_thrift-glib.sha256sum] = "d045332c2e192cdb9450e18560c8cf5e7d89c07cdeff44fa8ce4e33ad8619b41"

URI_x86_64_v2_thrift-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/thrift-qt-0.20.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_thrift-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_thrift-qt}"
SRC_URI[x86_64_v2_thrift-qt.sha256sum] = "5748e3e75fa44dd8de6f663dd00a354ddcb05c9ba13cac3d2b5c5842e475c2c9"

URI_aarch64_perl-thrift = "${EPEL_MIRROR}/aarch64/Packages/p/perl-thrift-0.20.0-4.el10_1.noarch.rpm;name=aarch64_perl-thrift;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-thrift}"
SRC_URI[aarch64_perl-thrift.sha256sum] = "78c54e362b35c800011efd6618f8dc5e96ffbbabc1e02f9f09e7427833376388"

URI_aarch64_python3-thrift = "${EPEL_MIRROR}/aarch64/Packages/p/python3-thrift-0.20.0-4.el10_1.aarch64.rpm;name=aarch64_python3-thrift;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-thrift}"
SRC_URI[aarch64_python3-thrift.sha256sum] = "7328cc542cc7f3fc5466a97417181fb0cf067cd40173ec5a53f6ceac77f3649e"

URI_aarch64_thrift = "${EPEL_MIRROR}/aarch64/Packages/t/thrift-0.20.0-4.el10_1.aarch64.rpm;name=aarch64_thrift;unpack=0"
SRC_URI:append = " ${URI_aarch64_thrift}"
SRC_URI[aarch64_thrift.sha256sum] = "3ee219e93424795b5c50ad72c1102f2b42d3d84a0472b261a3a43e5a72c2acb9"

URI_aarch64_thrift-devel = "${EPEL_MIRROR}/aarch64/Packages/t/thrift-devel-0.20.0-4.el10_1.aarch64.rpm;name=aarch64_thrift-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_thrift-devel}"
SRC_URI[aarch64_thrift-devel.sha256sum] = "a5238461b4cb760d36e27f71ae01d2f49a5284de50b61400b399e73c7d36ec28"

URI_aarch64_thrift-glib = "${EPEL_MIRROR}/aarch64/Packages/t/thrift-glib-0.20.0-4.el10_1.aarch64.rpm;name=aarch64_thrift-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_thrift-glib}"
SRC_URI[aarch64_thrift-glib.sha256sum] = "6af71f6bfd77e7d7adc34e64bc4fabcbb7fec8145314057ef9266168ef979cff"

URI_aarch64_thrift-qt = "${EPEL_MIRROR}/aarch64/Packages/t/thrift-qt-0.20.0-4.el10_1.aarch64.rpm;name=aarch64_thrift-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_thrift-qt}"
SRC_URI[aarch64_thrift-qt.sha256sum] = "e4d005ecaa9ff394a6518f1095160f856c6bea537b1ed184effd9ebe763cc3f8"

RDEPENDS:perl-thrift = " \
 perl-Bit-Vector \
 perl-Encode \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Socket-SSL \
 perl-IO-String \
 perl-POSIX \
 perl-base \
 perl-constant \
 perl-libs \
 perl-libwww-perl \
 perl-overload \
 perl-parent \
 perl-version \
 "
RDEPENDS:python3-thrift = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-six \
 thrift \
 "
RDEPENDS:thrift = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:thrift-devel = " \
 boost-devel \
 glib2 \
 glib2-devel \
 glibc \
 openssl-libs \
 pkgconf-pkg-config \
 thrift \
 zlib-ng-compat \
 "
RDEPENDS:thrift-glib = " \
 glib2 \
 glibc \
 openssl-libs \
 thrift \
 zlib-ng-compat \
 "
RDEPENDS:thrift-qt = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 thrift \
 "
