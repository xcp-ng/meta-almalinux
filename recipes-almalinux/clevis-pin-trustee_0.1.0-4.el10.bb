# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clevis-pin-trustee"
PV = "0.1.0"
PR = "4.el10"
PACKAGES = " \
 clevis-pin-trustee \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/clevis-pin-trustee-0.1.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2033f73e082801e221b37e6fd8740f8a27ab4418e697830a412c4c8297a7d292"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-pin-trustee-0.1.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_clevis-pin-trustee;unpack=0"
SRC_URI[x86_64_v2_clevis-pin-trustee.sha256sum] = "453c0dbd7cddc0afd3317823b50fd007e1da892d901e988ce8d8e2973452a9a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-pin-trustee-0.1.0-4.el10.aarch64.rpm;name=aarch64_clevis-pin-trustee;unpack=0"
SRC_URI[aarch64_clevis-pin-trustee.sha256sum] = "f4ba6807a09352e47a27ff49fb52a730b60f2921986df23cacae260563066975"

RDEPENDS:clevis-pin-trustee = " \
 bash \
 clevis \
 glibc \
 jose \
 libgcc \
 openssl-libs \
 "
