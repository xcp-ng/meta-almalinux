# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Convert-ASN1"
PV = "0.34"
PR = "5.el10"
PACKAGES = " \
 perl-Convert-ASN1 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Convert-ASN1-0.34-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4b72ccfd6ceec392784f5ca41390db54e990c855e2b2a5e4f126a371193cb27b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Convert-ASN1-0.34-5.el10.noarch.rpm;name=x86_64_v2_perl-Convert-ASN1;unpack=0"
SRC_URI[x86_64_v2_perl-Convert-ASN1.sha256sum] = "4656f416d412d0bcd92b9d063266a022d60ed6da40b66cc5fc85ecfd7d9e3577"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Convert-ASN1-0.34-5.el10.noarch.rpm;name=aarch64_perl-Convert-ASN1;unpack=0"
SRC_URI[aarch64_perl-Convert-ASN1.sha256sum] = "4656f416d412d0bcd92b9d063266a022d60ed6da40b66cc5fc85ecfd7d9e3577"

RDEPENDS:perl-Convert-ASN1 = " \
 perl-Carp \
 perl-Convert-ASN1 \
 perl-Encode \
 perl-Exporter \
 perl-POSIX \
 perl-Socket \
 perl-Time-Local \
 perl-constant \
 perl-libs \
 perl-vars \
 "
