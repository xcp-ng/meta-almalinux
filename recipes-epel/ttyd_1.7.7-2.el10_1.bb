# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ttyd"
PV = "1.7.7"
PR = "2.el10_1"
PACKAGES = " \
 ttyd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/ttyd-1.7.7-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfa08156b86d4866d928e6a69be03ef44efd116f645e72d60ca3f928cb580e05"

URI_x86_64_v2_ttyd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ttyd-1.7.7-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ttyd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ttyd}"
SRC_URI[x86_64_v2_ttyd.sha256sum] = "e5f50521ce60f47e11012af35ba87214368b9051971f453032b1ed22eb788394"

URI_aarch64_ttyd = "${EPEL_MIRROR}/aarch64/Packages/t/ttyd-1.7.7-2.el10_1.aarch64.rpm;name=aarch64_ttyd;unpack=0"
SRC_URI:append = " ${URI_aarch64_ttyd}"
SRC_URI[aarch64_ttyd.sha256sum] = "ed24ea21c7b5c135dbe3cd47e4aeca44f35ffc539016bdee03bbaaaecdc9db0f"

RDEPENDS:ttyd = " \
 glibc \
 json-c \
 libuv \
 libwebsockets \
 openssl-libs \
 zlib-ng-compat \
 "
