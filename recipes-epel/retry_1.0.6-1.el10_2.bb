# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "retry"
PV = "1.0.6"
PR = "1.el10_2"
PACKAGES = " \
 retry \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/retry-1.0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae93773707c9ed8ffbb234c2d6110e9a5bcd428767e3703e2a55ba6fe46b0f85"

URI_x86_64_v2_retry = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/retry-1.0.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_retry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_retry}"
SRC_URI[x86_64_v2_retry.sha256sum] = "eeebd5432609c38bee7984db6308d87c9365b748e9f6514af4da5ba38cf65ee1"

URI_aarch64_retry = "${EPEL_MIRROR}/aarch64/Packages/r/retry-1.0.6-1.el10_2.aarch64.rpm;name=aarch64_retry;unpack=0"
SRC_URI:append = " ${URI_aarch64_retry}"
SRC_URI[aarch64_retry.sha256sum] = "8a0b03cd7029ba4e241c10afd35a363a955dc78082b543881c944a421acb92eb"

RDEPENDS:retry = " \
 glibc \
 "
