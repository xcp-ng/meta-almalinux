# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postsrsd"
PV = "2.1.0"
PR = "2.el10_3"
PACKAGES = " \
 postsrsd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/postsrsd-2.1.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59b8fe57dea29ac7f8bf647989b35dfc4526d19f9583dd388c1ba61ceacc37af"

URI_x86_64_v2_postsrsd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/postsrsd-2.1.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_postsrsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postsrsd}"
SRC_URI[x86_64_v2_postsrsd.sha256sum] = "9c76d6ad083b8c06142ef6488ccafd9ead2e9d92a92dfbdce15c15245ceff908"

URI_aarch64_postsrsd = "${EPEL_MIRROR}/aarch64/Packages/p/postsrsd-2.1.0-2.el10_3.aarch64.rpm;name=aarch64_postsrsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_postsrsd}"
SRC_URI[aarch64_postsrsd.sha256sum] = "0826cdb67440d80cd5fd49c6db90e28568d0c8058bb9f3cb8e88c865be541772"

RDEPENDS:postsrsd = " \
 bash \
 glibc \
 libconfuse \
 policycoreutils \
 systemd \
 "
