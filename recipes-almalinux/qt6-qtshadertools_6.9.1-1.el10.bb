# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtshadertools"
PV = "6.9.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtshadertools \
 qt6-qtshadertools-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtshadertools-6.9.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d7fd5803fc347682d716e258eba5d71cd2fdaa38489c5c92029c50ee05cb2ab"

URI_x86_64_v2_qt6-qtshadertools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtshadertools-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtshadertools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtshadertools}"
SRC_URI[x86_64_v2_qt6-qtshadertools.sha256sum] = "b46cb177a062bc5f6c65d982fe8351a47b568fbfadc7a8b532693741201a361e"

URI_x86_64_v2_qt6-qtshadertools-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtshadertools-devel-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtshadertools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtshadertools-devel}"
SRC_URI[x86_64_v2_qt6-qtshadertools-devel.sha256sum] = "2ae75864f64743c25b7572fe82e05daca48c13d56404f134461c48c5b2a1596f"

URI_aarch64_qt6-qtshadertools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtshadertools-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtshadertools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtshadertools}"
SRC_URI[aarch64_qt6-qtshadertools.sha256sum] = "746e999334c9cdcfb179eb6f58a01d7826364b3c8d0f07e182408d3ba6be7373"

URI_aarch64_qt6-qtshadertools-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtshadertools-devel-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtshadertools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtshadertools-devel}"
SRC_URI[aarch64_qt6-qtshadertools-devel.sha256sum] = "4bb60944875df27b50844db16d812bc550c37dd33d05ef6ceab7bbf3b0957c0f"

RDEPENDS:qt6-qtshadertools = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 spirv-tools-libs \
 "
RDEPENDS:qt6-qtshadertools-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtshadertools \
 spirv-tools \
 "
