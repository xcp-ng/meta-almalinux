# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libplasma"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 libplasma \
 libplasma-devel \
 libplasma-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libplasma-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "593c3c13a54ea9b4ec6da7df5c25dff1af4afa01478e2f3f23f870b49da5408c"

URI_x86_64_v2_libplasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplasma-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libplasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libplasma}"
SRC_URI[x86_64_v2_libplasma.sha256sum] = "4c27c419d3a498aa849a507bfc226625a13ba657930b269d7bd57da92933552a"

URI_x86_64_v2_libplasma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplasma-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libplasma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libplasma-devel}"
SRC_URI[x86_64_v2_libplasma-devel.sha256sum] = "ed869f30a1f124b87403f9c6b90ccd735e0b213390d1c0157a7f1d8db2c37b5a"

URI_x86_64_v2_libplasma-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplasma-doc-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libplasma-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libplasma-doc}"
SRC_URI[x86_64_v2_libplasma-doc.sha256sum] = "0e07b95da9a6e08bab715601c0c578676d14c64c30a822cf16a81097454f2701"

URI_aarch64_libplasma = "${EPEL_MIRROR}/aarch64/Packages/l/libplasma-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_libplasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_libplasma}"
SRC_URI[aarch64_libplasma.sha256sum] = "a4f39e0f2406b4942cb32a15bd0f3a99aff88ccfb423bf5a257505ec1e4a1250"

URI_aarch64_libplasma-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libplasma-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_libplasma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libplasma-devel}"
SRC_URI[aarch64_libplasma-devel.sha256sum] = "e98bdce13af73792d3ad08be7ccec0e852f7058dab18308bcc6e17492184b7b7"

URI_aarch64_libplasma-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libplasma-doc-6.3.6-1.el10_0.noarch.rpm;name=aarch64_libplasma-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libplasma-doc}"
SRC_URI[aarch64_libplasma-doc.sha256sum] = "68c30c74bce117247d53a06b12178fd4210c0d733bcdc8be3bb7305957e0b075"

RDEPENDS:libplasma = " \
 glibc \
 kf6-filesystem \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-knotifications \
 kf6-kpackage \
 kf6-ksvg \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libX11 \
 libglvnd-egl \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 "
RDEPENDS:libplasma-devel = " \
 cmake-filesystem \
 kf6-kpackage-devel \
 kf6-kservice-devel \
 kf6-kwindowsystem-devel \
 libplasma \
 qt6-qtbase-devel \
 "
RDEPENDS:libplasma-doc = " \
 "
