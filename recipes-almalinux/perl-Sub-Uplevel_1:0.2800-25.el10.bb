# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sub-Uplevel"
PE = "1"
PV = "0.2800"
PR = "25.el10"
PACKAGES = " \
 perl-Sub-Uplevel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Sub-Uplevel-0.2800-25.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "63fe2dcc0e60544ea097865dd4ce8b44fcd1cc65d27d09722e17fecf68209b0b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Sub-Uplevel-0.2800-25.el10.noarch.rpm;name=x86_64_v2_perl-Sub-Uplevel;unpack=0"
SRC_URI[x86_64_v2_perl-Sub-Uplevel.sha256sum] = "f878331c26499cb509607e92d293e47c522f5d884771145de433f38e950aae7e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Sub-Uplevel-0.2800-25.el10.noarch.rpm;name=aarch64_perl-Sub-Uplevel;unpack=0"
SRC_URI[aarch64_perl-Sub-Uplevel.sha256sum] = "f878331c26499cb509607e92d293e47c522f5d884771145de433f38e950aae7e"

RDEPENDS:perl-Sub-Uplevel = " \
 perl-Carp \
 perl-constant \
 perl-libs \
 "
