# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-parse"
PV = "1.20.2"
PR = "3.el10_1"
PACKAGES = " \
 python3-parse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-parse-1.20.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0169b0f45259a706a45bcfb8fb31edd4716438f9062dd9c1fb202fc3519d165b"

URI_x86_64_v2_python3-parse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-parse-1.20.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-parse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-parse}"
SRC_URI[x86_64_v2_python3-parse.sha256sum] = "8bc33895be507ee0534aa00c4776eaecdd292e675a542c2fe1cf60b97803ceda"

URI_aarch64_python3-parse = "${EPEL_MIRROR}/aarch64/Packages/p/python3-parse-1.20.2-3.el10_1.noarch.rpm;name=aarch64_python3-parse;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-parse}"
SRC_URI[aarch64_python3-parse.sha256sum] = "bf6f9379a46d55204acb69c1b42f93f2bf08211cdfd0bb89196c05c095a1da63"

RDEPENDS:python3-parse = " \
 python3 \
 "
