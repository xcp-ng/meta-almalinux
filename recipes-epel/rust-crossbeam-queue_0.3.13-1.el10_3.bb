# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-queue"
PV = "0.3.13"
PR = "1.el10_3"
PACKAGES = " \
 rust-crossbeam-queue+alloc-devel \
 rust-crossbeam-queue+default-devel \
 rust-crossbeam-queue+nightly-devel \
 rust-crossbeam-queue+std-devel \
 rust-crossbeam-queue-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-queue-0.3.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2192054d6972364988281a19f4649920b3452fdbc07594e514c04177b92164ee"

URI_x86_64_v2_rust-crossbeam-queue+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+alloc-devel-0.3.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-queue+alloc-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-queue+alloc-devel.sha256sum] = "de8769a67145ed0f867db15fe930cd6c6e4d6a631d7fcaa04914660550fc1bd4"

URI_x86_64_v2_rust-crossbeam-queue+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+default-devel-0.3.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-queue+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-queue+default-devel.sha256sum] = "9fdd3886fde5092269879a01a685377c081107c134ad83b68c5b20d6c289441e"

URI_x86_64_v2_rust-crossbeam-queue+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+nightly-devel-0.3.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-queue+nightly-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-queue+nightly-devel.sha256sum] = "8aed21c2c21248ac609889b82bd7e814a2c289b0b04ff77cf7776b3bbf89db65"

URI_x86_64_v2_rust-crossbeam-queue+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+std-devel-0.3.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-queue+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-queue+std-devel.sha256sum] = "c84cd5cf4ae31496ca3e7915a2e69ecad08ed8cf183d3c53187b9ac469852839"

URI_x86_64_v2_rust-crossbeam-queue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue-devel-0.3.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-queue-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-queue-devel.sha256sum] = "50377caee748c3f9f8a1190271f69822e4b1f9974bbd945680edf56f07a927d6"

URI_aarch64_rust-crossbeam-queue+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+alloc-devel-0.3.13-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-queue+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-queue+alloc-devel}"
SRC_URI[aarch64_rust-crossbeam-queue+alloc-devel.sha256sum] = "15904d6b43e35c6f1cd3289ec3954e5398a14658c3bf7834d7b1dce87b6b65bb"

URI_aarch64_rust-crossbeam-queue+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+default-devel-0.3.13-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-queue+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-queue+default-devel}"
SRC_URI[aarch64_rust-crossbeam-queue+default-devel.sha256sum] = "f3942a2fe5b68acd0d83f4ac480b53a9b9754c4f0b016e0b5aaa2ed3c77473a7"

URI_aarch64_rust-crossbeam-queue+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+nightly-devel-0.3.13-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-queue+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-queue+nightly-devel}"
SRC_URI[aarch64_rust-crossbeam-queue+nightly-devel.sha256sum] = "af54ad48e967022375e16b0082ee15d487985cd5af9cb79bb390b298fbbc7a79"

URI_aarch64_rust-crossbeam-queue+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+std-devel-0.3.13-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-queue+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-queue+std-devel}"
SRC_URI[aarch64_rust-crossbeam-queue+std-devel.sha256sum] = "7bef7056fe4561c77e4d7dcf2ddf92139387ea629d294760846b043351df4eae"

URI_aarch64_rust-crossbeam-queue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue-devel-0.3.13-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-queue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-queue-devel}"
SRC_URI[aarch64_rust-crossbeam-queue-devel.sha256sum] = "2997d8ebc6c250c0117860e75f8b3ecc588667e70ab860212e39ff8df2d784d7"

RDEPENDS:rust-crossbeam-queue+alloc-devel = " \
 cargo \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam-queue+default-devel = " \
 cargo \
 rust-crossbeam-queue+std-devel \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam-queue+nightly-devel = " \
 cargo \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+nightly-devel \
 "
RDEPENDS:rust-crossbeam-queue+std-devel = " \
 cargo \
 rust-crossbeam-queue+alloc-devel \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-queue-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
