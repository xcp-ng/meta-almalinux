# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "swaks"
PV = "20240103.0"
PR = "2.el10_0"
PACKAGES = " \
 swaks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/swaks-20240103.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe50aa2f482fca4889d11f2fbf7f2e85142ea85f78c54dae22fd20c870ab1f24"

URI_x86_64_v2_swaks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/swaks-20240103.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_swaks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_swaks}"
SRC_URI[x86_64_v2_swaks.sha256sum] = "f01d2014712b371674f0ca6480e29e10f153cbe3f471718527119dc4f5f13137"

URI_aarch64_swaks = "${EPEL_MIRROR}/aarch64/Packages/s/swaks-20240103.0-2.el10_0.noarch.rpm;name=aarch64_swaks;unpack=0"
SRC_URI:append = " ${URI_aarch64_swaks}"
SRC_URI[aarch64_swaks.sha256sum] = "95507e3f9afd3164ca46d793620fed0909b68c20d50ca27d413d17d7f7bfd595"

RDEPENDS:swaks = " \
 perl-Authen-DigestMD5 \
 perl-Authen-SASL \
 perl-Digest-SHA \
 perl-IO-Socket-IP \
 perl-NTLM \
 perl-Net-DNS \
 perl-Net-SSLeay \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Time-HiRes \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
