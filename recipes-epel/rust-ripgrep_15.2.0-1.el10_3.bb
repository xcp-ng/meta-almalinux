# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ripgrep"
PV = "15.2.0"
PR = "1.el10_3"
PACKAGES = " \
 ripgrep \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ripgrep-15.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce440c6a0f781350a282e7bce4266e4bf97a043393b8ce76ef826fb9ba626613"

URI_x86_64_v2_ripgrep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ripgrep-15.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ripgrep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ripgrep}"
SRC_URI[x86_64_v2_ripgrep.sha256sum] = "ff6f856fed707e1b215e3021e30fa243d17b4a1309457e61fc77c3adfd50480a"

URI_aarch64_ripgrep = "${EPEL_MIRROR}/aarch64/Packages/r/ripgrep-15.2.0-1.el10_3.aarch64.rpm;name=aarch64_ripgrep;unpack=0"
SRC_URI:append = " ${URI_aarch64_ripgrep}"
SRC_URI[aarch64_ripgrep.sha256sum] = "bff8a09a85ad89911c1dc832d72c002f1cde5a4ac39df6ecb031c4d093ffb0d6"

RDEPENDS:ripgrep = " \
 glibc \
 libgcc \
 pcre2 \
 "
