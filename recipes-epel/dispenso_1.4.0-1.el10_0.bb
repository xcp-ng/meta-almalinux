# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dispenso"
PV = "1.4.0"
PR = "1.el10_0"
PACKAGES = " \
 dispenso \
 dispenso-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dispenso-1.4.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "292c211d3f703af56efff9647802e3f590a33b94577ac0c2c37efc36f73cfff3"

URI_x86_64_v2_dispenso = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dispenso-1.4.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dispenso;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dispenso}"
SRC_URI[x86_64_v2_dispenso.sha256sum] = "3f76ca33aa3a22351fd34a16ffc07b5298b295f4290969d0f83d1c7ce8454882"

URI_x86_64_v2_dispenso-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dispenso-devel-1.4.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dispenso-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dispenso-devel}"
SRC_URI[x86_64_v2_dispenso-devel.sha256sum] = "6cff6d315dcb3c4c770965df5f52d3720a9c7a873d9eb42b2659c12cf7b5ac89"

URI_aarch64_dispenso = "${EPEL_MIRROR}/aarch64/Packages/d/dispenso-1.4.0-1.el10_0.aarch64.rpm;name=aarch64_dispenso;unpack=0"
SRC_URI:append = " ${URI_aarch64_dispenso}"
SRC_URI[aarch64_dispenso.sha256sum] = "4c35d944f18b31a05a138bd9a92e4023de82337d7b1a7ed6f86941b5957b5225"

URI_aarch64_dispenso-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dispenso-devel-1.4.0-1.el10_0.aarch64.rpm;name=aarch64_dispenso-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dispenso-devel}"
SRC_URI[aarch64_dispenso-devel.sha256sum] = "3d7a0b216b5361a970a3d33cd6a1c704eb23c07f1a8ceaf8f08229b1a145e449"

RDEPENDS:dispenso = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dispenso-devel = " \
 cmake-filesystem \
 dispenso \
 moodycamel-concurrentqueue-devel \
 "
