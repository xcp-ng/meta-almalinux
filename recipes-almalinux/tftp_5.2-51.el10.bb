# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tftp"
PV = "5.2"
PR = "51.el10"
PACKAGES = " \
 tftp \
 tftp-server \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tftp-5.2-51.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0dc6ea5dc857dbcdc25dcbdacf0f4a51dea36643acd7a63f5ffe1db8714cabf0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tftp-5.2-51.el10.x86_64_v2.rpm;name=x86_64_v2_tftp;unpack=0"
SRC_URI[x86_64_v2_tftp.sha256sum] = "48f9bfb61f5ca22f42fd67c396f3977f0eec751405913ee7aa4fd9661f7fe6e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tftp-server-5.2-51.el10.x86_64_v2.rpm;name=x86_64_v2_tftp-server;unpack=0"
SRC_URI[x86_64_v2_tftp-server.sha256sum] = "edae4584fc4d24f0438a59f0592d497aeb429dfe9691f66b39e3c287a832d0d0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tftp-5.2-51.el10.aarch64.rpm;name=aarch64_tftp;unpack=0"
SRC_URI[aarch64_tftp.sha256sum] = "2adb525034d7c73a5507d979c65031e982388cc95f0d2626a8197a49232911c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tftp-server-5.2-51.el10.aarch64.rpm;name=aarch64_tftp-server;unpack=0"
SRC_URI[aarch64_tftp-server.sha256sum] = "1606c3cc011995a102a64e7c748bea48c0df40f46057c6112582c3dded08081f"

RDEPENDS:tftp = " \
 glibc \
 readline \
 "
RDEPENDS:tftp-server = " \
 bash \
 glibc \
 systemd \
 "
