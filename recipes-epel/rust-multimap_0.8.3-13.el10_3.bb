# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-multimap"
PV = "0.8.3"
PR = "13.el10_3"
PACKAGES = " \
 rust-multimap+default-devel \
 rust-multimap+serde-devel \
 rust-multimap+serde_impl-devel \
 rust-multimap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-multimap-0.8.3-13.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cfd51bbe7ef114790397881ecb5ed2c576804cee515ebdae6aea6d1477576ae"

URI_x86_64_v2_rust-multimap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multimap+default-devel-0.8.3-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multimap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multimap+default-devel}"
SRC_URI[x86_64_v2_rust-multimap+default-devel.sha256sum] = "817ccb27d19f22f62bd5a7fcc0152fc39ae56ae0988506b862e81286f0ac9417"

URI_x86_64_v2_rust-multimap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multimap+serde-devel-0.8.3-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multimap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multimap+serde-devel}"
SRC_URI[x86_64_v2_rust-multimap+serde-devel.sha256sum] = "159047237aaf14692ea6768241237d29378cb3b3ea589b4b8a4290a5a006804f"

URI_x86_64_v2_rust-multimap+serde_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multimap+serde_impl-devel-0.8.3-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multimap+serde_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multimap+serde_impl-devel}"
SRC_URI[x86_64_v2_rust-multimap+serde_impl-devel.sha256sum] = "e9fd8f64034bbe732b3688c565ade5a45ded0e41f46dca067ee7b9e9cd309924"

URI_x86_64_v2_rust-multimap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multimap-devel-0.8.3-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multimap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multimap-devel}"
SRC_URI[x86_64_v2_rust-multimap-devel.sha256sum] = "79bd474547b45fd1fd0cafe1391e97f1b7ef410df1d025c7adac83a44067b21c"

URI_aarch64_rust-multimap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multimap+default-devel-0.8.3-13.el10_3.noarch.rpm;name=aarch64_rust-multimap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multimap+default-devel}"
SRC_URI[aarch64_rust-multimap+default-devel.sha256sum] = "4d18161ab9970ad978a40db89d92177b2423702c33599a4f7c5d86ff11077928"

URI_aarch64_rust-multimap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multimap+serde-devel-0.8.3-13.el10_3.noarch.rpm;name=aarch64_rust-multimap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multimap+serde-devel}"
SRC_URI[aarch64_rust-multimap+serde-devel.sha256sum] = "a731ef3b9441c665381d9a641a9e5fc93d8f26f2282fab5ce34184f284d8874a"

URI_aarch64_rust-multimap+serde_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multimap+serde_impl-devel-0.8.3-13.el10_3.noarch.rpm;name=aarch64_rust-multimap+serde_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multimap+serde_impl-devel}"
SRC_URI[aarch64_rust-multimap+serde_impl-devel.sha256sum] = "502d95ac46e117bfcaf1c2410efd099415925b56e4b050af23dbce789c29232f"

URI_aarch64_rust-multimap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multimap-devel-0.8.3-13.el10_3.noarch.rpm;name=aarch64_rust-multimap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multimap-devel}"
SRC_URI[aarch64_rust-multimap-devel.sha256sum] = "0610a41663c69f26866530c9919388081db74dfbe69d65f8f4cbcc7b46a25ac5"

RDEPENDS:rust-multimap+default-devel = " \
 cargo \
 rust-multimap+serde_impl-devel \
 rust-multimap-devel \
 "
RDEPENDS:rust-multimap+serde-devel = " \
 cargo \
 rust-multimap-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-multimap+serde_impl-devel = " \
 cargo \
 rust-multimap+serde-devel \
 rust-multimap-devel \
 "
RDEPENDS:rust-multimap-devel = " \
 cargo \
 "
