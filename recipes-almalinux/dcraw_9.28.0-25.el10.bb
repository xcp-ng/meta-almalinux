# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dcraw"
PV = "9.28.0"
PR = "25.el10"
PACKAGES = " \
 dcraw \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dcraw-9.28.0-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47b4e3a6c5bc2685dc1173362d7edc59e81cc28f4da5e6c7c7e92d5e7ea4e097"

URI_x86_64_v2_dcraw = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dcraw-9.28.0-25.el10.x86_64_v2.rpm;name=x86_64_v2_dcraw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dcraw}"
SRC_URI[x86_64_v2_dcraw.sha256sum] = "e2ae909b7482b8f0696002d343a53fa94442803f36994abae152aeec87e02c07"

URI_aarch64_dcraw = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dcraw-9.28.0-25.el10.aarch64.rpm;name=aarch64_dcraw;unpack=0"
SRC_URI:append = " ${URI_aarch64_dcraw}"
SRC_URI[aarch64_dcraw.sha256sum] = "d0b4aa0afb65daa3b2513aa312b0ce10324b5396d5c9e68075eca560436739c9"

RDEPENDS:dcraw = " \
 glibc \
 jasper-libs \
 lcms2 \
 libjpeg-turbo \
 "
