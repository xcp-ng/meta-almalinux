# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-convert_case"
PV = "0.8.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-convert_case+default-devel \
 rust-convert_case+rand-devel \
 rust-convert_case+random-devel \
 rust-convert_case-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-convert_case-0.8.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1880ac32738ca30ab47a2e6e8f92bb2d581ae0a31eeffcf761e6bca87b638df2"

URI_x86_64_v2_rust-convert_case+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case+default-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case+default-devel}"
SRC_URI[x86_64_v2_rust-convert_case+default-devel.sha256sum] = "487d04d6dff5e96dfbaa873124a47be96a944843f92d7dcf74bf9444f4760198"

URI_x86_64_v2_rust-convert_case+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case+rand-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case+rand-devel}"
SRC_URI[x86_64_v2_rust-convert_case+rand-devel.sha256sum] = "db00d6105ea82aee3cbc24742315cdf231e4809a537c176bfe43f9ec218ffd31"

URI_x86_64_v2_rust-convert_case+random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case+random-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case+random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case+random-devel}"
SRC_URI[x86_64_v2_rust-convert_case+random-devel.sha256sum] = "3e7b8ef18e29530837e940a92f657f1717246564fe84027b6f8890e133447ced"

URI_x86_64_v2_rust-convert_case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case-devel}"
SRC_URI[x86_64_v2_rust-convert_case-devel.sha256sum] = "5e43aaafc72a36a4e2e790ee18ac0eaa80c45e48f0c8772f99acb32f6b724608"

URI_aarch64_rust-convert_case+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case+default-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-convert_case+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case+default-devel}"
SRC_URI[aarch64_rust-convert_case+default-devel.sha256sum] = "14110a3968a78af73826ec657f984ffdc092eea7f5437a5d421b1ff2bf020e13"

URI_aarch64_rust-convert_case+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case+rand-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-convert_case+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case+rand-devel}"
SRC_URI[aarch64_rust-convert_case+rand-devel.sha256sum] = "b3fce5a525ac0aabe29aedd46bf141c265c377d9dadf6f7fa0c9090692f8b1a4"

URI_aarch64_rust-convert_case+random-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case+random-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-convert_case+random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case+random-devel}"
SRC_URI[aarch64_rust-convert_case+random-devel.sha256sum] = "f090730f5337af537db8f176a37f1e89a365af22e2148b9fad2ee554e2b49bd3"

URI_aarch64_rust-convert_case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-convert_case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case-devel}"
SRC_URI[aarch64_rust-convert_case-devel.sha256sum] = "ebf2e671ec7d484de8e5a0ce242b7037c35ba913e57ad32c67f402a95001cd11"

RDEPENDS:rust-convert_case+default-devel = " \
 cargo \
 rust-convert_case-devel \
 "
RDEPENDS:rust-convert_case+rand-devel = " \
 cargo \
 rust-convert_case-devel \
 rust-rand0.8+default-devel \
 "
RDEPENDS:rust-convert_case+random-devel = " \
 cargo \
 rust-convert_case+rand-devel \
 rust-convert_case-devel \
 "
RDEPENDS:rust-convert_case-devel = " \
 cargo \
 rust-unicode-segmentation+default-devel \
 "
