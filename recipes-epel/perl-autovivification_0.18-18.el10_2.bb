# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-autovivification"
PV = "0.18"
PR = "18.el10_2"
PACKAGES = " \
 perl-autovivification \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-autovivification-0.18-18.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f17e1b6ff7ad4104ad2fe9a4d060ac88c53cab00ddb2f94c80422caed32d697"

URI_x86_64_v2_perl-autovivification = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-autovivification-0.18-18.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-autovivification;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-autovivification}"
SRC_URI[x86_64_v2_perl-autovivification.sha256sum] = "27cd2e4b7434966c18dc37a4535ad562d5ea9881a1a6d61818bcec864d6630f6"

URI_aarch64_perl-autovivification = "${EPEL_MIRROR}/aarch64/Packages/p/perl-autovivification-0.18-18.el10_2.aarch64.rpm;name=aarch64_perl-autovivification;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-autovivification}"
SRC_URI[aarch64_perl-autovivification.sha256sum] = "c86f43ae33b120426482fd1bfd92a14f96a9e5d41b169c0f3bb6dd65c336e8b8"

RDEPENDS:perl-autovivification = " \
 glibc \
 perl-libs \
 "
