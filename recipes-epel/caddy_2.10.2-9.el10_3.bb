# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "caddy"
PV = "2.10.2"
PR = "9.el10_3"
PACKAGES = " \
 caddy \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/caddy-2.10.2-9.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "13eb45af4e48b8da4da4a25d3ca044bce40041bb0d5352bca73fa0706dc7552a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/caddy-2.10.2-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_caddy;unpack=0"
SRC_URI[x86_64_v2_caddy.sha256sum] = "1f34b3efcde78568f4b1217383f9030182f5970d4ff0b5bb06d21db50b46f38c"
RPROVIDES:caddy:append:x86_64_v2 = " virtual/webserver"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/caddy-2.10.2-9.el10_3.aarch64.rpm;name=aarch64_caddy;unpack=0"
SRC_URI[aarch64_caddy.sha256sum] = "78db06b90425caa253b9b51a8adbb0e74f0e886c10c6b01bb1bd7feace35c011"
RPROVIDES:caddy:append:aarch64 = " virtual/webserver"

RDEPENDS:caddy = " \
 almalinux-logos-httpd \
 bash \
 glibc \
 shadow-utils \
 systemd \
 "
