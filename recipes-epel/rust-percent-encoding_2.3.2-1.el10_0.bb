# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-percent-encoding"
PV = "2.3.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-percent-encoding+alloc-devel \
 rust-percent-encoding+default-devel \
 rust-percent-encoding+std-devel \
 rust-percent-encoding-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-percent-encoding-2.3.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65535c9e582c871854d46ac5f33e672b45494d9d61c990aa0267da45a26eebf6"

URI_x86_64_v2_rust-percent-encoding+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-percent-encoding+alloc-devel-2.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-percent-encoding+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-percent-encoding+alloc-devel}"
SRC_URI[x86_64_v2_rust-percent-encoding+alloc-devel.sha256sum] = "ba98ffe852e49827af9b09f72d4446867d590f67888dcc3cd353a9d6e1acf61d"

URI_x86_64_v2_rust-percent-encoding+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-percent-encoding+default-devel-2.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-percent-encoding+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-percent-encoding+default-devel}"
SRC_URI[x86_64_v2_rust-percent-encoding+default-devel.sha256sum] = "a5efda9c12f29f1a8663337424984a624bf36c6410f66286ee630532e4f7db2e"

URI_x86_64_v2_rust-percent-encoding+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-percent-encoding+std-devel-2.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-percent-encoding+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-percent-encoding+std-devel}"
SRC_URI[x86_64_v2_rust-percent-encoding+std-devel.sha256sum] = "9220d403efe76b8eccf7c356bf2f475d9d61039515db25bacc9e35f10057e863"

URI_x86_64_v2_rust-percent-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-percent-encoding-devel-2.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-percent-encoding-devel}"
SRC_URI[x86_64_v2_rust-percent-encoding-devel.sha256sum] = "e89c2f28eab5e7d6d19d529ca8d1757a3f646f410fc2e84a712803237d8f43e7"

URI_aarch64_rust-percent-encoding+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-percent-encoding+alloc-devel-2.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-percent-encoding+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-percent-encoding+alloc-devel}"
SRC_URI[aarch64_rust-percent-encoding+alloc-devel.sha256sum] = "b0f016a11542982ed057893bbbc934d6c275839a77f114a568bf657ae23d5302"

URI_aarch64_rust-percent-encoding+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-percent-encoding+default-devel-2.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-percent-encoding+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-percent-encoding+default-devel}"
SRC_URI[aarch64_rust-percent-encoding+default-devel.sha256sum] = "71d630e5936df15a21283a88c6c12d4c4e0c4246b7e27aa7fcbca908f8de7857"

URI_aarch64_rust-percent-encoding+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-percent-encoding+std-devel-2.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-percent-encoding+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-percent-encoding+std-devel}"
SRC_URI[aarch64_rust-percent-encoding+std-devel.sha256sum] = "c1e3d22dd7982d3fc1a8c585ada3d8b154f8da04b4d44448fc23f33779179d92"

URI_aarch64_rust-percent-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-percent-encoding-devel-2.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-percent-encoding-devel}"
SRC_URI[aarch64_rust-percent-encoding-devel.sha256sum] = "7366ab5f0769982f90a9ec8f2454d3f013fac7267d091989b3dd14304652c8ba"

RDEPENDS:rust-percent-encoding+alloc-devel = " \
 cargo \
 rust-percent-encoding-devel \
 "
RDEPENDS:rust-percent-encoding+default-devel = " \
 cargo \
 rust-percent-encoding+std-devel \
 rust-percent-encoding-devel \
 "
RDEPENDS:rust-percent-encoding+std-devel = " \
 cargo \
 rust-percent-encoding+alloc-devel \
 rust-percent-encoding-devel \
 "
RDEPENDS:rust-percent-encoding-devel = " \
 cargo \
 rust \
 "
