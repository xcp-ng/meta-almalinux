# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-attributes"
PV = "0.24.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-attributes+default-devel \
 rust-gix-attributes+document-features-devel \
 rust-gix-attributes+serde-devel \
 rust-gix-attributes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-attributes-0.24.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfe87340e568e68c0b2d7a3a76655f1967fb683e042cb43127cc9c16d2964247"

URI_x86_64_v2_rust-gix-attributes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes+default-devel-0.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes+default-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes+default-devel.sha256sum] = "2685dce49a4606f3911570d1196c0bd1b9123b9129b86513690204c9de0f5335"

URI_x86_64_v2_rust-gix-attributes+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes+document-features-devel-0.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes+document-features-devel.sha256sum] = "ede13c51036a95f42dd9d2fc17cbd4214e2b6188e0f74e5c83978b39c7e7325f"

URI_x86_64_v2_rust-gix-attributes+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes+serde-devel-0.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes+serde-devel.sha256sum] = "12f32c04dade4df07cb1b86b80dd9dee8b4d8d22d154f593bd97f8604318ace6"

URI_x86_64_v2_rust-gix-attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes-devel-0.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes-devel.sha256sum] = "3d79fbea9a96f20a2b634265b829bc96a66d8ef07ec16bf2271972558d995106"

URI_aarch64_rust-gix-attributes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes+default-devel-0.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes+default-devel}"
SRC_URI[aarch64_rust-gix-attributes+default-devel.sha256sum] = "e352a5557d74ae93d09c8470eac11d002d264cdf8f4eb8e83df461b305c31ef7"

URI_aarch64_rust-gix-attributes+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes+document-features-devel-0.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-attributes+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes+document-features-devel}"
SRC_URI[aarch64_rust-gix-attributes+document-features-devel.sha256sum] = "875042b8e2ec2f1765255f8aa22d983e030199dc1473309e1edb6f076d182311"

URI_aarch64_rust-gix-attributes+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes+serde-devel-0.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-attributes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes+serde-devel}"
SRC_URI[aarch64_rust-gix-attributes+serde-devel.sha256sum] = "a72895df49aab86659d4b1e438c146fdc8ac7a7509c9595e1e118562b4c2f6a3"

URI_aarch64_rust-gix-attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes-devel-0.24.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes-devel}"
SRC_URI[aarch64_rust-gix-attributes-devel.sha256sum] = "c8c5cb426c23fd47871de8291dce8d522fd9899b2ff27a755f392542a62fc312"

RDEPENDS:rust-gix-attributes+default-devel = " \
 cargo \
 rust-gix-attributes-devel \
 "
RDEPENDS:rust-gix-attributes+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-attributes-devel \
 "
RDEPENDS:rust-gix-attributes+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-attributes-devel \
 rust-gix-glob+serde-devel \
 rust-kstring+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-attributes-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-glob+default-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-trace+default-devel \
 rust-kstring+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 rust-unicode-bom+default-devel \
 "
