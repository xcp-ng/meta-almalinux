# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-circonus-labs-circonusllhist"
PV = "0.1.4"
PR = "14.el10_0"
PACKAGES = " \
 golang-github-circonus-labs-circonusllhist-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-circonus-labs-circonusllhist-0.1.4-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "033c233d9813f9e55bb5f8aa1dabf8013ef6fabe49a0e19a450a4d84604b8cbb"

URI_x86_64_v2_golang-github-circonus-labs-circonusllhist-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-circonus-labs-circonusllhist-devel-0.1.4-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-circonus-labs-circonusllhist-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-circonus-labs-circonusllhist-devel}"
SRC_URI[x86_64_v2_golang-github-circonus-labs-circonusllhist-devel.sha256sum] = "0952d23abc6c2e8bc16ffe9f425f02f9c5a481e5a3badaf81f67b7b740c05acb"

URI_aarch64_golang-github-circonus-labs-circonusllhist-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-circonus-labs-circonusllhist-devel-0.1.4-14.el10_0.noarch.rpm;name=aarch64_golang-github-circonus-labs-circonusllhist-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-circonus-labs-circonusllhist-devel}"
SRC_URI[aarch64_golang-github-circonus-labs-circonusllhist-devel.sha256sum] = "c341f9507641ae1f1a705745be40a8b67148c1fe5ae9e8efbb8e12492039debc"

RDEPENDS:golang-github-circonus-labs-circonusllhist-devel = " \
 go-filesystem \
 "
