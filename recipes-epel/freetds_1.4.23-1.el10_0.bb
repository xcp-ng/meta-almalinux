# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freetds"
PV = "1.4.23"
PR = "1.el10_0"
PACKAGES = " \
 freetds \
 freetds-devel \
 freetds-doc \
 freetds-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/freetds-1.4.23-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e050b1f401c10762d65e280964271f56138ee303a2abfb8e34093422acc9ae12"

URI_x86_64_v2_freetds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freetds-1.4.23-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freetds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freetds}"
SRC_URI[x86_64_v2_freetds.sha256sum] = "3baad688ae1d8b42d2bbf5c14b50a5b1ed5423f1b5893415c6ca624e24900a93"

URI_x86_64_v2_freetds-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freetds-devel-1.4.23-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freetds-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freetds-devel}"
SRC_URI[x86_64_v2_freetds-devel.sha256sum] = "5bc09bb54760266933d9185ecdc370b5cd020c7bcb268c47d71785bb608ff5a1"

URI_x86_64_v2_freetds-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freetds-doc-1.4.23-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_freetds-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freetds-doc}"
SRC_URI[x86_64_v2_freetds-doc.sha256sum] = "7414258224662bd2b84eed503785ab82d2c21c382110e15192eab1c8d7d975ab"

URI_x86_64_v2_freetds-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freetds-libs-1.4.23-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freetds-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freetds-libs}"
SRC_URI[x86_64_v2_freetds-libs.sha256sum] = "8e08723e11e04e3a83cc471e198dd7b5afc886471d3df1c5ad8d5331e0bcd4c9"

URI_aarch64_freetds = "${EPEL_MIRROR}/aarch64/Packages/f/freetds-1.4.23-1.el10_0.aarch64.rpm;name=aarch64_freetds;unpack=0"
SRC_URI:append = " ${URI_aarch64_freetds}"
SRC_URI[aarch64_freetds.sha256sum] = "bac5f8ce3314dc5c7efbdf5fc89275aef3ba110069bc28d9d6aaad2593efdb64"

URI_aarch64_freetds-devel = "${EPEL_MIRROR}/aarch64/Packages/f/freetds-devel-1.4.23-1.el10_0.aarch64.rpm;name=aarch64_freetds-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freetds-devel}"
SRC_URI[aarch64_freetds-devel.sha256sum] = "2db5faebe9ca8e401dbce8ce9122e2081c0dbeb3c70d275172c30b897bb16df7"

URI_aarch64_freetds-doc = "${EPEL_MIRROR}/aarch64/Packages/f/freetds-doc-1.4.23-1.el10_0.noarch.rpm;name=aarch64_freetds-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_freetds-doc}"
SRC_URI[aarch64_freetds-doc.sha256sum] = "1143f802321ef5e3b3d8e389971db251a4e2067894931407bb3c9c6fc299d816"

URI_aarch64_freetds-libs = "${EPEL_MIRROR}/aarch64/Packages/f/freetds-libs-1.4.23-1.el10_0.aarch64.rpm;name=aarch64_freetds-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_freetds-libs}"
SRC_URI[aarch64_freetds-libs.sha256sum] = "b44503644dd380d4adae578a794ed3bd2b9e0bc18335fed341549d91026fbbf1"

RDEPENDS:freetds = " \
 bash \
 freetds-libs \
 glibc \
 gnutls \
 krb5-libs \
 libgcrypt \
 libtasn1 \
 readline \
 unixODBC \
 "
RDEPENDS:freetds-devel = " \
 freetds-libs \
 "
RDEPENDS:freetds-doc = " \
 "
RDEPENDS:freetds-libs = " \
 freetds \
 glibc \
 gnutls \
 krb5-libs \
 libgcrypt \
 libgpg-error \
 libtasn1 \
 unixODBC \
 "
