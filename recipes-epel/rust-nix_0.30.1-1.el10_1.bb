# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nix"
PV = "0.30.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-nix+acct-devel \
 rust-nix+aio-devel \
 rust-nix+default-devel \
 rust-nix+dir-devel \
 rust-nix+env-devel \
 rust-nix+event-devel \
 rust-nix+fanotify-devel \
 rust-nix+feature-devel \
 rust-nix+fs-devel \
 rust-nix+hostname-devel \
 rust-nix+inotify-devel \
 rust-nix+ioctl-devel \
 rust-nix+kmod-devel \
 rust-nix+memoffset-devel \
 rust-nix+mman-devel \
 rust-nix+mount-devel \
 rust-nix+mqueue-devel \
 rust-nix+net-devel \
 rust-nix+personality-devel \
 rust-nix+pin-utils-devel \
 rust-nix+poll-devel \
 rust-nix+process-devel \
 rust-nix+pthread-devel \
 rust-nix+ptrace-devel \
 rust-nix+quota-devel \
 rust-nix+reboot-devel \
 rust-nix+resource-devel \
 rust-nix+sched-devel \
 rust-nix+signal-devel \
 rust-nix+socket-devel \
 rust-nix+syslog-devel \
 rust-nix+term-devel \
 rust-nix+time-devel \
 rust-nix+ucontext-devel \
 rust-nix+uio-devel \
 rust-nix+user-devel \
 rust-nix+zerocopy-devel \
 rust-nix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nix-0.30.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d944953182e0824885aa21e216395a85950608cf5ac444c6ac1c43330d78637"

URI_x86_64_v2_rust-nix+acct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+acct-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+acct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+acct-devel}"
SRC_URI[x86_64_v2_rust-nix+acct-devel.sha256sum] = "308e35c155174984309926fd1b5d55bc031723b76386ae15a4c2b911c9d952c7"

URI_x86_64_v2_rust-nix+aio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+aio-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+aio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+aio-devel}"
SRC_URI[x86_64_v2_rust-nix+aio-devel.sha256sum] = "21b23d877f8b80615932562f572c2f221729d55b79165ea54ade6dfb80a10127"

URI_x86_64_v2_rust-nix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+default-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+default-devel}"
SRC_URI[x86_64_v2_rust-nix+default-devel.sha256sum] = "b4be7fe2cc3496628e64ca61676a8fa72054abd5955438750532960332804ac5"

URI_x86_64_v2_rust-nix+dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+dir-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+dir-devel}"
SRC_URI[x86_64_v2_rust-nix+dir-devel.sha256sum] = "fb689fd72675369fcabaafb7d48c0bd23d8da55b40fcc0229008f3356fa346db"

URI_x86_64_v2_rust-nix+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+env-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+env-devel}"
SRC_URI[x86_64_v2_rust-nix+env-devel.sha256sum] = "340985a871dd3f9a91809a657bed0ef634098d0c432dcb1d1c2f693e9ebe0b9d"

URI_x86_64_v2_rust-nix+event-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+event-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+event-devel}"
SRC_URI[x86_64_v2_rust-nix+event-devel.sha256sum] = "12bdd959eb7eb0ebbf20a91d313b128e8f66607bad6e3ddb37a364f7d0a26779"

URI_x86_64_v2_rust-nix+fanotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+fanotify-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+fanotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+fanotify-devel}"
SRC_URI[x86_64_v2_rust-nix+fanotify-devel.sha256sum] = "a6bc82cb57ff5f5593f83712de4f30d78e7a8ab8825b10e3d79e907c3f51f42d"

URI_x86_64_v2_rust-nix+feature-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+feature-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+feature-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+feature-devel}"
SRC_URI[x86_64_v2_rust-nix+feature-devel.sha256sum] = "f80cf29f68c8f82d1631dea20049b4fac88eb9ff6486229175fe1a8e1e7c3fea"

URI_x86_64_v2_rust-nix+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+fs-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+fs-devel}"
SRC_URI[x86_64_v2_rust-nix+fs-devel.sha256sum] = "b2b2d4482e23de413fed300b00ab01c846d725792c3f08040baafefa0f6abae2"

URI_x86_64_v2_rust-nix+hostname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+hostname-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+hostname-devel}"
SRC_URI[x86_64_v2_rust-nix+hostname-devel.sha256sum] = "b04c07ec03857ea4eb7db36d9a5d1bb486f7b47c6892db8ba236d8223452b2dd"

URI_x86_64_v2_rust-nix+inotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+inotify-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+inotify-devel}"
SRC_URI[x86_64_v2_rust-nix+inotify-devel.sha256sum] = "665decde8cbea83202af1607199833efc525a543e15de586391dccaed48af375"

URI_x86_64_v2_rust-nix+ioctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+ioctl-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+ioctl-devel}"
SRC_URI[x86_64_v2_rust-nix+ioctl-devel.sha256sum] = "fd2f90a2d6e4e1fe348b512ea300ddc2c3a6599bbaae1b5cd1bd10a637a8dcd8"

URI_x86_64_v2_rust-nix+kmod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+kmod-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+kmod-devel}"
SRC_URI[x86_64_v2_rust-nix+kmod-devel.sha256sum] = "b4c4ad96a3e45d7a88ec342074131e77aae799cf8477edd4ef502a8cece53819"

URI_x86_64_v2_rust-nix+memoffset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+memoffset-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+memoffset-devel}"
SRC_URI[x86_64_v2_rust-nix+memoffset-devel.sha256sum] = "6ad1b837e904ec91d6e5d1c2e4669fa59edaab8188b421785a21b77aee122c56"

URI_x86_64_v2_rust-nix+mman-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+mman-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+mman-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+mman-devel}"
SRC_URI[x86_64_v2_rust-nix+mman-devel.sha256sum] = "ba15cf43f5b95b1350b1bb22fd3fdf377b0ce12110c35a9db468a35d748bf714"

URI_x86_64_v2_rust-nix+mount-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+mount-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+mount-devel}"
SRC_URI[x86_64_v2_rust-nix+mount-devel.sha256sum] = "0fde3a5399fbd5bdbd5445675b09d7b14d936129745670d98e3a37206b651416"

URI_x86_64_v2_rust-nix+mqueue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+mqueue-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+mqueue-devel}"
SRC_URI[x86_64_v2_rust-nix+mqueue-devel.sha256sum] = "b5ff8797b17706d10de7f2cb484b3b80f111ead6a2d6a839d5b888921a511161"

URI_x86_64_v2_rust-nix+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+net-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+net-devel}"
SRC_URI[x86_64_v2_rust-nix+net-devel.sha256sum] = "cec6f9faec0116a88b5ab36d8c5aecb54af9c4086e12f67d236807231b863d9b"

URI_x86_64_v2_rust-nix+personality-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+personality-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+personality-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+personality-devel}"
SRC_URI[x86_64_v2_rust-nix+personality-devel.sha256sum] = "0ad02bf90a328093f5f90d2f2009d45c90889aa99aaca5a01c479ea06ce14cb6"

URI_x86_64_v2_rust-nix+pin-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+pin-utils-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+pin-utils-devel}"
SRC_URI[x86_64_v2_rust-nix+pin-utils-devel.sha256sum] = "1e478c3bc41b84618f072708374a5e807b2f8fcc205c58732cd4e63c05e69135"

URI_x86_64_v2_rust-nix+poll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+poll-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+poll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+poll-devel}"
SRC_URI[x86_64_v2_rust-nix+poll-devel.sha256sum] = "bec82146e8d6291aaea8d6fa5117def6cf4a52d739f5eb69c9fe8c490c6726c4"

URI_x86_64_v2_rust-nix+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+process-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+process-devel}"
SRC_URI[x86_64_v2_rust-nix+process-devel.sha256sum] = "8811ba2a44d0ffcc7804643e6dbbf609d01d580bfa64789db0e7f8b2ca5b46c9"

URI_x86_64_v2_rust-nix+pthread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+pthread-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+pthread-devel}"
SRC_URI[x86_64_v2_rust-nix+pthread-devel.sha256sum] = "d3b66a0199d12afbddd013c589331016bec51588af69477c34a32242d9d3b2d7"

URI_x86_64_v2_rust-nix+ptrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+ptrace-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+ptrace-devel}"
SRC_URI[x86_64_v2_rust-nix+ptrace-devel.sha256sum] = "fa9c44cb5bc4bfdcd0a33b9a7abc1a038b82d4079eb45e06b22e7a1ccb8eebed"

URI_x86_64_v2_rust-nix+quota-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+quota-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+quota-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+quota-devel}"
SRC_URI[x86_64_v2_rust-nix+quota-devel.sha256sum] = "5acd554ad49bf719c06cbdf4dabc9256df967f335d5425f9cd6b44ddf05a75f3"

URI_x86_64_v2_rust-nix+reboot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+reboot-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+reboot-devel}"
SRC_URI[x86_64_v2_rust-nix+reboot-devel.sha256sum] = "5e4785c33123557904919c1812be48433a13b11cd2fcc824ed82503fd850e826"

URI_x86_64_v2_rust-nix+resource-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+resource-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+resource-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+resource-devel}"
SRC_URI[x86_64_v2_rust-nix+resource-devel.sha256sum] = "242e61f016be3e55061082ac2dbfe63fb2c4c2437dcb95a307e652faf2a3397b"

URI_x86_64_v2_rust-nix+sched-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+sched-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+sched-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+sched-devel}"
SRC_URI[x86_64_v2_rust-nix+sched-devel.sha256sum] = "b7e781c683ed42e3016fa270ce14c58f799a358fdd41981eb783c85aa5b06212"

URI_x86_64_v2_rust-nix+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+signal-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+signal-devel}"
SRC_URI[x86_64_v2_rust-nix+signal-devel.sha256sum] = "da9d2ec003afe273dab5b330b45e1efaca1d39af20b5cdeb1f661f90f9a40cc9"

URI_x86_64_v2_rust-nix+socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+socket-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+socket-devel}"
SRC_URI[x86_64_v2_rust-nix+socket-devel.sha256sum] = "44a9741d322594c0ffdf139901af536b3d1d642835e973aad83c630836e286a9"

URI_x86_64_v2_rust-nix+syslog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+syslog-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+syslog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+syslog-devel}"
SRC_URI[x86_64_v2_rust-nix+syslog-devel.sha256sum] = "ee3d1e51571e1bf4907b412cf06679ecffee459bd3b5d953a04fa70025f2af08"

URI_x86_64_v2_rust-nix+term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+term-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+term-devel}"
SRC_URI[x86_64_v2_rust-nix+term-devel.sha256sum] = "e801cef61235217bf3ca74b04cb112c477eda0ca05744e0f025e3bc631a569a0"

URI_x86_64_v2_rust-nix+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+time-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+time-devel}"
SRC_URI[x86_64_v2_rust-nix+time-devel.sha256sum] = "596b48cd0a10a509caa9f31f80844118ef762084521666db48cc8bdd1ffdc0e6"

URI_x86_64_v2_rust-nix+ucontext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+ucontext-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+ucontext-devel}"
SRC_URI[x86_64_v2_rust-nix+ucontext-devel.sha256sum] = "8cd3d92744b434983522d3fd15f388028271f48ac9911ca38b7ee3cecfe3ce05"

URI_x86_64_v2_rust-nix+uio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+uio-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+uio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+uio-devel}"
SRC_URI[x86_64_v2_rust-nix+uio-devel.sha256sum] = "34f85e466611d3d1fc58dfa8b6665b48f530b5c23dc7ab88ca25b16a3563bc2a"

URI_x86_64_v2_rust-nix+user-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+user-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+user-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+user-devel}"
SRC_URI[x86_64_v2_rust-nix+user-devel.sha256sum] = "dba2d05ed8521bcdd9b6784e13563c74965a5d8b6a224756c41bbaa2ef5b1a39"

URI_x86_64_v2_rust-nix+zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+zerocopy-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+zerocopy-devel}"
SRC_URI[x86_64_v2_rust-nix+zerocopy-devel.sha256sum] = "2e1603e2d3d4cc1b81720de41ab1b77c3b6a307a16dab8afb83032a15d7b8eff"

URI_x86_64_v2_rust-nix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix-devel-0.30.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix-devel}"
SRC_URI[x86_64_v2_rust-nix-devel.sha256sum] = "9780a7bbd51e95c8aa2501279c04b7820a0d725117dda272542263aa55c40bdc"

URI_aarch64_rust-nix+acct-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+acct-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+acct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+acct-devel}"
SRC_URI[aarch64_rust-nix+acct-devel.sha256sum] = "11113fa3b0e43e02a041ba1e139ff664476a849e9bf1e5c472def439db9fcfaf"

URI_aarch64_rust-nix+aio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+aio-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+aio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+aio-devel}"
SRC_URI[aarch64_rust-nix+aio-devel.sha256sum] = "624e49ec837fd2704bd13fca05f74ab1155d5f202911ae54c3d1531c919032ed"

URI_aarch64_rust-nix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+default-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+default-devel}"
SRC_URI[aarch64_rust-nix+default-devel.sha256sum] = "c02043a45a0213a4cd24d0442da368122c1f89e3978b53e60870c9aed1bf809f"

URI_aarch64_rust-nix+dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+dir-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+dir-devel}"
SRC_URI[aarch64_rust-nix+dir-devel.sha256sum] = "de7245901393a80e3af464a1fee66d69177ec34842e0d9a9022e80dd86773feb"

URI_aarch64_rust-nix+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+env-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+env-devel}"
SRC_URI[aarch64_rust-nix+env-devel.sha256sum] = "25c108ba15520285d55c8d135d407f768c430b004dce6cf4143ae0c566a66c30"

URI_aarch64_rust-nix+event-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+event-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+event-devel}"
SRC_URI[aarch64_rust-nix+event-devel.sha256sum] = "805db03e86ac9a76f0e5e3cc061470ae9a54a5e906045075b05d1bc4bc7d8c16"

URI_aarch64_rust-nix+fanotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+fanotify-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+fanotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+fanotify-devel}"
SRC_URI[aarch64_rust-nix+fanotify-devel.sha256sum] = "f2cf61357fd1ec76e87c944df3d1654e67966d7ca799f0a2e8f494de11f72a07"

URI_aarch64_rust-nix+feature-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+feature-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+feature-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+feature-devel}"
SRC_URI[aarch64_rust-nix+feature-devel.sha256sum] = "cdc99f0694e23e4fd6fa6ee8ec3e0d1c039661b05d82b739c337089521022cac"

URI_aarch64_rust-nix+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+fs-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+fs-devel}"
SRC_URI[aarch64_rust-nix+fs-devel.sha256sum] = "77eafe4fefa0b11359aa8f59451d161f0c40f8549f1c44f3530485ac860fa32f"

URI_aarch64_rust-nix+hostname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+hostname-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+hostname-devel}"
SRC_URI[aarch64_rust-nix+hostname-devel.sha256sum] = "816100402cfba431216f16d401359a824709dbeef2edc884834ac1eaa88fae86"

URI_aarch64_rust-nix+inotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+inotify-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+inotify-devel}"
SRC_URI[aarch64_rust-nix+inotify-devel.sha256sum] = "700c6fd3630cd84939036ec167e55499f2fb0426d113f97e9abf72ed93a8e2c7"

URI_aarch64_rust-nix+ioctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+ioctl-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+ioctl-devel}"
SRC_URI[aarch64_rust-nix+ioctl-devel.sha256sum] = "ffa2c4776b6e9162282125e7790591f7536e1767314c51dc6473d653e1982cca"

URI_aarch64_rust-nix+kmod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+kmod-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+kmod-devel}"
SRC_URI[aarch64_rust-nix+kmod-devel.sha256sum] = "d384b992fe6b490206c29bfda3aeb5296e63036329cbc84fb494684cfe8248a4"

URI_aarch64_rust-nix+memoffset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+memoffset-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+memoffset-devel}"
SRC_URI[aarch64_rust-nix+memoffset-devel.sha256sum] = "d88e4894fe882949cbdd481609b39ede4902a7f3a9ca5305ef22df63cbf161f4"

URI_aarch64_rust-nix+mman-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+mman-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+mman-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+mman-devel}"
SRC_URI[aarch64_rust-nix+mman-devel.sha256sum] = "e0c62eec55a844587862949c9b7bb200f6103930585c1f6177a9c4325caa2f9c"

URI_aarch64_rust-nix+mount-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+mount-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+mount-devel}"
SRC_URI[aarch64_rust-nix+mount-devel.sha256sum] = "5dd81859bf7274f0780bb2cac547e439cfe256d5efb084f801df6e575e42292f"

URI_aarch64_rust-nix+mqueue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+mqueue-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+mqueue-devel}"
SRC_URI[aarch64_rust-nix+mqueue-devel.sha256sum] = "2d54bdb777122bc83018136cd4323d2e7e2cf992f2eb6d3f81b988d80eda1790"

URI_aarch64_rust-nix+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+net-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+net-devel}"
SRC_URI[aarch64_rust-nix+net-devel.sha256sum] = "3b29dbef41143d52d6c9314bcacfabe3d69b435c4b7e38153f8f82dbf95c7e15"

URI_aarch64_rust-nix+personality-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+personality-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+personality-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+personality-devel}"
SRC_URI[aarch64_rust-nix+personality-devel.sha256sum] = "96df9b01f8e937b212997baded96e827a475ee478c4a68995f8308c942ef488d"

URI_aarch64_rust-nix+pin-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+pin-utils-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+pin-utils-devel}"
SRC_URI[aarch64_rust-nix+pin-utils-devel.sha256sum] = "701c4316c0d2998273eee4e85856df62caab068ae37cfb333750be5b4b81d45a"

URI_aarch64_rust-nix+poll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+poll-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+poll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+poll-devel}"
SRC_URI[aarch64_rust-nix+poll-devel.sha256sum] = "9720ae5776dfefcb189aeb76048643b3b4f81cfa7af13e7acf8257e82869a2a4"

URI_aarch64_rust-nix+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+process-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+process-devel}"
SRC_URI[aarch64_rust-nix+process-devel.sha256sum] = "74cb5b9545a718a0d5c24a72fb488bdc79149809f55ce94dd1733c9e868d72c3"

URI_aarch64_rust-nix+pthread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+pthread-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+pthread-devel}"
SRC_URI[aarch64_rust-nix+pthread-devel.sha256sum] = "04c96d89af7b70d277dd2fa78f4993bc08a8c8a8cd914cc4c44611638bf88a82"

URI_aarch64_rust-nix+ptrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+ptrace-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+ptrace-devel}"
SRC_URI[aarch64_rust-nix+ptrace-devel.sha256sum] = "11082774c6c70aa0279c94ceea29645197192488bf9ee34cf3b433883c468926"

URI_aarch64_rust-nix+quota-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+quota-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+quota-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+quota-devel}"
SRC_URI[aarch64_rust-nix+quota-devel.sha256sum] = "46430c059af5701f04c0d625ea652f3d177e6ea691ecffd4e9a7e1f1be06c30b"

URI_aarch64_rust-nix+reboot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+reboot-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+reboot-devel}"
SRC_URI[aarch64_rust-nix+reboot-devel.sha256sum] = "4cc2cec09d46e4570c10a14527677ff1a7af839228c63d74c9d1cf207bd99e2a"

URI_aarch64_rust-nix+resource-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+resource-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+resource-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+resource-devel}"
SRC_URI[aarch64_rust-nix+resource-devel.sha256sum] = "ae9d34e87ca335f7964715de6461f6c93abb72c57cc03b7f158abb0ed11dda3c"

URI_aarch64_rust-nix+sched-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+sched-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+sched-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+sched-devel}"
SRC_URI[aarch64_rust-nix+sched-devel.sha256sum] = "ba1fb23f4ed70417576fba3dea0bd5dce2035ca35acdebe97640bdb15105e980"

URI_aarch64_rust-nix+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+signal-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+signal-devel}"
SRC_URI[aarch64_rust-nix+signal-devel.sha256sum] = "651736f24cea18eb431a09e6741307ecbb49365bab8ed80679bde1b30860d1ae"

URI_aarch64_rust-nix+socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+socket-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+socket-devel}"
SRC_URI[aarch64_rust-nix+socket-devel.sha256sum] = "f51fb68494c1f2359cdfbc3c10b0d809d87c9ecf6445e39438dafc03fae0ce88"

URI_aarch64_rust-nix+syslog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+syslog-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+syslog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+syslog-devel}"
SRC_URI[aarch64_rust-nix+syslog-devel.sha256sum] = "47e4206b6a3a399c83beb1513f23777435b36bb73d8afccdde3d8655ffa2d553"

URI_aarch64_rust-nix+term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+term-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+term-devel}"
SRC_URI[aarch64_rust-nix+term-devel.sha256sum] = "56749aba981cc83482e9976370fc5c3039c397e6bf2b6bab3af236d44cd1a477"

URI_aarch64_rust-nix+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+time-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+time-devel}"
SRC_URI[aarch64_rust-nix+time-devel.sha256sum] = "21d3fbca3a275354b80ee5058e87949776ace39d2a2572014d8ccc7aa083cf2d"

URI_aarch64_rust-nix+ucontext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+ucontext-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+ucontext-devel}"
SRC_URI[aarch64_rust-nix+ucontext-devel.sha256sum] = "91b2ab23da724f6a25ba254028ca773c6dfd8b807b4c7b3f2f341838d6c35af1"

URI_aarch64_rust-nix+uio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+uio-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+uio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+uio-devel}"
SRC_URI[aarch64_rust-nix+uio-devel.sha256sum] = "17104b5409e8829ef989a6973b8ee168d22ae3861474c9de1a50107beea8220c"

URI_aarch64_rust-nix+user-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+user-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+user-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+user-devel}"
SRC_URI[aarch64_rust-nix+user-devel.sha256sum] = "7c09236578a71e521e90bfb0ebe1af0b5765f4e548b6f1966f25ac7289c22609"

URI_aarch64_rust-nix+zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+zerocopy-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+zerocopy-devel}"
SRC_URI[aarch64_rust-nix+zerocopy-devel.sha256sum] = "e770d7b55ffa179b11185c39dd9b769525816147efafb322bd7bea6f02ab417b"

URI_aarch64_rust-nix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix-devel-0.30.1-1.el10_1.noarch.rpm;name=aarch64_rust-nix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix-devel}"
SRC_URI[aarch64_rust-nix-devel.sha256sum] = "7af4298d3ee35df9e108928c6ffca13fb8b7142db04b482efb2924b43a806380"

RDEPENDS:rust-nix+acct-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+aio-devel = " \
 cargo \
 rust-nix+pin-utils-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+default-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+dir-devel = " \
 cargo \
 rust-nix+fs-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+env-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+event-devel = " \
 cargo \
 rust-nix+poll-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+fanotify-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+feature-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+fs-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+hostname-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+inotify-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+ioctl-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+kmod-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+memoffset-devel = " \
 cargo \
 rust-memoffset+default-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+mman-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+mount-devel = " \
 cargo \
 rust-nix+uio-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+mqueue-devel = " \
 cargo \
 rust-nix+fs-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+net-devel = " \
 cargo \
 rust-nix+socket-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+personality-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+pin-utils-devel = " \
 cargo \
 rust-nix-devel \
 rust-pin-utils+default-devel \
 "
RDEPENDS:rust-nix+poll-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+process-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+pthread-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+ptrace-devel = " \
 cargo \
 rust-nix+process-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+quota-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+reboot-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+resource-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+sched-devel = " \
 cargo \
 rust-nix+process-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+signal-devel = " \
 cargo \
 rust-nix+process-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+socket-devel = " \
 cargo \
 rust-nix+memoffset-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+syslog-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+term-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+time-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+ucontext-devel = " \
 cargo \
 rust-nix+signal-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+uio-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+user-devel = " \
 cargo \
 rust-nix+feature-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+zerocopy-devel = " \
 cargo \
 rust-nix+fs-devel \
 rust-nix+uio-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cfg-if+default-devel \
 rust-cfg_aliases+default-devel \
 rust-libc+default-devel \
 rust-libc+extra_traits-devel \
 "
