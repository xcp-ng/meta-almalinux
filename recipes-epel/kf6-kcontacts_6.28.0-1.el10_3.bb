# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcontacts"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcontacts \
 kf6-kcontacts-devel \
 kf6-kcontacts-doc \
 kf6-kcontacts-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcontacts-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28fc8e12228761d59f5b58bec285906b3d11f840f6060ed1027917debc5a24e8"

URI_x86_64_v2_kf6-kcontacts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcontacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcontacts}"
SRC_URI[x86_64_v2_kf6-kcontacts.sha256sum] = "1726c39807503044df3e3a864af9c1e82fb1b1448f50d713f8778a3e57e565c9"

URI_x86_64_v2_kf6-kcontacts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcontacts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcontacts-devel}"
SRC_URI[x86_64_v2_kf6-kcontacts-devel.sha256sum] = "45247620e688be49c845c80776241ccb970add33ea73a7ee28ae4b5f54b85e60"

URI_x86_64_v2_kf6-kcontacts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcontacts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcontacts-doc}"
SRC_URI[x86_64_v2_kf6-kcontacts-doc.sha256sum] = "176882bf30ea77c5c622aee4bb4421fa680eaad8f131a107b0ae19441bab76f2"

URI_x86_64_v2_kf6-kcontacts-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcontacts-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcontacts-html}"
SRC_URI[x86_64_v2_kf6-kcontacts-html.sha256sum] = "35812c7da6067449370f47127783b47ed18f1294d3e156e0e1d2f4fe0626f772"

URI_aarch64_kf6-kcontacts = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcontacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcontacts}"
SRC_URI[aarch64_kf6-kcontacts.sha256sum] = "f95f9aed650336cbee7151f395b0b48cbc747622f8593df310bce7b314db5d13"

URI_aarch64_kf6-kcontacts-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcontacts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcontacts-devel}"
SRC_URI[aarch64_kf6-kcontacts-devel.sha256sum] = "a4c97a6979ea6241b430c7bf5035316a910666d699b57803c180e190f02cc6fb"

URI_aarch64_kf6-kcontacts-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcontacts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcontacts-doc}"
SRC_URI[aarch64_kf6-kcontacts-doc.sha256sum] = "719761a53b4ea6e7da77d6f01e085644ebcb545c2b7a36644f745eab18077b0d"

URI_aarch64_kf6-kcontacts-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcontacts-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcontacts-html}"
SRC_URI[aarch64_kf6-kcontacts-html.sha256sum] = "c3faabcb509efc0c2fa738eccbc0baa4d4d7fa530ed7b2740bb134a85f3ba92a"

RDEPENDS:kf6-kcontacts = " \
 glibc \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcontacts-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kcodecs-devel \
 kf6-kcontacts \
 kf6-kcoreaddons-devel \
 kf6-ki18n-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcontacts-doc = " \
 "
RDEPENDS:kf6-kcontacts-html = " \
 "
