# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snpguest"
PV = "0.8.3"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 snpguest \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/snpguest-0.8.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0745d5176d3d622b7995850dcb516093836807573e861853541943d4ef5ec633"

URI_x86_64_v2_snpguest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/snpguest-0.8.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_snpguest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snpguest}"
SRC_URI[x86_64_v2_snpguest.sha256sum] = "d107ae8665477331305487a126f35db3f2b767c70b73600f150990cd0d2f9c4d"

RDEPENDS:snpguest = " \
 glibc \
 libgcc \
 openssl-libs \
 "
