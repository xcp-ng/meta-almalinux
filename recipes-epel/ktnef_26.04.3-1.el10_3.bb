# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktnef"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ktnef \
 ktnef-devel \
 ktnef-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktnef-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9b1b027b194c433c43f92fb2e2bb5096d335b647b034357b9932de77548ad5d"

URI_x86_64_v2_ktnef = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktnef-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktnef;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktnef}"
SRC_URI[x86_64_v2_ktnef.sha256sum] = "1f2fd4bae22a65e3414ddff04b18e7f9ed538f561914e78623a9d26a5d163f16"

URI_x86_64_v2_ktnef-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktnef-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktnef-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktnef-devel}"
SRC_URI[x86_64_v2_ktnef-devel.sha256sum] = "4a1b9e20563390740dbfbcd3e4bcec801846c880f6a1ff0cd01ab58f373788d8"

URI_x86_64_v2_ktnef-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktnef-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ktnef-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktnef-doc}"
SRC_URI[x86_64_v2_ktnef-doc.sha256sum] = "e6b19e4954b2ecdf9c943b1f23f4eebc92705db6c6ab2f871e86504b77b00b98"

URI_aarch64_ktnef = "${EPEL_MIRROR}/aarch64/Packages/k/ktnef-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ktnef;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktnef}"
SRC_URI[aarch64_ktnef.sha256sum] = "deca500e4f8c6110f3593af5a286cf47ca5db05a93416ad6c7eba1e459656a74"

URI_aarch64_ktnef-devel = "${EPEL_MIRROR}/aarch64/Packages/k/ktnef-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ktnef-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktnef-devel}"
SRC_URI[aarch64_ktnef-devel.sha256sum] = "22f80a9d0643c2b2f307aea974030c6b7124afbe5f3d1eae88df6418bdf282ac"

URI_aarch64_ktnef-doc = "${EPEL_MIRROR}/aarch64/Packages/k/ktnef-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_ktnef-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktnef-doc}"
SRC_URI[aarch64_ktnef-doc.sha256sum] = "e3de8bad4f5f19d43f80662206e4bf2d2de7ab74041dd9985994fca9f42cf8d6"

RDEPENDS:ktnef = " \
 glibc \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcontacts \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:ktnef-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 ktnef \
 "
RDEPENDS:ktnef-doc = " \
 "
