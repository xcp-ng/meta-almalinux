# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-orion"
PV = "0.17.15"
PR = "1.el10_3"
PACKAGES = " \
 rust-orion+alloc-devel \
 rust-orion+ct-codecs-devel \
 rust-orion+default-devel \
 rust-orion+experimental-devel \
 rust-orion+getrandom-devel \
 rust-orion+safe_api-devel \
 rust-orion+serde-devel \
 rust-orion+zeroize-devel \
 rust-orion-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-orion-0.17.15-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d60f1a9fc38a0e9838eb5d39157b4a328ab17d6f06af119233bde34f7eaf70e5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+alloc-devel-0.17.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+alloc-devel.sha256sum] = "a79ff16466574d790e9e11c439d7859a44f79934aba570080db1d7ae2075b134"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+ct-codecs-devel-0.17.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+ct-codecs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+ct-codecs-devel.sha256sum] = "c9fe4979b5e11f3330aacde7493e9162a858e2656d89451ad9390863577a03cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+default-devel-0.17.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+default-devel.sha256sum] = "9123cd9e3f8c020df2ccf336c70046a47d01f744c30ac9549d46af5e05e67072"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+experimental-devel-0.17.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+experimental-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+experimental-devel.sha256sum] = "51a9d1dfae0d8d54bddef5f8f75e8333e9f69165edfec5203d3c74112c206432"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+getrandom-devel-0.17.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+getrandom-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+getrandom-devel.sha256sum] = "00803b60f72cb6d77dc5a6da3cb9dff281e065de1727e59c5380af6adba75586"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+safe_api-devel-0.17.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+safe_api-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+safe_api-devel.sha256sum] = "bad5042ab409d799df9c609ec125a30f331fd82f74e8bcbaf71011a6e4f4fc2f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+serde-devel-0.17.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+serde-devel.sha256sum] = "febaa6d785d8ceaf8dadb068939b0382b623d876bf6818cfe67b464d8d9d8d98"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+zeroize-devel-0.17.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+zeroize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion+zeroize-devel.sha256sum] = "43ab9c2ef7b69610f52a63d346829acfe8370613c1ed2f9debf8d227952209ae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion-devel-0.17.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion-devel;unpack=0"
SRC_URI[x86_64_v2_rust-orion-devel.sha256sum] = "06681f55e0c542c7bff175e90f0ff208595c9b4843bf3c58e0597ce351cd5606"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+alloc-devel-0.17.15-1.el10_3.noarch.rpm;name=aarch64_rust-orion+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-orion+alloc-devel.sha256sum] = "92cc9ce1b7deee8050ffa26e2d7625731ec56cf5276f5a658aa5c0c4d14be1da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+ct-codecs-devel-0.17.15-1.el10_3.noarch.rpm;name=aarch64_rust-orion+ct-codecs-devel;unpack=0"
SRC_URI[aarch64_rust-orion+ct-codecs-devel.sha256sum] = "7b029939c9a45a2cddd9896cccc90a10c458356fd0a726a38818059aeb64e0b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+default-devel-0.17.15-1.el10_3.noarch.rpm;name=aarch64_rust-orion+default-devel;unpack=0"
SRC_URI[aarch64_rust-orion+default-devel.sha256sum] = "102d458924d8bb30bbac1bf4cca2570ce5c4cbfecfb29feda0d87d06c8407987"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+experimental-devel-0.17.15-1.el10_3.noarch.rpm;name=aarch64_rust-orion+experimental-devel;unpack=0"
SRC_URI[aarch64_rust-orion+experimental-devel.sha256sum] = "efa7db2406bbe8c955694d9516754903eb180e8029a1bef8431c002324e4fbb9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+getrandom-devel-0.17.15-1.el10_3.noarch.rpm;name=aarch64_rust-orion+getrandom-devel;unpack=0"
SRC_URI[aarch64_rust-orion+getrandom-devel.sha256sum] = "e038190a8b61d2a6e91651adafb945423aa37b64e83ce31bac594961780858ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+safe_api-devel-0.17.15-1.el10_3.noarch.rpm;name=aarch64_rust-orion+safe_api-devel;unpack=0"
SRC_URI[aarch64_rust-orion+safe_api-devel.sha256sum] = "eb7960e3b98fd118d0633a07afa3731af6dad9ceea6ae360c21bb90b7be04944"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+serde-devel-0.17.15-1.el10_3.noarch.rpm;name=aarch64_rust-orion+serde-devel;unpack=0"
SRC_URI[aarch64_rust-orion+serde-devel.sha256sum] = "d6536acc4b196784ed7e4be27de3067ea353a8b403473adee496462b4126871c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+zeroize-devel-0.17.15-1.el10_3.noarch.rpm;name=aarch64_rust-orion+zeroize-devel;unpack=0"
SRC_URI[aarch64_rust-orion+zeroize-devel.sha256sum] = "cd26d61fc9c5e55578a1f6f09650799e3840d91138a5829da8dc9b94b4a634d4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-orion-devel-0.17.15-1.el10_3.noarch.rpm;name=aarch64_rust-orion-devel;unpack=0"
SRC_URI[aarch64_rust-orion-devel.sha256sum] = "989a6cfbb003e7341f9ff1d66063441bf9a670a714005a1fa489a3f4b6c3fa67"

RDEPENDS:rust-orion+alloc-devel = " \
 cargo \
 rust-orion-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-orion+ct-codecs-devel = " \
 cargo \
 rust-ct-codecs+default-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+default-devel = " \
 cargo \
 rust-orion+safe_api-devel \
 rust-orion+zeroize-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+experimental-devel = " \
 cargo \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+getrandom-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+safe_api-devel = " \
 cargo \
 rust-orion+ct-codecs-devel \
 rust-orion+getrandom-devel \
 rust-orion-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-orion+serde-devel = " \
 cargo \
 rust-orion+alloc-devel \
 rust-orion-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-orion+zeroize-devel = " \
 cargo \
 rust-orion-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-orion-devel = " \
 cargo \
 rust \
 rust-fiat-crypto-devel \
 rust-subtle-devel \
 "
