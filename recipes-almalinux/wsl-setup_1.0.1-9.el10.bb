# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wsl-setup"
PV = "1.0.1"
PR = "9.el10"
PACKAGES = " \
 wsl-setup \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wsl-setup-1.0.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4719ae3cefdf7662b4d0996b84e88a6968ab0ed16b85586e449df4614944b004"

URI_x86_64_v2_wsl-setup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wsl-setup-1.0.1-9.el10.noarch.rpm;name=x86_64_v2_wsl-setup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wsl-setup}"
SRC_URI[x86_64_v2_wsl-setup.sha256sum] = "49888b146bfa9e74e479c594118f8b7f5b4b0fa25d3c071faef388440d776888"

URI_aarch64_wsl-setup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wsl-setup-1.0.1-9.el10.noarch.rpm;name=aarch64_wsl-setup;unpack=0"
SRC_URI:append = " ${URI_aarch64_wsl-setup}"
SRC_URI[aarch64_wsl-setup.sha256sum] = "49888b146bfa9e74e479c594118f8b7f5b4b0fa25d3c071faef388440d776888"

RDEPENDS:wsl-setup = " \
 almalinux-logos \
 bash \
 shadow-utils \
 systemd \
 "
