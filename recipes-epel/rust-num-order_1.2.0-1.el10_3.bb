# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-order"
PV = "1.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-num-order+default-devel \
 rust-num-order+num-bigint-devel \
 rust-num-order+num-complex-devel \
 rust-num-order+num-rational-devel \
 rust-num-order+num-traits-devel \
 rust-num-order+std-devel \
 rust-num-order-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-order-1.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3891ba0eef114d0d05e9f6279456372fdac9619fa70d16e96629299440a49db0"

URI_x86_64_v2_rust-num-order+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-order+default-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-order+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-order+default-devel}"
SRC_URI[x86_64_v2_rust-num-order+default-devel.sha256sum] = "d5766ae7fa2cbd8f11219499738810b174a7beb3d1c67a4a4796a329b77b1549"

URI_x86_64_v2_rust-num-order+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-order+num-bigint-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-order+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-order+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-num-order+num-bigint-devel.sha256sum] = "1ca09912ac5473b5805759ea291c6514df0175dc4b5fc63c1de1368912188d43"

URI_x86_64_v2_rust-num-order+num-complex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-order+num-complex-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-order+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-order+num-complex-devel}"
SRC_URI[x86_64_v2_rust-num-order+num-complex-devel.sha256sum] = "bfa806a809239cb58417ac359962e77b86a94edd6284e0ff0b7eb6ad5e028f6b"

URI_x86_64_v2_rust-num-order+num-rational-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-order+num-rational-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-order+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-order+num-rational-devel}"
SRC_URI[x86_64_v2_rust-num-order+num-rational-devel.sha256sum] = "5a1a47ccc3f007ba47019087e221097cd56a193acf96589eec996731b928baea"

URI_x86_64_v2_rust-num-order+num-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-order+num-traits-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-order+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-order+num-traits-devel}"
SRC_URI[x86_64_v2_rust-num-order+num-traits-devel.sha256sum] = "dd9fe51f05c3ca7e83d2e1a9270265ec466aafe84341122660ee182b3ab63534"

URI_x86_64_v2_rust-num-order+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-order+std-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-order+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-order+std-devel}"
SRC_URI[x86_64_v2_rust-num-order+std-devel.sha256sum] = "2c13d52de7fa69d1d813066d8b6fc25ffd359e629dc5fb3aa8919224ba4bb500"

URI_x86_64_v2_rust-num-order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-order-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-order-devel}"
SRC_URI[x86_64_v2_rust-num-order-devel.sha256sum] = "90fa65f70ed9daed5b8e0f9ed657fc40b33f0f3bbee1814a859c66769c9bc2e5"

URI_aarch64_rust-num-order+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-order+default-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-num-order+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-order+default-devel}"
SRC_URI[aarch64_rust-num-order+default-devel.sha256sum] = "5e24eb9908cb589d1c544e1c7004fb5cb64465187166f19dfe65766ed8c44e13"

URI_aarch64_rust-num-order+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-order+num-bigint-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-num-order+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-order+num-bigint-devel}"
SRC_URI[aarch64_rust-num-order+num-bigint-devel.sha256sum] = "9becb1e4094ee3e8dcb91c7cb5d5e742f3d612b37acff6a9ad8b5fb2f2f1d791"

URI_aarch64_rust-num-order+num-complex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-order+num-complex-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-num-order+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-order+num-complex-devel}"
SRC_URI[aarch64_rust-num-order+num-complex-devel.sha256sum] = "36a8ab06d9d957980484bf08b78e441b073cef2134371871be738056f67c1bc6"

URI_aarch64_rust-num-order+num-rational-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-order+num-rational-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-num-order+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-order+num-rational-devel}"
SRC_URI[aarch64_rust-num-order+num-rational-devel.sha256sum] = "6ec9d612c0387150b7571bdda46e39e2567695aeaece2ef526bb99fbc52faedc"

URI_aarch64_rust-num-order+num-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-order+num-traits-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-num-order+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-order+num-traits-devel}"
SRC_URI[aarch64_rust-num-order+num-traits-devel.sha256sum] = "9149f31beec1187d0e4a2c47e0a9f696de7c024280dcefbd6f21631b7b6c7e51"

URI_aarch64_rust-num-order+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-order+std-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-num-order+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-order+std-devel}"
SRC_URI[aarch64_rust-num-order+std-devel.sha256sum] = "2db0a1321161e078decbd4ec65480b155cefa6265ff456c56cdaded8bac0fc48"

URI_aarch64_rust-num-order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-order-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-num-order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-order-devel}"
SRC_URI[aarch64_rust-num-order-devel.sha256sum] = "4aedc2ebd54b5bade0e8be12060ad317ccfbb054481d5c9373b7bad7baffdcf8"

RDEPENDS:rust-num-order+default-devel = " \
 cargo \
 rust-num-order-devel \
 "
RDEPENDS:rust-num-order+num-bigint-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-num-order+num-traits-devel \
 rust-num-order-devel \
 "
RDEPENDS:rust-num-order+num-complex-devel = " \
 cargo \
 rust-num-complex+default-devel \
 rust-num-order-devel \
 "
RDEPENDS:rust-num-order+num-rational-devel = " \
 cargo \
 rust-num-order+num-traits-devel \
 rust-num-order-devel \
 rust-num-rational+default-devel \
 "
RDEPENDS:rust-num-order+num-traits-devel = " \
 cargo \
 rust-num-order-devel \
 rust-num-traits+default-devel \
 "
RDEPENDS:rust-num-order+std-devel = " \
 cargo \
 rust-num-order-devel \
 "
RDEPENDS:rust-num-order-devel = " \
 cargo \
 rust-num-modular+default-devel \
 "
