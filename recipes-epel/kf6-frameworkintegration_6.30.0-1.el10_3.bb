# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-frameworkintegration"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-frameworkintegration \
 kf6-frameworkintegration-devel \
 kf6-frameworkintegration-doc \
 kf6-frameworkintegration-html \
 kf6-frameworkintegration-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-frameworkintegration-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4e2657630c24d4b62481718850b2cd6d189fc9bf04d7f979d9b7c497b4876ba4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-frameworkintegration;unpack=0"
SRC_URI[x86_64_v2_kf6-frameworkintegration.sha256sum] = "428447bfc9e73d2a012125f54073b217fb9eabd471fecbd531b843f6c69bb542"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-frameworkintegration-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-frameworkintegration-devel.sha256sum] = "bdce643878e0135375a73ef0d3584e088bc7181dc58148bd69087c78390f07fe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-frameworkintegration-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-frameworkintegration-doc.sha256sum] = "6abade9d4233944d0ce17ae0b3aeab6fda88e8057bc7663d5ec65dbafdf072b4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-frameworkintegration-html;unpack=0"
SRC_URI[x86_64_v2_kf6-frameworkintegration-html.sha256sum] = "e36acb7f402232df7f8de558ff5fac5ba40e9b5ecaeebb82a1dadc3ce9d1761a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-libs-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-frameworkintegration-libs;unpack=0"
SRC_URI[x86_64_v2_kf6-frameworkintegration-libs.sha256sum] = "c7862e709b731b41a58f469bed1c38dcccc4e9c360ec6af41a2855ddd85e652e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-frameworkintegration;unpack=0"
SRC_URI[aarch64_kf6-frameworkintegration.sha256sum] = "f35e6b2518f65051cd6932b386b825d0e8832209ba1d183b7c36a1264004e8e0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-frameworkintegration-devel;unpack=0"
SRC_URI[aarch64_kf6-frameworkintegration-devel.sha256sum] = "0d9013a0d95ddd5645c4e75f3d9fd17fbbbe8982724e94304be19382de8b6c1e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-frameworkintegration-doc;unpack=0"
SRC_URI[aarch64_kf6-frameworkintegration-doc.sha256sum] = "dcd05d436ad800beb324b4933ea900705ed246c935f7f22870cea174c3a8a2a8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-frameworkintegration-html;unpack=0"
SRC_URI[aarch64_kf6-frameworkintegration-html.sha256sum] = "0a18059e11d7f3c2637f3f2b18d8e3e71e82c08a2f9f8db83d2a16bf4af6fef8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-libs-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-frameworkintegration-libs;unpack=0"
SRC_URI[aarch64_kf6-frameworkintegration-libs.sha256sum] = "7e25eb3d7197e6da132efa397a67ad160641482322f6376b92f239a4abaff837"

RDEPENDS:kf6-frameworkintegration = " \
 glibc \
 kf6-filesystem \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-knotifications \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-frameworkintegration-devel = " \
 cmake-filesystem \
 kf6-frameworkintegration-libs \
 kf6-kconfigwidgets-devel \
 kf6-kiconthemes-devel \
 "
RDEPENDS:kf6-frameworkintegration-doc = " \
 "
RDEPENDS:kf6-frameworkintegration-html = " \
 "
RDEPENDS:kf6-frameworkintegration-libs = " \
 PackageKit-Qt6 \
 appstream-qt \
 glibc \
 kf6-frameworkintegration \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kiconthemes \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
