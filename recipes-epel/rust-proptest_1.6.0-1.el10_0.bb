# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proptest"
PV = "1.6.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-proptest+alloc-devel \
 rust-proptest+atomic64bit-devel \
 rust-proptest+attr-macro-devel \
 rust-proptest+bit-set-devel \
 rust-proptest+default-code-coverage-devel \
 rust-proptest+default-devel \
 rust-proptest+fork-devel \
 rust-proptest+handle-panics-devel \
 rust-proptest+lazy_static-devel \
 rust-proptest+no_std-devel \
 rust-proptest+proptest-macro-devel \
 rust-proptest+regex-syntax-devel \
 rust-proptest+rusty-fork-devel \
 rust-proptest+std-devel \
 rust-proptest+tempfile-devel \
 rust-proptest+timeout-devel \
 rust-proptest+unstable-devel \
 rust-proptest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proptest-1.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0ba0bb4c6db8a634a675327b6954b5260bbca2d52432d245c91bbee1d56fcbe"

URI_x86_64_v2_rust-proptest+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+alloc-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+alloc-devel}"
SRC_URI[x86_64_v2_rust-proptest+alloc-devel.sha256sum] = "975bb601de48adb0944fb22ec42209fa395802e3af13aaa7a5c3e8e6d3559bde"

URI_x86_64_v2_rust-proptest+atomic64bit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+atomic64bit-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+atomic64bit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+atomic64bit-devel}"
SRC_URI[x86_64_v2_rust-proptest+atomic64bit-devel.sha256sum] = "3085c54b21392a6063a381fcc3d1236a38e3b6f43bcd707b73e8b702bc080501"

URI_x86_64_v2_rust-proptest+attr-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+attr-macro-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+attr-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+attr-macro-devel}"
SRC_URI[x86_64_v2_rust-proptest+attr-macro-devel.sha256sum] = "cf6ee631713bb48ebe6b5a43af5b118259295615dfbacc9f265a4dc019e47e8d"

URI_x86_64_v2_rust-proptest+bit-set-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+bit-set-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+bit-set-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+bit-set-devel}"
SRC_URI[x86_64_v2_rust-proptest+bit-set-devel.sha256sum] = "c4850fefc5ad41a575145f4cf82dac0e6ca3bbdf704823fa9943c29ddd7ddb1e"

URI_x86_64_v2_rust-proptest+default-code-coverage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+default-code-coverage-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+default-code-coverage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+default-code-coverage-devel}"
SRC_URI[x86_64_v2_rust-proptest+default-code-coverage-devel.sha256sum] = "ca2e2ce4ef6cfd3f7772f5fc98ffca4b063e62c0ab2cfbf7107a663713fd64e2"

URI_x86_64_v2_rust-proptest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+default-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+default-devel}"
SRC_URI[x86_64_v2_rust-proptest+default-devel.sha256sum] = "66447d8fe36996512f3117a396e9381cc0fc882a2760bd54221eaa1fbbd6fa56"

URI_x86_64_v2_rust-proptest+fork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+fork-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+fork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+fork-devel}"
SRC_URI[x86_64_v2_rust-proptest+fork-devel.sha256sum] = "e83d790ec8820eb5981a38b1f94c2d9757ac8f2a2c0e554244e11a6cadc52f7e"

URI_x86_64_v2_rust-proptest+handle-panics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+handle-panics-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+handle-panics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+handle-panics-devel}"
SRC_URI[x86_64_v2_rust-proptest+handle-panics-devel.sha256sum] = "362c98b9e33b43e33f4bbdce99d4833580b69c89b00fb7633a9082710f5ce54c"

URI_x86_64_v2_rust-proptest+lazy_static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+lazy_static-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+lazy_static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+lazy_static-devel}"
SRC_URI[x86_64_v2_rust-proptest+lazy_static-devel.sha256sum] = "3c19a89d55b01227c16e4f9a73e4b7438ff46dfe982c8dea1a9061f98823f060"

URI_x86_64_v2_rust-proptest+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+no_std-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+no_std-devel}"
SRC_URI[x86_64_v2_rust-proptest+no_std-devel.sha256sum] = "81b4afa5ef224829d80463d3d78d2ab91577106f791340f30896ea3c2f57d9d3"

URI_x86_64_v2_rust-proptest+proptest-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+proptest-macro-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+proptest-macro-devel}"
SRC_URI[x86_64_v2_rust-proptest+proptest-macro-devel.sha256sum] = "45d16c9655ec933472f61a76f8250649439f72f4a405a624380f2afb21ca6a70"

URI_x86_64_v2_rust-proptest+regex-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+regex-syntax-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+regex-syntax-devel}"
SRC_URI[x86_64_v2_rust-proptest+regex-syntax-devel.sha256sum] = "08eba69ae992a50b086c3b43d03b4fd2dc631c94bf7b303ea1b3368e5403c480"

URI_x86_64_v2_rust-proptest+rusty-fork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+rusty-fork-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+rusty-fork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+rusty-fork-devel}"
SRC_URI[x86_64_v2_rust-proptest+rusty-fork-devel.sha256sum] = "858c828a074599a0b1c8e52249af5ea162d3a486048693b802d73ca51a2030e9"

URI_x86_64_v2_rust-proptest+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+std-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+std-devel}"
SRC_URI[x86_64_v2_rust-proptest+std-devel.sha256sum] = "8fb157264377dfe71bd97cdfeadeccf3bcb795a095624d5f63036567e201453c"

URI_x86_64_v2_rust-proptest+tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+tempfile-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+tempfile-devel}"
SRC_URI[x86_64_v2_rust-proptest+tempfile-devel.sha256sum] = "bb8de93f800323d5a81b85226b76b437a9e9dbe33f1226f568cae9eb852a4ee2"

URI_x86_64_v2_rust-proptest+timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+timeout-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+timeout-devel}"
SRC_URI[x86_64_v2_rust-proptest+timeout-devel.sha256sum] = "e516a8c95978d7c28a13eb46f69f993cac0bbbe1ec9a7fb8704391a3501f0fef"

URI_x86_64_v2_rust-proptest+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+unstable-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+unstable-devel}"
SRC_URI[x86_64_v2_rust-proptest+unstable-devel.sha256sum] = "df9d415bf30dec123b57920620cbc70dcd06ed96e653cb199c6844dc3d05c004"

URI_x86_64_v2_rust-proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest-devel-1.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest-devel}"
SRC_URI[x86_64_v2_rust-proptest-devel.sha256sum] = "751eae038036cc2777820a20ae3a81e9984dc7d4885f044e49a3d532541ad3fc"

URI_aarch64_rust-proptest+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+alloc-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+alloc-devel}"
SRC_URI[aarch64_rust-proptest+alloc-devel.sha256sum] = "365850778a98035080746269aefbca4267c1873e24f004b6173fe037d5216d48"

URI_aarch64_rust-proptest+atomic64bit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+atomic64bit-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+atomic64bit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+atomic64bit-devel}"
SRC_URI[aarch64_rust-proptest+atomic64bit-devel.sha256sum] = "da4b6217302b8d86eee6db6a20d4668b3f6e53e165dc5d0e8c6bffaebf64b012"

URI_aarch64_rust-proptest+attr-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+attr-macro-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+attr-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+attr-macro-devel}"
SRC_URI[aarch64_rust-proptest+attr-macro-devel.sha256sum] = "80d107a3c39b23c85f703d2d737d0dad3bb301beb8b89f4e216ccb091d5043e2"

URI_aarch64_rust-proptest+bit-set-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+bit-set-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+bit-set-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+bit-set-devel}"
SRC_URI[aarch64_rust-proptest+bit-set-devel.sha256sum] = "3adf07fb1e4b05d8bcd11cd0bb7cbcdc04224d046c31a00d612c244c802213e3"

URI_aarch64_rust-proptest+default-code-coverage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+default-code-coverage-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+default-code-coverage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+default-code-coverage-devel}"
SRC_URI[aarch64_rust-proptest+default-code-coverage-devel.sha256sum] = "d3da86a2177dc30ce11e863e4e495c306dd1b5584f9e6a2fa64ed6378f8a1d2b"

URI_aarch64_rust-proptest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+default-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+default-devel}"
SRC_URI[aarch64_rust-proptest+default-devel.sha256sum] = "35143ded3b60793cb1ecb742c9a017a73c64a91e276576e02c8e35c2e96c0192"

URI_aarch64_rust-proptest+fork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+fork-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+fork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+fork-devel}"
SRC_URI[aarch64_rust-proptest+fork-devel.sha256sum] = "9d34ba67ce760a28a1ce773a01a59aac230e90fc7251d62ad5eb4e113cd9319c"

URI_aarch64_rust-proptest+handle-panics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+handle-panics-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+handle-panics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+handle-panics-devel}"
SRC_URI[aarch64_rust-proptest+handle-panics-devel.sha256sum] = "e78922a62c19c7a841fa1cfe75f9cf6ba735405b91b96eb877996716125ecefb"

URI_aarch64_rust-proptest+lazy_static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+lazy_static-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+lazy_static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+lazy_static-devel}"
SRC_URI[aarch64_rust-proptest+lazy_static-devel.sha256sum] = "28b9830c6ec343fdd3ff6540ef0b9c4407df70a50c07795baddcf5a183e81fe5"

URI_aarch64_rust-proptest+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+no_std-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+no_std-devel}"
SRC_URI[aarch64_rust-proptest+no_std-devel.sha256sum] = "06a1c2a20735bc25858bb154b918ef15e3265fe03246b7f33f423aac72be1c98"

URI_aarch64_rust-proptest+proptest-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+proptest-macro-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+proptest-macro-devel}"
SRC_URI[aarch64_rust-proptest+proptest-macro-devel.sha256sum] = "259d298d272ad28b248340ff8657fb0b336f9bfe237313ff435bdbcdc8219aae"

URI_aarch64_rust-proptest+regex-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+regex-syntax-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+regex-syntax-devel}"
SRC_URI[aarch64_rust-proptest+regex-syntax-devel.sha256sum] = "53589008b088ed7131b9e0615a62d857a9fa265303e0ee4a9381d95e3ec62a21"

URI_aarch64_rust-proptest+rusty-fork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+rusty-fork-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+rusty-fork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+rusty-fork-devel}"
SRC_URI[aarch64_rust-proptest+rusty-fork-devel.sha256sum] = "0194347a100c146880a75dd8a7ac6fa74a89c4b599e44764c78465b921e06818"

URI_aarch64_rust-proptest+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+std-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+std-devel}"
SRC_URI[aarch64_rust-proptest+std-devel.sha256sum] = "5e8c0bbc51e7b26df8278d261db8d0b555567d1cb7bb110cf6257d6525f588d2"

URI_aarch64_rust-proptest+tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+tempfile-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+tempfile-devel}"
SRC_URI[aarch64_rust-proptest+tempfile-devel.sha256sum] = "770f78c2946c82d00fd30ea443421891183bf293973c188690c4a434696574c7"

URI_aarch64_rust-proptest+timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+timeout-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+timeout-devel}"
SRC_URI[aarch64_rust-proptest+timeout-devel.sha256sum] = "094d94413cced4bc7f31e83f7aa6fcf7a5d29e1719992c241cb55731a8da1197"

URI_aarch64_rust-proptest+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+unstable-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+unstable-devel}"
SRC_URI[aarch64_rust-proptest+unstable-devel.sha256sum] = "a28f47f26205f921b191738c7fe964c0c490e0e2a15c79cac9ec84595cc55b87"

URI_aarch64_rust-proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest-devel-1.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest-devel}"
SRC_URI[aarch64_rust-proptest-devel.sha256sum] = "1ce894a9dff2a13ed3bcac55a5e8ab4fdedd829d7f493b5ac0232f04905d8c01"

RDEPENDS:rust-proptest+alloc-devel = " \
 cargo \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+atomic64bit-devel = " \
 cargo \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+attr-macro-devel = " \
 cargo \
 rust-proptest+proptest-macro-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+bit-set-devel = " \
 cargo \
 rust-bit-set+default-devel \
 rust-bit-vec+default-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+default-code-coverage-devel = " \
 cargo \
 rust-proptest+bit-set-devel \
 rust-proptest+fork-devel \
 rust-proptest+std-devel \
 rust-proptest+timeout-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+default-devel = " \
 cargo \
 rust-proptest+bit-set-devel \
 rust-proptest+fork-devel \
 rust-proptest+std-devel \
 rust-proptest+timeout-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+fork-devel = " \
 cargo \
 rust-proptest+rusty-fork-devel \
 rust-proptest+std-devel \
 rust-proptest+tempfile-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+handle-panics-devel = " \
 cargo \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+lazy_static-devel = " \
 cargo \
 rust-lazy_static+default-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+no_std-devel = " \
 cargo \
 rust-num-traits+libm-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+proptest-macro-devel = " \
 cargo \
 rust-proptest-devel \
 rust-proptest-macro+default-devel \
 "
RDEPENDS:rust-proptest+regex-syntax-devel = " \
 cargo \
 rust-proptest-devel \
 rust-regex-syntax+default-devel \
 "
RDEPENDS:rust-proptest+rusty-fork-devel = " \
 cargo \
 rust-proptest-devel \
 rust-rusty-fork-devel \
 "
RDEPENDS:rust-proptest+std-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-proptest+lazy_static-devel \
 rust-proptest+regex-syntax-devel \
 rust-proptest-devel \
 rust-rand0.8+std-devel \
 "
RDEPENDS:rust-proptest+tempfile-devel = " \
 cargo \
 rust-proptest-devel \
 rust-tempfile+default-devel \
 "
RDEPENDS:rust-proptest+timeout-devel = " \
 cargo \
 rust-proptest+fork-devel \
 rust-proptest-devel \
 rust-rusty-fork+timeout-devel \
 rust-rusty-fork-devel \
 "
RDEPENDS:rust-proptest+unstable-devel = " \
 cargo \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-num-traits-devel \
 rust-rand0.8+alloc-devel \
 rust-rand0.8-devel \
 rust-rand_chacha0.3-devel \
 rust-rand_xorshift+default-devel \
 rust-unarray+default-devel \
 "
