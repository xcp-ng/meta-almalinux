# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pgrouting"
PV = "4.0.1"
PR = "1.el10_3"
PACKAGES = " \
 pgrouting \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pgrouting-4.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f8d2c3bde58fd9c0cb1f80a20fa6d4f2f5490f30d8d224f838c04fe62fd6c43c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pgrouting-4.0.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pgrouting;unpack=0"
SRC_URI[x86_64_v2_pgrouting.sha256sum] = "9bada3eed154381fcbeaf31b952ad7a274de96923e4d5262cbcc9c9d0af6471e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pgrouting-4.0.1-1.el10_3.aarch64.rpm;name=aarch64_pgrouting;unpack=0"
SRC_URI[aarch64_pgrouting.sha256sum] = "365fac1d1d61ebd039a88467e2a2bfa213c557bdfc5f04254a7646349dff7e6c"

RDEPENDS:pgrouting = " \
 glibc \
 libgcc \
 libstdc++ \
 postgis \
 postgresql-server \
 "
