# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-theme-builder"
PV = "0.2.0"
PR = "0.16.b2.el10_0~bootstrap"
PACKAGES = " \
 python3-sphinx-theme-builder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-theme-builder-0.2.0-0.16.b2.el10_0~bootstrap.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8b4fc6b3be7324591adbfc4564b1defea3ea4a51c8821ffd9dd67bfda8d1f21"

URI_x86_64_v2_python3-sphinx-theme-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-theme-builder-0.2.0-0.16.b2.el10_0~bootstrap.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-theme-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-theme-builder}"
SRC_URI[x86_64_v2_python3-sphinx-theme-builder.sha256sum] = "82714c4e85cd0f6a94330054052bbe78889fa4188dc94e16e777a5289b85b89b"

URI_aarch64_python3-sphinx-theme-builder = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-theme-builder-0.2.0-0.16.b2.el10_0~bootstrap.noarch.rpm;name=aarch64_python3-sphinx-theme-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-theme-builder}"
SRC_URI[aarch64_python3-sphinx-theme-builder.sha256sum] = "96617d3f27d044694379a98b608a04b4f78c134337c6fc8d59efe9f86c7d1356"

RDEPENDS:python3-sphinx-theme-builder = " \
 python3 \
 python3-nodeenv \
 python3-packaging \
 python3-pyproject-metadata \
 python3-rich \
 python3-setuptools \
 "
