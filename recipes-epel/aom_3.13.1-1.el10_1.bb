# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aom"
PV = "3.13.1"
PR = "1.el10_1"
PACKAGES = " \
 aom \
 libaom \
 libaom-devel \
 libaom-devel-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aom-3.13.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7ce37c7b97f34f8061a43e749e1097185ca87eb03fb45891c3e81c014a4c1f8"

URI_x86_64_v2_aom = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aom-3.13.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aom}"
SRC_URI[x86_64_v2_aom.sha256sum] = "7e438fc9eb2cae031e81bf20ebd00a2214fcbb660bb136346b6f69fb1fa8dd22"

URI_x86_64_v2_libaom = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaom-3.13.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaom}"
SRC_URI[x86_64_v2_libaom.sha256sum] = "fc54e1cebd2ca528dc86b220a012746a403e208b092727d6bee721b2f054e084"

URI_x86_64_v2_libaom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaom-devel-3.13.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaom-devel}"
SRC_URI[x86_64_v2_libaom-devel.sha256sum] = "79280dcb3c8fa57cb49f98f30a74536495bb432918279c9887b771bc5ee67afc"

URI_x86_64_v2_libaom-devel-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaom-devel-docs-3.13.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaom-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaom-devel-docs}"
SRC_URI[x86_64_v2_libaom-devel-docs.sha256sum] = "c25115a33370446fbe80b3179ebcd077aa88986cc5d8622e81f872a392575a10"

URI_aarch64_aom = "${EPEL_MIRROR}/aarch64/Packages/a/aom-3.13.1-1.el10_1.aarch64.rpm;name=aarch64_aom;unpack=0"
SRC_URI:append = " ${URI_aarch64_aom}"
SRC_URI[aarch64_aom.sha256sum] = "ccac4504153b4739f8ae3e18d96d69eb300bdd046109a38894d28212dd6f6713"

URI_aarch64_libaom = "${EPEL_MIRROR}/aarch64/Packages/l/libaom-3.13.1-1.el10_1.aarch64.rpm;name=aarch64_libaom;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaom}"
SRC_URI[aarch64_libaom.sha256sum] = "1a93ce3561565310b491a284a2ecea83723e598844a4194cc34e9815345d3abd"

URI_aarch64_libaom-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libaom-devel-3.13.1-1.el10_1.aarch64.rpm;name=aarch64_libaom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaom-devel}"
SRC_URI[aarch64_libaom-devel.sha256sum] = "6108d31a25e4fe03157498a15802c362d3f72295b6003396b96b9c53f500a60d"

URI_aarch64_libaom-devel-docs = "${EPEL_MIRROR}/aarch64/Packages/l/libaom-devel-docs-3.13.1-1.el10_1.aarch64.rpm;name=aarch64_libaom-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaom-devel-docs}"
SRC_URI[aarch64_libaom-devel-docs.sha256sum] = "a5e73551f083521eecc895f51fb688f671f20415f8e5bca3c1d25c8edd9a9452"

RDEPENDS:aom = " \
 glibc \
 libaom \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libaom:x86_64_v2 = " \
 glibc \
 libvmaf \
"
RDEPENDS:libaom:aarch64 = " \
 glibc \
"
RDEPENDS:libaom-devel:x86_64_v2 = " \
 cmake-filesystem \
 libaom \
 libvmaf-devel \
 pkgconf-pkg-config \
"
RDEPENDS:libaom-devel:aarch64 = " \
 cmake-filesystem \
 libaom \
 pkgconf-pkg-config \
"
RDEPENDS:libaom-devel-docs = " \
 libaom-devel \
 "
