# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-gssapi"
PV = "1.3.1"
PR = "10.el10_0"
PACKAGES = " \
 rubygem-gssapi \
 rubygem-gssapi-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rubygem-gssapi-1.3.1-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "be33c0e371457ec475f0af34c75140982f8055b004bfee7c0fdacb3776c9757f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-gssapi-1.3.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-gssapi;unpack=0"
SRC_URI[x86_64_v2_rubygem-gssapi.sha256sum] = "1db748c77220dfa6674f3fc80fa669ada84d311671c0f83e2796cb8d4a5b8763"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-gssapi-doc-1.3.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-gssapi-doc;unpack=0"
SRC_URI[x86_64_v2_rubygem-gssapi-doc.sha256sum] = "0b0896e39f6be609c8635dcee09bc12f6665ed1746400d41950c8b3584b7816c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rubygem-gssapi-1.3.1-10.el10_0.noarch.rpm;name=aarch64_rubygem-gssapi;unpack=0"
SRC_URI[aarch64_rubygem-gssapi.sha256sum] = "fb98b2bde1f80b951b903774b947a09dfe817bdfc82216cc7d1cb6af21c61ea8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rubygem-gssapi-doc-1.3.1-10.el10_0.noarch.rpm;name=aarch64_rubygem-gssapi-doc;unpack=0"
SRC_URI[aarch64_rubygem-gssapi-doc.sha256sum] = "8272c463948c1c4dc12ad62939d1599b562b1ffac86c43116cc0e4ef63dac163"

RDEPENDS:rubygem-gssapi = " \
 krb5-libs \
 rubygem-ffi \
 rubygems \
 virtual/ruby_release_ \
 "
RDEPENDS:rubygem-gssapi-doc = " \
 rubygem-gssapi \
 "
