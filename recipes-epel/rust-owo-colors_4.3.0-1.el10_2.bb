# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-owo-colors"
PV = "4.3.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-owo-colors+alloc-devel \
 rust-owo-colors+default-devel \
 rust-owo-colors+supports-color-devel \
 rust-owo-colors+supports-colors-devel \
 rust-owo-colors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-owo-colors-4.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3678e300189ff81eee19c556210c71b58c467666a8883b5316de0ae23d902640"

URI_x86_64_v2_rust-owo-colors+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+alloc-devel-4.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+alloc-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+alloc-devel.sha256sum] = "8a3478e90d0a5fc15c4624389f551d19af860fb9b212aaec674fcfa171dde88f"

URI_x86_64_v2_rust-owo-colors+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+default-devel-4.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+default-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+default-devel.sha256sum] = "1bd2181691caa3057f1d126af0d602f148593b695b8e9c0dc53a41b2d1be0944"

URI_x86_64_v2_rust-owo-colors+supports-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+supports-color-devel-4.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+supports-color-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+supports-color-devel.sha256sum] = "df1bdb3768e08bb0a3575702ef79db2d2cc0ceb2e0b606afc9a82c21f325eb48"

URI_x86_64_v2_rust-owo-colors+supports-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+supports-colors-devel-4.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+supports-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+supports-colors-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+supports-colors-devel.sha256sum] = "9bbf06dc063572013dd677135a7431fed5b445e3bc8b6ad077185b1dd14f9e0e"

URI_x86_64_v2_rust-owo-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors-devel-4.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors-devel}"
SRC_URI[x86_64_v2_rust-owo-colors-devel.sha256sum] = "43c2bf5ab822886bd728c6dac8bc8216e174c5723de9b5a5fd3d0c4698dd2faa"
RPROVIDES:rust-owo-colors-devel:x86_64_v2 = "virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

URI_aarch64_rust-owo-colors+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+alloc-devel-4.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-owo-colors+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+alloc-devel}"
SRC_URI[aarch64_rust-owo-colors+alloc-devel.sha256sum] = "0012e0c58ab64697f640ca0e55162de346fe0724e76993652cd9dc9e9e8ef533"

URI_aarch64_rust-owo-colors+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+default-devel-4.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-owo-colors+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+default-devel}"
SRC_URI[aarch64_rust-owo-colors+default-devel.sha256sum] = "0706b60ba2c7ae4307d7d1fc3762e9e1b3622c2ce1b31b23f2a624c2918c0f7e"

URI_aarch64_rust-owo-colors+supports-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+supports-color-devel-4.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-owo-colors+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+supports-color-devel}"
SRC_URI[aarch64_rust-owo-colors+supports-color-devel.sha256sum] = "6f6cdb5a8587b389eeac406ecc99a5eb75d4533e8936e2f29fbf8e2da264e184"

URI_aarch64_rust-owo-colors+supports-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+supports-colors-devel-4.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-owo-colors+supports-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+supports-colors-devel}"
SRC_URI[aarch64_rust-owo-colors+supports-colors-devel.sha256sum] = "e51b087c0b87af63f542344902a55f92e1fa50141da3a0f3c788fa1df33ffed0"

URI_aarch64_rust-owo-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors-devel-4.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors-devel}"
SRC_URI[aarch64_rust-owo-colors-devel.sha256sum] = "8cd72d75452f77c981a813fb150f9c422da224527ce7f55237b9310a936c829a"
RPROVIDES:rust-owo-colors-devel:aarch64 = "virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

RDEPENDS:rust-owo-colors+alloc-devel = " \
 cargo \
 rust-owo-colors-devel \
 "
RDEPENDS:rust-owo-colors+default-devel = " \
 cargo \
 rust-owo-colors-devel \
 "
RDEPENDS:rust-owo-colors+supports-color-devel = " \
 cargo \
 rust-owo-colors-devel \
 rust-supports-color+default-devel \
 "
RDEPENDS:rust-owo-colors+supports-colors-devel = " \
 cargo \
 rust-owo-colors+supports-color-devel \
 rust-owo-colors-devel \
 rust-supports-color2+default-devel \
 "
RDEPENDS:rust-owo-colors-devel = " \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"
