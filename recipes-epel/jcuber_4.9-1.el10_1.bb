# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jcuber"
PV = "4.9"
PR = "1.el10_1"
PACKAGES = " \
 jcuber \
 jcuber-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/jcuber-4.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "efaf2c528ccad63c35f6eb563c4ba8560eed5c793cd274bf01bc3a750b197a1b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jcuber-4.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_jcuber;unpack=0"
SRC_URI[x86_64_v2_jcuber.sha256sum] = "821703c79a0ff7f1a2410b6881b03c51ff7ae6db83da0f86ca65eaef584d2339"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jcuber-doc-4.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_jcuber-doc;unpack=0"
SRC_URI[x86_64_v2_jcuber-doc.sha256sum] = "75592d55c97de094a7a7d0f8d442246c6012fbfaf7a83e8620bb68e536e0e674"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/jcuber-4.9-1.el10_1.noarch.rpm;name=aarch64_jcuber;unpack=0"
SRC_URI[aarch64_jcuber.sha256sum] = "999b16679546f4d8e4e8331ce7702bf36f2adc47d77bf3f2fb3ccb5cafdac9c9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/jcuber-doc-4.9-1.el10_1.noarch.rpm;name=aarch64_jcuber-doc;unpack=0"
SRC_URI[aarch64_jcuber-doc.sha256sum] = "4b198f410d593533964ce1617a96b0acc6de60ff117785bb60c15e675b13868e"

RDEPENDS:jcuber = " \
 bash \
 java-21-openjdk \
 javapackages-tools \
 "
RDEPENDS:jcuber-doc = " \
 "
