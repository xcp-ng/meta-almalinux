# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bindgen-cli"
PV = "0.72.1"
PR = "1.el10"
PACKAGES = " \
 bindgen-cli \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/rust-bindgen-cli-0.72.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a90fcd85479f3aed6425e83f12f305bbc4029babe3fb7616ce8a7384b1c442a3"

URI_x86_64_v2_bindgen-cli = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bindgen-cli-0.72.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_bindgen-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bindgen-cli}"
SRC_URI[x86_64_v2_bindgen-cli.sha256sum] = "b3d4297f3f5f96ee6fd35d73d916c1a35717c29ba78c1ed49248b42799a5ff6c"

URI_aarch64_bindgen-cli = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bindgen-cli-0.72.1-1.el10.aarch64.rpm;name=aarch64_bindgen-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_bindgen-cli}"
SRC_URI[aarch64_bindgen-cli.sha256sum] = "5544daa4e2bf17a70a007959c406c32e9798eded20b149fcfcdfed9c7b2f725b"

RDEPENDS:bindgen-cli = " \
 clang-libs \
 glibc \
 libgcc \
 "
