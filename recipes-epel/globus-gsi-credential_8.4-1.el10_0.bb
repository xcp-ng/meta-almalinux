# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gsi-credential"
PV = "8.4"
PR = "1.el10_0"
PACKAGES = " \
 globus-gsi-credential \
 globus-gsi-credential-devel \
 globus-gsi-credential-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gsi-credential-8.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bde01a017cc01c2ea6177d2f4afea44d8522b797e8f5629e0c187b812b66bad"

URI_x86_64_v2_globus-gsi-credential = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-credential-8.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-credential;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-credential}"
SRC_URI[x86_64_v2_globus-gsi-credential.sha256sum] = "5d08ef7e8b45c8127b18d74ac88ff4a28263eb0859c122e933db002a79a9cfe3"

URI_x86_64_v2_globus-gsi-credential-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-credential-devel-8.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-credential-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-credential-devel}"
SRC_URI[x86_64_v2_globus-gsi-credential-devel.sha256sum] = "67b16ad039ecfff8ca4969828d63d10c8e0645ca45bc70af7dc706c76aff3b71"

URI_x86_64_v2_globus-gsi-credential-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-credential-doc-8.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gsi-credential-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-credential-doc}"
SRC_URI[x86_64_v2_globus-gsi-credential-doc.sha256sum] = "73a58a7768684195e33705788f7b4379b3799b995cc1c3f129491ced6f486046"

URI_aarch64_globus-gsi-credential = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-credential-8.4-1.el10_0.aarch64.rpm;name=aarch64_globus-gsi-credential;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-credential}"
SRC_URI[aarch64_globus-gsi-credential.sha256sum] = "976e63c3c647fa68ddaf4dafa142b5a7efcf91e7d8c648f3ed00ebc9ac221602"

URI_aarch64_globus-gsi-credential-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-credential-devel-8.4-1.el10_0.aarch64.rpm;name=aarch64_globus-gsi-credential-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-credential-devel}"
SRC_URI[aarch64_globus-gsi-credential-devel.sha256sum] = "a7ac2a1804128bd00bdd089db77f5cbb217d5de6d74d0986de61b183abf111c0"

URI_aarch64_globus-gsi-credential-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-credential-doc-8.4-1.el10_0.noarch.rpm;name=aarch64_globus-gsi-credential-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-credential-doc}"
SRC_URI[aarch64_globus-gsi-credential-doc.sha256sum] = "ebbe56d8061f18f3e2af8a91e777b85518c50920956abd1cb35d37d510aa3d9b"

RDEPENDS:globus-gsi-credential = " \
 glibc \
 globus-common \
 globus-gsi-callback \
 globus-gsi-cert-utils \
 globus-gsi-openssl-error \
 globus-gsi-sysconfig \
 openssl-libs \
 "
RDEPENDS:globus-gsi-credential-devel = " \
 globus-common-devel \
 globus-gsi-callback-devel \
 globus-gsi-cert-utils-devel \
 globus-gsi-credential \
 globus-gsi-openssl-error-devel \
 globus-gsi-sysconfig-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gsi-credential-doc = " \
 "
