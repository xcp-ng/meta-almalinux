# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest-middleware"
PV = "0.5.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqwest-middleware+charset-devel \
 rust-reqwest-middleware+default-devel \
 rust-reqwest-middleware+form-devel \
 rust-reqwest-middleware+http2-devel \
 rust-reqwest-middleware+json-devel \
 rust-reqwest-middleware+multipart-devel \
 rust-reqwest-middleware+query-devel \
 rust-reqwest-middleware+rustls-devel \
 rust-reqwest-middleware+stream-devel \
 rust-reqwest-middleware-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest-middleware-0.5.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9acdc9628e31530a8ae5c1b151721804a6883993eaa87ac437a57650870249f"

URI_x86_64_v2_rust-reqwest-middleware+charset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+charset-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+charset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+charset-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+charset-devel.sha256sum] = "4b369ee4c7ab1aef262fca280834cbd4a802476f49e871b9d33e6af55cc6b40c"

URI_x86_64_v2_rust-reqwest-middleware+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+default-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+default-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+default-devel.sha256sum] = "4c4c30bb53b1e5cd09adb6752a6dee184a0d4cdfe6838aacd037762ce77ec520"

URI_x86_64_v2_rust-reqwest-middleware+form-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+form-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+form-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+form-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+form-devel.sha256sum] = "b2b66694a58be573a3a25a0c5f05c439c60d268bd8e3297eed1d244fdbc1413e"

URI_x86_64_v2_rust-reqwest-middleware+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+http2-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+http2-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+http2-devel.sha256sum] = "aed70b25e009429e373aef6410e2ad5ee9cc7a4c01786acfd535afa11395fa71"

URI_x86_64_v2_rust-reqwest-middleware+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+json-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+json-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+json-devel.sha256sum] = "66aee64a2c33c8fe5d7122f64ed8aba14ef19be9ecdabd46e919f61345062ea9"

URI_x86_64_v2_rust-reqwest-middleware+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+multipart-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+multipart-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+multipart-devel.sha256sum] = "34cac3169b05d490219cf3519859de054bc10922eda8073c49f519a2d2589b00"

URI_x86_64_v2_rust-reqwest-middleware+query-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+query-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+query-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+query-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+query-devel.sha256sum] = "701159e3f58796e8df982e3816479ce47310093b34f68a6b5fc59b6a9b95ee44"

URI_x86_64_v2_rust-reqwest-middleware+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+rustls-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+rustls-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+rustls-devel.sha256sum] = "41c71100201ca164f24e73df48dd5a313c92ec29e8c900ad54091e4036112c07"

URI_x86_64_v2_rust-reqwest-middleware+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+stream-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+stream-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+stream-devel.sha256sum] = "adf30e9acd3c4141f7e79748ecf1174d839c218f5796c6b88861038bd99cb210"

URI_x86_64_v2_rust-reqwest-middleware-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware-devel.sha256sum] = "c2e1eec2a2c9970d0885796ff33f1350740d9a38e6fb6a9a6199a2e16e7f537e"

URI_aarch64_rust-reqwest-middleware+charset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+charset-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest-middleware+charset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+charset-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+charset-devel.sha256sum] = "46448fb89dfc790648bcabe07c6e7249f3aa910097ff1dd23b511276649a3529"

URI_aarch64_rust-reqwest-middleware+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+default-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest-middleware+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+default-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+default-devel.sha256sum] = "b6ff2c696503affa5512dadda485c2f1ba55e2c3af1400e1d1f4967fe52c6bf0"

URI_aarch64_rust-reqwest-middleware+form-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+form-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest-middleware+form-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+form-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+form-devel.sha256sum] = "079bc40fbd56873819484cd901c31f11c260be559f1a58825f292b85483b2330"

URI_aarch64_rust-reqwest-middleware+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+http2-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest-middleware+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+http2-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+http2-devel.sha256sum] = "d35eb5a5de7061cdc3aa9f82728bbb8e6667fd79aec19fb31a70258190fea96b"

URI_aarch64_rust-reqwest-middleware+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+json-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest-middleware+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+json-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+json-devel.sha256sum] = "a12ab3d531d6c66ddc96d4852f41b04ad411734704cd77df6002fe393bb577ad"

URI_aarch64_rust-reqwest-middleware+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+multipart-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest-middleware+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+multipart-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+multipart-devel.sha256sum] = "b23ea790841e68c398d25da210e9d0874178405f4b016e0b9a465ae376b076ca"

URI_aarch64_rust-reqwest-middleware+query-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+query-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest-middleware+query-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+query-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+query-devel.sha256sum] = "8d5f1880d149240df6f1014cd859d219d0757fcd5aab1f7b2d6b57750f65e880"

URI_aarch64_rust-reqwest-middleware+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+rustls-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest-middleware+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+rustls-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+rustls-devel.sha256sum] = "756edd45e20947c57f0524036dc8bcd9dad1fb264af863c5617ee4889bc3340e"

URI_aarch64_rust-reqwest-middleware+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+stream-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest-middleware+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+stream-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+stream-devel.sha256sum] = "08ec1c5c3ca591f5d3dcf00af7bac2392028d378f3382b12bdb08687f0c747f2"

URI_aarch64_rust-reqwest-middleware-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware-devel}"
SRC_URI[aarch64_rust-reqwest-middleware-devel.sha256sum] = "c21698b8f821ed885dd4164666ad65bc0d1bdade51e281e3a498bbb47f6e9d10"

RDEPENDS:rust-reqwest-middleware+charset-devel = " \
 cargo \
 rust-reqwest+charset-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+default-devel = " \
 cargo \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+form-devel = " \
 cargo \
 rust-reqwest+form-devel \
 rust-reqwest-middleware-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-reqwest-middleware+http2-devel = " \
 cargo \
 rust-reqwest+http2-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+json-devel = " \
 cargo \
 rust-reqwest+json-devel \
 rust-reqwest-middleware-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-reqwest-middleware+multipart-devel = " \
 cargo \
 rust-reqwest+multipart-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+query-devel = " \
 cargo \
 rust-reqwest+query-devel \
 rust-reqwest-middleware-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-reqwest-middleware+rustls-devel = " \
 cargo \
 rust-reqwest+rustls-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+stream-devel = " \
 cargo \
 rust-reqwest+stream-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-http+default-devel \
 rust-reqwest-devel \
 rust-thiserror+default-devel \
 rust-tower-service+default-devel \
 "
