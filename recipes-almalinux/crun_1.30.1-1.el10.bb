# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crun"
PV = "1.30.1"
PR = "1.el10"
PACKAGES = " \
 crun \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/crun-1.30.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3cee0b700cb5b68aea1c9e150607f4b7dd59cf147c25a1e8d2852a78b46831af"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - crun: libcap.so.2()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crun-1.30.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_crun;unpack=0"
SRC_URI[x86_64_v2_crun.sha256sum] = "4ec75370bf499240958670fac49551f160621fb6bea153cec18debdaa670c4ce"
RPROVIDES:crun:append:x86_64_v2 = " virtual/oci-runtime"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crun-1.30.1-1.el10.aarch64.rpm;name=aarch64_crun;unpack=0"
SRC_URI[aarch64_crun.sha256sum] = "6fd5727a687c0093bf7e832b90211c5b2ec2136b974086a9e727f391e82162e3"
RPROVIDES:crun:append:aarch64 = " virtual/oci-runtime"

RDEPENDS:crun:x86_64_v2 = " \
 container-selinux \
 glibc \
 json-c \
 libcap \
 libgcc \
 libseccomp \
 systemd-libs \
"
RDEPENDS:crun:aarch64 = " \
 container-selinux \
 glibc \
 json-c \
 libgcc \
 libseccomp \
 systemd-libs \
"
