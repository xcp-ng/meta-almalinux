# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-deque"
PV = "0.8.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-crossbeam-deque+default-devel \
 rust-crossbeam-deque+std-devel \
 rust-crossbeam-deque-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-deque-0.8.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "667fb5bc718401406145490e8dc16aecfa8e936a00a743e2281db9a9262d58c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-deque+default-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-deque+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-deque+default-devel.sha256sum] = "89aed9d35f91fcfabc6f3a593029b01b69373985934423e06048d67ca23ccaf2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-deque+std-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-deque+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-deque+std-devel.sha256sum] = "ebb924e1a909ed6f2b777891c5733dadcc99636c60700a1e7473321ca8f967cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-deque-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-deque-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-deque-devel.sha256sum] = "288a0eb4c11d50c3f304620b3f0167fdc82197ac5d2f5a18ec1d6f037b0c9d97"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-deque+default-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-deque+default-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-deque+default-devel.sha256sum] = "ad6a5037bbf03dcd4f7408310cad67722403b4ba0c091a3bcaa15b8dc21aec05"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-deque+std-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-deque+std-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-deque+std-devel.sha256sum] = "89c0f000deccfdbcfe41478ce728a0164d3f92a6dcf4978da748e2def2db4a68"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-deque-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-deque-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-deque-devel.sha256sum] = "e41bd20fbcb4a46f63fb4e965002cfd99a879e2b8237e88260e77b11589d6b8d"

RDEPENDS:rust-crossbeam-deque+default-devel = " \
 cargo \
 rust-crossbeam-deque+std-devel \
 rust-crossbeam-deque-devel \
 "
RDEPENDS:rust-crossbeam-deque+std-devel = " \
 cargo \
 rust-crossbeam-deque-devel \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-deque-devel = " \
 cargo \
 rust \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-utils-devel \
 "
