# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aiohappyeyeballs"
PV = "2.4.4"
PR = "5.el10_0"
PACKAGES = " \
 python3-aiohappyeyeballs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aiohappyeyeballs-2.4.4-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "251675e37a1c7a2bdde9890e17cd4274e755be55d9cbf314c1f69900ceb7535c"

URI_x86_64_v2_python3-aiohappyeyeballs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiohappyeyeballs-2.4.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aiohappyeyeballs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiohappyeyeballs}"
SRC_URI[x86_64_v2_python3-aiohappyeyeballs.sha256sum] = "6aad0bd5a5b7b1a2df74523935b7601725dd4fad4cd81fc022e76e7a4e5e1039"

URI_aarch64_python3-aiohappyeyeballs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiohappyeyeballs-2.4.4-5.el10_0.noarch.rpm;name=aarch64_python3-aiohappyeyeballs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiohappyeyeballs}"
SRC_URI[aarch64_python3-aiohappyeyeballs.sha256sum] = "c151d70f03964435bc9a752dcd49c47be9c00898499450dd3d3a95bcae6f7ee4"

RDEPENDS:python3-aiohappyeyeballs = " \
 python3 \
 "
