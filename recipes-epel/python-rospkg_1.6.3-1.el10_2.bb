# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rospkg"
PV = "1.6.3"
PR = "1.el10_2"
PACKAGES = " \
 python-rospkg-doc \
 python3-rospkg \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-rospkg-1.6.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9fdf288c429c63b4f168965f2b1953394d4285e8e8cdcaacac9efa2aac87d136"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-rospkg-doc-1.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-rospkg-doc;unpack=0"
SRC_URI[x86_64_v2_python-rospkg-doc.sha256sum] = "a5d1c90e3c41658e111b820cb3642f35eab2dfb91c00c4cb7e59f6b06759fea8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rospkg-1.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rospkg;unpack=0"
SRC_URI[x86_64_v2_python3-rospkg.sha256sum] = "7fb77ed726f7c574bf12851cbe242726627f117fa3e6026072daec84259da8be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-rospkg-doc-1.6.3-1.el10_2.noarch.rpm;name=aarch64_python-rospkg-doc;unpack=0"
SRC_URI[aarch64_python-rospkg-doc.sha256sum] = "ac85729014645e75a270dfe1a6a85d5cd3107dbbac77467442ea4cd11af8435d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-rospkg-1.6.3-1.el10_2.noarch.rpm;name=aarch64_python3-rospkg;unpack=0"
SRC_URI[aarch64_python3-rospkg.sha256sum] = "72851c7678afa09ba8fd802ee69cafc5cf5c7ecadba4567da670fe1c07c17269"

RDEPENDS:python-rospkg-doc = " \
 "
RDEPENDS:python3-rospkg = " \
 python3 \
 python3-catkin_pkg \
 python3-distro \
 python3-pyyaml \
 "
