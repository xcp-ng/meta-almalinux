# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iotop-c"
PV = "1.26"
PR = "3.el10"
PACKAGES = " \
 iotop-c \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iotop-c-1.26-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fa5ba0999fced0d65a4efc176c880d1ccebe7473c4cbeef73ab7a9def5a1df2"

URI_x86_64_v2_iotop-c = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iotop-c-1.26-3.el10.x86_64_v2.rpm;name=x86_64_v2_iotop-c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iotop-c}"
SRC_URI[x86_64_v2_iotop-c.sha256sum] = "4f6025b33c4b38037a9060f5bc6f129a02e2fd34889ea8295a215979c7360f8b"

URI_aarch64_iotop-c = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iotop-c-1.26-3.el10.aarch64.rpm;name=aarch64_iotop-c;unpack=0"
SRC_URI:append = " ${URI_aarch64_iotop-c}"
SRC_URI[aarch64_iotop-c.sha256sum] = "b78805c9427d0c1c73c8882c63c401f4050560f9f58e959628195b7fef372ccc"

RDEPENDS:iotop-c = " \
 glibc \
 ncurses-libs \
 "
