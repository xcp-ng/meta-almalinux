# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kweather"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kweather \
 kweather-plasma-applet \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kweather-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f9e8c7dbc64f1a4321246ead70b2ed822322cfd3445766888239db0d9001fd01"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweather-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweather;unpack=0"
SRC_URI[x86_64_v2_kweather.sha256sum] = "568dce244557c0a84e316bae0d4b20dc32a90ee6473feee1786fa624999b8487"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweather-plasma-applet-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweather-plasma-applet;unpack=0"
SRC_URI[x86_64_v2_kweather-plasma-applet.sha256sum] = "9ad01d86546f493eaaf5792351bf575470b71ec6e22905b95b388968a6c5d754"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kweather-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kweather;unpack=0"
SRC_URI[aarch64_kweather.sha256sum] = "5f8fd15b5641d8f8ec6db90e95fc2d54eba3d8191e8621fd5384b27c24e32a8c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kweather-plasma-applet-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kweather-plasma-applet;unpack=0"
SRC_URI[aarch64_kweather-plasma-applet.sha256sum] = "e97a1e70f23798485181ff67626a4967c6636e9b78e4632dfca26d01a17aea00"

RDEPENDS:kweather = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-krunner \
 kweathercore \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtdeclarative \
 "
RDEPENDS:kweather-plasma-applet = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kirigami \
 kf6-kirigami-addons \
 kweather \
 kweathercore \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
