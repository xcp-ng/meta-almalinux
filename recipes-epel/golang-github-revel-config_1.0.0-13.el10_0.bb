# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-revel-config"
PV = "1.0.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-revel-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-revel-config-1.0.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a622e520a583bb207379294679af7e6de293908dc7df584d0ae05caa8e7a311d"

URI_x86_64_v2_golang-github-revel-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-revel-config-devel-1.0.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-revel-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-revel-config-devel}"
SRC_URI[x86_64_v2_golang-github-revel-config-devel.sha256sum] = "d6613177250e6636673413a29350560f8968ceaf82b468ea1eac55751eb59f83"

URI_aarch64_golang-github-revel-config-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-revel-config-devel-1.0.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-revel-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-revel-config-devel}"
SRC_URI[aarch64_golang-github-revel-config-devel.sha256sum] = "9732d53c9267d59a49b9b752f320b6cf8766720857ade2775c0e063824366563"

RDEPENDS:golang-github-revel-config-devel = " \
 go-filesystem \
 "
