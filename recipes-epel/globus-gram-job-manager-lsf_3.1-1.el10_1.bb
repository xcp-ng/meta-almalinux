# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager-lsf"
PV = "3.1"
PR = "1.el10_1"
PACKAGES = " \
 globus-gram-job-manager-lsf \
 globus-gram-job-manager-lsf-setup-poll \
 globus-gram-job-manager-lsf-setup-seg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-lsf-3.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a4faaf6fd1015025adf04200b34961c46a02ae76525288ad837db204c6d7970"

URI_x86_64_v2_globus-gram-job-manager-lsf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-lsf-3.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-lsf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-lsf}"
SRC_URI[x86_64_v2_globus-gram-job-manager-lsf.sha256sum] = "0b53e620a3e3999624a4897cdc8b664afa3f2551ae57c0af95c31e3e1ab6e530"

URI_x86_64_v2_globus-gram-job-manager-lsf-setup-poll = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-lsf-setup-poll-3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-job-manager-lsf-setup-poll;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-lsf-setup-poll}"
SRC_URI[x86_64_v2_globus-gram-job-manager-lsf-setup-poll.sha256sum] = "cf6185baa52dd6c0cefa70b8149b830402d604a7403cf9e3fb78d42e24a1bee2"
RPROVIDES:globus-gram-job-manager-lsf-setup-poll:x86_64_v2 = "virtual/globus-gram-job-manager-lsf-setup_eq_3.1-1.el10_1.alma_altarch"

URI_x86_64_v2_globus-gram-job-manager-lsf-setup-seg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-lsf-setup-seg-3.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-lsf-setup-seg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-lsf-setup-seg}"
SRC_URI[x86_64_v2_globus-gram-job-manager-lsf-setup-seg.sha256sum] = "c2e95da570c371c59df283e54abb9d5ae8697a6368b2c970fc9bb67ef54c7241"
RPROVIDES:globus-gram-job-manager-lsf-setup-seg:x86_64_v2 = "virtual/globus-gram-job-manager-lsf-setup_eq_3.1-1.el10_1.alma_altarch"

URI_aarch64_globus-gram-job-manager-lsf = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-lsf-3.1-1.el10_1.aarch64.rpm;name=aarch64_globus-gram-job-manager-lsf;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-lsf}"
SRC_URI[aarch64_globus-gram-job-manager-lsf.sha256sum] = "3c8a004374aaaa388eb08ca3ce6816e8ba1a9f562884c806148d13a90e1c37c2"

URI_aarch64_globus-gram-job-manager-lsf-setup-poll = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-lsf-setup-poll-3.1-1.el10_1.noarch.rpm;name=aarch64_globus-gram-job-manager-lsf-setup-poll;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-lsf-setup-poll}"
SRC_URI[aarch64_globus-gram-job-manager-lsf-setup-poll.sha256sum] = "ae11723c6b59f99a87be009da4106d2401f2e740904a4d25f95e606e1ba22763"
RPROVIDES:globus-gram-job-manager-lsf-setup-poll:aarch64 = "virtual/globus-gram-job-manager-lsf-setup_eq_3.1-1.el10_1"

URI_aarch64_globus-gram-job-manager-lsf-setup-seg = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-lsf-setup-seg-3.1-1.el10_1.aarch64.rpm;name=aarch64_globus-gram-job-manager-lsf-setup-seg;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-lsf-setup-seg}"
SRC_URI[aarch64_globus-gram-job-manager-lsf-setup-seg.sha256sum] = "fcfd6f25d5915b7556f0f9cd08e8cffc0d271d05cefce1344227a6a60df601b8"
RPROVIDES:globus-gram-job-manager-lsf-setup-seg:aarch64 = "virtual/globus-gram-job-manager-lsf-setup_eq_3.1-1.el10_1"

RDEPENDS:globus-gram-job-manager-lsf:x86_64_v2 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-lsf-setup_eq_3.1-1.el10_1.alma_altarch \
"
RDEPENDS:globus-gram-job-manager-lsf:aarch64 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-lsf-setup_eq_3.1-1.el10_1 \
"
RDEPENDS:globus-gram-job-manager-lsf-setup-poll = " \
 bash \
 globus-gram-job-manager-lsf \
 globus-gram-job-manager-scripts \
 "
RDEPENDS:globus-gram-job-manager-lsf-setup-seg = " \
 bash \
 glibc \
 globus-common \
 globus-gram-job-manager-lsf \
 globus-gram-job-manager-scripts \
 globus-scheduler-event-generator \
 globus-scheduler-event-generator-progs \
 systemd \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/globus-gram-job-manager-lsf-setup_eq_3.1-1.el10_1.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/globus-gram-job-manager-lsf-setup_eq_3.1-1.el10_1"
