# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tmt"
PV = "1.77.0"
PR = "1.el10_3"
PACKAGES = " \
 tmt \
 tmt+all \
 tmt+export-polarion \
 tmt+link-jira \
 tmt+prepare-artifact \
 tmt+provision-beaker \
 tmt+provision-bootc \
 tmt+provision-container \
 tmt+provision-mock \
 tmt+provision-virtual \
 tmt+report-junit \
 tmt+report-polarion \
 tmt+test-convert \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tmt-1.77.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5fd2897e8b2a483d4c2cf1f29a390096e2d5afd0ba5fd317197a05b3c5410fa"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - tmt: sshpass

URI_x86_64_v2_tmt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt-1.77.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_tmt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt}"
SRC_URI[x86_64_v2_tmt.sha256sum] = "b1d9f3532ba8b8c1a8a8f64ca3c72f665718792c33d6cc3533e67c3af5a3a935"

URI_x86_64_v2_tmt+all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+all-1.77.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+all}"
SRC_URI[x86_64_v2_tmt+all.sha256sum] = "fec0b50c8b4699ceb3d7c9b9f74708f3c6a9e85ef839a024c4ddb7a8810708be"

URI_x86_64_v2_tmt+export-polarion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+export-polarion-1.77.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+export-polarion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+export-polarion}"
SRC_URI[x86_64_v2_tmt+export-polarion.sha256sum] = "3742813b5b540bce80125a3bc0967cc15076d4ebac2e237e21fc5576d8fa7f1e"

URI_x86_64_v2_tmt+link-jira = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+link-jira-1.77.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+link-jira;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+link-jira}"
SRC_URI[x86_64_v2_tmt+link-jira.sha256sum] = "d93166af28e6fb0ba9b3192d88fb172f19a700a89f55bd681772c6d7d8028609"

URI_x86_64_v2_tmt+prepare-artifact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+prepare-artifact-1.77.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+prepare-artifact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+prepare-artifact}"
SRC_URI[x86_64_v2_tmt+prepare-artifact.sha256sum] = "28144b9f3d13545b45509154080e99c0815316165f80b80031e82f663fc1f3f1"

URI_x86_64_v2_tmt+provision-beaker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+provision-beaker-1.77.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+provision-beaker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+provision-beaker}"
SRC_URI[x86_64_v2_tmt+provision-beaker.sha256sum] = "3de6c621bd861f7eae8316133af25d96b98942e877133f7be2abecaae1b162a5"

URI_x86_64_v2_tmt+provision-bootc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+provision-bootc-1.77.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+provision-bootc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+provision-bootc}"
SRC_URI[x86_64_v2_tmt+provision-bootc.sha256sum] = "d1323687da0f3ff7f4ed96179781e01a8b889c758d224cb865958d207cfa055c"

URI_x86_64_v2_tmt+provision-container = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+provision-container-1.77.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+provision-container;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+provision-container}"
SRC_URI[x86_64_v2_tmt+provision-container.sha256sum] = "8a7c90c8c9eda15bc7abed2a6e967905b6ab9a3a63fd75fcebd1686e8d9c8a0b"

URI_x86_64_v2_tmt+provision-mock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+provision-mock-1.77.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+provision-mock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+provision-mock}"
SRC_URI[x86_64_v2_tmt+provision-mock.sha256sum] = "81883d7eca3999b1a1391077ede4df19a4c6fe8f423968c9147244fbf4234758"

URI_x86_64_v2_tmt+provision-virtual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+provision-virtual-1.77.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+provision-virtual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+provision-virtual}"
SRC_URI[x86_64_v2_tmt+provision-virtual.sha256sum] = "7bdb0e9f9c20e5bb7eaabbe1ee92b0aa351514272506a4acd953728a5f9470d0"

URI_x86_64_v2_tmt+report-junit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+report-junit-1.77.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+report-junit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+report-junit}"
SRC_URI[x86_64_v2_tmt+report-junit.sha256sum] = "14612e113ba28a3fbeb02f0e6d9ea1e19722e830a2c5552f98072e88cce39473"

URI_x86_64_v2_tmt+report-polarion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+report-polarion-1.77.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+report-polarion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+report-polarion}"
SRC_URI[x86_64_v2_tmt+report-polarion.sha256sum] = "a586ab0773a71e2a8f0e827f535fc55ac8eef505919bfc829c5811ee4f70f1d7"

URI_x86_64_v2_tmt+test-convert = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+test-convert-1.77.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+test-convert;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+test-convert}"
SRC_URI[x86_64_v2_tmt+test-convert.sha256sum] = "edcec49c9ac6a4851096853c1313487210ab155b27f5aeafae5f9aab78debe06"

URI_aarch64_tmt = "${EPEL_MIRROR}/aarch64/Packages/t/tmt-1.77.0-1.el10_3.noarch.rpm;name=aarch64_tmt;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt}"
SRC_URI[aarch64_tmt.sha256sum] = "e7914f47410d455cb6413927491ca6a3d8fd05001ebc80f0500973dd4946e00c"

URI_aarch64_tmt+all = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+all-1.77.0-1.el10_3.noarch.rpm;name=aarch64_tmt+all;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+all}"
SRC_URI[aarch64_tmt+all.sha256sum] = "86a00fc4acb03c742db20cada35723a522824f05676bcc558263dc95b7b5dbe6"

URI_aarch64_tmt+export-polarion = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+export-polarion-1.77.0-1.el10_3.noarch.rpm;name=aarch64_tmt+export-polarion;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+export-polarion}"
SRC_URI[aarch64_tmt+export-polarion.sha256sum] = "81766dc1f536679bc12c202b3ae12515d914b263d91ac6bc6f19ac0467eab8c5"

URI_aarch64_tmt+link-jira = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+link-jira-1.77.0-1.el10_3.noarch.rpm;name=aarch64_tmt+link-jira;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+link-jira}"
SRC_URI[aarch64_tmt+link-jira.sha256sum] = "cbdba409e8acbd3fcf14dba5f5849d5a820388b46158e4cf3886af68fe053e0f"

URI_aarch64_tmt+prepare-artifact = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+prepare-artifact-1.77.0-1.el10_3.noarch.rpm;name=aarch64_tmt+prepare-artifact;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+prepare-artifact}"
SRC_URI[aarch64_tmt+prepare-artifact.sha256sum] = "9b7cf22fd67a514ced78f3775c3e1ead459f3bb0fa7954534a260868aaf7ed8d"

URI_aarch64_tmt+provision-beaker = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+provision-beaker-1.77.0-1.el10_3.noarch.rpm;name=aarch64_tmt+provision-beaker;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+provision-beaker}"
SRC_URI[aarch64_tmt+provision-beaker.sha256sum] = "d6b2b503948bf0a5ef7a7a309a7017ae2b55953c5ade4074f3b0e9a5c70d76d0"

URI_aarch64_tmt+provision-bootc = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+provision-bootc-1.77.0-1.el10_3.noarch.rpm;name=aarch64_tmt+provision-bootc;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+provision-bootc}"
SRC_URI[aarch64_tmt+provision-bootc.sha256sum] = "2cb746a425aa1debf5684bef26c32b7ba9cd0ca6f92e8306bb79c4f255bd1d94"

URI_aarch64_tmt+provision-container = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+provision-container-1.77.0-1.el10_3.noarch.rpm;name=aarch64_tmt+provision-container;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+provision-container}"
SRC_URI[aarch64_tmt+provision-container.sha256sum] = "aa69d79cfa9d15b7de885ddbcceb577d865b1db0e834061aa29aa879e593a3b0"

URI_aarch64_tmt+provision-mock = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+provision-mock-1.77.0-1.el10_3.noarch.rpm;name=aarch64_tmt+provision-mock;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+provision-mock}"
SRC_URI[aarch64_tmt+provision-mock.sha256sum] = "2ec4cab197321fc3e01a30670e5740262dc2e50fd5c88306b7a960d10543c7c6"

URI_aarch64_tmt+provision-virtual = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+provision-virtual-1.77.0-1.el10_3.noarch.rpm;name=aarch64_tmt+provision-virtual;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+provision-virtual}"
SRC_URI[aarch64_tmt+provision-virtual.sha256sum] = "045d55721b24a0391212879976ae2cea319af7f74041d28befb9257bb249dfcd"

URI_aarch64_tmt+report-junit = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+report-junit-1.77.0-1.el10_3.noarch.rpm;name=aarch64_tmt+report-junit;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+report-junit}"
SRC_URI[aarch64_tmt+report-junit.sha256sum] = "a28fb796c25453f49f85b9e148069706337541e180fd5ac677cb7705e77efa12"

URI_aarch64_tmt+report-polarion = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+report-polarion-1.77.0-1.el10_3.noarch.rpm;name=aarch64_tmt+report-polarion;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+report-polarion}"
SRC_URI[aarch64_tmt+report-polarion.sha256sum] = "c215812a2e4e45b887b953ea7ff95ed95f5215cd8ae275e71663a278f4f0e9f3"

URI_aarch64_tmt+test-convert = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+test-convert-1.77.0-1.el10_3.noarch.rpm;name=aarch64_tmt+test-convert;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+test-convert}"
SRC_URI[aarch64_tmt+test-convert.sha256sum] = "9a2eea58b394df3c3005342bbb6f1e794cf2ecf85e62711616bfb5828879e3a9"

RDEPENDS:tmt:x86_64_v2 = " \
 bash \
 fmf \
 git-core \
 python3 \
 python3-click \
 python3-docutils \
 python3-jinja2 \
 python3-packaging \
 python3-pint \
 python3-pydantic \
 python3-pygments \
 python3-requests \
 python3-ruamel-yaml \
 python3-ruamel-yaml-clib \
 python3-typing-extensions \
 python3-urllib3 \
 rsync \
"
RDEPENDS:tmt:aarch64 = " \
 bash \
 fmf \
 git-core \
 python3 \
 python3-click \
 python3-docutils \
 python3-jinja2 \
 python3-packaging \
 python3-pint \
 python3-pydantic \
 python3-pygments \
 python3-requests \
 python3-ruamel-yaml \
 python3-ruamel-yaml-clib \
 python3-typing-extensions \
 python3-urllib3 \
 rsync \
 sshpass \
"
RDEPENDS:tmt+all = " \
 python3 \
 python3-bugzilla \
 python3-copr \
 python3-html2text \
 python3-jira \
 python3-koji \
 python3-lxml \
 python3-markdown \
 python3-mracklib \
 python3-nitrate \
 python3-pylero \
 python3-testcloud \
 tmt+export-polarion \
 tmt+link-jira \
 tmt+prepare-artifact \
 tmt+provision-beaker \
 tmt+provision-bootc \
 tmt+provision-container \
 tmt+provision-mock \
 tmt+provision-virtual \
 tmt+report-junit \
 tmt+report-polarion \
 tmt+test-convert \
 "
RDEPENDS:tmt+export-polarion = " \
 python3 \
 python3-pylero \
 tmt \
 "
RDEPENDS:tmt+link-jira = " \
 python3 \
 python3-jira \
 tmt \
 "
RDEPENDS:tmt+prepare-artifact = " \
 koji \
 python3 \
 python3-copr \
 python3-koji \
 tmt \
 "
RDEPENDS:tmt+provision-beaker = " \
 python3 \
 python3-mrack-beaker \
 python3-mracklib \
 tmt \
 "
RDEPENDS:tmt+provision-bootc = " \
 podman \
 python3 \
 python3-testcloud \
 tmt \
 tmt+provision-virtual \
 "
RDEPENDS:tmt+provision-container = " \
 ansible-collection-containers-podman \
 podman \
 python3 \
 tmt \
 "
RDEPENDS:tmt+provision-mock = " \
 mock \
 python3 \
 tmt \
 "
RDEPENDS:tmt+provision-virtual = " \
 libvirt-daemon-config-network \
 openssh-clients \
 python3 \
 python3-testcloud \
 tmt \
 "
RDEPENDS:tmt+report-junit = " \
 python3 \
 python3-lxml \
 tmt \
 "
RDEPENDS:tmt+report-polarion = " \
 python3 \
 python3-lxml \
 python3-pylero \
 tmt \
 "
RDEPENDS:tmt+test-convert = " \
 make \
 python3 \
 python3-bugzilla \
 python3-html2text \
 python3-markdown \
 python3-nitrate \
 tmt \
 "
