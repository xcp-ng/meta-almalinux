# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-CIDR-Lite"
PV = "0.24"
PR = "1.el10_3"
PACKAGES = " \
 perl-Net-CIDR-Lite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-CIDR-Lite-0.24-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a889679f8f2081924a11267f235c29b4d91f16ae9e8fc9cd677ad6993f334db"

URI_x86_64_v2_perl-Net-CIDR-Lite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-CIDR-Lite-0.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-CIDR-Lite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-CIDR-Lite}"
SRC_URI[x86_64_v2_perl-Net-CIDR-Lite.sha256sum] = "4affe80ae4d1621241f1ba25535d620c3e09972bafa7ccc59696c184d8ec7e0f"

URI_aarch64_perl-Net-CIDR-Lite = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-CIDR-Lite-0.24-1.el10_3.noarch.rpm;name=aarch64_perl-Net-CIDR-Lite;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-CIDR-Lite}"
SRC_URI[aarch64_perl-Net-CIDR-Lite.sha256sum] = "d3977e1c5d11569be8760c18158dd542e8937beae01baca27a39991d53d0d958"

RDEPENDS:perl-Net-CIDR-Lite = " \
 perl-Carp \
 perl-libs \
 perl-vars \
 "
