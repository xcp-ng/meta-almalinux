# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-utility-libraries"
PV = "1.4.313.0"
PR = "1.el10"
PACKAGES = " \
 vulkan-utility-libraries-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/vulkan-utility-libraries-1.4.313.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f79a21075c53418c8a56d175912a45192c1568f97e303ad59f5e744aa1a734c7"

URI_x86_64_v2_vulkan-utility-libraries-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/vulkan-utility-libraries-devel-1.4.313.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-utility-libraries-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-utility-libraries-devel}"
SRC_URI[x86_64_v2_vulkan-utility-libraries-devel.sha256sum] = "64f522fd2723f734a7f3a6364b107648e01a1c1fc96ad35d4f650a3de1618dfb"

URI_aarch64_vulkan-utility-libraries-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/vulkan-utility-libraries-devel-1.4.313.0-1.el10.aarch64.rpm;name=aarch64_vulkan-utility-libraries-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-utility-libraries-devel}"
SRC_URI[aarch64_vulkan-utility-libraries-devel.sha256sum] = "34a8b22775979bcc8af10ce6375e4a8c8679ac055e225a03ad1db96fea492970"

RDEPENDS:vulkan-utility-libraries-devel = " \
 cmake-filesystem \
 vulkan-headers \
 "
