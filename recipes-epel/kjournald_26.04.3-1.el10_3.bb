# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kjournald"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kjournald \
 kjournald-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kjournald-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffabf4d3745ee9da87821aa692597c5d5f320d8060d623cc8f6b7bff4d319266"

URI_x86_64_v2_kjournald = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kjournald-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kjournald;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kjournald}"
SRC_URI[x86_64_v2_kjournald.sha256sum] = "35ff0c4c75347c7edb4108566194c16911dbb9bf80d69e90fb487718b278427c"

URI_x86_64_v2_kjournald-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kjournald-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kjournald-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kjournald-libs}"
SRC_URI[x86_64_v2_kjournald-libs.sha256sum] = "3b091311ac3eab62aadc055ae14f4b866c716fe391bc3eaf80c804988e360d42"

URI_aarch64_kjournald = "${EPEL_MIRROR}/aarch64/Packages/k/kjournald-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kjournald;unpack=0"
SRC_URI:append = " ${URI_aarch64_kjournald}"
SRC_URI[aarch64_kjournald.sha256sum] = "da2e16b0c4bde207388862d21b854f62d63294548dad6811bc3d143ec9dad02f"

URI_aarch64_kjournald-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kjournald-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kjournald-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kjournald-libs}"
SRC_URI[aarch64_kjournald-libs.sha256sum] = "1260d8159bddf2b37ab66a0dcfc8ffbac5c433d6b6157af3f848c764ab81cf6c"

RDEPENDS:kjournald = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kjournald-libs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kjournald-libs = " \
 glibc \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 systemd-libs \
 "
