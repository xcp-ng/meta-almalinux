# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-vi"
PV = "0.20120418"
PR = "18.el10"
PACKAGES = " \
 hunspell-vi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-vi-0.20120418-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec6a5eab85fbc9862149b2a597d67a013e8028fd8ee5f24bada05965faa67ccd"

URI_x86_64_v2_hunspell-vi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-vi-0.20120418-18.el10.noarch.rpm;name=x86_64_v2_hunspell-vi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-vi}"
SRC_URI[x86_64_v2_hunspell-vi.sha256sum] = "8b4dd7981ff2fc4f9482b96554d7da6549d513293124a4b5fad0dc96b0d1fc67"

URI_aarch64_hunspell-vi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-vi-0.20120418-18.el10.noarch.rpm;name=aarch64_hunspell-vi;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-vi}"
SRC_URI[aarch64_hunspell-vi.sha256sum] = "8b4dd7981ff2fc4f9482b96554d7da6549d513293124a4b5fad0dc96b0d1fc67"

RDEPENDS:hunspell-vi = " \
 hunspell-filesystem \
 "
