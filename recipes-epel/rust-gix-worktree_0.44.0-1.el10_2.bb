# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-worktree"
PV = "0.44.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree+default-devel \
 rust-gix-worktree+document-features-devel \
 rust-gix-worktree+serde-devel \
 rust-gix-worktree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-worktree-0.44.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "845a3a480a9b2656a0f94fdefc372b6d643df1e80fd6cdd293a7d9a1c43ba757"

URI_x86_64_v2_rust-gix-worktree+attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+attributes-devel-0.44.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+attributes-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+attributes-devel.sha256sum] = "5d5f41f761c2ee3604836186e968fa51bb1dc94726e828deca74b9fec4e187db"

URI_x86_64_v2_rust-gix-worktree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+default-devel-0.44.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+default-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+default-devel.sha256sum] = "4855761097f4780f365ae41e300cd2bd3dc67f70a06b2cfbcac3617ee279596d"

URI_x86_64_v2_rust-gix-worktree+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+document-features-devel-0.44.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+document-features-devel.sha256sum] = "f764024c91b8e5a673580fcfa0bcc8d457d9aa9fd64f9761f12b836d49a388d2"

URI_x86_64_v2_rust-gix-worktree+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+serde-devel-0.44.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+serde-devel.sha256sum] = "3759ad69cae1429bc553837f901f5666ee1638f654060933daee8e03a83078ee"

URI_x86_64_v2_rust-gix-worktree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-devel-0.44.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-devel.sha256sum] = "f7e155145bc38801bbcf7727488d49c1e5744e65f95520e73b02fe81a62c33f1"

URI_aarch64_rust-gix-worktree+attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+attributes-devel-0.44.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-worktree+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+attributes-devel}"
SRC_URI[aarch64_rust-gix-worktree+attributes-devel.sha256sum] = "bb9f55be03ff0cb52c2c7de328df650945ef29edecdc71ddc32710054653047a"

URI_aarch64_rust-gix-worktree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+default-devel-0.44.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-worktree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+default-devel}"
SRC_URI[aarch64_rust-gix-worktree+default-devel.sha256sum] = "e1b6b39bc77b990e15797a4c7579b8fffcd795b4f207edeefceee2c7502596d0"

URI_aarch64_rust-gix-worktree+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+document-features-devel-0.44.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-worktree+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+document-features-devel}"
SRC_URI[aarch64_rust-gix-worktree+document-features-devel.sha256sum] = "d5330250d664667df882440818833dc008283b0a50a07a39e03ec4dbdd4b8206"

URI_aarch64_rust-gix-worktree+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+serde-devel-0.44.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-worktree+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+serde-devel}"
SRC_URI[aarch64_rust-gix-worktree+serde-devel.sha256sum] = "7a87f80b542be930717413e0b6941cef0bebcebce4a069b606aa6f9f5b78c278"

URI_aarch64_rust-gix-worktree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-devel-0.44.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-worktree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-devel}"
SRC_URI[aarch64_rust-gix-worktree-devel.sha256sum] = "b9b883c2b0b7e66b3c7554da98114ad445706888fece345363945517de47cc99"

RDEPENDS:rust-gix-worktree+attributes-devel = " \
 cargo \
 rust-gix-attributes+default-devel \
 rust-gix-validate+default-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree+default-devel = " \
 cargo \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-attributes+default-devel \
 rust-gix-attributes+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-ignore+serde-devel \
 rust-gix-index+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-worktree-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-worktree-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-features+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-ignore+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 "
