# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_calendar_data"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_calendar_data+default-devel \
 rust-icu_calendar_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_calendar_data-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1113d90459ba2ee4334ab80706cbb153c48c7deace4f427570c6b18fa8fae99d"

URI_x86_64_v2_rust-icu_calendar_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar_data+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar_data+default-devel.sha256sum] = "a5a2fd703f92e02e9de06f6c0ee3f72f76eb4a69b0c20e3ff3ede654ea71deeb"

URI_x86_64_v2_rust-icu_calendar_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar_data-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar_data-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar_data-devel.sha256sum] = "cce5b201955c15bee2a97e944d37ebff7205bd8cc28049f004e674ef208a1e92"

URI_aarch64_rust-icu_calendar_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar_data+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_calendar_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar_data+default-devel}"
SRC_URI[aarch64_rust-icu_calendar_data+default-devel.sha256sum] = "876275428d312b39567678f3130870148b4bc5d36919f0e192cb8c9e9e33d364"

URI_aarch64_rust-icu_calendar_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar_data-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_calendar_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar_data-devel}"
SRC_URI[aarch64_rust-icu_calendar_data-devel.sha256sum] = "e28504ef9c95d5373226d66b2c9e9e1ad9618765f3eddbb9d39c73cfe0b7ea4b"

RDEPENDS:rust-icu_calendar_data+default-devel = " \
 cargo \
 rust-icu_calendar_data-devel \
 "
RDEPENDS:rust-icu_calendar_data-devel = " \
 cargo \
 rust \
 "
