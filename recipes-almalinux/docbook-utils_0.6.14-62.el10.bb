# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "docbook-utils"
PV = "0.6.14"
PR = "62.el10"
PACKAGES = " \
 docbook-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/docbook-utils-0.6.14-62.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04058dbf367080e7ee8433b833adb2f741325dcac386c63817e87d6f11d2c340"

URI_x86_64_v2_docbook-utils = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/docbook-utils-0.6.14-62.el10.noarch.rpm;name=x86_64_v2_docbook-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_docbook-utils}"
SRC_URI[x86_64_v2_docbook-utils.sha256sum] = "6266dd3520c14c0164f14965a56a59d988c55192c45681d8ebba6dc7a9460f55"

URI_aarch64_docbook-utils = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/docbook-utils-0.6.14-62.el10.noarch.rpm;name=aarch64_docbook-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_docbook-utils}"
SRC_URI[aarch64_docbook-utils.sha256sum] = "6266dd3520c14c0164f14965a56a59d988c55192c45681d8ebba6dc7a9460f55"

RDEPENDS:docbook-utils = " \
 bash \
 docbook-dtds \
 docbook-style-dsssl \
 gawk \
 grep \
 perl-Getopt-Long \
 perl-SGMLSpm \
 perl-interpreter \
 perl-libs \
 perl-vars \
 virtual/text-www-browser \
 which \
 "
