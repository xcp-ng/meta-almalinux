# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-utils"
PV = "0.8.23"
PR = "1.el10_2"
PACKAGES = " \
 rust-crossbeam-utils+default-devel \
 rust-crossbeam-utils+nightly-devel \
 rust-crossbeam-utils+std-devel \
 rust-crossbeam-utils-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-utils-0.8.23-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2d65ed1c849165cd29dffc06e88b306c25a9544531f865cc71ef56076fcb5ed1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils+default-devel-0.8.23-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-utils+default-devel.sha256sum] = "e3a0eed5d5009fccb53d160f6be3f4e7f4ec79ec92ae98f1803d8c12d4d45ace"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils+nightly-devel-0.8.23-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils+nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-utils+nightly-devel.sha256sum] = "ae3e8c2cdc21c9c4d87cde24015d2ac87da1598aa18306cd61fc826aaa6e7b5a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils+std-devel-0.8.23-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-utils+std-devel.sha256sum] = "59446dc535b59226c89b2a8a59d9c179060fba56da64947b195a804fcc4949cc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils-devel-0.8.23-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-utils-devel.sha256sum] = "cbac8c6816f90b9c634a998dc7a8c34c18fb567ee2ae223da7b1ee1745f94f00"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils+default-devel-0.8.23-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-utils+default-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-utils+default-devel.sha256sum] = "e96f32f6ab3f1d9b8d96f9d4cb8cdf210ee1b8f5b17fb910c071e2817266e49d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils+nightly-devel-0.8.23-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-utils+nightly-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-utils+nightly-devel.sha256sum] = "bb5ebe74cd55611b77eb18b029137268ba1bbc843eb27fef36d36fffb75cd260"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils+std-devel-0.8.23-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-utils+std-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-utils+std-devel.sha256sum] = "c1fe53595e83150e5587d224f77328c54b8303a498033885420c39c991ad9863"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils-devel-0.8.23-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-utils-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-utils-devel.sha256sum] = "af9de55b41e66f4c0af958f78f8342a87e885189b5ffdf18a5631f9310c89924"

RDEPENDS:rust-crossbeam-utils+default-devel = " \
 cargo \
 rust-crossbeam-utils+std-devel \
 rust-crossbeam-utils-devel \
 "
RDEPENDS:rust-crossbeam-utils+nightly-devel = " \
 cargo \
 rust-crossbeam-utils-devel \
 "
RDEPENDS:rust-crossbeam-utils+std-devel = " \
 cargo \
 rust-crossbeam-utils-devel \
 "
RDEPENDS:rust-crossbeam-utils-devel = " \
 cargo \
 rust \
 "
