# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager"
PE = "1"
PV = "1.58~rc1"
PR = "1.el10"
PACKAGES = " \
 NetworkManager \
 NetworkManager-adsl \
 NetworkManager-bluetooth \
 NetworkManager-cloud-setup \
 NetworkManager-config-connectivity-redhat \
 NetworkManager-config-server \
 NetworkManager-libnm \
 NetworkManager-libnm-devel \
 NetworkManager-ovs \
 NetworkManager-ppp \
 NetworkManager-tui \
 NetworkManager-wifi \
 NetworkManager-wwan \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/NetworkManager-1.58~rc1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ccf40c6700abfe781cbdb1ebf108b489504730f48b061ba2728a18d14168a399"

URI_x86_64_v2_NetworkManager = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-1.58~rc1-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager}"
SRC_URI[x86_64_v2_NetworkManager.sha256sum] = "0b8c49302cb80cad962c849ed9afb332a0048cf36a7691e73fa294cb55b3346f"

URI_x86_64_v2_NetworkManager-adsl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-adsl-1.58~rc1-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-adsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-adsl}"
SRC_URI[x86_64_v2_NetworkManager-adsl.sha256sum] = "47fcf326061d400c17e660e55468edc382af96694eb16d74b38aa2a4ac85d8bf"

URI_x86_64_v2_NetworkManager-bluetooth = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-bluetooth-1.58~rc1-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-bluetooth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-bluetooth}"
SRC_URI[x86_64_v2_NetworkManager-bluetooth.sha256sum] = "e0d67f145e48ffd5887013b1d18a77b2d9358b9965222f87e5006bf0ca37363e"

URI_x86_64_v2_NetworkManager-cloud-setup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-cloud-setup-1.58~rc1-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-cloud-setup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-cloud-setup}"
SRC_URI[x86_64_v2_NetworkManager-cloud-setup.sha256sum] = "d0f5fd0605b0cea67165994dbac8b9f33ff3968eaee6c1fa8a4e80788687bb2f"

URI_x86_64_v2_NetworkManager-config-connectivity-redhat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-config-connectivity-redhat-1.58~rc1-1.el10.noarch.rpm;name=x86_64_v2_NetworkManager-config-connectivity-redhat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-config-connectivity-redhat}"
SRC_URI[x86_64_v2_NetworkManager-config-connectivity-redhat.sha256sum] = "aed02e2d81722b43ef0c4e087d2ccea04101556644e3805368ed9ceaddd9f2fe"

URI_x86_64_v2_NetworkManager-config-server = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-config-server-1.58~rc1-1.el10.noarch.rpm;name=x86_64_v2_NetworkManager-config-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-config-server}"
SRC_URI[x86_64_v2_NetworkManager-config-server.sha256sum] = "497648231d06a91937bab48273bb252808e0328635a7d4e0d3347256a525f24c"

URI_x86_64_v2_NetworkManager-libnm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-libnm-1.58~rc1-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libnm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libnm}"
SRC_URI[x86_64_v2_NetworkManager-libnm.sha256sum] = "bb2b3b046f5c795756da509befabae8313912a8b401c26b11975edcf1bcc69f4"

URI_x86_64_v2_NetworkManager-libnm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/NetworkManager-libnm-devel-1.58~rc1-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libnm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libnm-devel}"
SRC_URI[x86_64_v2_NetworkManager-libnm-devel.sha256sum] = "20de5e21a84cb9897ae268ecd27be0689be5dd4f762b63319bf0299ff81579a0"

URI_x86_64_v2_NetworkManager-ovs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-ovs-1.58~rc1-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-ovs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-ovs}"
SRC_URI[x86_64_v2_NetworkManager-ovs.sha256sum] = "35a3be3d5123f9f1e1becb03c153a9daab64cf2bfa94a1f2daa07a513afe30d2"

URI_x86_64_v2_NetworkManager-ppp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-ppp-1.58~rc1-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-ppp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-ppp}"
SRC_URI[x86_64_v2_NetworkManager-ppp.sha256sum] = "1471b09664726336694f14b6419be47ed5f76dae774063df4c2c5e1edb2527ab"

URI_x86_64_v2_NetworkManager-tui = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-tui-1.58~rc1-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-tui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-tui}"
SRC_URI[x86_64_v2_NetworkManager-tui.sha256sum] = "38fd8882fa2638c2377defefce4def1fb88e814c4deeb008366acb33321107ad"

URI_x86_64_v2_NetworkManager-wifi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-wifi-1.58~rc1-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-wifi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-wifi}"
SRC_URI[x86_64_v2_NetworkManager-wifi.sha256sum] = "82324ade009261da8c145bbbdd811cedc685fe8fca387714e932cf5dac23abf4"

URI_x86_64_v2_NetworkManager-wwan = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-wwan-1.58~rc1-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-wwan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-wwan}"
SRC_URI[x86_64_v2_NetworkManager-wwan.sha256sum] = "f98cb2ffeceb1efe11655fdb990ec1e96069b7b80b952436b4cb1a1de52a91a5"

URI_aarch64_NetworkManager = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-1.58~rc1-1.el10.aarch64.rpm;name=aarch64_NetworkManager;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager}"
SRC_URI[aarch64_NetworkManager.sha256sum] = "de8cb334e4707dfd6681904d3687e6ea35418a5128d99ed50fb01a5fbfd7082a"

URI_aarch64_NetworkManager-adsl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-adsl-1.58~rc1-1.el10.aarch64.rpm;name=aarch64_NetworkManager-adsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-adsl}"
SRC_URI[aarch64_NetworkManager-adsl.sha256sum] = "a2db24ba73b9b7631dde82f5b71d7264de3148f11a9f08093c74b72f7d6bf91a"

URI_aarch64_NetworkManager-bluetooth = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-bluetooth-1.58~rc1-1.el10.aarch64.rpm;name=aarch64_NetworkManager-bluetooth;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-bluetooth}"
SRC_URI[aarch64_NetworkManager-bluetooth.sha256sum] = "fe5b198ae2c21d597f599ccf46b548171d94d942795a2077490d6d6ac4db4481"

URI_aarch64_NetworkManager-cloud-setup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-cloud-setup-1.58~rc1-1.el10.aarch64.rpm;name=aarch64_NetworkManager-cloud-setup;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-cloud-setup}"
SRC_URI[aarch64_NetworkManager-cloud-setup.sha256sum] = "0f1267e535c638937a3cd65b1eabbb60b4c4f90b7ed911b6c920801213f9f54b"

URI_aarch64_NetworkManager-config-connectivity-redhat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-config-connectivity-redhat-1.58~rc1-1.el10.noarch.rpm;name=aarch64_NetworkManager-config-connectivity-redhat;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-config-connectivity-redhat}"
SRC_URI[aarch64_NetworkManager-config-connectivity-redhat.sha256sum] = "aed02e2d81722b43ef0c4e087d2ccea04101556644e3805368ed9ceaddd9f2fe"

URI_aarch64_NetworkManager-config-server = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-config-server-1.58~rc1-1.el10.noarch.rpm;name=aarch64_NetworkManager-config-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-config-server}"
SRC_URI[aarch64_NetworkManager-config-server.sha256sum] = "497648231d06a91937bab48273bb252808e0328635a7d4e0d3347256a525f24c"

URI_aarch64_NetworkManager-libnm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-libnm-1.58~rc1-1.el10.aarch64.rpm;name=aarch64_NetworkManager-libnm;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libnm}"
SRC_URI[aarch64_NetworkManager-libnm.sha256sum] = "37c81039464c2939481e650814fef08e3cfeebba2d569e08f6cfcc0c19798a46"

URI_aarch64_NetworkManager-libnm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/NetworkManager-libnm-devel-1.58~rc1-1.el10.aarch64.rpm;name=aarch64_NetworkManager-libnm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libnm-devel}"
SRC_URI[aarch64_NetworkManager-libnm-devel.sha256sum] = "ba1a8920f404523b56cd1fe15e49e8ca26f6d038753ab40eb7e9156fb152817c"

URI_aarch64_NetworkManager-ovs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-ovs-1.58~rc1-1.el10.aarch64.rpm;name=aarch64_NetworkManager-ovs;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-ovs}"
SRC_URI[aarch64_NetworkManager-ovs.sha256sum] = "c18c89cc80be2d420c3884e7df282fc480ad4b685b80776c8aaeca3c9b6bb54e"

URI_aarch64_NetworkManager-ppp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-ppp-1.58~rc1-1.el10.aarch64.rpm;name=aarch64_NetworkManager-ppp;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-ppp}"
SRC_URI[aarch64_NetworkManager-ppp.sha256sum] = "fcda0154b8325ba7723ea75d1c7617a4d0185e68970a4c8110c54462edf5502a"

URI_aarch64_NetworkManager-tui = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-tui-1.58~rc1-1.el10.aarch64.rpm;name=aarch64_NetworkManager-tui;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-tui}"
SRC_URI[aarch64_NetworkManager-tui.sha256sum] = "06781e130a099e2a5f84642a6d71202556dadb120b913f923abbaa5031d8a1b9"

URI_aarch64_NetworkManager-wifi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-wifi-1.58~rc1-1.el10.aarch64.rpm;name=aarch64_NetworkManager-wifi;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-wifi}"
SRC_URI[aarch64_NetworkManager-wifi.sha256sum] = "03e7dc4c650196be39967c8dfe60d37174bd614972537d89082f452a8448fef4"

URI_aarch64_NetworkManager-wwan = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-wwan-1.58~rc1-1.el10.aarch64.rpm;name=aarch64_NetworkManager-wwan;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-wwan}"
SRC_URI[aarch64_NetworkManager-wwan.sha256sum] = "9844c03a18d9e992e54e784a5131e943cdf3df6f1bf8056629baa9db0bbe74ef"

RDEPENDS:NetworkManager = " \
 NetworkManager-libnm \
 audit-libs \
 bash \
 dbus \
 glib2 \
 glibc \
 gnutls \
 libbpf \
 libgcc \
 libndp \
 libselinux \
 readline \
 systemd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:NetworkManager-adsl = " \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:NetworkManager-bluetooth = " \
 NetworkManager \
 NetworkManager-wwan \
 bluez \
 bluez-libs \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:NetworkManager-cloud-setup = " \
 NetworkManager \
 NetworkManager-libnm \
 bash \
 glib2 \
 glibc \
 jansson \
 libgcc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:NetworkManager-config-connectivity-redhat = " \
 "
RDEPENDS:NetworkManager-config-server = " \
 "
RDEPENDS:NetworkManager-libnm = " \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 systemd-libs \
 "
RDEPENDS:NetworkManager-libnm-devel = " \
 NetworkManager-libnm \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:NetworkManager-ovs = " \
 NetworkManager \
 glib2 \
 glibc \
 jansson \
 libgcc \
 "
RDEPENDS:NetworkManager-ppp = " \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 ppp \
 "
RDEPENDS:NetworkManager-tui = " \
 NetworkManager \
 NetworkManager-libnm \
 glib2 \
 glibc \
 libgcc \
 newt \
 slang \
 "
RDEPENDS:NetworkManager-wifi = " \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 wireless-regdb \
 wpa_supplicant \
 "
RDEPENDS:NetworkManager-wwan = " \
 ModemManager \
 ModemManager-glib \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 systemd-libs \
 "
