# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-const-oid"
PV = "0.9.6"
PR = "3.el10_0"
PACKAGES = " \
 rust-const-oid+arbitrary-devel \
 rust-const-oid+db-devel \
 rust-const-oid+default-devel \
 rust-const-oid+std-devel \
 rust-const-oid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-const-oid-0.9.6-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fbd3482c879d7d46a1fbdabaf76181a01683b2d95216bfc7a62e2444e4fd176"

URI_x86_64_v2_rust-const-oid+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-oid+arbitrary-devel-0.9.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-oid+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-oid+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-const-oid+arbitrary-devel.sha256sum] = "8d95ec74fe21dcc3589c657b9665137e59c79698640ff45cfe2452dbdb7e26c5"

URI_x86_64_v2_rust-const-oid+db-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-oid+db-devel-0.9.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-oid+db-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-oid+db-devel}"
SRC_URI[x86_64_v2_rust-const-oid+db-devel.sha256sum] = "6750d6bea7e7b0729f5c25268b54d578d7d3eeef277e6fdad6c986bd68dc12f9"

URI_x86_64_v2_rust-const-oid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-oid+default-devel-0.9.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-oid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-oid+default-devel}"
SRC_URI[x86_64_v2_rust-const-oid+default-devel.sha256sum] = "72ecf1078128ee433e4ae260b618a8e284591f97fbb7dcb8758d64bc74986deb"

URI_x86_64_v2_rust-const-oid+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-oid+std-devel-0.9.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-oid+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-oid+std-devel}"
SRC_URI[x86_64_v2_rust-const-oid+std-devel.sha256sum] = "95b11e0b12f4cef9550caf288ef1ae47c412727ed73cc4a8385cd772a9c16c51"

URI_x86_64_v2_rust-const-oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-oid-devel-0.9.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-oid-devel}"
SRC_URI[x86_64_v2_rust-const-oid-devel.sha256sum] = "016ad114c0a9a28374a23659c75a9b7d6423ae1c64442ae429d663b2f17b1da6"

URI_aarch64_rust-const-oid+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-oid+arbitrary-devel-0.9.6-3.el10_0.noarch.rpm;name=aarch64_rust-const-oid+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-oid+arbitrary-devel}"
SRC_URI[aarch64_rust-const-oid+arbitrary-devel.sha256sum] = "0568f6c8f2c087c12ec39ad837ba81de5e055e54cf7564e06d683808e7f51905"

URI_aarch64_rust-const-oid+db-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-oid+db-devel-0.9.6-3.el10_0.noarch.rpm;name=aarch64_rust-const-oid+db-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-oid+db-devel}"
SRC_URI[aarch64_rust-const-oid+db-devel.sha256sum] = "5a00895104339424ee2d546f316705500f2e3cdd5f432e624a7f4fdf6b36075c"

URI_aarch64_rust-const-oid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-oid+default-devel-0.9.6-3.el10_0.noarch.rpm;name=aarch64_rust-const-oid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-oid+default-devel}"
SRC_URI[aarch64_rust-const-oid+default-devel.sha256sum] = "0c3894136fe8bd269b6a954dcba478d2f2746f76a2736ac81fa778e1884582c1"

URI_aarch64_rust-const-oid+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-oid+std-devel-0.9.6-3.el10_0.noarch.rpm;name=aarch64_rust-const-oid+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-oid+std-devel}"
SRC_URI[aarch64_rust-const-oid+std-devel.sha256sum] = "09901a751f1bd63f40a6240bae7a14e89aa1561c7eab8368b9c7592f585e73de"

URI_aarch64_rust-const-oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-oid-devel-0.9.6-3.el10_0.noarch.rpm;name=aarch64_rust-const-oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-oid-devel}"
SRC_URI[aarch64_rust-const-oid-devel.sha256sum] = "d6db56bea55476a6c7404e632422994dbdaf429d497b0b10879a8bd63e7e7cdd"

RDEPENDS:rust-const-oid+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-const-oid-devel \
 "
RDEPENDS:rust-const-oid+db-devel = " \
 cargo \
 rust-const-oid-devel \
 "
RDEPENDS:rust-const-oid+default-devel = " \
 cargo \
 rust-const-oid-devel \
 "
RDEPENDS:rust-const-oid+std-devel = " \
 cargo \
 rust-const-oid-devel \
 "
RDEPENDS:rust-const-oid-devel = " \
 cargo \
 rust \
 "
