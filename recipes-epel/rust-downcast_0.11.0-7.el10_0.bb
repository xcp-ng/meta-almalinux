# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-downcast"
PV = "0.11.0"
PR = "7.el10_0"
PACKAGES = " \
 rust-downcast+default-devel \
 rust-downcast+std-devel \
 rust-downcast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-downcast-0.11.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d6a63dde16d5a4c558cc0201f1c2f1e476631be645818cacc4b8ab72442e784"

URI_x86_64_v2_rust-downcast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-downcast+default-devel-0.11.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-downcast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-downcast+default-devel}"
SRC_URI[x86_64_v2_rust-downcast+default-devel.sha256sum] = "a4b80aea90ddbbbf2a656e7cafc976757606eda4fad7fd16622632c3b87fd8a1"

URI_x86_64_v2_rust-downcast+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-downcast+std-devel-0.11.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-downcast+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-downcast+std-devel}"
SRC_URI[x86_64_v2_rust-downcast+std-devel.sha256sum] = "bb02897caab9c8d2fefa645238ead4f7f3bce7421953cf4a90f36b24e7ffeaae"

URI_x86_64_v2_rust-downcast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-downcast-devel-0.11.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-downcast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-downcast-devel}"
SRC_URI[x86_64_v2_rust-downcast-devel.sha256sum] = "78a5b21f97259ad97c6da668bd39dfa08f3f6cb97a1032a56dcf9d3d52877fab"

URI_aarch64_rust-downcast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-downcast+default-devel-0.11.0-7.el10_0.noarch.rpm;name=aarch64_rust-downcast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-downcast+default-devel}"
SRC_URI[aarch64_rust-downcast+default-devel.sha256sum] = "d333484d2f546b3b34d00d6c517ba8d828abd4ff00170bc041a6aa74ad4b9462"

URI_aarch64_rust-downcast+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-downcast+std-devel-0.11.0-7.el10_0.noarch.rpm;name=aarch64_rust-downcast+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-downcast+std-devel}"
SRC_URI[aarch64_rust-downcast+std-devel.sha256sum] = "8559fd8e594dcf78d4781d10f9ee4c32cd0af06d8e7974cd92e757cbda6454c3"

URI_aarch64_rust-downcast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-downcast-devel-0.11.0-7.el10_0.noarch.rpm;name=aarch64_rust-downcast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-downcast-devel}"
SRC_URI[aarch64_rust-downcast-devel.sha256sum] = "459786a35f5feecd8fecebb398cde7878b4631d4571f14647f01a9520a6a65e8"

RDEPENDS:rust-downcast+default-devel = " \
 cargo \
 rust-downcast+std-devel \
 rust-downcast-devel \
 "
RDEPENDS:rust-downcast+std-devel = " \
 cargo \
 rust-downcast-devel \
 "
RDEPENDS:rust-downcast-devel = " \
 cargo \
 "
