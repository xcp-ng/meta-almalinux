# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nawk"
PV = "20240728"
PR = "1.el10_0"
PACKAGES = " \
 nawk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nawk-20240728-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df7d2c4d44f48e8d8ee0ca2bfc9771e79ed42d6651594563a6bc9ee7e26c3d73"

URI_x86_64_v2_nawk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nawk-20240728-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nawk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nawk}"
SRC_URI[x86_64_v2_nawk.sha256sum] = "3ff0e9079eb71e1a0362c5ee08262d12f073796187116dea8cd543c0b4a48b29"

URI_aarch64_nawk = "${EPEL_MIRROR}/aarch64/Packages/n/nawk-20240728-1.el10_0.aarch64.rpm;name=aarch64_nawk;unpack=0"
SRC_URI:append = " ${URI_aarch64_nawk}"
SRC_URI[aarch64_nawk.sha256sum] = "2080fa8eec252e6c5fa55f6bb5d9efd8d5cc9cdc8c95eefcdfe5112e7b21f23d"

RDEPENDS:nawk = " \
 glibc \
 "
