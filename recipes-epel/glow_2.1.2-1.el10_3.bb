# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glow"
PV = "2.1.2"
PR = "1.el10_3"
PACKAGES = " \
 glow \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/glow-2.1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c16b12f54ea016da188f568688360f8956c76dfc464b278a0dfa5f2c9a9e17d8"

URI_x86_64_v2_glow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glow-2.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glow}"
SRC_URI[x86_64_v2_glow.sha256sum] = "68a2b400a35bdd673031731b1e163616a396259aaa1d9a8653903b9bb6497628"

URI_aarch64_glow = "${EPEL_MIRROR}/aarch64/Packages/g/glow-2.1.2-1.el10_3.aarch64.rpm;name=aarch64_glow;unpack=0"
SRC_URI:append = " ${URI_aarch64_glow}"
SRC_URI[aarch64_glow.sha256sum] = "8c8a3c0866457829fef33844c27053030694009739bcf0d373529929e58e3d44"

RDEPENDS:glow = " \
 glibc \
 "
