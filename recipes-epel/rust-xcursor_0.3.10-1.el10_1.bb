# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xcursor"
PV = "0.3.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-xcursor+default-devel \
 rust-xcursor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-xcursor-0.3.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4175ec98723e5e87a00885a417fabafd82b07c3e46419d84bdff9e9fb5aa3e33"

URI_x86_64_v2_rust-xcursor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xcursor+default-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xcursor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xcursor+default-devel}"
SRC_URI[x86_64_v2_rust-xcursor+default-devel.sha256sum] = "cc748939e8868c799799d24643295ed1d4afd3e1afc4e11d2684afa8d60a9a12"

URI_x86_64_v2_rust-xcursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xcursor-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xcursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xcursor-devel}"
SRC_URI[x86_64_v2_rust-xcursor-devel.sha256sum] = "c3beeff6bb58b059650253c66761f28cb7061f787b7c2e7c75dc77a221cc33e7"

URI_aarch64_rust-xcursor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xcursor+default-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-xcursor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xcursor+default-devel}"
SRC_URI[aarch64_rust-xcursor+default-devel.sha256sum] = "9c73f50a433125285b044da4155f4a8424884418d105e2f994fec5795ae0ae42"

URI_aarch64_rust-xcursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xcursor-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-xcursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xcursor-devel}"
SRC_URI[aarch64_rust-xcursor-devel.sha256sum] = "db65e8d1940f8ac85cfbb5c75da2f6d234747c79802e0547d2106e94a853ad2b"

RDEPENDS:rust-xcursor+default-devel = " \
 cargo \
 rust-xcursor-devel \
 "
RDEPENDS:rust-xcursor-devel = " \
 cargo \
 "
