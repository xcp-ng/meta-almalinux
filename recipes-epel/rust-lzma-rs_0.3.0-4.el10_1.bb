# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lzma-rs"
PV = "0.3.0"
PR = "4.el10_1"
PACKAGES = " \
 rust-lzma-rs+default-devel \
 rust-lzma-rs+enable_logging-devel \
 rust-lzma-rs+env_logger-devel \
 rust-lzma-rs+log-devel \
 rust-lzma-rs+raw_decoder-devel \
 rust-lzma-rs+stream-devel \
 rust-lzma-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lzma-rs-0.3.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fb0e79eb87d8915c170f24d2c8284b68af58fe9581869e4901197b9f6109cca"

URI_x86_64_v2_rust-lzma-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rs+default-devel-0.3.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rs+default-devel}"
SRC_URI[x86_64_v2_rust-lzma-rs+default-devel.sha256sum] = "aed620d44ad682952964fc45b1e6d26662c9093544ffa2e443eff1986e234ab5"

URI_x86_64_v2_rust-lzma-rs+enable_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rs+enable_logging-devel-0.3.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rs+enable_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rs+enable_logging-devel}"
SRC_URI[x86_64_v2_rust-lzma-rs+enable_logging-devel.sha256sum] = "18294685c8d6ab4ebae0bfaa6561fad34cbb86a64476f182e6665c216aca302d"

URI_x86_64_v2_rust-lzma-rs+env_logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rs+env_logger-devel-0.3.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rs+env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rs+env_logger-devel}"
SRC_URI[x86_64_v2_rust-lzma-rs+env_logger-devel.sha256sum] = "a02180a3f110703e5e6dc675e637c2760bb388d57d29dc52b1ef6b44cd0da85d"

URI_x86_64_v2_rust-lzma-rs+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rs+log-devel-0.3.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rs+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rs+log-devel}"
SRC_URI[x86_64_v2_rust-lzma-rs+log-devel.sha256sum] = "6894790692fb8916bb9a7a11777e67bd5f42dc5fe9beff10082530b354cf1eea"

URI_x86_64_v2_rust-lzma-rs+raw_decoder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rs+raw_decoder-devel-0.3.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rs+raw_decoder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rs+raw_decoder-devel}"
SRC_URI[x86_64_v2_rust-lzma-rs+raw_decoder-devel.sha256sum] = "25a56d4ae9b676f1f5d7aad6ee3df75482fd90cec4efa1680f0224fe45734d94"

URI_x86_64_v2_rust-lzma-rs+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rs+stream-devel-0.3.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rs+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rs+stream-devel}"
SRC_URI[x86_64_v2_rust-lzma-rs+stream-devel.sha256sum] = "163918bb29ab3abed031e0af39a65e1ffe2046c2df87f5c1b4588b26c7dbfc55"

URI_x86_64_v2_rust-lzma-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rs-devel-0.3.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-rs-devel}"
SRC_URI[x86_64_v2_rust-lzma-rs-devel.sha256sum] = "cd54c257513c6a1a60899a0cc6bd8a58ceb4c0bb1a8a1e31b811aca3c16d7ef0"

URI_aarch64_rust-lzma-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rs+default-devel-0.3.0-4.el10_1.noarch.rpm;name=aarch64_rust-lzma-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rs+default-devel}"
SRC_URI[aarch64_rust-lzma-rs+default-devel.sha256sum] = "3cf89f11481243b43c7e926acc7164c09dafcb73534e95c4b9c199e857347e47"

URI_aarch64_rust-lzma-rs+enable_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rs+enable_logging-devel-0.3.0-4.el10_1.noarch.rpm;name=aarch64_rust-lzma-rs+enable_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rs+enable_logging-devel}"
SRC_URI[aarch64_rust-lzma-rs+enable_logging-devel.sha256sum] = "7263c75420afc281b4021b5b813dfe85f205f75de00c7ddebf6327bcae6063c5"

URI_aarch64_rust-lzma-rs+env_logger-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rs+env_logger-devel-0.3.0-4.el10_1.noarch.rpm;name=aarch64_rust-lzma-rs+env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rs+env_logger-devel}"
SRC_URI[aarch64_rust-lzma-rs+env_logger-devel.sha256sum] = "06ac1379581bdd3dd6830b8be639758db3304d3a4717f61fb213fe2103da0bf0"

URI_aarch64_rust-lzma-rs+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rs+log-devel-0.3.0-4.el10_1.noarch.rpm;name=aarch64_rust-lzma-rs+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rs+log-devel}"
SRC_URI[aarch64_rust-lzma-rs+log-devel.sha256sum] = "1c4e32e0e077322c5a67058fc7b7d21e3c6dff931464e0fedc4e67548d1b7579"

URI_aarch64_rust-lzma-rs+raw_decoder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rs+raw_decoder-devel-0.3.0-4.el10_1.noarch.rpm;name=aarch64_rust-lzma-rs+raw_decoder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rs+raw_decoder-devel}"
SRC_URI[aarch64_rust-lzma-rs+raw_decoder-devel.sha256sum] = "69a35b09d13e2cce46e5e1ddb5347f51f4ab43fc225f3aba7128b920d924b5c8"

URI_aarch64_rust-lzma-rs+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rs+stream-devel-0.3.0-4.el10_1.noarch.rpm;name=aarch64_rust-lzma-rs+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rs+stream-devel}"
SRC_URI[aarch64_rust-lzma-rs+stream-devel.sha256sum] = "0c7f2dbc8f230085af83fa6daf6190a77408567a276d1bd32418e1c62bba6b2c"

URI_aarch64_rust-lzma-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rs-devel-0.3.0-4.el10_1.noarch.rpm;name=aarch64_rust-lzma-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-rs-devel}"
SRC_URI[aarch64_rust-lzma-rs-devel.sha256sum] = "d968c448aa0a581dbd55f4c0fbabb2341fff4bc3d6e1ade968f5c7dbdd71a7f5"

RDEPENDS:rust-lzma-rs+default-devel = " \
 cargo \
 rust-lzma-rs-devel \
 "
RDEPENDS:rust-lzma-rs+enable_logging-devel = " \
 cargo \
 rust-lzma-rs+env_logger-devel \
 rust-lzma-rs+log-devel \
 rust-lzma-rs-devel \
 "
RDEPENDS:rust-lzma-rs+env_logger-devel = " \
 cargo \
 rust-env_logger0.9+default-devel \
 rust-lzma-rs-devel \
 "
RDEPENDS:rust-lzma-rs+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-lzma-rs-devel \
 "
RDEPENDS:rust-lzma-rs+raw_decoder-devel = " \
 cargo \
 rust-lzma-rs-devel \
 "
RDEPENDS:rust-lzma-rs+stream-devel = " \
 cargo \
 rust-lzma-rs-devel \
 "
RDEPENDS:rust-lzma-rs-devel = " \
 cargo \
 rust-byteorder+default-devel \
 rust-crc+default-devel \
 "
