# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-dev-utils"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kde-dev-utils \
 kde-dev-utils-common \
 kpartloader \
 kuiviewer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-dev-utils-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b8bda96a73b5cb504be379955601aca23bace05cf115bf5a766dd1995864d23"

URI_x86_64_v2_kde-dev-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-dev-utils-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-dev-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-dev-utils}"
SRC_URI[x86_64_v2_kde-dev-utils.sha256sum] = "3e7579f48134622e27b26e95cf39030373c4dc29e93965b0b782401e5284e3d2"

URI_x86_64_v2_kde-dev-utils-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-dev-utils-common-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kde-dev-utils-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-dev-utils-common}"
SRC_URI[x86_64_v2_kde-dev-utils-common.sha256sum] = "c33c7a85cda2c15defdfc206db611597adf073fd8e25dbedc0eea5bde5ad7a7a"

URI_x86_64_v2_kpartloader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpartloader-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpartloader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpartloader}"
SRC_URI[x86_64_v2_kpartloader.sha256sum] = "58aaea17e5f6d8df37084ac2119df10e53f1e4c3a970ed265e3d2d02c928d784"

URI_x86_64_v2_kuiviewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kuiviewer-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kuiviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kuiviewer}"
SRC_URI[x86_64_v2_kuiviewer.sha256sum] = "7276e22dd5a7f6779c0d0de2769710e5fe1fb3ca460b307c23db36563d855778"

URI_aarch64_kde-dev-utils = "${EPEL_MIRROR}/aarch64/Packages/k/kde-dev-utils-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kde-dev-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-dev-utils}"
SRC_URI[aarch64_kde-dev-utils.sha256sum] = "2875478d2151282b3432069934a48a549adc6c4773dab5f45944c79280d2235c"

URI_aarch64_kde-dev-utils-common = "${EPEL_MIRROR}/aarch64/Packages/k/kde-dev-utils-common-25.08.1-1.el10_1.noarch.rpm;name=aarch64_kde-dev-utils-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-dev-utils-common}"
SRC_URI[aarch64_kde-dev-utils-common.sha256sum] = "236df5f3701e4f4011c82bf71fad5efcaccafa5be6f3e98eb6baff0b1b5b39b2"

URI_aarch64_kpartloader = "${EPEL_MIRROR}/aarch64/Packages/k/kpartloader-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kpartloader;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpartloader}"
SRC_URI[aarch64_kpartloader.sha256sum] = "9933551340c1e3df4d9c984990a946be4f0785904d731e962e5199c211fef969"

URI_aarch64_kuiviewer = "${EPEL_MIRROR}/aarch64/Packages/k/kuiviewer-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kuiviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_kuiviewer}"
SRC_URI[aarch64_kuiviewer.sha256sum] = "91c2930df6c9992536f7a4260e77aaa41a18cd9276e2d9ed310da9a976226451"

RDEPENDS:kde-dev-utils = " \
 kpartloader \
 kuiviewer \
 "
RDEPENDS:kde-dev-utils-common = " \
 "
RDEPENDS:kpartloader = " \
 glibc \
 kde-dev-utils-common \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kuiviewer = " \
 glibc \
 kde-dev-utils-common \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-designer \
 "
