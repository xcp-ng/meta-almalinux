# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-dir"
PV = "0.15.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-dir+default-devel \
 rust-gix-dir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-dir-0.15.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bed5961a850256688cda917dd99590a54618d76418c1d8b5fa6d33698b17e7a1"

URI_x86_64_v2_rust-gix-dir+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-dir+default-devel-0.15.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-dir+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-dir+default-devel}"
SRC_URI[x86_64_v2_rust-gix-dir+default-devel.sha256sum] = "04f486347e39a8ca725cb4d0f42e0f631a37f923484fc355094bf4fff0e834c5"

URI_x86_64_v2_rust-gix-dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-dir-devel-0.15.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-dir-devel}"
SRC_URI[x86_64_v2_rust-gix-dir-devel.sha256sum] = "f4d4ad398678673432f81061a1feedaa690162ce21413eb5612b7e5bfe135887"

URI_aarch64_rust-gix-dir+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-dir+default-devel-0.15.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-dir+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-dir+default-devel}"
SRC_URI[aarch64_rust-gix-dir+default-devel.sha256sum] = "4d7a4d9ef6c016b583e56fdc706f74c7c1c443fa0a13c89f9dce96dd655d90a7"

URI_aarch64_rust-gix-dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-dir-devel-0.15.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-dir-devel}"
SRC_URI[aarch64_rust-gix-dir-devel.sha256sum] = "ca2bfea7feb4ce690c0125e148e87e8e168fd3cc82466baa7fca7f7b340c8810"

RDEPENDS:rust-gix-dir+default-devel = " \
 cargo \
 rust-gix-dir-devel \
 "
RDEPENDS:rust-gix-dir-devel = " \
 bash \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-discover+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-ignore+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-utils+bstr-devel \
 rust-gix-utils+default-devel \
 rust-gix-worktree-devel \
 rust-thiserror+default-devel \
 "
