# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-OpenSSL-X509"
PV = "2.1.3"
PR = "1.el10_3"
PACKAGES = " \
 perl-Crypt-OpenSSL-X509 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-OpenSSL-X509-2.1.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b7c127e77e1d1d4d7b8f2d6b7b8392ddc8bf624fcf24cadbefc00b487e83b1b"

URI_x86_64_v2_perl-Crypt-OpenSSL-X509 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-X509-2.1.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-X509;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-X509}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-X509.sha256sum] = "1a34bb094017b22b09c7853a6671f4485a5a088027fa2d0f7358f9221ae52355"

URI_aarch64_perl-Crypt-OpenSSL-X509 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-X509-2.1.3-1.el10_3.aarch64.rpm;name=aarch64_perl-Crypt-OpenSSL-X509;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-X509}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-X509.sha256sum] = "3e5d0fc9a9d12eba4122994948cc3a7ad1a726f39b4da904760a9ec671f67315"

RDEPENDS:perl-Crypt-OpenSSL-X509 = " \
 glibc \
 openssl-libs \
 perl-Convert-ASN1 \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-version \
 "
