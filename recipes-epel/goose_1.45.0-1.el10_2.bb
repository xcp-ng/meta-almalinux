# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "goose"
PV = "1.45.0"
PR = "1.el10_2"
PACKAGES = " \
 goose \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/goose-1.45.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4fb01ca2b10b6d48d5a44d4e6455ec8beb72a58247d9889a016ded7e12a99172"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/goose-1.45.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_goose;unpack=0"
SRC_URI[x86_64_v2_goose.sha256sum] = "48a4a7d2080822208c5abf0f2e5157602a8365a330137d6e603e911fb492a75b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/goose-1.45.0-1.el10_2.aarch64.rpm;name=aarch64_goose;unpack=0"
SRC_URI[aarch64_goose.sha256sum] = "9014a8a9e2ced6a3cdeac209928a6a4cf43111805661b81d9a2947c594248017"

RDEPENDS:goose = " \
 dbus-libs \
 glibc \
 libgcc \
 libzstd \
 oniguruma \
 openssl-libs \
 sqlite-libs \
 "
