# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "powerpc-utils"
PV = "1.3.13"
PR = "4.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/powerpc-utils-1.3.13-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3811a5ee22d849cd1aa34d2a9b9c0081d69774f09ee60a65335fd8a9c291cf57"

