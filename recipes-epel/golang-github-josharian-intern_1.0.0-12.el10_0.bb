# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-josharian-intern"
PV = "1.0.0"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-josharian-intern-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-josharian-intern-1.0.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "653fc6cf4ee92323323648f011dccaf45d24ec7d01bf2388fa8f33ae942d9abc"

URI_x86_64_v2_golang-github-josharian-intern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-josharian-intern-devel-1.0.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-josharian-intern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-josharian-intern-devel}"
SRC_URI[x86_64_v2_golang-github-josharian-intern-devel.sha256sum] = "f3f29591b9fe910b87a4ce8abea4daddd0c7ef69d8c2271104c92bd65a583a49"

URI_aarch64_golang-github-josharian-intern-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-josharian-intern-devel-1.0.0-12.el10_0.noarch.rpm;name=aarch64_golang-github-josharian-intern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-josharian-intern-devel}"
SRC_URI[aarch64_golang-github-josharian-intern-devel.sha256sum] = "d1e064055dfb932faab6a6510aea2b8fdfbc63fe5a22db603163b30d150a2b1b"

RDEPENDS:golang-github-josharian-intern-devel = " \
 go-filesystem \
 "
