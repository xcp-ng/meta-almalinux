# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-argmax"
PV = "0.3.1"
PR = "8.el10_0"
PACKAGES = " \
 rust-argmax+default-devel \
 rust-argmax-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-argmax-0.3.1-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48694d1a201a94c7a3402df7976341f0500d4d282b3c148d248625f775b01c9d"

URI_x86_64_v2_rust-argmax+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argmax+default-devel-0.3.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argmax+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argmax+default-devel}"
SRC_URI[x86_64_v2_rust-argmax+default-devel.sha256sum] = "b2bfe6d88e947ea53bac2871e770b62ed9e5e21e13e4debf45a3d4924d2726ba"

URI_x86_64_v2_rust-argmax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argmax-devel-0.3.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argmax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argmax-devel}"
SRC_URI[x86_64_v2_rust-argmax-devel.sha256sum] = "36eea005101687082a9cb3800e0b2d91bf195c585e847269b4c07fed2e8d2998"

URI_aarch64_rust-argmax+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argmax+default-devel-0.3.1-8.el10_0.noarch.rpm;name=aarch64_rust-argmax+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argmax+default-devel}"
SRC_URI[aarch64_rust-argmax+default-devel.sha256sum] = "c3bcceccf4b70eae1f3635e19babc995e8ca6819b894cb6fa493ba40f0a2e391"

URI_aarch64_rust-argmax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argmax-devel-0.3.1-8.el10_0.noarch.rpm;name=aarch64_rust-argmax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argmax-devel}"
SRC_URI[aarch64_rust-argmax-devel.sha256sum] = "d3f9db86d95b6176706d47271305f0c6c07bdd0f0fd6ac3d2867551cca4b3f5d"

RDEPENDS:rust-argmax+default-devel = " \
 cargo \
 rust-argmax-devel \
 "
RDEPENDS:rust-argmax-devel = " \
 cargo \
 rust-lazy_static+default-devel \
 rust-libc+default-devel \
 virtual/crate_nix/feature__ge_0.24.2_with_crate_nix/feature__lt_0.30.0~ \
 virtual/crate_nix__ge_0.24.2_with_crate_nix__lt_0.30.0~ \
 "
