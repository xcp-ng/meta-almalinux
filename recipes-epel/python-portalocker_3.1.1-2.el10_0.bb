# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-portalocker"
PV = "3.1.1"
PR = "2.el10_0"
PACKAGES = " \
 python3-portalocker \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-portalocker-3.1.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27e8f452f195cc3d4f3654139ae5f48367c2efb84fc3f9f65e3752b2327c3d29"

URI_x86_64_v2_python3-portalocker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-portalocker-3.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-portalocker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-portalocker}"
SRC_URI[x86_64_v2_python3-portalocker.sha256sum] = "5fd366700d3e21c5d0b68863e3fc71e9e96da284aa75ccd9c660eb68cc72e31d"

URI_aarch64_python3-portalocker = "${EPEL_MIRROR}/aarch64/Packages/p/python3-portalocker-3.1.1-2.el10_0.noarch.rpm;name=aarch64_python3-portalocker;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-portalocker}"
SRC_URI[aarch64_python3-portalocker.sha256sum] = "6651da193a0767ca71464a5ac673222e572b13cb7505c69fb8d4533b9764bcd1"

RDEPENDS:python3-portalocker = " \
 python3 \
 "
