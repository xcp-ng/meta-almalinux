# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-coreos-installer"
PV = "0.24.0"
PR = "5.el10_1"
PACKAGES = " \
 coreos-installer \
 coreos-installer-bootinfra \
 coreos-installer-dracut \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-coreos-installer-0.24.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28f7353f7859653e5103f3db3b7198c0e54291f61be562325caa8a5f481cee04"

URI_x86_64_v2_coreos-installer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/coreos-installer-0.24.0-5.el10_1.x86_64_v2.rpm;name=x86_64_v2_coreos-installer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coreos-installer}"
SRC_URI[x86_64_v2_coreos-installer.sha256sum] = "f563752490978864e647320de7e285e7178a7c486bd89e7e39310cf9d611af38"

URI_x86_64_v2_coreos-installer-bootinfra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/coreos-installer-bootinfra-0.24.0-5.el10_1.x86_64_v2.rpm;name=x86_64_v2_coreos-installer-bootinfra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coreos-installer-bootinfra}"
SRC_URI[x86_64_v2_coreos-installer-bootinfra.sha256sum] = "f775394fd3d5231f918c23f3f6eab78f4ed60c3bebbf6481b81d35e0a3af954d"

URI_x86_64_v2_coreos-installer-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/coreos-installer-dracut-0.24.0-5.el10_1.x86_64_v2.rpm;name=x86_64_v2_coreos-installer-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coreos-installer-dracut}"
SRC_URI[x86_64_v2_coreos-installer-dracut.sha256sum] = "ce047a3cb2a4ea251029a9033e16589f77060f6e934e010014ef292f9f13b1c4"

URI_aarch64_coreos-installer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/coreos-installer-0.24.0-5.el10_1.aarch64.rpm;name=aarch64_coreos-installer;unpack=0"
SRC_URI:append = " ${URI_aarch64_coreos-installer}"
SRC_URI[aarch64_coreos-installer.sha256sum] = "1b5f4051db8348c16adbc5fbfcb4da4945e6f6bdf3d8e071675ad973e4ae003e"

URI_aarch64_coreos-installer-bootinfra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/coreos-installer-bootinfra-0.24.0-5.el10_1.aarch64.rpm;name=aarch64_coreos-installer-bootinfra;unpack=0"
SRC_URI:append = " ${URI_aarch64_coreos-installer-bootinfra}"
SRC_URI[aarch64_coreos-installer-bootinfra.sha256sum] = "6e3a867d9644382e6f933b9651c2e219778b6b844eb29abf943a17fe7d4f002a"

URI_aarch64_coreos-installer-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/coreos-installer-dracut-0.24.0-5.el10_1.aarch64.rpm;name=aarch64_coreos-installer-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_coreos-installer-dracut}"
SRC_URI[aarch64_coreos-installer-dracut.sha256sum] = "037717d5a1d44d74dbb7b2a9f40ac545423ac2ce84366093324b19bbc5503f43"

RDEPENDS:coreos-installer = " \
 glibc \
 gnupg2 \
 kpartx \
 libgcc \
 libzstd \
 openssl-libs \
 systemd-udev \
 util-linux \
 xz-libs \
 "
RDEPENDS:coreos-installer-bootinfra = " \
 bash \
 coreos-installer \
 glibc \
 libgcc \
 libzstd \
 openssl-libs \
 xz-libs \
 "
RDEPENDS:coreos-installer-dracut = " \
 bash \
 coreos-installer \
 "
