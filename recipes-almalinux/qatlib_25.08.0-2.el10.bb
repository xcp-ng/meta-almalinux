# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qatlib"
PV = "25.08.0"
PR = "2.el10"
PACKAGES:x86_64_v2 = " \
 qatlib \
 qatlib-devel \
 qatlib-service \
 qatlib-tests \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qatlib-25.08.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57295e9125d3f0d2d1a4513624d3d0e07021f2e443091fc65666c26d4aac3085"

URI_x86_64_v2_qatlib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatlib-25.08.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_qatlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatlib}"
SRC_URI[x86_64_v2_qatlib.sha256sum] = "789b56278ac013b79395f8111db1230c34fc5e2e888afafffd6d514f9c67acab"

URI_x86_64_v2_qatlib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qatlib-devel-25.08.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_qatlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatlib-devel}"
SRC_URI[x86_64_v2_qatlib-devel.sha256sum] = "1039ff7c52c27de28b5f2563f6b2a38d5cfe6a9042063542fb61c5374a673643"

URI_x86_64_v2_qatlib-service = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatlib-service-25.08.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_qatlib-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatlib-service}"
SRC_URI[x86_64_v2_qatlib-service.sha256sum] = "13991d484a28130582a88ff0092825160e7985929f02a1b7afc11fd1a79ea5ee"

URI_x86_64_v2_qatlib-tests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qatlib-tests-25.08.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_qatlib-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatlib-tests}"
SRC_URI[x86_64_v2_qatlib-tests.sha256sum] = "d8725bfaf9291dec6a0b0ba27ecb2a11bdf01064b92382d35a1fa968ceda829c"

RDEPENDS:qatlib = " \
 glibc \
 numactl-libs \
 openssl-libs \
 "
RDEPENDS:qatlib-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 qatlib \
 qatlib-devel \
 "
RDEPENDS:qatlib-service = " \
 bash \
 glibc \
 numactl-libs \
 pciutils \
 qatlib \
 systemd \
 "
RDEPENDS:qatlib-tests = " \
 glibc \
 openssl-libs \
 qatlib \
 zlib-ng-compat \
 "
