# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tbb"
PV = "2021.11.0"
PR = "8.el10"
PACKAGES = " \
 python3-tbb \
 tbb \
 tbb-bind \
 tbb-devel \
 tbb-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tbb-2021.11.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "239e88dc7226b02dcda8208e99e390e859274b81df2fd34c2e74ee9d5be36479"

URI_x86_64_v2_python3-tbb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tbb-2021.11.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_python3-tbb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tbb}"
SRC_URI[x86_64_v2_python3-tbb.sha256sum] = "423ae646384b13cd9814ccaecc4c4e82cc19e333e44653eb766d07a6203de0ba"

URI_x86_64_v2_tbb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tbb-2021.11.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_tbb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tbb}"
SRC_URI[x86_64_v2_tbb.sha256sum] = "9339d3e8ef2b8f797e605bbd91c999d1d568ad97f313b75f181985bd16b5d6e9"

URI_x86_64_v2_tbb-bind = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tbb-bind-2021.11.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_tbb-bind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tbb-bind}"
SRC_URI[x86_64_v2_tbb-bind.sha256sum] = "db27177990b8726843d090346bd297b02bb3e06f06721c16c0e663c0618540e1"

URI_x86_64_v2_tbb-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tbb-devel-2021.11.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_tbb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tbb-devel}"
SRC_URI[x86_64_v2_tbb-devel.sha256sum] = "17a3eb4c0865dada9f0037fbda36673928fcf7f1524662aee620942cf77fbec6"

URI_x86_64_v2_tbb-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tbb-doc-2021.11.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_tbb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tbb-doc}"
SRC_URI[x86_64_v2_tbb-doc.sha256sum] = "5f8230545aba251c56b8a9247585b088ce3be6dbc8dee6a65653933c0f7f67c9"

URI_aarch64_python3-tbb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tbb-2021.11.0-8.el10.aarch64.rpm;name=aarch64_python3-tbb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tbb}"
SRC_URI[aarch64_python3-tbb.sha256sum] = "89f8f0b50ba0fd20fd876238be1c13f529ddf2551d697d49358f4307e050cab0"

URI_aarch64_tbb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tbb-2021.11.0-8.el10.aarch64.rpm;name=aarch64_tbb;unpack=0"
SRC_URI:append = " ${URI_aarch64_tbb}"
SRC_URI[aarch64_tbb.sha256sum] = "9c13658e8f17a2a3fd276787979e089191dc5222292e9e38ca93359d0afd6eac"

URI_aarch64_tbb-bind = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tbb-bind-2021.11.0-8.el10.aarch64.rpm;name=aarch64_tbb-bind;unpack=0"
SRC_URI:append = " ${URI_aarch64_tbb-bind}"
SRC_URI[aarch64_tbb-bind.sha256sum] = "cc852d8c698a79243bbf4cc54288a7dcbe4094b49bf854459a3fe48f3a45896d"

URI_aarch64_tbb-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tbb-devel-2021.11.0-8.el10.aarch64.rpm;name=aarch64_tbb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tbb-devel}"
SRC_URI[aarch64_tbb-devel.sha256sum] = "d0666f50ea22524ff46658a9b62f3da316056041ad60515569f82ede68d56f85"

URI_aarch64_tbb-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tbb-doc-2021.11.0-8.el10.aarch64.rpm;name=aarch64_tbb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_tbb-doc}"
SRC_URI[aarch64_tbb-doc.sha256sum] = "dfdadd987f474d5ff9aa5f45132ed3b428f71ac9c3401cdd78d106cd98d9657d"

RDEPENDS:python3-tbb = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 tbb \
 "
RDEPENDS:tbb = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:tbb-bind = " \
 glibc \
 hwloc-libs \
 libgcc \
 libstdc++ \
 tbb \
 "
RDEPENDS:tbb-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 tbb \
 tbb-bind \
 "
RDEPENDS:tbb-doc = " \
 "
