# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-search"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 akonadi-search \
 akonadi-search-devel \
 akonadi-search-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/akonadi-search-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "807e1e671f6ff2b740e6e7b43882251ea92c4f2c159169110c1e5e98d2e53d2b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-search-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-search;unpack=0"
SRC_URI[x86_64_v2_akonadi-search.sha256sum] = "3307ee72650a97a9ca8242d27bf2b8c7094c6edbbf1afceee055617b796a9485"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-search-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-search-devel;unpack=0"
SRC_URI[x86_64_v2_akonadi-search-devel.sha256sum] = "3f44b7686f6d13e0f36e947c3263cea346567dc9bd5fcf54bf198394a62bb7c3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-search-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-search-doc;unpack=0"
SRC_URI[x86_64_v2_akonadi-search-doc.sha256sum] = "17bfd8b0988ee0911a68cd01c675b4248815fbc2ee25af12ffe30e535a571f48"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-search-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_akonadi-search;unpack=0"
SRC_URI[aarch64_akonadi-search.sha256sum] = "896a97e292f60b5425750c027bb9366e3795876b6989e4b07def51bb5e9cdda4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-search-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_akonadi-search-devel;unpack=0"
SRC_URI[aarch64_akonadi-search-devel.sha256sum] = "2bf789f522c3f445114c6bb32cdafbf9fed2dfef5e2f658dc9965aba4aedf686"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-search-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_akonadi-search-doc;unpack=0"
SRC_URI[aarch64_akonadi-search-doc.sha256sum] = "7cdd3daf9641d2925a5bd988b5ffebc8d2aa120c873be7d824a814b67fa0c8ab"

RDEPENDS:akonadi-search = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kmime \
 kf6-krunner \
 kf6-kwidgetsaddons \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 xapian-core-libs \
 "
RDEPENDS:akonadi-search-devel = " \
 akonadi-mime-devel \
 akonadi-search \
 akonadi-server-devel \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kf6-kcontacts-devel \
 kf6-kcoreaddons-devel \
 kf6-kmime-devel \
 qt6-qtbase-devel \
 "
RDEPENDS:akonadi-search-doc = " \
 "
