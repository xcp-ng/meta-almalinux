# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tap"
PV = "1.0.1"
PR = "10.el10_0"
PACKAGES = " \
 rust-tap+default-devel \
 rust-tap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tap-1.0.1-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ae7611762af5734be09d1b3f067493676b9c62a468d7cedf1ac1a72352cdcd0"

URI_x86_64_v2_rust-tap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tap+default-devel-1.0.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tap+default-devel}"
SRC_URI[x86_64_v2_rust-tap+default-devel.sha256sum] = "8d5531a3c6318076c86fb19f9b289f31f349184c3806c62eaf72e8fc7005c04a"

URI_x86_64_v2_rust-tap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tap-devel-1.0.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tap-devel}"
SRC_URI[x86_64_v2_rust-tap-devel.sha256sum] = "2484859b34a75e8acbf38fa018e87dbd8da962114e8fcaf18d673e5891431ac8"

URI_aarch64_rust-tap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tap+default-devel-1.0.1-10.el10_0.noarch.rpm;name=aarch64_rust-tap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tap+default-devel}"
SRC_URI[aarch64_rust-tap+default-devel.sha256sum] = "04c263145f6b13802d5ea57b6e0659f3c978c20a161ff243c9ba423560557554"

URI_aarch64_rust-tap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tap-devel-1.0.1-10.el10_0.noarch.rpm;name=aarch64_rust-tap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tap-devel}"
SRC_URI[aarch64_rust-tap-devel.sha256sum] = "918bc1b4c96945b7299fe8d168740549904ff14fc356e4b4c0d2ff4a5d7d5a9a"

RDEPENDS:rust-tap+default-devel = " \
 cargo \
 rust-tap-devel \
 "
RDEPENDS:rust-tap-devel = " \
 cargo \
 "
