# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-threads"
PE = "1"
PV = "2.40"
PR = "511.el10"
PACKAGES = " \
 perl-threads \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-threads-2.40-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f318939d143e05b4841cac644dd6ebdaeae02e6d5ca4f2ae70e0ca0d4250b76e"

URI_x86_64_v2_perl-threads = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-threads-2.40-511.el10.x86_64_v2.rpm;name=x86_64_v2_perl-threads;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-threads}"
SRC_URI[x86_64_v2_perl-threads.sha256sum] = "a0b59829795f525f419da8d228cf2d93e091ee329a3d8bfb9f7cadf67c3d31f3"

URI_aarch64_perl-threads = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-threads-2.40-511.el10.aarch64.rpm;name=aarch64_perl-threads;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-threads}"
SRC_URI[aarch64_perl-threads.sha256sum] = "ef9a5552aea3d9bceb63616674dec195ff5dd68b33bdf9f2cef6b6637e2dbdc2"

RDEPENDS:perl-threads = " \
 glibc \
 perl-Carp \
 perl-libs \
 perl-overload \
 "
