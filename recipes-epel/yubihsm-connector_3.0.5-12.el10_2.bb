# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yubihsm-connector"
PV = "3.0.5"
PR = "12.el10_2"
PACKAGES = " \
 yubihsm-connector \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yubihsm-connector-3.0.5-12.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d20c41f920053a059a4528eebd98cefa37e69b8e11870b89eea81d7604d48e7d"

URI_x86_64_v2_yubihsm-connector = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yubihsm-connector-3.0.5-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yubihsm-connector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yubihsm-connector}"
SRC_URI[x86_64_v2_yubihsm-connector.sha256sum] = "79f54e0f6d9dff99fa0c8c70d554377859f8d70f5c2906a2fc30ff6b55fbb459"

URI_aarch64_yubihsm-connector = "${EPEL_MIRROR}/aarch64/Packages/y/yubihsm-connector-3.0.5-12.el10_2.aarch64.rpm;name=aarch64_yubihsm-connector;unpack=0"
SRC_URI:append = " ${URI_aarch64_yubihsm-connector}"
SRC_URI[aarch64_yubihsm-connector.sha256sum] = "5959f4361b35be837097440a6092c84eb8741a5523ac2e9a8dcf650dbefbbf67"

RDEPENDS:yubihsm-connector = " \
 bash \
 glibc \
 libusb1 \
 systemd \
 "
