# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-ishidawataru-sctp"
PV = "0"
PR = "0.17.20220917git9a39160.el10_0"
PACKAGES = " \
 golang-github-ishidawataru-sctp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-ishidawataru-sctp-0-0.17.20220917git9a39160.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f64633c697b86d929eeb245241f8435b02d875b33e56d9a1dd79acae479ccd5f"

URI_aarch64_golang-github-ishidawataru-sctp-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-ishidawataru-sctp-devel-0-0.17.20220917git9a39160.el10_0.noarch.rpm;name=aarch64_golang-github-ishidawataru-sctp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-ishidawataru-sctp-devel}"
SRC_URI[aarch64_golang-github-ishidawataru-sctp-devel.sha256sum] = "acb31071a7ef40b2c5bcadf14d013c3217623e803e15660a7002795c50672512"

RDEPENDS:golang-github-ishidawataru-sctp-devel = " \
 go-filesystem \
 "
