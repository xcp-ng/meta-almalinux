# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-channel"
PV = "2.5.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-async-channel+default-devel \
 rust-async-channel+portable-atomic-devel \
 rust-async-channel+std-devel \
 rust-async-channel-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-channel-2.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ee978d3fc37e040a504f761e303a413ebe48972f3e679f008f97461d8cd3c4f"

URI_x86_64_v2_rust-async-channel+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-channel+default-devel-2.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-channel+default-devel}"
SRC_URI[x86_64_v2_rust-async-channel+default-devel.sha256sum] = "696bfa5f12f749b35ceed4761d08d287c82a9cde9bffbd9bcbca06b16698ba9f"

URI_x86_64_v2_rust-async-channel+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-channel+portable-atomic-devel-2.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-channel+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-channel+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-async-channel+portable-atomic-devel.sha256sum] = "5887b35d1967de25bd1fcdbcb01427d464d534a5bf094d35530a550c75471e57"

URI_x86_64_v2_rust-async-channel+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-channel+std-devel-2.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-channel+std-devel}"
SRC_URI[x86_64_v2_rust-async-channel+std-devel.sha256sum] = "930dbc09acd8f3eac31e7115e2d4a4fa86710a7dad354dd4060f854de6059736"

URI_x86_64_v2_rust-async-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-channel-devel-2.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-channel-devel}"
SRC_URI[x86_64_v2_rust-async-channel-devel.sha256sum] = "250aa028855546c14c47d6ad30b32acc0b3e054be446574c4b3aeae2715f2139"

URI_aarch64_rust-async-channel+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-channel+default-devel-2.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-async-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-channel+default-devel}"
SRC_URI[aarch64_rust-async-channel+default-devel.sha256sum] = "15f85d629ab5fe695e64b82042ad87c7cdae071771d8c720ab016336ba6042ad"

URI_aarch64_rust-async-channel+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-channel+portable-atomic-devel-2.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-async-channel+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-channel+portable-atomic-devel}"
SRC_URI[aarch64_rust-async-channel+portable-atomic-devel.sha256sum] = "8a9faa7bf3b321724abea85319fc4cc8ad0a7c7134b503a8dc3ed2f627dad134"

URI_aarch64_rust-async-channel+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-channel+std-devel-2.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-async-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-channel+std-devel}"
SRC_URI[aarch64_rust-async-channel+std-devel.sha256sum] = "196d33cd5be9fda8e32603ee898e81f6085877e4048150297f86913c1bf1f5c4"

URI_aarch64_rust-async-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-channel-devel-2.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-async-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-channel-devel}"
SRC_URI[aarch64_rust-async-channel-devel.sha256sum] = "1ee0309df65520f0eae63bf52133289c308b0374edad64934e4cb1a334745a7f"

RDEPENDS:rust-async-channel+default-devel = " \
 cargo \
 rust-async-channel+std-devel \
 rust-async-channel-devel \
 "
RDEPENDS:rust-async-channel+portable-atomic-devel = " \
 cargo \
 rust-async-channel-devel \
 rust-concurrent-queue+portable-atomic-devel \
 rust-event-listener-strategy+portable-atomic-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-async-channel+std-devel = " \
 cargo \
 rust-async-channel-devel \
 rust-concurrent-queue+std-devel \
 rust-event-listener-strategy+std-devel \
 "
RDEPENDS:rust-async-channel-devel = " \
 cargo \
 rust \
 rust-concurrent-queue-devel \
 rust-event-listener-strategy-devel \
 rust-futures-core-devel \
 rust-pin-project-lite+default-devel \
 "
