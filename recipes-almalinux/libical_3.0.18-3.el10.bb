# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libical"
PV = "3.0.18"
PR = "3.el10"
PACKAGES = " \
 libical \
 libical-devel \
 libical-glib \
 libical-glib-devel \
 libical-glib-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libical-3.0.18-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31a9aa0e7b29c93a7c70709957ddd6742d1c67e2a667f63c2595f7188a4654e3"

URI_x86_64_v2_libical = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libical-3.0.18-3.el10.x86_64_v2.rpm;name=x86_64_v2_libical;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libical}"
SRC_URI[x86_64_v2_libical.sha256sum] = "9b1402d4c494d94c56b33f53b9327304105c560638f4d3d54d82bba74486b53b"

URI_x86_64_v2_libical-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libical-devel-3.0.18-3.el10.x86_64_v2.rpm;name=x86_64_v2_libical-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libical-devel}"
SRC_URI[x86_64_v2_libical-devel.sha256sum] = "36b1fca847b184717a04d2610a7e469a6f40cae568f6bde8b96962a2b430ce96"

URI_x86_64_v2_libical-glib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libical-glib-3.0.18-3.el10.x86_64_v2.rpm;name=x86_64_v2_libical-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libical-glib}"
SRC_URI[x86_64_v2_libical-glib.sha256sum] = "f8091c26ef65c36cd02a3602acc9fddc774f8b2f5a879d99b4bffa04d9413261"

URI_x86_64_v2_libical-glib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libical-glib-devel-3.0.18-3.el10.x86_64_v2.rpm;name=x86_64_v2_libical-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libical-glib-devel}"
SRC_URI[x86_64_v2_libical-glib-devel.sha256sum] = "33c80a3a92e8ab304c125d9443c4def69c3e60c79f0355fb566f4f8bd28fdc9f"

URI_x86_64_v2_libical-glib-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libical-glib-doc-3.0.18-3.el10.noarch.rpm;name=x86_64_v2_libical-glib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libical-glib-doc}"
SRC_URI[x86_64_v2_libical-glib-doc.sha256sum] = "11adbb2b84f10bd6a8556358be31132151f40899811d90d9be81ffbc89f01b95"

URI_aarch64_libical = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libical-3.0.18-3.el10.aarch64.rpm;name=aarch64_libical;unpack=0"
SRC_URI:append = " ${URI_aarch64_libical}"
SRC_URI[aarch64_libical.sha256sum] = "0ea859134fe0de21dba3753810d7e0adade71de1163db6203d5352ea8fedc5e8"

URI_aarch64_libical-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libical-devel-3.0.18-3.el10.aarch64.rpm;name=aarch64_libical-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libical-devel}"
SRC_URI[aarch64_libical-devel.sha256sum] = "4d1329f37a8db63a7b731d94a311f3f97b6dd293ca7f08674874572e3ba4dc9a"

URI_aarch64_libical-glib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libical-glib-3.0.18-3.el10.aarch64.rpm;name=aarch64_libical-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_libical-glib}"
SRC_URI[aarch64_libical-glib.sha256sum] = "04aa34fc1a53a62183eff3f594c65fb7a058e8d5abc730ebf4c08dd7a692ced9"

URI_aarch64_libical-glib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libical-glib-devel-3.0.18-3.el10.aarch64.rpm;name=aarch64_libical-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libical-glib-devel}"
SRC_URI[aarch64_libical-glib-devel.sha256sum] = "fe0390e288d1aa2d0046d84403fd3dc8003dd6baf531fe9c7e88fa63bedc4a91"

URI_aarch64_libical-glib-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libical-glib-doc-3.0.18-3.el10.noarch.rpm;name=aarch64_libical-glib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libical-glib-doc}"
SRC_URI[aarch64_libical-glib-doc.sha256sum] = "11adbb2b84f10bd6a8556358be31132151f40899811d90d9be81ffbc89f01b95"

RDEPENDS:libical = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 tzdata \
 "
RDEPENDS:libical-devel = " \
 cmake-filesystem \
 libical \
 libicu-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libical-glib = " \
 glib2 \
 glibc \
 libical \
 "
RDEPENDS:libical-glib-devel = " \
 glib2-devel \
 libical-devel \
 libical-glib \
 pkgconf-pkg-config \
 "
RDEPENDS:libical-glib-doc = " \
 "
