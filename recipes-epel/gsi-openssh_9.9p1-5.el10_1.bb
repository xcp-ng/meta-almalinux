# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gsi-openssh"
PV = "9.9p1"
PR = "5.el10_1"
PACKAGES = " \
 gsi-openssh \
 gsi-openssh-clients \
 gsi-openssh-keysign \
 gsi-openssh-server \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gsi-openssh-9.9p1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "427cf48cf1f86861eb2a50487071961f3d61e21d5ac6e46de71d2b8eb961e34b"

URI_x86_64_v2_gsi-openssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-9.9p1-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh}"
SRC_URI[x86_64_v2_gsi-openssh.sha256sum] = "5f6cbef4546912fbffba73c89e70c3bd8f19035a4cdd7382716d4746d8ae7144"

URI_x86_64_v2_gsi-openssh-clients = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-clients-9.9p1-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh-clients}"
SRC_URI[x86_64_v2_gsi-openssh-clients.sha256sum] = "a7914a319fb5893e9f9918c0a975950c6f0a3b87f3bafc856e78b294996b6b72"

URI_x86_64_v2_gsi-openssh-keysign = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-keysign-9.9p1-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh-keysign}"
SRC_URI[x86_64_v2_gsi-openssh-keysign.sha256sum] = "7c9aac2813d0d5d7edb7c30a9a486d00d58f0dd2359f4b955c815d2c22ddbfe6"

URI_x86_64_v2_gsi-openssh-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-server-9.9p1-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh-server}"
SRC_URI[x86_64_v2_gsi-openssh-server.sha256sum] = "e9a96c61fbce79e00fc4f3f7bfb0c39ee189a560698e4550dce3650f8c81b07b"

URI_aarch64_gsi-openssh = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-9.9p1-5.el10_1.aarch64.rpm;name=aarch64_gsi-openssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh}"
SRC_URI[aarch64_gsi-openssh.sha256sum] = "6cab2d3997a24591f4ac3e5eebe4a6eb809326bb2c720b9162fc4d7a78441b85"

URI_aarch64_gsi-openssh-clients = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-clients-9.9p1-5.el10_1.aarch64.rpm;name=aarch64_gsi-openssh-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh-clients}"
SRC_URI[aarch64_gsi-openssh-clients.sha256sum] = "996b50886f8172549f77997be8e2134bd0703cd72ff311f73811cddcb3540f43"

URI_aarch64_gsi-openssh-keysign = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-keysign-9.9p1-5.el10_1.aarch64.rpm;name=aarch64_gsi-openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh-keysign}"
SRC_URI[aarch64_gsi-openssh-keysign.sha256sum] = "ace0e63529544940bd8a8aa4c8cf5b578e6a6c9b45c718233aa8f46d4e33fa31"

URI_aarch64_gsi-openssh-server = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-server-9.9p1-5.el10_1.aarch64.rpm;name=aarch64_gsi-openssh-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh-server}"
SRC_URI[aarch64_gsi-openssh-server.sha256sum] = "aa85b8d376f3e58af88d3fa745d93a5f8e02d4bbabc55bfe8509bbfe5a174812"

RDEPENDS:gsi-openssh = " \
 audit-libs \
 glibc \
 libgcc \
 libselinux \
 openssl-libs \
 util-linux \
 "
RDEPENDS:gsi-openssh-clients = " \
 crypto-policies \
 glibc \
 globus-gssapi-gsi \
 gsi-openssh \
 libedit \
 libfido2 \
 libgcc \
 libselinux \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:gsi-openssh-keysign = " \
 glibc \
 gsi-openssh \
 libgcc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:gsi-openssh-server = " \
 audit-libs \
 bash \
 crypto-policies \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 gsi-openssh \
 libgcc \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam \
 pam-libs \
 policycoreutils-python-utils \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
