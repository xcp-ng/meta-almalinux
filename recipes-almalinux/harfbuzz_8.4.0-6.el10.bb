# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "harfbuzz"
PV = "8.4.0"
PR = "6.el10"
PACKAGES = " \
 harfbuzz \
 harfbuzz-cairo \
 harfbuzz-devel \
 harfbuzz-icu \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/harfbuzz-8.4.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d8596aad6cf9a09d0f77c13f4909e8deaccf822a98187a366682d1544705da8"

URI_x86_64_v2_harfbuzz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/harfbuzz-8.4.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_harfbuzz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_harfbuzz}"
SRC_URI[x86_64_v2_harfbuzz.sha256sum] = "587b44404de519c23a390c5b92b949df490d1c0d16864a3ee550a31ae5023041"

URI_x86_64_v2_harfbuzz-cairo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/harfbuzz-cairo-8.4.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_harfbuzz-cairo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_harfbuzz-cairo}"
SRC_URI[x86_64_v2_harfbuzz-cairo.sha256sum] = "409f6deae01f43ac842dfe0286a44b1b0fe778579acd2e62efb18cd2d57e4cad"

URI_x86_64_v2_harfbuzz-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/harfbuzz-devel-8.4.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_harfbuzz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_harfbuzz-devel}"
SRC_URI[x86_64_v2_harfbuzz-devel.sha256sum] = "a15b3d5ea977929219e9d693716a7622578534fd6a0993177910c6868cdbd0a7"

URI_x86_64_v2_harfbuzz-icu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/harfbuzz-icu-8.4.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_harfbuzz-icu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_harfbuzz-icu}"
SRC_URI[x86_64_v2_harfbuzz-icu.sha256sum] = "b0cca69752e15a5fe63ea03598fbfa8a77e0911857405971089a09c30426b353"

URI_aarch64_harfbuzz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/harfbuzz-8.4.0-6.el10.aarch64.rpm;name=aarch64_harfbuzz;unpack=0"
SRC_URI:append = " ${URI_aarch64_harfbuzz}"
SRC_URI[aarch64_harfbuzz.sha256sum] = "25db5632bda3fa610400142f0d424674f6ace45370a2e0b235f048b57a621aaa"

URI_aarch64_harfbuzz-cairo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/harfbuzz-cairo-8.4.0-6.el10.aarch64.rpm;name=aarch64_harfbuzz-cairo;unpack=0"
SRC_URI:append = " ${URI_aarch64_harfbuzz-cairo}"
SRC_URI[aarch64_harfbuzz-cairo.sha256sum] = "7061d2cd432595b15822734a05b2e6b3589b32af9ef726d4c6747ab64d51379b"

URI_aarch64_harfbuzz-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/harfbuzz-devel-8.4.0-6.el10.aarch64.rpm;name=aarch64_harfbuzz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_harfbuzz-devel}"
SRC_URI[aarch64_harfbuzz-devel.sha256sum] = "70aabdec8354b7c24e080ad0da4102385bfffca0694cd7ec476de398dbf5ddb3"

URI_aarch64_harfbuzz-icu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/harfbuzz-icu-8.4.0-6.el10.aarch64.rpm;name=aarch64_harfbuzz-icu;unpack=0"
SRC_URI:append = " ${URI_aarch64_harfbuzz-icu}"
SRC_URI[aarch64_harfbuzz-icu.sha256sum] = "cdfa2a535934cc60b0f269edeed39377e901a4233641e113beb65406b50c0137"

RDEPENDS:harfbuzz = " \
 freetype \
 glib2 \
 glibc \
 graphite2 \
 "
RDEPENDS:harfbuzz-cairo = " \
 cairo \
 glibc \
 harfbuzz \
 "
RDEPENDS:harfbuzz-devel = " \
 cairo \
 cairo-devel \
 freetype \
 freetype-devel \
 glib2 \
 glib2-devel \
 glibc \
 graphite2-devel \
 harfbuzz \
 harfbuzz-cairo \
 harfbuzz-icu \
 libicu-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:harfbuzz-icu = " \
 glibc \
 harfbuzz \
 libicu \
 "
