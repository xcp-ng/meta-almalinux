# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdevelop-pg-qt"
PV = "2.4.0"
PR = "2.el10_2"
PACKAGES = " \
 kdevelop-pg-qt \
 kdevelop-pg-qt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdevelop-pg-qt-2.4.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03f17056e095954bd5ae993b1864b04ac65a9f7bfc34c0e4d356ed637a125649"

URI_x86_64_v2_kdevelop-pg-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdevelop-pg-qt-2.4.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdevelop-pg-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdevelop-pg-qt}"
SRC_URI[x86_64_v2_kdevelop-pg-qt.sha256sum] = "28bc2c0dff4e2ffcc58e3a3093bc1e0af03153050c6018c00546a99eb843cd44"

URI_x86_64_v2_kdevelop-pg-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdevelop-pg-qt-devel-2.4.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdevelop-pg-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdevelop-pg-qt-devel}"
SRC_URI[x86_64_v2_kdevelop-pg-qt-devel.sha256sum] = "b25b6c26d0619b4f7a1ee1b544e0eadf108d9cec5f491ed8789c9a864b9d9a07"

URI_aarch64_kdevelop-pg-qt = "${EPEL_MIRROR}/aarch64/Packages/k/kdevelop-pg-qt-2.4.0-2.el10_2.aarch64.rpm;name=aarch64_kdevelop-pg-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdevelop-pg-qt}"
SRC_URI[aarch64_kdevelop-pg-qt.sha256sum] = "584dbf2c02151056212ae5abf7e487450fa2214e79ab0c7b25672c9a11f961b6"

URI_aarch64_kdevelop-pg-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdevelop-pg-qt-devel-2.4.0-2.el10_2.aarch64.rpm;name=aarch64_kdevelop-pg-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdevelop-pg-qt-devel}"
SRC_URI[aarch64_kdevelop-pg-qt-devel.sha256sum] = "1843faceeb56360e1bbfb7a148993db39d1baaa1b7a2ced756bb4ff23a958e05"

RDEPENDS:kdevelop-pg-qt = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kdevelop-pg-qt-devel = " \
 cmake-filesystem \
 kdevelop-pg-qt \
 "
