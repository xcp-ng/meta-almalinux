# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rstest_macros0.23"
PV = "0.23.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-rstest_macros0.23+async-timeout-devel \
 rust-rstest_macros0.23+crate-name-devel \
 rust-rstest_macros0.23+default-devel \
 rust-rstest_macros0.23-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rstest_macros0.23-0.23.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72a089b54607cfaf9cfa199a824613b4a8fffcfb7f265166964961eedb0e1c3b"

URI_x86_64_v2_rust-rstest_macros0.23+async-timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest_macros0.23+async-timeout-devel-0.23.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest_macros0.23+async-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest_macros0.23+async-timeout-devel}"
SRC_URI[x86_64_v2_rust-rstest_macros0.23+async-timeout-devel.sha256sum] = "56be70413b3249d2d443866c33c5c5f5e378a688774a965db33833bb483c46a9"

URI_x86_64_v2_rust-rstest_macros0.23+crate-name-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest_macros0.23+crate-name-devel-0.23.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest_macros0.23+crate-name-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest_macros0.23+crate-name-devel}"
SRC_URI[x86_64_v2_rust-rstest_macros0.23+crate-name-devel.sha256sum] = "7753627e49b15984677d943310d966c7c3b4b9e036e0054b3ae3fc6288c7ddf4"

URI_x86_64_v2_rust-rstest_macros0.23+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest_macros0.23+default-devel-0.23.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest_macros0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest_macros0.23+default-devel}"
SRC_URI[x86_64_v2_rust-rstest_macros0.23+default-devel.sha256sum] = "fb121ddb7a4f4b123b1fb5f43cb10cb30e014cc252b7176a39cd04bc86c11d45"

URI_x86_64_v2_rust-rstest_macros0.23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest_macros0.23-devel-0.23.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest_macros0.23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest_macros0.23-devel}"
SRC_URI[x86_64_v2_rust-rstest_macros0.23-devel.sha256sum] = "2d1c6b4afdbb6e6f5c4651da969cb401b9ce8cd27fe44afa8bf03f5f4952a39b"

URI_aarch64_rust-rstest_macros0.23+async-timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest_macros0.23+async-timeout-devel-0.23.0-1.el10_1.noarch.rpm;name=aarch64_rust-rstest_macros0.23+async-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest_macros0.23+async-timeout-devel}"
SRC_URI[aarch64_rust-rstest_macros0.23+async-timeout-devel.sha256sum] = "430cec22523dbc7d0bd1577df9dfe2407348169975ded74d506187df068721d8"

URI_aarch64_rust-rstest_macros0.23+crate-name-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest_macros0.23+crate-name-devel-0.23.0-1.el10_1.noarch.rpm;name=aarch64_rust-rstest_macros0.23+crate-name-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest_macros0.23+crate-name-devel}"
SRC_URI[aarch64_rust-rstest_macros0.23+crate-name-devel.sha256sum] = "44a36381b8cae7abd2f16df597152e9265dfd08823c9b6e602e2f3cdaed83eef"

URI_aarch64_rust-rstest_macros0.23+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest_macros0.23+default-devel-0.23.0-1.el10_1.noarch.rpm;name=aarch64_rust-rstest_macros0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest_macros0.23+default-devel}"
SRC_URI[aarch64_rust-rstest_macros0.23+default-devel.sha256sum] = "736e65e11a6bff60946b0e3dda73fb93056a84ef717e94f544fe4d3e1cfe88d3"

URI_aarch64_rust-rstest_macros0.23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest_macros0.23-devel-0.23.0-1.el10_1.noarch.rpm;name=aarch64_rust-rstest_macros0.23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest_macros0.23-devel}"
SRC_URI[aarch64_rust-rstest_macros0.23-devel.sha256sum] = "fc9799c8ad906464ff4c16d383f1ad3d9b66556f1f0b5e397ad4a8b93533ad6c"

RDEPENDS:rust-rstest_macros0.23+async-timeout-devel = " \
 cargo \
 rust-rstest_macros0.23-devel \
 "
RDEPENDS:rust-rstest_macros0.23+crate-name-devel = " \
 cargo \
 rust-proc-macro-crate+default-devel \
 rust-rstest_macros0.23-devel \
 "
RDEPENDS:rust-rstest_macros0.23+default-devel = " \
 cargo \
 rust-rstest_macros0.23+async-timeout-devel \
 rust-rstest_macros0.23+crate-name-devel \
 rust-rstest_macros0.23-devel \
 "
RDEPENDS:rust-rstest_macros0.23-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-glob+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-regex+default-devel \
 rust-relative-path+default-devel \
 rust-rustc_version+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+visit-devel \
 rust-syn+visit-mut-devel \
 rust-unicode-ident+default-devel \
 "
