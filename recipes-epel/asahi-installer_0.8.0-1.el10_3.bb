# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "asahi-installer"
PV = "0.8.0"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 python3-asahi_firmware \
"
PACKAGES:aarch64 = " \
 asahi-installer-package \
 python3-asahi_firmware \
"

URI_src = "${EPELSRC_MIRROR}/Packages/a/asahi-installer-0.8.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f50272987eb58a4b4f09afb6f10c2d76c45c4dd2978a855966ae2817b2060efd"

URI_x86_64_v2_python3-asahi_firmware = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-asahi_firmware-0.8.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-asahi_firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-asahi_firmware}"
SRC_URI[x86_64_v2_python3-asahi_firmware.sha256sum] = "dc9fb9bf4ff1f3b9dd59ef0a38a4bed11a57b9b3dbe5524841d06870ab5645d8"

URI_aarch64_asahi-installer-package = "${EPEL_MIRROR}/aarch64/Packages/a/asahi-installer-package-0.8.0-1.el10_3.aarch64.rpm;name=aarch64_asahi-installer-package;unpack=0"
SRC_URI:append = " ${URI_aarch64_asahi-installer-package}"
SRC_URI[aarch64_asahi-installer-package.sha256sum] = "fbf312bcaff4fe6d4a7fa504b4c3c7339b3c06867935b0774706853cbebb2519"

URI_aarch64_python3-asahi_firmware = "${EPEL_MIRROR}/aarch64/Packages/p/python3-asahi_firmware-0.8.0-1.el10_3.aarch64.rpm;name=aarch64_python3-asahi_firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-asahi_firmware}"
SRC_URI[aarch64_python3-asahi_firmware.sha256sum] = "eeee0498635c805f04bae4eee6b23cea044a628f1b0f017131c5750f81a0e145"

RDEPENDS:python3-asahi_firmware = " \
 lzfse-libs \
 python3 \
 python3-asn1 \
 tar \
 "
RDEPENDS:asahi-installer-package = " \
 "
