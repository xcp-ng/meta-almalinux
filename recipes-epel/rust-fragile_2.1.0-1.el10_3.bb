# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fragile"
PV = "2.1.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-fragile+default-devel \
 rust-fragile+future-devel \
 rust-fragile+futures-core-devel \
 rust-fragile+slab-devel \
 rust-fragile+stream-devel \
 rust-fragile-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-fragile-2.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "953c8c2723cb0d5ad3f1273afaa08f66c25a728e3dac69259cf25303b64d5f59"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile+default-devel-2.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fragile+default-devel.sha256sum] = "0aae2f6e9e6a01206e1cd167cacfde332913da11be2489c61bc247f2f42eeb93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile+future-devel-2.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile+future-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fragile+future-devel.sha256sum] = "c89972a302e9ff38a0f79a9c189e9781cdc9d38bf044df8a426a64ba02d941e6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile+futures-core-devel-2.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile+futures-core-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fragile+futures-core-devel.sha256sum] = "5068102858967e15a8b737b3906a08f7a17b65e8a6d9f870456b25d9a5c57288"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile+slab-devel-2.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile+slab-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fragile+slab-devel.sha256sum] = "993554ba0be994ec70b44e68fd3e0966512b6ca7d1d4ba5fd3d4060caa4690e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile+stream-devel-2.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile+stream-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fragile+stream-devel.sha256sum] = "52d8d0a3d83ab1768aafed2e68108c987bc29e9962655474cf9650f115506889"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile-devel-2.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fragile-devel.sha256sum] = "e95257429ef38d385116b4469212efbad76da7572fa49bb289265bed14bfa534"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile+default-devel-2.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-fragile+default-devel;unpack=0"
SRC_URI[aarch64_rust-fragile+default-devel.sha256sum] = "46bde05193800c80bd992cf647dbf71ecd6387960408203dec2c706937ba2461"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile+future-devel-2.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-fragile+future-devel;unpack=0"
SRC_URI[aarch64_rust-fragile+future-devel.sha256sum] = "288c13fb976e70fb6f63ce8b3cc88fa30c14971d4d74533c739d049b66513dc2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile+futures-core-devel-2.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-fragile+futures-core-devel;unpack=0"
SRC_URI[aarch64_rust-fragile+futures-core-devel.sha256sum] = "34780284d102992ce59c6734eb21e26983744302bea4179ac8e1cd3ff1d04338"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile+slab-devel-2.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-fragile+slab-devel;unpack=0"
SRC_URI[aarch64_rust-fragile+slab-devel.sha256sum] = "ee5a466dc30435f096f005ac2b23096c6eddf42ff63eab5d325172ebe153fa47"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile+stream-devel-2.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-fragile+stream-devel;unpack=0"
SRC_URI[aarch64_rust-fragile+stream-devel.sha256sum] = "9282c80e260c2d7db2bab63d51e97fbd929bebba608bc3e6280ba7db3da4e916"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile-devel-2.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-fragile-devel;unpack=0"
SRC_URI[aarch64_rust-fragile-devel.sha256sum] = "db3da2646876278338a72536d6550e3c0d488d55bcfa9d06f3a24ecf041a6d47"

RDEPENDS:rust-fragile+default-devel = " \
 cargo \
 rust-fragile+stream-devel \
 rust-fragile-devel \
 "
RDEPENDS:rust-fragile+future-devel = " \
 cargo \
 rust-fragile-devel \
 "
RDEPENDS:rust-fragile+futures-core-devel = " \
 cargo \
 rust-fragile-devel \
 rust-futures-core+default-devel \
 "
RDEPENDS:rust-fragile+slab-devel = " \
 cargo \
 rust-fragile-devel \
 rust-slab+default-devel \
 "
RDEPENDS:rust-fragile+stream-devel = " \
 cargo \
 rust-fragile+future-devel \
 rust-fragile+futures-core-devel \
 rust-fragile-devel \
 "
RDEPENDS:rust-fragile-devel = " \
 cargo \
 rust \
 "
