# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jdepend"
PV = "2.10"
PR = "12.el10"
PACKAGES = " \
 jdepend \
 jdepend-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jdepend-2.10-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10c4fbfd373f0335248a97be371e7117a483fecf8b3cc40d4b50dc1108e76f1c"

URI_x86_64_v2_jdepend = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jdepend-2.10-12.el10.noarch.rpm;name=x86_64_v2_jdepend;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jdepend}"
SRC_URI[x86_64_v2_jdepend.sha256sum] = "6f2b7cad50387e61d87b10ab60f663a789c2c0b139bc1dae11dbba4514e0e52e"

URI_x86_64_v2_jdepend-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jdepend-javadoc-2.10-12.el10.noarch.rpm;name=x86_64_v2_jdepend-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jdepend-javadoc}"
SRC_URI[x86_64_v2_jdepend-javadoc.sha256sum] = "830ad7482b508b773947632f3c890ca859e9d4282f5ac200e52e440ed18fd856"

URI_aarch64_jdepend = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jdepend-2.10-12.el10.noarch.rpm;name=aarch64_jdepend;unpack=0"
SRC_URI:append = " ${URI_aarch64_jdepend}"
SRC_URI[aarch64_jdepend.sha256sum] = "6f2b7cad50387e61d87b10ab60f663a789c2c0b139bc1dae11dbba4514e0e52e"

URI_aarch64_jdepend-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jdepend-javadoc-2.10-12.el10.noarch.rpm;name=aarch64_jdepend-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jdepend-javadoc}"
SRC_URI[aarch64_jdepend-javadoc.sha256sum] = "830ad7482b508b773947632f3c890ca859e9d4282f5ac200e52e440ed18fd856"

RDEPENDS:jdepend = " \
 javapackages-filesystem \
 "
RDEPENDS:jdepend-javadoc = " \
 javapackages-filesystem \
 "
