# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-List-UtilsBy"
PV = "0.12"
PR = "10.el10_0"
PACKAGES = " \
 perl-List-UtilsBy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-List-UtilsBy-0.12-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fbf976da0e98408e288a92e8aebcfa89dacc72540a96623ea0dae9594e9e1a3"

URI_x86_64_v2_perl-List-UtilsBy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-List-UtilsBy-0.12-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-List-UtilsBy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-List-UtilsBy}"
SRC_URI[x86_64_v2_perl-List-UtilsBy.sha256sum] = "bc8187ca4fbb2071c8d5b865236ae37f270457a45aedda23763014717e2290e2"

URI_aarch64_perl-List-UtilsBy = "${EPEL_MIRROR}/aarch64/Packages/p/perl-List-UtilsBy-0.12-10.el10_0.noarch.rpm;name=aarch64_perl-List-UtilsBy;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-List-UtilsBy}"
SRC_URI[aarch64_perl-List-UtilsBy.sha256sum] = "572f4519d56075eb4455419f643a7dbef8755d6e591d74070b41e18875c0223a"

RDEPENDS:perl-List-UtilsBy = " \
 perl-Exporter \
 perl-libs \
 "
