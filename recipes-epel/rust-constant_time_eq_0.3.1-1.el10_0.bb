# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-constant_time_eq"
PV = "0.3.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-constant_time_eq+default-devel \
 rust-constant_time_eq-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-constant_time_eq-0.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4005f29695c4e08643e5a8e0188d7c1e133dffd2bef635b291e557de6c56303d"

URI_x86_64_v2_rust-constant_time_eq+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-constant_time_eq+default-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-constant_time_eq+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-constant_time_eq+default-devel}"
SRC_URI[x86_64_v2_rust-constant_time_eq+default-devel.sha256sum] = "228bcbdb01e953baa9d71a4a2933f379d38b2e9a4a95aca0f50db76b099bd677"

URI_x86_64_v2_rust-constant_time_eq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-constant_time_eq-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-constant_time_eq-devel}"
SRC_URI[x86_64_v2_rust-constant_time_eq-devel.sha256sum] = "91d6f3880eaa9d611039be2ae14d9ad02092000fc91bb1c8ffde2fe08eedf9c7"

URI_aarch64_rust-constant_time_eq+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-constant_time_eq+default-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-constant_time_eq+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-constant_time_eq+default-devel}"
SRC_URI[aarch64_rust-constant_time_eq+default-devel.sha256sum] = "de13a276bf54a815445ffa8091fab208f247862234d2cfa45311d9b15dd4eb77"

URI_aarch64_rust-constant_time_eq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-constant_time_eq-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-constant_time_eq-devel}"
SRC_URI[aarch64_rust-constant_time_eq-devel.sha256sum] = "157afb71aeec02f7cc989ac35dba06a6789cc86a12bbe3a3ea52d03c88bc28c9"

RDEPENDS:rust-constant_time_eq+default-devel = " \
 cargo \
 rust-constant_time_eq-devel \
 "
RDEPENDS:rust-constant_time_eq-devel = " \
 cargo \
 rust \
 "
