# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "the_foundation"
PV = "1.10.1"
PR = "2.el10_2"
PACKAGES = " \
 the_foundation \
 the_foundation-devel \
 the_foundation-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/the_foundation-1.10.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5a80223c79d3abe90311a02d28ba2c6741ea23b80d1f9c9fa2050d09e77f06e"

URI_x86_64_v2_the_foundation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/the_foundation-1.10.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_the_foundation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_the_foundation}"
SRC_URI[x86_64_v2_the_foundation.sha256sum] = "7777e0cbd4a3002db8498382058287b426b4d802078a6349dddd5d7405edd34d"

URI_x86_64_v2_the_foundation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/the_foundation-devel-1.10.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_the_foundation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_the_foundation-devel}"
SRC_URI[x86_64_v2_the_foundation-devel.sha256sum] = "131f42777213abbc8c1167e373294535ffd39ae78401c6751b2baca107e5192f"

URI_x86_64_v2_the_foundation-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/the_foundation-doc-1.10.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_the_foundation-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_the_foundation-doc}"
SRC_URI[x86_64_v2_the_foundation-doc.sha256sum] = "d30da5a0ae83b66e37e30dad8ff9fbdad1c6dad04fe877fa76bf263cd3f678ac"

URI_aarch64_the_foundation = "${EPEL_MIRROR}/aarch64/Packages/t/the_foundation-1.10.1-2.el10_2.aarch64.rpm;name=aarch64_the_foundation;unpack=0"
SRC_URI:append = " ${URI_aarch64_the_foundation}"
SRC_URI[aarch64_the_foundation.sha256sum] = "909947c6ada6ace7f0606e3363bb761675708a4bd94cfc67a83b362a4b014015"

URI_aarch64_the_foundation-devel = "${EPEL_MIRROR}/aarch64/Packages/t/the_foundation-devel-1.10.1-2.el10_2.aarch64.rpm;name=aarch64_the_foundation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_the_foundation-devel}"
SRC_URI[aarch64_the_foundation-devel.sha256sum] = "bbec4664b5b540bcf95cd282ab52a5db562bb62c1fe899e564055552920f34bf"

URI_aarch64_the_foundation-doc = "${EPEL_MIRROR}/aarch64/Packages/t/the_foundation-doc-1.10.1-2.el10_2.noarch.rpm;name=aarch64_the_foundation-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_the_foundation-doc}"
SRC_URI[aarch64_the_foundation-doc.sha256sum] = "0cc8e0acbdbcdba081cd868665c924867ff02ab1efb0e1ca17e4ade23945043b"

RDEPENDS:the_foundation = " \
 glibc \
 libunistring \
 openssl-libs \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:the_foundation-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 the_foundation \
 "
RDEPENDS:the_foundation-doc = " \
 "
