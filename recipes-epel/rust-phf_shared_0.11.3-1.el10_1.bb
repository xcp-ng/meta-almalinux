# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf_shared"
PV = "0.11.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-phf_shared+default-devel \
 rust-phf_shared+std-devel \
 rust-phf_shared+uncased-devel \
 rust-phf_shared+unicase-devel \
 rust-phf_shared-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf_shared-0.11.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87119f633ac6839c1e0a54c1533f472a24daacb9388419004f8a3cd3c7e407c3"

URI_x86_64_v2_rust-phf_shared+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared+default-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared+default-devel}"
SRC_URI[x86_64_v2_rust-phf_shared+default-devel.sha256sum] = "5aafab8d43e0bf1e846af614a03908bc10f453834d03413ef02c1f1ab7f2e001"

URI_x86_64_v2_rust-phf_shared+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared+std-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared+std-devel}"
SRC_URI[x86_64_v2_rust-phf_shared+std-devel.sha256sum] = "901d0ace094c2e5d78567fcb27de8dd51447ee7ebe48604ff70f93a6f12880e4"

URI_x86_64_v2_rust-phf_shared+uncased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared+uncased-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared+uncased-devel}"
SRC_URI[x86_64_v2_rust-phf_shared+uncased-devel.sha256sum] = "9a78aaeb73cf49572d82cd65ce758602b8d4b8c630098189b1f6a78b0fbedbbf"

URI_x86_64_v2_rust-phf_shared+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared+unicase-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared+unicase-devel}"
SRC_URI[x86_64_v2_rust-phf_shared+unicase-devel.sha256sum] = "9c0731a85ebf72150b4d655c88cb6a84ed2d571eb97d89b847436bd030d565fa"

URI_x86_64_v2_rust-phf_shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared-devel}"
SRC_URI[x86_64_v2_rust-phf_shared-devel.sha256sum] = "8a51e6e78fecc0da3b788f2066872c6c4a6b13eb8a8bb8264c9d7b2cb9f8d0a4"

URI_aarch64_rust-phf_shared+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared+default-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf_shared+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared+default-devel}"
SRC_URI[aarch64_rust-phf_shared+default-devel.sha256sum] = "68487a3adf3280ea5d8abdb12a20966c25568908176ec649946098fa2cb1b0e1"

URI_aarch64_rust-phf_shared+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared+std-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf_shared+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared+std-devel}"
SRC_URI[aarch64_rust-phf_shared+std-devel.sha256sum] = "74c4bf8790df458e31e8dd4b6feb374d21139a07d944dc4fc4c2dc4b7af8353e"

URI_aarch64_rust-phf_shared+uncased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared+uncased-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf_shared+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared+uncased-devel}"
SRC_URI[aarch64_rust-phf_shared+uncased-devel.sha256sum] = "b926ad89436a94b0e8eeda8aa9f9d337d95cd8f12b4cf6882e61985e05925dea"

URI_aarch64_rust-phf_shared+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared+unicase-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf_shared+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared+unicase-devel}"
SRC_URI[aarch64_rust-phf_shared+unicase-devel.sha256sum] = "2702d4fb23d31ec4e7689a2ca12b3f9e998f0fbf1c87d537954f4a73e3e948ea"

URI_aarch64_rust-phf_shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf_shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared-devel}"
SRC_URI[aarch64_rust-phf_shared-devel.sha256sum] = "9cfb8b38829b0d194dbba35a1d0cceb5ff9c7334fb4df79f226d340868465d4f"

RDEPENDS:rust-phf_shared+default-devel = " \
 cargo \
 rust-phf_shared+std-devel \
 rust-phf_shared-devel \
 "
RDEPENDS:rust-phf_shared+std-devel = " \
 cargo \
 rust-phf_shared-devel \
 "
RDEPENDS:rust-phf_shared+uncased-devel = " \
 cargo \
 rust-phf_shared-devel \
 rust-uncased-devel \
 "
RDEPENDS:rust-phf_shared+unicase-devel = " \
 cargo \
 rust-phf_shared-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-phf_shared-devel = " \
 cargo \
 rust \
 rust-siphasher+default-devel \
 "
