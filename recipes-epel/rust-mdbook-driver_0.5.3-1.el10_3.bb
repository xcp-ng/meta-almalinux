# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mdbook-driver"
PV = "0.5.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-mdbook-driver+default-devel \
 rust-mdbook-driver+search-devel \
 rust-mdbook-driver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mdbook-driver-0.5.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a164b44a15217866d0a9072fe4f7c0c5391504bfe989bec0cff1352eabcb7aa8"

URI_x86_64_v2_rust-mdbook-driver+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-driver+default-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-driver+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-driver+default-devel}"
SRC_URI[x86_64_v2_rust-mdbook-driver+default-devel.sha256sum] = "b6eae8b2dabdbd2a9d32a9414098a0a4cbe1f4f8cac370e596748fad26eda4cc"

URI_x86_64_v2_rust-mdbook-driver+search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-driver+search-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-driver+search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-driver+search-devel}"
SRC_URI[x86_64_v2_rust-mdbook-driver+search-devel.sha256sum] = "c59e91ecc3a78c5a1def5e66644845104d68d00bc7d293f460637faf4b74c0a5"

URI_x86_64_v2_rust-mdbook-driver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-driver-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-driver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-driver-devel}"
SRC_URI[x86_64_v2_rust-mdbook-driver-devel.sha256sum] = "c652786021198f8561838cb15906309e0c169ab5c60021e278aaa4088ef875ca"

URI_aarch64_rust-mdbook-driver+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-driver+default-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-driver+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-driver+default-devel}"
SRC_URI[aarch64_rust-mdbook-driver+default-devel.sha256sum] = "6f7de20742d5ba12c8c6d8ec4172d27fe221b23a85f52656f68b0248e83de45e"

URI_aarch64_rust-mdbook-driver+search-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-driver+search-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-driver+search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-driver+search-devel}"
SRC_URI[aarch64_rust-mdbook-driver+search-devel.sha256sum] = "b4cb46f0db84b401631432c5e2b4ad375def26a02e1026cc41b11faab8b35fb5"

URI_aarch64_rust-mdbook-driver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-driver-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-driver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-driver-devel}"
SRC_URI[aarch64_rust-mdbook-driver-devel.sha256sum] = "abbddf61c9ef09a3de2112f40ec7da86a20ff3c00d3b489b1e4064540efc83ec"

RDEPENDS:rust-mdbook-driver+default-devel = " \
 cargo \
 rust-mdbook-driver-devel \
 "
RDEPENDS:rust-mdbook-driver+search-devel = " \
 cargo \
 rust-mdbook-driver-devel \
 rust-mdbook-html+search-devel \
 "
RDEPENDS:rust-mdbook-driver-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-indexmap+default-devel \
 rust-mdbook-core+default-devel \
 rust-mdbook-html+default-devel \
 rust-mdbook-markdown+default-devel \
 rust-mdbook-preprocessor+default-devel \
 rust-mdbook-renderer+default-devel \
 rust-mdbook-summary+default-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-shlex+default-devel \
 rust-tempfile+default-devel \
 rust-toml+default-devel \
 rust-topological-sort+default-devel \
 rust-tracing+default-devel \
 "
