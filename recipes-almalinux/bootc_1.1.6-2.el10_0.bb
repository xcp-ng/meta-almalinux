# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bootc"
PV = "1.1.6"
PR = "2.el10_0"
PACKAGES = " \
 bootc \
 system-reinstall-bootc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bootc-1.1.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2f76085f1ed3a947b964f54268d33fb3758ac27cda3246d3b2b1c83b0c780c2"

URI_x86_64_v2_bootc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bootc-1.1.6-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_bootc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bootc}"
SRC_URI[x86_64_v2_bootc.sha256sum] = "bf85e8e773b07e4e0ef44a36bc798c5ea4b3da8a9c6aa0431f3591c7b2b5e63d"

URI_x86_64_v2_system-reinstall-bootc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/system-reinstall-bootc-1.1.6-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_system-reinstall-bootc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_system-reinstall-bootc}"
SRC_URI[x86_64_v2_system-reinstall-bootc.sha256sum] = "de97c4519e6cef86ededfca9f80245f1a6dd9307870fe34e1cc12626a3ba269b"

URI_aarch64_bootc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bootc-1.1.6-2.el10_0.aarch64.rpm;name=aarch64_bootc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bootc}"
SRC_URI[aarch64_bootc.sha256sum] = "83236b818a5aca85740f50ac90b91ddde09c9c6ede52e0a07c58185e514913b5"

URI_aarch64_system-reinstall-bootc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/system-reinstall-bootc-1.1.6-2.el10_0.aarch64.rpm;name=aarch64_system-reinstall-bootc;unpack=0"
SRC_URI:append = " ${URI_aarch64_system-reinstall-bootc}"
SRC_URI[aarch64_system-reinstall-bootc.sha256sum] = "4636edcc8ef86103c915da3658a1536a3f09b08a87d1ae50fcd30b8d664ff85f"

RDEPENDS:bootc = " \
 bash \
 composefs \
 glib2 \
 glibc \
 libgcc \
 libzstd \
 openssl-libs \
 ostree \
 ostree-libs \
 podman \
 skopeo \
 zlib-ng-compat \
 "
RDEPENDS:system-reinstall-bootc = " \
 bash \
 glibc \
 libgcc \
 "
