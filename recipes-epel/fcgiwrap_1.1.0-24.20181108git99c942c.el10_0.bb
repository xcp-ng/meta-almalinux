# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fcgiwrap"
PV = "1.1.0"
PR = "24.20181108git99c942c.el10_0"
PACKAGES = " \
 fcgiwrap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fcgiwrap-1.1.0-24.20181108git99c942c.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6de1854f718bdf431c4048c167a2c34b00bc9d6ccb8c5ea16bece5d05eac0372"

URI_x86_64_v2_fcgiwrap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fcgiwrap-1.1.0-24.20181108git99c942c.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fcgiwrap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fcgiwrap}"
SRC_URI[x86_64_v2_fcgiwrap.sha256sum] = "708419e0d5455d2d23febbe339ad34eb7c1bef67dde0242163b6420f87585a6c"

URI_aarch64_fcgiwrap = "${EPEL_MIRROR}/aarch64/Packages/f/fcgiwrap-1.1.0-24.20181108git99c942c.el10_0.aarch64.rpm;name=aarch64_fcgiwrap;unpack=0"
SRC_URI:append = " ${URI_aarch64_fcgiwrap}"
SRC_URI[aarch64_fcgiwrap.sha256sum] = "ba34a99cf46a5fc5ac52b3d895a7473b40c1870ace63fce8e3e7e02769c5af64"

RDEPENDS:fcgiwrap = " \
 bash \
 fcgi \
 glibc \
 systemd \
 systemd-libs \
 "
