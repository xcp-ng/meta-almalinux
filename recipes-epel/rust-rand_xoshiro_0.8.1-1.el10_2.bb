# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_xoshiro"
PV = "0.8.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_xoshiro+default-devel \
 rust-rand_xoshiro+serde-devel \
 rust-rand_xoshiro-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rand_xoshiro-0.8.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "48684c22173414176d952901d2624072ebf6fd6b38dff499730da52d310f937b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro+default-devel-0.8.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand_xoshiro+default-devel.sha256sum] = "7c6d2d261cedf5bb0ef2bcc5390fddd230b4deb2261058372ecb8450098c4fd0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro+serde-devel-0.8.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand_xoshiro+serde-devel.sha256sum] = "102fbcfc94322eff70685861a1f69f646e633d83da2a5dc6899ddcfb21967b80"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro-devel-0.8.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand_xoshiro-devel.sha256sum] = "e6289fae93aaf680e187a5d6f042d6c2b3311cafe66135105f4d57380e846223"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro+default-devel-0.8.1-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xoshiro+default-devel;unpack=0"
SRC_URI[aarch64_rust-rand_xoshiro+default-devel.sha256sum] = "138f559e569a7778852ef26396a7f9e6c188d77319d567015cd42d41a7bd9acf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro+serde-devel-0.8.1-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xoshiro+serde-devel;unpack=0"
SRC_URI[aarch64_rust-rand_xoshiro+serde-devel.sha256sum] = "5d314b88cd382512076a9fb17f4ffbd34865fdac6244256baa2b0b90e54d0a0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro-devel-0.8.1-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xoshiro-devel;unpack=0"
SRC_URI[aarch64_rust-rand_xoshiro-devel.sha256sum] = "e3df192b69c4170c2dc1c29d81f8451fd34f4bd3e7c6cee087df53fc50e1ee32"

RDEPENDS:rust-rand_xoshiro+default-devel = " \
 cargo \
 rust-rand_xoshiro-devel \
 "
RDEPENDS:rust-rand_xoshiro+serde-devel = " \
 cargo \
 rust-rand_xoshiro-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_xoshiro-devel = " \
 cargo \
 rust \
 rust-rand_core+default-devel \
 "
