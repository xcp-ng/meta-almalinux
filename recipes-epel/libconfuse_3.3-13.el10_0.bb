# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libconfuse"
PV = "3.3"
PR = "13.el10_0"
PACKAGES = " \
 libconfuse \
 libconfuse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libconfuse-3.3-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48c85e9b99c8fc1681dc258ee043c9c15d4b30bde9d0143c1390759c0a5ac79d"

URI_x86_64_v2_libconfuse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libconfuse-3.3-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libconfuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libconfuse}"
SRC_URI[x86_64_v2_libconfuse.sha256sum] = "d65b909504fbe31a3d02a69294a6c06a3db1fbf3358dab94a4d2be0ecd1e3ca6"

URI_x86_64_v2_libconfuse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libconfuse-devel-3.3-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libconfuse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libconfuse-devel}"
SRC_URI[x86_64_v2_libconfuse-devel.sha256sum] = "064fd7478fa1255fa4e55463eec9fb8257c014a96bfc1886a4064cea33ac3ab8"

URI_aarch64_libconfuse = "${EPEL_MIRROR}/aarch64/Packages/l/libconfuse-3.3-13.el10_0.aarch64.rpm;name=aarch64_libconfuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_libconfuse}"
SRC_URI[aarch64_libconfuse.sha256sum] = "66fdd5bf8a1be6f2be4da04cd9ee3a223efcda93a507714ec65a091a102c019b"

URI_aarch64_libconfuse-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libconfuse-devel-3.3-13.el10_0.aarch64.rpm;name=aarch64_libconfuse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libconfuse-devel}"
SRC_URI[aarch64_libconfuse-devel.sha256sum] = "2f76e04dff78047620b61d7c33de4cd4ae61bc65e9f2ec7c8d3cd1a9d9853532"

RDEPENDS:libconfuse = " \
 glibc \
 "
RDEPENDS:libconfuse-devel = " \
 libconfuse \
 pkgconf-pkg-config \
 "
