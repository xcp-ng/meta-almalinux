# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-iso8601-time"
PV = "0.1.5"
PR = "19.el10_0"
PACKAGES = " \
 ghc-iso8601-time \
 ghc-iso8601-time-devel \
 ghc-iso8601-time-doc \
 ghc-iso8601-time-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-iso8601-time-0.1.5-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa61699cb6b31f386947d027bc9e1cd8bd14296b3629faafd232b40617fc3de8"

URI_x86_64_v2_ghc-iso8601-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-iso8601-time-0.1.5-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-iso8601-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-iso8601-time}"
SRC_URI[x86_64_v2_ghc-iso8601-time.sha256sum] = "5f67874243ffea769ee7ef3ca46a0ccd65969380d622b987a45231f1c5035de5"

URI_x86_64_v2_ghc-iso8601-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-iso8601-time-devel-0.1.5-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-iso8601-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-iso8601-time-devel}"
SRC_URI[x86_64_v2_ghc-iso8601-time-devel.sha256sum] = "e7b4a5f1c1f8a1b395ffc4629c1dde656d02436ce92e75d51e08f6852067e4a7"

URI_x86_64_v2_ghc-iso8601-time-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-iso8601-time-doc-0.1.5-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-iso8601-time-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-iso8601-time-doc}"
SRC_URI[x86_64_v2_ghc-iso8601-time-doc.sha256sum] = "acadf8deca5205abe5e871da9394eb64368fa43a7315ee38cebbc7d272c36a27"

URI_x86_64_v2_ghc-iso8601-time-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-iso8601-time-prof-0.1.5-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-iso8601-time-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-iso8601-time-prof}"
SRC_URI[x86_64_v2_ghc-iso8601-time-prof.sha256sum] = "23028666dcee6443fd6f73b55930640a7bb4ed9ecf0974453c645458f2d19585"

URI_aarch64_ghc-iso8601-time = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-iso8601-time-0.1.5-19.el10_0.aarch64.rpm;name=aarch64_ghc-iso8601-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-iso8601-time}"
SRC_URI[aarch64_ghc-iso8601-time.sha256sum] = "27fddf8d37b9ae173509f02255e672d9dbf842e8fa944e6aaa1e9c1f99344128"

URI_aarch64_ghc-iso8601-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-iso8601-time-devel-0.1.5-19.el10_0.aarch64.rpm;name=aarch64_ghc-iso8601-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-iso8601-time-devel}"
SRC_URI[aarch64_ghc-iso8601-time-devel.sha256sum] = "3c4d548fcbb490e38db2961d0b653522f71b4b9c058696a129b5fb768d82967e"

URI_aarch64_ghc-iso8601-time-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-iso8601-time-doc-0.1.5-19.el10_0.noarch.rpm;name=aarch64_ghc-iso8601-time-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-iso8601-time-doc}"
SRC_URI[aarch64_ghc-iso8601-time-doc.sha256sum] = "d7e1c12f0f9496da22313867e7dfecf63fea1e6e56134523ed9f147beccf8230"

URI_aarch64_ghc-iso8601-time-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-iso8601-time-prof-0.1.5-19.el10_0.aarch64.rpm;name=aarch64_ghc-iso8601-time-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-iso8601-time-prof}"
SRC_URI[aarch64_ghc-iso8601-time-prof.sha256sum] = "38989dcb07e196ed658fc236e4affd7a19da4d17fc8175a7864de9fcd3d8032d"

RDEPENDS:ghc-iso8601-time = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-time \
 glibc \
 gmp \
 "
RDEPENDS:ghc-iso8601-time-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-iso8601-time \
 ghc-time-devel \
 "
RDEPENDS:ghc-iso8601-time-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-iso8601-time-prof = " \
 ghc-base-prof \
 ghc-iso8601-time-devel \
 ghc-time-prof \
 "
