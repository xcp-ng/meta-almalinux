# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-blur-my-shell"
PV = "70"
PR = "1.el10_2"
PACKAGES = " \
 gnome-shell-extension-blur-my-shell \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnome-shell-extension-blur-my-shell-70-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86c9021cb4ccc1b751f571890f725d50ee8db04dcdc441060eb5cf4918dda520"

URI_x86_64_v2_gnome-shell-extension-blur-my-shell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-shell-extension-blur-my-shell-70-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-shell-extension-blur-my-shell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-blur-my-shell}"
SRC_URI[x86_64_v2_gnome-shell-extension-blur-my-shell.sha256sum] = "3694f687fc7390c1cd4f349726c8e2bd3ce4f3bb008f87043c44ddaba7108c20"

URI_aarch64_gnome-shell-extension-blur-my-shell = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-shell-extension-blur-my-shell-70-1.el10_2.noarch.rpm;name=aarch64_gnome-shell-extension-blur-my-shell;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-blur-my-shell}"
SRC_URI[aarch64_gnome-shell-extension-blur-my-shell.sha256sum] = "590cb38eca651a59990a06dd27ef994701c0af100935d9a11ea7b078d22a981f"

RDEPENDS:gnome-shell-extension-blur-my-shell = " \
 gnome-shell \
 "
