# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-imagick"
PV = "3.8.0"
PR = "1.el10_0"
PACKAGES = " \
 php-pecl-imagick \
 php-pecl-imagick-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-imagick-3.8.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2528d133db6acb573c324e5fe1206823c98a07b28719be791db5378cbea7cfb4"

URI_x86_64_v2_php-pecl-imagick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-imagick-3.8.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-imagick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-imagick}"
SRC_URI[x86_64_v2_php-pecl-imagick.sha256sum] = "bffa3fcfd1146e31ccdc7e48a8cf0cda387db892ba4b37a3d6d405c31f25a0ed"

URI_x86_64_v2_php-pecl-imagick-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-imagick-devel-3.8.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-imagick-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-imagick-devel}"
SRC_URI[x86_64_v2_php-pecl-imagick-devel.sha256sum] = "d9695104ebdfae7611b85ccd403c84f7c8f9c7bd0c42d85884b8ed5d3f2b0158"

URI_aarch64_php-pecl-imagick = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-imagick-3.8.0-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-imagick;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-imagick}"
SRC_URI[aarch64_php-pecl-imagick.sha256sum] = "3b45b909955ce55a745ea44ae02c83abb3f5e71e0d5201b3e7e963e38aed44b5"

URI_aarch64_php-pecl-imagick-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-imagick-devel-3.8.0-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-imagick-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-imagick-devel}"
SRC_URI[aarch64_php-pecl-imagick-devel.sha256sum] = "ebc8e63c241a0fe677d97ff4f2592505ae6c83bd019d7a78809cb7995d9aec1a"

RDEPENDS:php-pecl-imagick = " \
 ImageMagick-libs \
 glibc \
 libgomp \
 php-common \
 "
RDEPENDS:php-pecl-imagick-devel = " \
 php-devel \
 php-pecl-imagick \
 "
