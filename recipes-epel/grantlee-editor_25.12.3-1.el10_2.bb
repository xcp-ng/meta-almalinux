# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grantlee-editor"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 grantlee-editor \
 grantlee-editor-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/grantlee-editor-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3eea6329b05fae74dd0e8a16521f4b722747b778a6da9b0c36eb286e8bfd1de"

URI_x86_64_v2_grantlee-editor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantlee-editor-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantlee-editor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantlee-editor}"
SRC_URI[x86_64_v2_grantlee-editor.sha256sum] = "0184c13db084379a0bee2ed3b8a6171478f4ee7867ed9ef45aac67541f30221b"

URI_x86_64_v2_grantlee-editor-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantlee-editor-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantlee-editor-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantlee-editor-libs}"
SRC_URI[x86_64_v2_grantlee-editor-libs.sha256sum] = "c7783a5f89c164584507aacb77cdc6c4f9b38ad898d6bbd1aab8adf1cd0d84cd"

URI_aarch64_grantlee-editor = "${EPEL_MIRROR}/aarch64/Packages/g/grantlee-editor-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_grantlee-editor;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantlee-editor}"
SRC_URI[aarch64_grantlee-editor.sha256sum] = "afa9545318bd72bac64f1b02d4615e95f828f1b4ac93e8b46959a5bc36938c8a"

URI_aarch64_grantlee-editor-libs = "${EPEL_MIRROR}/aarch64/Packages/g/grantlee-editor-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_grantlee-editor-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantlee-editor-libs}"
SRC_URI[aarch64_grantlee-editor-libs.sha256sum] = "d9effdbde63154802b1f3c8d047d8154dca2cc8b3217ddfc5cd028c6ac9aad02"

RDEPENDS:grantlee-editor = " \
 akonadi-contacts \
 glibc \
 grantlee-editor-libs \
 grantleetheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 messagelib \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:grantlee-editor-libs = " \
 glibc \
 grantlee-editor \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-syntax-highlighting \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
