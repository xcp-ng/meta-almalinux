# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-firewall"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-firewall \
 plasma-firewall-firewalld \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-firewall-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4baac101a8ee06ee8bc6be9cb461d333a9e037470fd9b9fab7dc5dfd46c19123"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-firewall-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-firewall;unpack=0"
SRC_URI[x86_64_v2_plasma-firewall.sha256sum] = "7f0fa592d5f65ba63e46f034d5f116c39b16379a7ea681938ad29fa5716f4b75"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-firewall-firewalld-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-firewall-firewalld;unpack=0"
SRC_URI[x86_64_v2_plasma-firewall-firewalld.sha256sum] = "b208de07e98e7a995c63cbaa6d31362e6385a9550d19c1fbf3305be19b78440d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-firewall-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-firewall;unpack=0"
SRC_URI[aarch64_plasma-firewall.sha256sum] = "b9a53955998a7471ea8b41049fa137cf21959dcac325d45a68694aa7a0047a2e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-firewall-firewalld-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-firewall-firewalld;unpack=0"
SRC_URI[aarch64_plasma-firewall-firewalld.sha256sum] = "f870573520804d399747af08a61b23074241752fdf859f56aa727bf10a32131d"

RDEPENDS:plasma-firewall = " \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 plasma-firewall-firewalld \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-firewall-firewalld = " \
 firewalld \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 plasma-firewall \
 qt6-qtbase \
 "
