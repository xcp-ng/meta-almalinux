# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-headers"
PV = "1.4.328.1"
PR = "1.el10"
PACKAGES = " \
 vulkan-headers \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-headers-1.4.328.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f808094eb43b55ebfb68deb8db5e58ef9d7c8df3f811dbaead9e50f414271850"

URI_x86_64_v2_vulkan-headers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-headers-1.4.328.1-1.el10.noarch.rpm;name=x86_64_v2_vulkan-headers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-headers}"
SRC_URI[x86_64_v2_vulkan-headers.sha256sum] = "35e80271127a5bd0b78f1feda671e1b2b8c95e5b0b4a68589462a49b9efe443d"

URI_aarch64_vulkan-headers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-headers-1.4.328.1-1.el10.noarch.rpm;name=aarch64_vulkan-headers;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-headers}"
SRC_URI[aarch64_vulkan-headers.sha256sum] = "35e80271127a5bd0b78f1feda671e1b2b8c95e5b0b4a68589462a49b9efe443d"

RDEPENDS:vulkan-headers = " \
 cmake-filesystem \
 python3 \
 "
