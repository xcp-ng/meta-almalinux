# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "patchelf"
PV = "0.18.0"
PR = "6.el10_0"
PACKAGES = " \
 patchelf \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/patchelf-0.18.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a95c6e94f7f0450c0a164d1f1d881259b8d060ccd8e3305061f76f835d31d495"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/patchelf-0.18.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_patchelf;unpack=0"
SRC_URI[x86_64_v2_patchelf.sha256sum] = "78e64f8eeed769f2bffdc29ebd796de530a625a4608ed5a721482420ea3c6377"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/patchelf-0.18.0-6.el10_0.aarch64.rpm;name=aarch64_patchelf;unpack=0"
SRC_URI[aarch64_patchelf.sha256sum] = "b0e86aad24cb8e9cec0e62d98fe2f41197544b0649ab93437a4972ab5434b1ba"

RDEPENDS:patchelf = " \
 glibc \
 libgcc \
 libstdc++ \
 "
