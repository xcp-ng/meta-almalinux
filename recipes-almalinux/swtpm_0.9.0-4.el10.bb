# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "swtpm"
PV = "0.9.0"
PR = "4.el10"
PACKAGES = " \
 swtpm \
 swtpm-libs \
 swtpm-selinux \
 swtpm-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/swtpm-0.9.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5a0848de90e8bab22a6189e4e0a193c81f23dac405cd6478650a1800b02e477"

URI_x86_64_v2_swtpm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/swtpm-0.9.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_swtpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_swtpm}"
SRC_URI[x86_64_v2_swtpm.sha256sum] = "85926e8249947f69445a36eec548c3cfb85e008355169f84395e3358d0e2a80b"

URI_x86_64_v2_swtpm-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/swtpm-libs-0.9.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_swtpm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_swtpm-libs}"
SRC_URI[x86_64_v2_swtpm-libs.sha256sum] = "8b149a55714fbc1d02a8c446f2b5bf7bfc27acf06ca450627e7319fac4a6cd6f"

URI_x86_64_v2_swtpm-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/swtpm-selinux-0.9.0-4.el10.noarch.rpm;name=x86_64_v2_swtpm-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_swtpm-selinux}"
SRC_URI[x86_64_v2_swtpm-selinux.sha256sum] = "c6ef6f22265e5b5bbf55d60d324075a6c4afef1f4c17c696c1aef1080181bbcd"

URI_x86_64_v2_swtpm-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/swtpm-tools-0.9.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_swtpm-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_swtpm-tools}"
SRC_URI[x86_64_v2_swtpm-tools.sha256sum] = "40ca481c37f196d107c69c36492716e666fdddc8e642aa8ae019f1ba6a5759dc"

URI_aarch64_swtpm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/swtpm-0.9.0-4.el10.aarch64.rpm;name=aarch64_swtpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_swtpm}"
SRC_URI[aarch64_swtpm.sha256sum] = "46d74ef49ac28154d28dbfd122735c340a2c2a5bb8910386582dcac400d1cd2e"

URI_aarch64_swtpm-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/swtpm-libs-0.9.0-4.el10.aarch64.rpm;name=aarch64_swtpm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_swtpm-libs}"
SRC_URI[aarch64_swtpm-libs.sha256sum] = "c142da86a9e4af49763b49c58b01fae3b0f49948d166d65694e42f4030ed2483"

URI_aarch64_swtpm-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/swtpm-selinux-0.9.0-4.el10.noarch.rpm;name=aarch64_swtpm-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_swtpm-selinux}"
SRC_URI[aarch64_swtpm-selinux.sha256sum] = "c6ef6f22265e5b5bbf55d60d324075a6c4afef1f4c17c696c1aef1080181bbcd"

URI_aarch64_swtpm-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/swtpm-tools-0.9.0-4.el10.aarch64.rpm;name=aarch64_swtpm-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_swtpm-tools}"
SRC_URI[aarch64_swtpm-tools.sha256sum] = "b1a16e27c3d90faf14698d7d46de59e66e33c12abbe4733ff7da87c13416f9db"

RDEPENDS:swtpm = " \
 glibc \
 libtpms \
 swtpm-libs \
 swtpm-selinux \
 "
RDEPENDS:swtpm-libs = " \
 glib2 \
 glibc \
 libseccomp \
 libtpms \
 openssl-libs \
 "
RDEPENDS:swtpm-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 swtpm \
 "
RDEPENDS:swtpm-tools = " \
 bash \
 glib2 \
 glibc \
 gmp \
 gnutls \
 gnutls-utils \
 json-glib \
 libgcc \
 libtasn1 \
 openssl-libs \
 swtpm \
 tpm2-tss \
 "
