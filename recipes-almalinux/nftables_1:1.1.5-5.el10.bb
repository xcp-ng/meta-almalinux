# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nftables"
PE = "1"
PV = "1.1.5"
PR = "5.el10"
PACKAGES = " \
 nftables \
 nftables-devel \
 python3-nftables \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nftables-1.1.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1519960c422196c7a210d364b7882bd7bbb90f856679e35ec80e0c12b81f82ca"

URI_x86_64_v2_nftables = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nftables-1.1.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_nftables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nftables}"
SRC_URI[x86_64_v2_nftables.sha256sum] = "3cbc7e14a2b5ab2124c6b43dd5600c3d6824c0799503fa9b5c772a8d6d5903be"

URI_x86_64_v2_nftables-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nftables-devel-1.1.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_nftables-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nftables-devel}"
SRC_URI[x86_64_v2_nftables-devel.sha256sum] = "d08adfe3e3a35f01e61ef34007c6db10422a660ac35bf4523400022740aa4c8e"

URI_x86_64_v2_python3-nftables = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-nftables-1.1.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-nftables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nftables}"
SRC_URI[x86_64_v2_python3-nftables.sha256sum] = "9aac0d2c313eb9a42bbbc38c258d1586235938978fa2f77ffa59207a74223208"

URI_aarch64_nftables = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nftables-1.1.5-5.el10.aarch64.rpm;name=aarch64_nftables;unpack=0"
SRC_URI:append = " ${URI_aarch64_nftables}"
SRC_URI[aarch64_nftables.sha256sum] = "7050bcc85042c7799495c11b0976f18487a6fbcd6576d6261340e30d5f1f3de4"

URI_aarch64_nftables-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nftables-devel-1.1.5-5.el10.aarch64.rpm;name=aarch64_nftables-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nftables-devel}"
SRC_URI[aarch64_nftables-devel.sha256sum] = "270e3dded53da3390d8f8ce21b515c1da7971bfaad05ef56ade384171a35a592"

URI_aarch64_python3-nftables = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-nftables-1.1.5-5.el10.aarch64.rpm;name=aarch64_python3-nftables;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nftables}"
SRC_URI[aarch64_python3-nftables.sha256sum] = "3f2056c627b7c9104a3b9db10adeb23d8a057d5ed569657c1da04732c61bd3a0"

RDEPENDS:nftables = " \
 bash \
 glibc \
 gmp \
 iptables-libs \
 jansson \
 libmnl \
 libnftnl \
 readline \
 "
RDEPENDS:nftables-devel = " \
 nftables \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-nftables = " \
 nftables \
 python3 \
 "
