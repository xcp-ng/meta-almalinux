# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_link"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_link+default-devel \
 rust-uu_link-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_link-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4fd8bc9b21ba2a6d08d882237e6767c3083422c4ace44676dd7d33dea7e11b3"

URI_x86_64_v2_rust-uu_link+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_link+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_link+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_link+default-devel}"
SRC_URI[x86_64_v2_rust-uu_link+default-devel.sha256sum] = "48faffa0902d9fb3ac80bb08d1d93afd4756558ae129f5c6b0243d478a1024dc"

URI_x86_64_v2_rust-uu_link-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_link-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_link-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_link-devel}"
SRC_URI[x86_64_v2_rust-uu_link-devel.sha256sum] = "f7a5453d00fe6944b25ca715ae023a6f41f382f2c75522c9a47fabecdd1eb223"

URI_aarch64_rust-uu_link+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_link+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_link+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_link+default-devel}"
SRC_URI[aarch64_rust-uu_link+default-devel.sha256sum] = "032bbe5a42f339c4bc41c88ea91b20bfba5e2d93f1b25a308119426e838f006a"

URI_aarch64_rust-uu_link-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_link-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_link-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_link-devel}"
SRC_URI[aarch64_rust-uu_link-devel.sha256sum] = "8476d7713ca67e237739fb201f3b2f53bc519eb0b47a29c10019730b5944aa96"

RDEPENDS:rust-uu_link+default-devel = " \
 cargo \
 rust-uu_link-devel \
 "
RDEPENDS:rust-uu_link-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 "
