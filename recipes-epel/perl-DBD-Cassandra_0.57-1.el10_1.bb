# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DBD-Cassandra"
PV = "0.57"
PR = "1.el10_1"
PACKAGES = " \
 perl-DBD-Cassandra \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-DBD-Cassandra-0.57-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c21b5989bb53dbd1fc70dc62957983d99dc4993a8b5be308612840093c98e7eb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DBD-Cassandra-0.57-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DBD-Cassandra;unpack=0"
SRC_URI[x86_64_v2_perl-DBD-Cassandra.sha256sum] = "3a8ad06d224c1dea56c3debf1f10f4061191a5315b624be3845d87e982f35fcd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-DBD-Cassandra-0.57-1.el10_1.noarch.rpm;name=aarch64_perl-DBD-Cassandra;unpack=0"
SRC_URI[aarch64_perl-DBD-Cassandra.sha256sum] = "83419a469d7edcfeadf994654a2816a08bfcf000d6166e4df330328e737ce807"

RDEPENDS:perl-DBD-Cassandra = " \
 perl-Cassandra-Client \
 perl-DBD-Cassandra \
 perl-DBI \
 perl-Devel-GlobalDestruction \
 perl-libs \
 "
