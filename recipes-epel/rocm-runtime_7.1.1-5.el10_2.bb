# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-runtime"
PV = "7.1.1"
PR = "5.el10_2"
PACKAGES:x86_64_v2 = " \
 kfdtest \
 rocm-runtime \
 rocm-runtime-devel \
 rocm-runtime-static \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-runtime-7.1.1-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d0c3a7525a7ddd49f7fb2f5cfb18a0e902dfecde35b86dc4dac54f47371dbdb"

URI_x86_64_v2_kfdtest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kfdtest-7.1.1-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kfdtest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kfdtest}"
SRC_URI[x86_64_v2_kfdtest.sha256sum] = "a983d4842711ed4f6ac86b3fb8807624a9db2c26b1da7e6e8a5ec0c1d74dcd43"

URI_x86_64_v2_rocm-runtime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-runtime-7.1.1-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-runtime}"
SRC_URI[x86_64_v2_rocm-runtime.sha256sum] = "dc408e199702c67065e527f3482e454dcbb1a629681f94e376f0ded6c4ad47f0"

URI_x86_64_v2_rocm-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-runtime-devel-7.1.1-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-runtime-devel}"
SRC_URI[x86_64_v2_rocm-runtime-devel.sha256sum] = "740c858665c143ad05ea68d92680163774a151c6b9f019a844ef4f5bac674cb1"

URI_x86_64_v2_rocm-runtime-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-runtime-static-7.1.1-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-runtime-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-runtime-static}"
SRC_URI[x86_64_v2_rocm-runtime-static.sha256sum] = "63544035ba1a70d71c4dabeee7f20abd9d01a96a6595bf57ee4260986ecfbf4d"

RDEPENDS:kfdtest = " \
 bash \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libzstd \
 numactl-libs \
 rocm-smi \
 zlib-ng-compat \
 "
RDEPENDS:rocm-runtime = " \
 elfutils-libelf \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 numactl-libs \
 "
RDEPENDS:rocm-runtime-devel = " \
 cmake-filesystem \
 rocm-runtime \
 "
RDEPENDS:rocm-runtime-static = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 rocm-runtime-devel \
 "
