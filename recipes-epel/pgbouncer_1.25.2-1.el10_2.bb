# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pgbouncer"
PV = "1.25.2"
PR = "1.el10_2"
PACKAGES = " \
 pgbouncer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pgbouncer-1.25.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "beebf12deeb2efac6f1f781c24bf8d1f2086f5ce002b4ce9ace9caaa3eca3c2e"

URI_x86_64_v2_pgbouncer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pgbouncer-1.25.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pgbouncer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pgbouncer}"
SRC_URI[x86_64_v2_pgbouncer.sha256sum] = "491e1fc0f0042b579918bf33ba57a51c1b4ab1afdbf869476c9cc804814b86f0"

URI_aarch64_pgbouncer = "${EPEL_MIRROR}/aarch64/Packages/p/pgbouncer-1.25.2-1.el10_2.aarch64.rpm;name=aarch64_pgbouncer;unpack=0"
SRC_URI:append = " ${URI_aarch64_pgbouncer}"
SRC_URI[aarch64_pgbouncer.sha256sum] = "0be8a1225ba263af26774e363f68a47981ea75cd8315af5c0acd89190856715e"

RDEPENDS:pgbouncer = " \
 bash \
 c-ares \
 glibc \
 libevent \
 logrotate \
 openldap \
 openssl-libs \
 pam-libs \
 python3 \
 python3-psycopg2 \
 shadow-utils \
 systemd \
 systemd-libs \
 "
