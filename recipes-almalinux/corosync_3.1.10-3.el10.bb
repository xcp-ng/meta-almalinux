# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "corosync"
PV = "3.1.10"
PR = "3.el10"
PACKAGES = " \
 corosync-vqsim \
 corosynclib \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/corosync-3.1.10-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f97a4711ee10b4e331337ff8ce24191da5404add4d94e5b4c66649fe6007cb82"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/corosync-vqsim-3.1.10-3.el10.x86_64_v2.rpm;name=x86_64_v2_corosync-vqsim;unpack=0"
SRC_URI[x86_64_v2_corosync-vqsim.sha256sum] = "d1f2f2319ce40273ba6cae9adb1c6f9b1b57623272e3e7220ab7fd03d7226474"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/corosynclib-3.1.10-3.el10.x86_64_v2.rpm;name=x86_64_v2_corosynclib;unpack=0"
SRC_URI[x86_64_v2_corosynclib.sha256sum] = "ba7ead6792e26debe82b3e2e1793c1bc53532fb5832ae8c725fda2735c20c989"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/corosync-vqsim-3.1.10-3.el10.aarch64.rpm;name=aarch64_corosync-vqsim;unpack=0"
SRC_URI[aarch64_corosync-vqsim.sha256sum] = "b73db954de2d42780089a025c78e8f96285c1af5bc076bd700680781a8b39701"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/corosynclib-3.1.10-3.el10.aarch64.rpm;name=aarch64_corosynclib;unpack=0"
SRC_URI[aarch64_corosynclib.sha256sum] = "07360663b2b0aa165c9513c0fb1fb5f7c9ebdbebf865027cc99836d87345b6ad"

RDEPENDS:corosync-vqsim = " \
 corosynclib \
 glibc \
 libknet1 \
 libqb \
 pkgconf-pkg-config \
 readline \
 "
RDEPENDS:corosynclib = " \
 glibc \
 libqb \
 "
