# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pkginfo"
PV = "1.12.0"
PR = "3.el10_0"
PACKAGES = " \
 python-pkginfo-doc \
 python3-pkginfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pkginfo-1.12.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0749ca99fd7de7cbc4ee13263864357b3a8682e7984f13bf04480579a32cf51"

URI_x86_64_v2_python-pkginfo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pkginfo-doc-1.12.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-pkginfo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pkginfo-doc}"
SRC_URI[x86_64_v2_python-pkginfo-doc.sha256sum] = "56ef8414fd0089e4d1b8f7a55808cd1230f768bb9d4d2e1a84465967e5cc1ee9"

URI_x86_64_v2_python3-pkginfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pkginfo-1.12.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pkginfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pkginfo}"
SRC_URI[x86_64_v2_python3-pkginfo.sha256sum] = "ed313b15052830f91fa48c5cf1c3d0e58930028413e82a58e67ceba2ec470cd8"

URI_aarch64_python-pkginfo-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-pkginfo-doc-1.12.0-3.el10_0.noarch.rpm;name=aarch64_python-pkginfo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pkginfo-doc}"
SRC_URI[aarch64_python-pkginfo-doc.sha256sum] = "dfa557fe4b414665397d35e04071d250f0034aea05e2c88c8e752f4defaa100c"

URI_aarch64_python3-pkginfo = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pkginfo-1.12.0-3.el10_0.noarch.rpm;name=aarch64_python3-pkginfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pkginfo}"
SRC_URI[aarch64_python3-pkginfo.sha256sum] = "5277e09f7ccc050ff4f35ba806a148fb6dd5c4adb7ea63083a6b3e2ecd991180"

RDEPENDS:python-pkginfo-doc = " \
 "
RDEPENDS:python3-pkginfo = " \
 python3 \
 python3-setuptools \
 "
