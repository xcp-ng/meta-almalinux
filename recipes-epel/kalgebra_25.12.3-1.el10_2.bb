# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalgebra"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kalgebra \
 kalgebra-plasma-applet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kalgebra-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f073a59f968471217d252d72a56c5e82ef51cb3a11c055a490a6ecb055a0d49"

URI_x86_64_v2_kalgebra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalgebra-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalgebra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kalgebra}"
SRC_URI[x86_64_v2_kalgebra.sha256sum] = "f92f80b74e0743285aec5dc12d7aca003ac9e98cca815ce06927356fd2e108ee"

URI_x86_64_v2_kalgebra-plasma-applet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalgebra-plasma-applet-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalgebra-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kalgebra-plasma-applet}"
SRC_URI[x86_64_v2_kalgebra-plasma-applet.sha256sum] = "2b4fc259bbec698363be4d3cb465e5b0342636440a7789730b5706ee7103eb83"

URI_aarch64_kalgebra = "${EPEL_MIRROR}/aarch64/Packages/k/kalgebra-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kalgebra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kalgebra}"
SRC_URI[aarch64_kalgebra.sha256sum] = "173717595a59b9643303e664ec3e241bb62616c790a2cb266a27ff69b1b2fe74"

URI_aarch64_kalgebra-plasma-applet = "${EPEL_MIRROR}/aarch64/Packages/k/kalgebra-plasma-applet-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kalgebra-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kalgebra-plasma-applet}"
SRC_URI[aarch64_kalgebra-plasma-applet.sha256sum] = "74462c6c698247fbe6df67794d6f943875a9e68bba642e28ea868a47038e4b0b"

RDEPENDS:kalgebra = " \
 analitza \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 readline \
 "
RDEPENDS:kalgebra-plasma-applet = " \
 kalgebra \
 libplasma \
 "
