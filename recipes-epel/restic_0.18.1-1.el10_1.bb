# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "restic"
PV = "0.18.1"
PR = "1.el10_1"
PACKAGES = " \
 restic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/restic-0.18.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4a2fe84e0a84b1e761dd915f8898fe0c79cc90005d5ef2afa30716e9eca4aea"

URI_x86_64_v2_restic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/restic-0.18.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_restic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_restic}"
SRC_URI[x86_64_v2_restic.sha256sum] = "00311d5a39669a7e492828dd45b4c21dc18f8d97e08b7970e965f06202ec5465"

URI_aarch64_restic = "${EPEL_MIRROR}/aarch64/Packages/r/restic-0.18.1-1.el10_1.aarch64.rpm;name=aarch64_restic;unpack=0"
SRC_URI:append = " ${URI_aarch64_restic}"
SRC_URI[aarch64_restic.sha256sum] = "ed8fc67d4cdae6f8c0a7216da7be8316269232961776d17f0d625a069c5db010"

RDEPENDS:restic = " \
 glibc \
 "
