# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-siphasher"
PV = "1.0.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-siphasher+default-devel \
 rust-siphasher+serde-devel \
 rust-siphasher+serde_json-devel \
 rust-siphasher+serde_no_std-devel \
 rust-siphasher+serde_std-devel \
 rust-siphasher+std-devel \
 rust-siphasher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-siphasher-1.0.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e67b7e91ffee870d41463e6fb37b47b3856708daed5dcc2cd339e878784d4db5"

URI_x86_64_v2_rust-siphasher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+default-devel-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+default-devel}"
SRC_URI[x86_64_v2_rust-siphasher+default-devel.sha256sum] = "2fd6722dd704481c71ec3b4a51dd19dad089d487f9275bc22a432a2cd53f88d8"

URI_x86_64_v2_rust-siphasher+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde-devel-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+serde-devel}"
SRC_URI[x86_64_v2_rust-siphasher+serde-devel.sha256sum] = "14817ac438b0213e141d0bb26851052187da4701499bf220d177156ab1a37cd2"

URI_x86_64_v2_rust-siphasher+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde_json-devel-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+serde_json-devel}"
SRC_URI[x86_64_v2_rust-siphasher+serde_json-devel.sha256sum] = "bd6ad939787dac7c25ef25f4802ea1a9ac972f641da91482c5cc7910b5d393b3"

URI_x86_64_v2_rust-siphasher+serde_no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde_no_std-devel-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde_no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+serde_no_std-devel}"
SRC_URI[x86_64_v2_rust-siphasher+serde_no_std-devel.sha256sum] = "a89bbcb02f8acf2d14c56e20b15e02f98b2b5b688bce2c2dd292fb7f5967a5c9"

URI_x86_64_v2_rust-siphasher+serde_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde_std-devel-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+serde_std-devel}"
SRC_URI[x86_64_v2_rust-siphasher+serde_std-devel.sha256sum] = "76ed6762305fc5e6e730290c136ba5b518b47f02a3f7b5399aa54398f5e92f18"

URI_x86_64_v2_rust-siphasher+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+std-devel-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+std-devel}"
SRC_URI[x86_64_v2_rust-siphasher+std-devel.sha256sum] = "dc1dc81d6e8579c032e4df3f6a6fe96bd588679145b4cb7f773f5c91a271c312"

URI_x86_64_v2_rust-siphasher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher-devel-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher-devel}"
SRC_URI[x86_64_v2_rust-siphasher-devel.sha256sum] = "a0d8d4ed290b158abce326a904138fda07d279ce442c4fcf3c2adb388bcb8db2"

URI_aarch64_rust-siphasher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+default-devel-1.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-siphasher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+default-devel}"
SRC_URI[aarch64_rust-siphasher+default-devel.sha256sum] = "ba8a29c76722445c12f3a03c5470c6373bcf1522dc2a99aede95923fbcb05e9e"

URI_aarch64_rust-siphasher+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde-devel-1.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-siphasher+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+serde-devel}"
SRC_URI[aarch64_rust-siphasher+serde-devel.sha256sum] = "be8cf092ba3bdf803a8888398a396c91c1ecbfebba5bd75f2e406797594764eb"

URI_aarch64_rust-siphasher+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde_json-devel-1.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-siphasher+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+serde_json-devel}"
SRC_URI[aarch64_rust-siphasher+serde_json-devel.sha256sum] = "77fca3002a579d4e90a9aef5dfa9851467d14127f75d9d9df4f0da7f550ac70f"

URI_aarch64_rust-siphasher+serde_no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde_no_std-devel-1.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-siphasher+serde_no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+serde_no_std-devel}"
SRC_URI[aarch64_rust-siphasher+serde_no_std-devel.sha256sum] = "82be5f63add91d14bd0a5bb4155ce2e5ace073a4a47252ad48d2405e769167a8"

URI_aarch64_rust-siphasher+serde_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde_std-devel-1.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-siphasher+serde_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+serde_std-devel}"
SRC_URI[aarch64_rust-siphasher+serde_std-devel.sha256sum] = "299f3d1c2c7657c39f58bf887ab38050ddf86c2205bc9cf1e892da990605107e"

URI_aarch64_rust-siphasher+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+std-devel-1.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-siphasher+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+std-devel}"
SRC_URI[aarch64_rust-siphasher+std-devel.sha256sum] = "eaefc29d1259e68b3cdabac97a6928f4c27cf33c295c6468c01a2ee707c9550d"

URI_aarch64_rust-siphasher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher-devel-1.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-siphasher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher-devel}"
SRC_URI[aarch64_rust-siphasher-devel.sha256sum] = "9f54a83b889eb26a12fb64c0df1a61d1421e63aa7735918c3014a86f8fb6292a"

RDEPENDS:rust-siphasher+default-devel = " \
 cargo \
 rust-siphasher+std-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde_json-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde_no_std-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde_std-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-siphasher+std-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+std-devel = " \
 cargo \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher-devel = " \
 cargo \
 "
