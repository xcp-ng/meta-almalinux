# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jsonschema-path"
PV = "0.3.4"
PR = "6.el10_2"
PACKAGES = " \
 python3-jsonschema-path \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jsonschema-path-0.3.4-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77988f48880c83598160e852f15dc6d50cd8bbaf661c0b4dde0cbc2ae70cb393"

URI_x86_64_v2_python3-jsonschema-path = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jsonschema-path-0.3.4-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jsonschema-path;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jsonschema-path}"
SRC_URI[x86_64_v2_python3-jsonschema-path.sha256sum] = "7126c9b8b3e8732405331a49f2d47110eafa1aed71bf24e54549479f044549a1"

URI_aarch64_python3-jsonschema-path = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jsonschema-path-0.3.4-6.el10_2.noarch.rpm;name=aarch64_python3-jsonschema-path;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jsonschema-path}"
SRC_URI[aarch64_python3-jsonschema-path.sha256sum] = "d486436dacaec9a38539cbb5495289d59d74cfbd88e25b5392e4c5e35849f88b"

RDEPENDS:python3-jsonschema-path = " \
 python3 \
 python3-pathable \
 python3-pyyaml \
 python3-referencing \
 python3-requests \
 "
