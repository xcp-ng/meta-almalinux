# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxx"
PV = "1.0.199"
PR = "1.el10_3"
PACKAGES = " \
 rust-cxx+alloc-devel \
 rust-cxx+c++14-devel \
 rust-cxx+c++17-devel \
 rust-cxx+c++20-devel \
 rust-cxx+default-devel \
 rust-cxx+std-devel \
 rust-cxx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxx-1.0.199-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7026fbf99e3a162d716a48f2f197a909ff9bc9be60ad4c159bab9d7e17ed62bb"

URI_x86_64_v2_rust-cxx+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+alloc-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+alloc-devel}"
SRC_URI[x86_64_v2_rust-cxx+alloc-devel.sha256sum] = "d1fc4fa645fe54b27fc5db4c43981d975be5a84270807210885f0711e7b000c6"

URI_x86_64_v2_rust-cxx+c++14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+c++14-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+c++14-devel}"
SRC_URI[x86_64_v2_rust-cxx+c++14-devel.sha256sum] = "7dde0d9a7a75a1ac430b0c73141cc271d96f00b8e5ba6071b6e41b46cc8d36d9"

URI_x86_64_v2_rust-cxx+c++17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+c++17-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+c++17-devel}"
SRC_URI[x86_64_v2_rust-cxx+c++17-devel.sha256sum] = "80d282d66bc179d44e4c3575fd177f50e61a8eaefa2af90622b66ea251f531b6"

URI_x86_64_v2_rust-cxx+c++20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+c++20-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+c++20-devel}"
SRC_URI[x86_64_v2_rust-cxx+c++20-devel.sha256sum] = "cade387d7858d6475cce1e4b715ce3cb2541ee0216850a1dc237ce2ae2982ea1"

URI_x86_64_v2_rust-cxx+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+default-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+default-devel}"
SRC_URI[x86_64_v2_rust-cxx+default-devel.sha256sum] = "a4786f51305dde58daae349dc422c8b7ea37afd279db6361c75283af4c0b8284"

URI_x86_64_v2_rust-cxx+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+std-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+std-devel}"
SRC_URI[x86_64_v2_rust-cxx+std-devel.sha256sum] = "45a0d1edddd44d044701fa2921b5bde5f594cf7c1d6f86c0733432e654dd6691"

URI_x86_64_v2_rust-cxx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-devel}"
SRC_URI[x86_64_v2_rust-cxx-devel.sha256sum] = "e37a6e77ff57c96f9262f88e421182c27a2c244e8d8d42ab37d11528b7a9340b"

URI_aarch64_rust-cxx+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+alloc-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxx+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+alloc-devel}"
SRC_URI[aarch64_rust-cxx+alloc-devel.sha256sum] = "f1ca51672fcf22349eef87a7ee82f9b21851440daf8e18800a6a807e32a80341"

URI_aarch64_rust-cxx+c++14-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+c++14-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxx+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+c++14-devel}"
SRC_URI[aarch64_rust-cxx+c++14-devel.sha256sum] = "e549c23fd4d441934f7871185d9cb6719356573f6a5569922b35f4ec0bb012da"

URI_aarch64_rust-cxx+c++17-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+c++17-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxx+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+c++17-devel}"
SRC_URI[aarch64_rust-cxx+c++17-devel.sha256sum] = "b68d5b5985c5d07826827389955636e1cfea4cd749d6010a449f2e50edfd21eb"

URI_aarch64_rust-cxx+c++20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+c++20-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxx+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+c++20-devel}"
SRC_URI[aarch64_rust-cxx+c++20-devel.sha256sum] = "4cf7387a8277bfd689ef0c35a4980f22a9b2f37c12b4428aa0e66f2da0da525e"

URI_aarch64_rust-cxx+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+default-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxx+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+default-devel}"
SRC_URI[aarch64_rust-cxx+default-devel.sha256sum] = "0720c82c0d0d2d20b6a5e2ee0d19264eed67f6e548364c29dbe09474cb289f75"

URI_aarch64_rust-cxx+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+std-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxx+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+std-devel}"
SRC_URI[aarch64_rust-cxx+std-devel.sha256sum] = "0adc1ed5ae4b90e2c27f512d0a6fc1c8339b89ce1676417aa6ac86e57bc03bd2"

URI_aarch64_rust-cxx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-devel}"
SRC_URI[aarch64_rust-cxx-devel.sha256sum] = "ef77e937d7a4779fea9c5d111971126cb759ff95658d2ddfc2ced0ad2f71b8fb"

RDEPENDS:rust-cxx+alloc-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+c++14-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+c++17-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+c++20-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+default-devel = " \
 cargo \
 rust-cxx+std-devel \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+std-devel = " \
 cargo \
 rust-cxx+alloc-devel \
 rust-cxx-devel \
 rust-foldhash+std-devel \
 "
RDEPENDS:rust-cxx-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-cxxbridge-flags-devel \
 rust-cxxbridge-macro+default-devel \
 rust-foldhash-devel \
 rust-link-cplusplus+default-devel \
 "
