# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flexmock"
PV = "0.12.2"
PR = "1.el10_1"
PACKAGES = " \
 python3-flexmock \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-flexmock-0.12.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84e7c22cb0f8f172504a30766e7d5657a87d19e762ac94e9ae1481e4c43ad628"

URI_x86_64_v2_python3-flexmock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flexmock-0.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flexmock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flexmock}"
SRC_URI[x86_64_v2_python3-flexmock.sha256sum] = "1c85cea3cb3f33e7a67f6521c342bfe85376400c76560d374cfc7b05c060b994"

URI_aarch64_python3-flexmock = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flexmock-0.12.2-1.el10_1.noarch.rpm;name=aarch64_python3-flexmock;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flexmock}"
SRC_URI[aarch64_python3-flexmock.sha256sum] = "75c815ae365afb402c8428827145349a8a8046b23bd208e7d088a9081460ea98"

RDEPENDS:python3-flexmock = " \
 python3 \
 "
