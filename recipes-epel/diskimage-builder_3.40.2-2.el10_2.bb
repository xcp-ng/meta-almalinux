# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "diskimage-builder"
PV = "3.40.2"
PR = "2.el10_2"
PACKAGES = " \
 diskimage-builder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/diskimage-builder-3.40.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d60b993f27f48bedb16536ec3e7e7bb0b3fe466c6c00bd5634e833f2c6a4607"

URI_x86_64_v2_diskimage-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/diskimage-builder-3.40.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_diskimage-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_diskimage-builder}"
SRC_URI[x86_64_v2_diskimage-builder.sha256sum] = "b2aff7ffce22dc7cca0e28941f7ef2e67c745d14b6a38ba37fc5eea823ceacae"

URI_aarch64_diskimage-builder = "${EPEL_MIRROR}/aarch64/Packages/d/diskimage-builder-3.40.2-2.el10_2.noarch.rpm;name=aarch64_diskimage-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_diskimage-builder}"
SRC_URI[aarch64_diskimage-builder.sha256sum] = "6ea8e10bde057b3122944495ff44406e0915d29d239379a8d8c412f64592e16c"

RDEPENDS:diskimage-builder = " \
 bash \
 curl \
 dosfstools \
 e2fsprogs \
 gdisk \
 git-core \
 kpartx \
 libguestfs \
 lvm2 \
 python3 \
 python3-flake8 \
 python3-jsonschema \
 python3-networkx \
 python3-pbr \
 python3-pyyaml \
 python3-stevedore \
 qemu-img \
 tar \
 virtual//usr/bin/env \
 xfsprogs \
 "
