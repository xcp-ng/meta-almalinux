# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcharselect"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kcharselect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcharselect-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51dcd2b8f4bb120653a59b0b63be29b244785186d0fb51ad11f63d630d245bac"

URI_x86_64_v2_kcharselect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcharselect-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcharselect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcharselect}"
SRC_URI[x86_64_v2_kcharselect.sha256sum] = "6da595d0bbfd139c324b2125e87c156670c91ead12b1ae19a3e941dd8a47c00b"

URI_aarch64_kcharselect = "${EPEL_MIRROR}/aarch64/Packages/k/kcharselect-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kcharselect;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcharselect}"
SRC_URI[aarch64_kcharselect.sha256sum] = "665449769110bfd3018c2c76b9eeeacb608cb74e16f7ea9dd7c3674b370e39be"

RDEPENDS:kcharselect = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
