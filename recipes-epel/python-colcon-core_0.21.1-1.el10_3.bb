# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-core"
PV = "0.21.1"
PR = "1.el10_3"
PACKAGES = " \
 python3-colcon-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-core-0.21.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b24fdccc38d54a723d8d012957d4adc78fd302a910d5909ca1254e55707f4281"

URI_x86_64_v2_python3-colcon-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-core-0.21.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-core}"
SRC_URI[x86_64_v2_python3-colcon-core.sha256sum] = "627db689fafee4fc1ae592d81848e552f632515b14fd1a50544d2574cedb9f93"

URI_aarch64_python3-colcon-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-core-0.21.1-1.el10_3.noarch.rpm;name=aarch64_python3-colcon-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-core}"
SRC_URI[aarch64_python3-colcon-core.sha256sum] = "e6d15c5a310810cb138b2c5b78cfa8ad512273ab64002be64d56d36489cb101c"

RDEPENDS:python3-colcon-core = " \
 python3 \
 python3-distlib \
 python3-empy \
 python3-packaging \
 python3-setuptools \
 "
