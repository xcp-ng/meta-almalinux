# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indoc"
PV = "2.0.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-indoc+default-devel \
 rust-indoc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indoc-2.0.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6faa504fbb8ddbf57e322b44d364a7edf663b47771e83ad2dda78e83df2afb8d"

URI_x86_64_v2_rust-indoc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indoc+default-devel-2.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indoc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indoc+default-devel}"
SRC_URI[x86_64_v2_rust-indoc+default-devel.sha256sum] = "016f722223af991b65c80fe1ea22c09fc61af1151d31e93a667c9102665a3b30"

URI_x86_64_v2_rust-indoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indoc-devel-2.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indoc-devel}"
SRC_URI[x86_64_v2_rust-indoc-devel.sha256sum] = "058bdf2fbb6aec4115f6a41c79b48ea6c185bf9008eb4f4a6d696b143780bd5e"

URI_aarch64_rust-indoc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indoc+default-devel-2.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-indoc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indoc+default-devel}"
SRC_URI[aarch64_rust-indoc+default-devel.sha256sum] = "802cb5434650a9074cee0a14ab3ef6bf8664dccd662b7750f9556275559f8920"

URI_aarch64_rust-indoc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indoc-devel-2.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-indoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indoc-devel}"
SRC_URI[aarch64_rust-indoc-devel.sha256sum] = "c531723b38244d54494f50271f0c892a27937458372ebdb8d49dfefd01019ce8"

RDEPENDS:rust-indoc+default-devel = " \
 cargo \
 rust-indoc-devel \
 "
RDEPENDS:rust-indoc-devel = " \
 cargo \
 rust \
 rust-rustversion+default-devel \
 "
