# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest_meta"
PV = "2.8.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-pest_meta+default-devel \
 rust-pest_meta+grammar-extras-devel \
 rust-pest_meta-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest_meta-2.8.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d920f8f12e2d2eed4b93fefbcc9222721af959b49d2d6f90255820af3513b512"

URI_x86_64_v2_rust-pest_meta+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_meta+default-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_meta+default-devel}"
SRC_URI[x86_64_v2_rust-pest_meta+default-devel.sha256sum] = "da178eb94a04aacbd2845d1774d99692ca7e5e904d0b631963c6afaad4cff714"

URI_x86_64_v2_rust-pest_meta+grammar-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_meta+grammar-extras-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_meta+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_meta+grammar-extras-devel}"
SRC_URI[x86_64_v2_rust-pest_meta+grammar-extras-devel.sha256sum] = "01d912b0cfe500178b91942b6af4efe62ab5a26495385e9baca39f0dec5f63c5"

URI_x86_64_v2_rust-pest_meta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_meta-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_meta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_meta-devel}"
SRC_URI[x86_64_v2_rust-pest_meta-devel.sha256sum] = "77788a19658fb9db26fcfe1beb48ff3e8c6a9f10614c9b18559d470c4c32f858"

URI_aarch64_rust-pest_meta+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_meta+default-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_meta+default-devel}"
SRC_URI[aarch64_rust-pest_meta+default-devel.sha256sum] = "f5101f02e3c3a8e697e2e40e881212fafafbdf89186010faca1828bc248c79b5"

URI_aarch64_rust-pest_meta+grammar-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_meta+grammar-extras-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest_meta+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_meta+grammar-extras-devel}"
SRC_URI[aarch64_rust-pest_meta+grammar-extras-devel.sha256sum] = "c1062ea29267f923640ab6a5e2896d1cf1c7caaead0a60aed4c6fd780cdbb591"

URI_aarch64_rust-pest_meta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_meta-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest_meta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_meta-devel}"
SRC_URI[aarch64_rust-pest_meta-devel.sha256sum] = "a662d1a583f17c16cb21eb8236f5e7a432a980d3442a199ca0139d1fec725008"

RDEPENDS:rust-pest_meta+default-devel = " \
 cargo \
 rust-pest_meta-devel \
 "
RDEPENDS:rust-pest_meta+grammar-extras-devel = " \
 cargo \
 rust-pest_meta-devel \
 "
RDEPENDS:rust-pest_meta-devel = " \
 cargo \
 rust \
 rust-pest+default-devel \
 rust-sha2-devel \
 "
