# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-platform"
PV = "0.3.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-cargo-platform+default-devel \
 rust-cargo-platform-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-platform-0.3.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b8720d4d04a565f408f401d42511b7d33cae53bb9e87062f1ac3163cda952d8"

URI_x86_64_v2_rust-cargo-platform+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-platform+default-devel-0.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-platform+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-platform+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-platform+default-devel.sha256sum] = "e5e0f3e1cb1472820dde201cd2ae638c3f20b53a47731aade258588081da47f4"

URI_x86_64_v2_rust-cargo-platform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-platform-devel-0.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-platform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-platform-devel}"
SRC_URI[x86_64_v2_rust-cargo-platform-devel.sha256sum] = "026f77df2acc256c9609510b613910c5f25ea421f82c5c53a33b3a76ee24dc7b"

URI_aarch64_rust-cargo-platform+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-platform+default-devel-0.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-platform+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-platform+default-devel}"
SRC_URI[aarch64_rust-cargo-platform+default-devel.sha256sum] = "6aaaf1111c026ecc47185dbf9fc04f7f7c17180ce710bbca94eba00928be30ec"

URI_aarch64_rust-cargo-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-platform-devel-0.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-platform-devel}"
SRC_URI[aarch64_rust-cargo-platform-devel.sha256sum] = "1574782a4184e826edd5427438e86ac4e09dd395f2717590d52400ac0bdd34d6"

RDEPENDS:rust-cargo-platform+default-devel = " \
 cargo \
 rust-cargo-platform-devel \
 "
RDEPENDS:rust-cargo-platform-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde_core+default-devel \
 "
