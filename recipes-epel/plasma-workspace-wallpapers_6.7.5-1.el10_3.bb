# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-workspace-wallpapers"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-workspace-wallpapers \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-workspace-wallpapers-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9112bfe118140998ad3e3808ed55e14ee0df6a9d188fbe781965dc6982c5261f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-wallpapers-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-workspace-wallpapers;unpack=0"
SRC_URI[x86_64_v2_plasma-workspace-wallpapers.sha256sum] = "1cfb6d0a18b9bc6c542a5ef22ddd5ee8b7c03aa62e13ea7ad4a1cf5abf48306f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-wallpapers-6.7.5-1.el10_3.noarch.rpm;name=aarch64_plasma-workspace-wallpapers;unpack=0"
SRC_URI[aarch64_plasma-workspace-wallpapers.sha256sum] = "767fc6913aa0b5c02d7872acb60534458709af8d16104f9dc056bdd0a604f815"

RDEPENDS:plasma-workspace-wallpapers = " \
 kde-filesystem \
 "
