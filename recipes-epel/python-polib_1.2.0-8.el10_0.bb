# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-polib"
PV = "1.2.0"
PR = "8.el10_0"
PACKAGES = " \
 python3-polib \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-polib-1.2.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2b4beea21f2f9edc326effc96db50caf48bb2ff97d5c29e6e126ffa8254cccbd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-polib-1.2.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-polib;unpack=0"
SRC_URI[x86_64_v2_python3-polib.sha256sum] = "fae7fc4092306a53934bcd2a963d8b8f5957b29578b0881592b77cc251009a07"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-polib-1.2.0-8.el10_0.noarch.rpm;name=aarch64_python3-polib;unpack=0"
SRC_URI[aarch64_python3-polib.sha256sum] = "e2399c3ce46d8035cedb1f4275d731597c63256fbd9861f1a8a63145ffcd3e0f"

RDEPENDS:python3-polib = " \
 python3 \
 "
