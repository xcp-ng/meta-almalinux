# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "m17n-db"
PV = "1.8.5"
PR = "7.el10"
PACKAGES = " \
 m17n-db \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/m17n-db-1.8.5-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "937b4b077f9f1eeafee50330cc2c129e11933710f63f34429c7c8fba808a8653"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/m17n-db-1.8.5-7.el10.noarch.rpm;name=x86_64_v2_m17n-db;unpack=0"
SRC_URI[x86_64_v2_m17n-db.sha256sum] = "3b256ebaece406fe4aa0342cbd085843e137c94cf7bfaef8f422cae5b46c9227"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/m17n-db-1.8.5-7.el10.noarch.rpm;name=aarch64_m17n-db;unpack=0"
SRC_URI[aarch64_m17n-db.sha256sum] = "3b256ebaece406fe4aa0342cbd085843e137c94cf7bfaef8f422cae5b46c9227"

RDEPENDS:m17n-db = " \
 gawk \
 "
