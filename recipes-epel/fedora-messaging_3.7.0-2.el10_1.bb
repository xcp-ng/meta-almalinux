# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-messaging"
PV = "3.7.0"
PR = "2.el10_1"
PACKAGES = " \
 fedora-messaging \
 python3-fedora-messaging \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-messaging-3.7.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16c84aa3d56c47311cb8089fe42eb9c0bd39d2bc1d853a0d8bf652d28520a3ab"

URI_x86_64_v2_fedora-messaging = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-messaging-3.7.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-messaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-messaging}"
SRC_URI[x86_64_v2_fedora-messaging.sha256sum] = "dbcc9c931122f38e9fe9291b22b377043f0f0116939f451d75d059eda9bbe8cf"

URI_x86_64_v2_python3-fedora-messaging = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fedora-messaging-3.7.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fedora-messaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fedora-messaging}"
SRC_URI[x86_64_v2_python3-fedora-messaging.sha256sum] = "8545b038d384b2bcae482e78e54c100729b7ba4b724352357fa83fc1bbf5ce7a"

URI_aarch64_fedora-messaging = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-messaging-3.7.0-2.el10_1.noarch.rpm;name=aarch64_fedora-messaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-messaging}"
SRC_URI[aarch64_fedora-messaging.sha256sum] = "cfa35e9bba3ea5bcf666da602a9f5385e5956e0e7a89feeea248bc84d30f7d7a"

URI_aarch64_python3-fedora-messaging = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fedora-messaging-3.7.0-2.el10_1.noarch.rpm;name=aarch64_python3-fedora-messaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fedora-messaging}"
SRC_URI[aarch64_python3-fedora-messaging.sha256sum] = "35e31fe6b3128f981740105cf60352566e5f41859694dd617d661cf90dbb4576"

RDEPENDS:fedora-messaging = " \
 python3 \
 python3-fedora-messaging \
 "
RDEPENDS:python3-fedora-messaging = " \
 python3 \
 python3-blinker \
 python3-click \
 python3-crochet \
 python3-jsonschema \
 python3-pika \
 python3-pyOpenSSL \
 python3-requests \
 python3-service-identity \
 python3-tomli \
 python3-twisted \
 "
