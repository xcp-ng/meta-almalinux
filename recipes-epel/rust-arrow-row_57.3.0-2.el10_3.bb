# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrow-row"
PV = "57.3.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-arrow-row+default-devel \
 rust-arrow-row-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrow-row-57.3.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81647db409aff5033ccc2164628fb48c65f9a2d1ce25204742353bec6bc862d3"

URI_x86_64_v2_rust-arrow-row+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-row+default-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-row+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-row+default-devel}"
SRC_URI[x86_64_v2_rust-arrow-row+default-devel.sha256sum] = "a88088c5ff2c0869f5de7521602ff43b6438ccda7ae88bb524766439608c4f40"

URI_x86_64_v2_rust-arrow-row-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-row-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-row-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-row-devel}"
SRC_URI[x86_64_v2_rust-arrow-row-devel.sha256sum] = "fe8999f5c56e458393d2feec7c787d49e41d0589ae8797eb05509bbc965698c8"

URI_aarch64_rust-arrow-row+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-row+default-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-row+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-row+default-devel}"
SRC_URI[aarch64_rust-arrow-row+default-devel.sha256sum] = "2bc79d77071bf8431d73bc784019d8e5b348b11ddcda84b9f9de7205ae272236"

URI_aarch64_rust-arrow-row-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-row-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-row-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-row-devel}"
SRC_URI[aarch64_rust-arrow-row-devel.sha256sum] = "260e7607e3e7c1e5b45a62fc3d2c25ae9324bc6c6c93bf11b6835a331948bb27"

RDEPENDS:rust-arrow-row+default-devel = " \
 cargo \
 rust-arrow-row-devel \
 "
RDEPENDS:rust-arrow-row-devel = " \
 cargo \
 rust \
 rust-arrow-array+default-devel \
 rust-arrow-buffer+default-devel \
 rust-arrow-data+default-devel \
 rust-arrow-schema+default-devel \
 rust-half-devel \
 "
