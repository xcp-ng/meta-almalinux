# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-core"
PV = "0.1.34"
PR = "1.el10_0"
PACKAGES = " \
 rust-tracing-core+default-devel \
 rust-tracing-core+once_cell-devel \
 rust-tracing-core+std-devel \
 rust-tracing-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-core-0.1.34-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db246861a58b525fa8825431f4b57dfc7e491b8aa6493fee8e1e373f79ae4609"

URI_x86_64_v2_rust-tracing-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-core+default-devel-0.1.34-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-core+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-core+default-devel.sha256sum] = "168c73c2191e8223e4d06b4256023740788926848c72b1a765f99442e135ca17"

URI_x86_64_v2_rust-tracing-core+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-core+once_cell-devel-0.1.34-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-core+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-core+once_cell-devel}"
SRC_URI[x86_64_v2_rust-tracing-core+once_cell-devel.sha256sum] = "b2283a2ef1e8d7df1b9107b0e02b889e1755d7cade01a515beb1d875a74a7254"

URI_x86_64_v2_rust-tracing-core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-core+std-devel-0.1.34-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-core+std-devel}"
SRC_URI[x86_64_v2_rust-tracing-core+std-devel.sha256sum] = "0e7650f8137621727079804e8c5a01fc42711977efd976d79894743826fc1700"

URI_x86_64_v2_rust-tracing-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-core-devel-0.1.34-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-core-devel}"
SRC_URI[x86_64_v2_rust-tracing-core-devel.sha256sum] = "1a4d7e942c1d8d2142dd155328b89a03adcc650aae8c32049784ead806861d67"

URI_aarch64_rust-tracing-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-core+default-devel-0.1.34-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-core+default-devel}"
SRC_URI[aarch64_rust-tracing-core+default-devel.sha256sum] = "9385ee5052ae8781d6d466d65a24fc325c9df751bb12ac9f5c9968093636f7e8"

URI_aarch64_rust-tracing-core+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-core+once_cell-devel-0.1.34-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-core+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-core+once_cell-devel}"
SRC_URI[aarch64_rust-tracing-core+once_cell-devel.sha256sum] = "81aa7451613362026f84ac98031aba4c273d2c53ed248bcd7f8b05ee4bf65e6e"

URI_aarch64_rust-tracing-core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-core+std-devel-0.1.34-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-core+std-devel}"
SRC_URI[aarch64_rust-tracing-core+std-devel.sha256sum] = "c923e6ce210dbd5c938783eac513d40e2c922ca1d716242b33ca69cd6acd19d8"

URI_aarch64_rust-tracing-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-core-devel-0.1.34-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-core-devel}"
SRC_URI[aarch64_rust-tracing-core-devel.sha256sum] = "77889d8929c57b8e53838ddc166989cef5423f0aa691a5b040cb744f66355b13"

RDEPENDS:rust-tracing-core+default-devel = " \
 cargo \
 rust-tracing-core+std-devel \
 rust-tracing-core-devel \
 "
RDEPENDS:rust-tracing-core+once_cell-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-tracing-core-devel \
 "
RDEPENDS:rust-tracing-core+std-devel = " \
 cargo \
 rust-tracing-core+once_cell-devel \
 rust-tracing-core-devel \
 "
RDEPENDS:rust-tracing-core-devel = " \
 cargo \
 rust \
 "
