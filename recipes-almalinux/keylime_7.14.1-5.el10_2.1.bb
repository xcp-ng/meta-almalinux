# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keylime"
PV = "7.14.1"
PR = "5.el10_2.1"
PACKAGES = " \
 keylime \
 keylime-base \
 keylime-registrar \
 keylime-selinux \
 keylime-tenant \
 keylime-tools \
 keylime-verifier \
 python3-keylime \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/keylime-7.14.1-5.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40ed25f956ec1ecf5dc24fdc7cdfaf63cd268a2861e735055df17dd47df07766"

URI_x86_64_v2_keylime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-7.14.1-5.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_keylime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime}"
SRC_URI[x86_64_v2_keylime.sha256sum] = "1b1367ced566707e37fe1708297631a1c7e1dcd80fb664f53f5454ca96477b4c"

URI_x86_64_v2_keylime-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-base-7.14.1-5.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_keylime-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-base}"
SRC_URI[x86_64_v2_keylime-base.sha256sum] = "4eb62bd33dee595e8cda8773469696804a8c423cbaffdb7a127b06ae5287fe48"

URI_x86_64_v2_keylime-registrar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-registrar-7.14.1-5.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_keylime-registrar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-registrar}"
SRC_URI[x86_64_v2_keylime-registrar.sha256sum] = "77bef8955aa78ae262f8974f44634e51123424f7e8984cc1d05b526c886cbc52"

URI_x86_64_v2_keylime-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-selinux-7.14.1-5.el10_2.1.noarch.rpm;name=x86_64_v2_keylime-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-selinux}"
SRC_URI[x86_64_v2_keylime-selinux.sha256sum] = "d087cd9f6da8c7f7422c92a84a47ffcc48661ffb612541d27410ec43622a490a"

URI_x86_64_v2_keylime-tenant = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-tenant-7.14.1-5.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_keylime-tenant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-tenant}"
SRC_URI[x86_64_v2_keylime-tenant.sha256sum] = "cc4b1b1ace432ad69b751aa4b6d82908255377819bccb76d75a7dcba2021ed0c"

URI_x86_64_v2_keylime-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-tools-7.14.1-5.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_keylime-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-tools}"
SRC_URI[x86_64_v2_keylime-tools.sha256sum] = "fddc6cc5b42386a2964d24db70feb5dc9185e4a0a0624923100e4915bdcb3744"

URI_x86_64_v2_keylime-verifier = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-verifier-7.14.1-5.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_keylime-verifier;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-verifier}"
SRC_URI[x86_64_v2_keylime-verifier.sha256sum] = "7f54eb0faa1eda49969397d3b956c22f691fe00f54426eeeef1ce7d3a7b09a10"

URI_x86_64_v2_python3-keylime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-keylime-7.14.1-5.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3-keylime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keylime}"
SRC_URI[x86_64_v2_python3-keylime.sha256sum] = "b54322c9265eadf34404e7565566f3603bbea0ddffe1ae1f00e790dc069d6668"

URI_aarch64_keylime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-7.14.1-5.el10_2.1.aarch64.rpm;name=aarch64_keylime;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime}"
SRC_URI[aarch64_keylime.sha256sum] = "02906b2fd442799b46e5634b5e6ea75607e741c7f9489d533cad3eb509bbaa83"

URI_aarch64_keylime-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-base-7.14.1-5.el10_2.1.aarch64.rpm;name=aarch64_keylime-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-base}"
SRC_URI[aarch64_keylime-base.sha256sum] = "ab85b9df2adfe1b69d73b8828dd92bb3e4813b5a2330aa9b4d2f135703d29ed6"

URI_aarch64_keylime-registrar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-registrar-7.14.1-5.el10_2.1.aarch64.rpm;name=aarch64_keylime-registrar;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-registrar}"
SRC_URI[aarch64_keylime-registrar.sha256sum] = "82a76e548785fda6e969ccf72aef55d4694d8cd02a874990db625d594dcd8b82"

URI_aarch64_keylime-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-selinux-7.14.1-5.el10_2.1.noarch.rpm;name=aarch64_keylime-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-selinux}"
SRC_URI[aarch64_keylime-selinux.sha256sum] = "d087cd9f6da8c7f7422c92a84a47ffcc48661ffb612541d27410ec43622a490a"

URI_aarch64_keylime-tenant = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-tenant-7.14.1-5.el10_2.1.aarch64.rpm;name=aarch64_keylime-tenant;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-tenant}"
SRC_URI[aarch64_keylime-tenant.sha256sum] = "47da61efcdb599705d13f94c800cb3e9bfc63bd49816964b14c1e109d929bae4"

URI_aarch64_keylime-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-tools-7.14.1-5.el10_2.1.aarch64.rpm;name=aarch64_keylime-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-tools}"
SRC_URI[aarch64_keylime-tools.sha256sum] = "c1930416038862ed3df5b02c67dbe128a17115785bdef559b646e7cbe9d9acc8"

URI_aarch64_keylime-verifier = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-verifier-7.14.1-5.el10_2.1.aarch64.rpm;name=aarch64_keylime-verifier;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-verifier}"
SRC_URI[aarch64_keylime-verifier.sha256sum] = "4faabbbbf47898e9486d25ec4f290d0a5481102413ba49edc672c860519fbc8a"

URI_aarch64_python3-keylime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-keylime-7.14.1-5.el10_2.1.aarch64.rpm;name=aarch64_python3-keylime;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keylime}"
SRC_URI[aarch64_python3-keylime.sha256sum] = "3b5f34f412ed77a3cc87f4cdb89fb8d8a0311d7474cabb4a833a62274bee56d6"

RDEPENDS:keylime = " \
 keylime-base \
 keylime-registrar \
 keylime-tenant \
 keylime-tools \
 keylime-verifier \
 python3-keylime \
 virtual/keylime-agent \
 "
RDEPENDS:keylime-base = " \
 bash \
 efivar-libs \
 openssl \
 procps-ng \
 python3 \
 python3-jinja2 \
 shadow-utils \
 tpm2-tss \
 "
RDEPENDS:keylime-registrar = " \
 bash \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:keylime-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:keylime-tenant = " \
 bash \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:keylime-tools = " \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:keylime-verifier = " \
 bash \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:python3-keylime = " \
 keylime-base \
 python3 \
 python3-alembic \
 python3-cryptography \
 python3-gpg \
 python3-jsonschema \
 python3-lark \
 python3-packaging \
 python3-psutil \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-pyyaml \
 python3-requests \
 python3-sqlalchemy \
 python3-tornado \
 python3-typing-extensions \
 tpm2-tools \
 "
