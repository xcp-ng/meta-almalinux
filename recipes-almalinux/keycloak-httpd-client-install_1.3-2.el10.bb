# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keycloak-httpd-client-install"
PV = "1.3"
PR = "2.el10"
PACKAGES = " \
 keycloak-httpd-client-install \
 python3-keycloak-httpd-client-install \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/keycloak-httpd-client-install-1.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3950a29fb7c818801d5b72c1b500c7f2a2900f254014112462b648c4fc649919"

URI_x86_64_v2_keycloak-httpd-client-install = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keycloak-httpd-client-install-1.3-2.el10.noarch.rpm;name=x86_64_v2_keycloak-httpd-client-install;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keycloak-httpd-client-install}"
SRC_URI[x86_64_v2_keycloak-httpd-client-install.sha256sum] = "e1bdbbde69c0bbdb503803f95768e271a7560e96836cbf3426093659dc621b29"

URI_x86_64_v2_python3-keycloak-httpd-client-install = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-keycloak-httpd-client-install-1.3-2.el10.noarch.rpm;name=x86_64_v2_python3-keycloak-httpd-client-install;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keycloak-httpd-client-install}"
SRC_URI[x86_64_v2_python3-keycloak-httpd-client-install.sha256sum] = "26aabadd57c1596ac1f83b1ee737083c5cf3ad1c32cf56cec9bef38d30ddfd52"

URI_aarch64_keycloak-httpd-client-install = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keycloak-httpd-client-install-1.3-2.el10.noarch.rpm;name=aarch64_keycloak-httpd-client-install;unpack=0"
SRC_URI:append = " ${URI_aarch64_keycloak-httpd-client-install}"
SRC_URI[aarch64_keycloak-httpd-client-install.sha256sum] = "e1bdbbde69c0bbdb503803f95768e271a7560e96836cbf3426093659dc621b29"

URI_aarch64_python3-keycloak-httpd-client-install = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-keycloak-httpd-client-install-1.3-2.el10.noarch.rpm;name=aarch64_python3-keycloak-httpd-client-install;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keycloak-httpd-client-install}"
SRC_URI[aarch64_python3-keycloak-httpd-client-install.sha256sum] = "26aabadd57c1596ac1f83b1ee737083c5cf3ad1c32cf56cec9bef38d30ddfd52"

RDEPENDS:keycloak-httpd-client-install = " \
 python3-keycloak-httpd-client-install \
 "
RDEPENDS:python3-keycloak-httpd-client-install = " \
 keycloak-httpd-client-install \
 python3 \
 python3-jinja2 \
 python3-lxml \
 python3-requests \
 python3-requests-oauthlib \
 "
