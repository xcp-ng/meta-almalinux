# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ar_archive_writer"
PV = "0.5.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-ar_archive_writer+default-devel \
 rust-ar_archive_writer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ar_archive_writer-0.5.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8176f0830636f9ed3d0b5a4fb7e14bd5dc60c58948a5b55520ed381242a01569"

URI_x86_64_v2_rust-ar_archive_writer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ar_archive_writer+default-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ar_archive_writer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ar_archive_writer+default-devel}"
SRC_URI[x86_64_v2_rust-ar_archive_writer+default-devel.sha256sum] = "a51822bd888b60d56799f8fd0e5d56bc0067bfd8f21c64ffb14a7b8982189c5e"

URI_x86_64_v2_rust-ar_archive_writer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ar_archive_writer-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ar_archive_writer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ar_archive_writer-devel}"
SRC_URI[x86_64_v2_rust-ar_archive_writer-devel.sha256sum] = "ff0d6b02681f6b4fa4f88a2fefe3d3788f4cc4bec5207c87319620fc0bc6e491"

URI_aarch64_rust-ar_archive_writer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ar_archive_writer+default-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-ar_archive_writer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ar_archive_writer+default-devel}"
SRC_URI[aarch64_rust-ar_archive_writer+default-devel.sha256sum] = "78d8ea229a314871f669496a82846a4ebd889c870dcf25194b7ecd532ec1d7e2"

URI_aarch64_rust-ar_archive_writer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ar_archive_writer-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-ar_archive_writer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ar_archive_writer-devel}"
SRC_URI[aarch64_rust-ar_archive_writer-devel.sha256sum] = "8f110a11e8e3c20e89df6c089d36d73e1e7468a6c4f32bf8b1360330a4d20464"

RDEPENDS:rust-ar_archive_writer+default-devel = " \
 cargo \
 rust-ar_archive_writer-devel \
 "
RDEPENDS:rust-ar_archive_writer-devel = " \
 cargo \
 rust \
 rust-object+read-devel \
 rust-object+std-devel \
 rust-object-devel \
 "
