# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-dev-utils"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kde-dev-utils \
 kde-dev-utils-common \
 kpartloader \
 kuiviewer \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kde-dev-utils-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2094f4aece7c714b2bd8f7ce1208339f007016b3b88885d075bd05f1a569e05d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-dev-utils-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-dev-utils;unpack=0"
SRC_URI[x86_64_v2_kde-dev-utils.sha256sum] = "70ae5408bcea7c922fbbf0722fd894b08b3598c7e45491062a0c94cbcb5c1fdf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-dev-utils-common-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kde-dev-utils-common;unpack=0"
SRC_URI[x86_64_v2_kde-dev-utils-common.sha256sum] = "97308c23c2031f7a7345b3c334be34e2c4efb6a86a89ddea13523cd57dde1108"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpartloader-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpartloader;unpack=0"
SRC_URI[x86_64_v2_kpartloader.sha256sum] = "cebf3f6f43066e21a13c92fae5e8ff91f98956bdcdde1d7d76d9051e2ae571ab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kuiviewer-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kuiviewer;unpack=0"
SRC_URI[x86_64_v2_kuiviewer.sha256sum] = "d477b9d2518682870fdaf3128c0b9fd936247ab66cc5b8f54761d3897130aa4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kde-dev-utils-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kde-dev-utils;unpack=0"
SRC_URI[aarch64_kde-dev-utils.sha256sum] = "bbcc8547f01d464c9270947b5fa3428354220974471c948c6e4312d73fed04ec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kde-dev-utils-common-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kde-dev-utils-common;unpack=0"
SRC_URI[aarch64_kde-dev-utils-common.sha256sum] = "28b4033867d19250ae9948fc98563121e26bec83c23e4684a2cb6ab5e7f25ca3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kpartloader-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kpartloader;unpack=0"
SRC_URI[aarch64_kpartloader.sha256sum] = "6a16204f67aaeeb35cdb358e746f9a5f1c7035cf94c70bda5cb019de4fb049b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kuiviewer-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kuiviewer;unpack=0"
SRC_URI[aarch64_kuiviewer.sha256sum] = "e72f334ca254aae847af2e91bfb23a09b1f693fa7eb51b7d0fb193c41cc63737"

RDEPENDS:kde-dev-utils = " \
 kpartloader \
 kuiviewer \
 "
RDEPENDS:kde-dev-utils-common = " \
 "
RDEPENDS:kpartloader = " \
 glibc \
 kde-dev-utils-common \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kuiviewer = " \
 glibc \
 kde-dev-utils-common \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-designer \
 "
