# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-des"
PV = "0.9.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-des+default-devel \
 rust-des+zeroize-devel \
 rust-des-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-des-0.9.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23e15d05271b11703ddabf21469224f693121691e7dbeab2227424524c90af7f"

URI_x86_64_v2_rust-des+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-des+default-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-des+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-des+default-devel}"
SRC_URI[x86_64_v2_rust-des+default-devel.sha256sum] = "06ee995b649381c4c9e4220878defde8a3499b451f6c13abb314f84196655a32"

URI_x86_64_v2_rust-des+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-des+zeroize-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-des+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-des+zeroize-devel}"
SRC_URI[x86_64_v2_rust-des+zeroize-devel.sha256sum] = "85319b1f43e1c9c0892f808ca507ec8e52e3754034142729f30b0f951a7102dc"

URI_x86_64_v2_rust-des-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-des-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-des-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-des-devel}"
SRC_URI[x86_64_v2_rust-des-devel.sha256sum] = "8a96f216f9f298b18a594f5c819429b18ccd2e4136d290bf4a89f5257d39da09"

URI_aarch64_rust-des+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-des+default-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-des+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-des+default-devel}"
SRC_URI[aarch64_rust-des+default-devel.sha256sum] = "c84b4e9ea8636cd5886380de08a1dc4b6df7182218b5e5c84bbe741c8968ae8a"

URI_aarch64_rust-des+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-des+zeroize-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-des+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-des+zeroize-devel}"
SRC_URI[aarch64_rust-des+zeroize-devel.sha256sum] = "03d52521a72fd5cb8a5ef9c93066ca49a6e870fe4a25a5047309831e12e6aa23"

URI_aarch64_rust-des-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-des-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-des-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-des-devel}"
SRC_URI[aarch64_rust-des-devel.sha256sum] = "cbe5bc1760ed497a7974fed80cf2c47c5ba53051602898c991e6ab203a3ace70"

RDEPENDS:rust-des+default-devel = " \
 cargo \
 rust-des-devel \
 "
RDEPENDS:rust-des+zeroize-devel = " \
 cargo \
 rust-cipher+zeroize-devel \
 rust-des-devel \
 "
RDEPENDS:rust-des-devel = " \
 cargo \
 rust \
 rust-cipher+default-devel \
 "
