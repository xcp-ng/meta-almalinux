# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kteatime"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kteatime \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kteatime-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69c87699a25e7a9018f725cf7f5c1ef3da182e280898b992445fe7d42bea6241"

URI_x86_64_v2_kteatime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kteatime-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kteatime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kteatime}"
SRC_URI[x86_64_v2_kteatime.sha256sum] = "38a9e4a4df3cc353765a7cc5cdf58c8697462aa5c604da1c3eda6098db52f177"

URI_aarch64_kteatime = "${EPEL_MIRROR}/aarch64/Packages/k/kteatime-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kteatime;unpack=0"
SRC_URI:append = " ${URI_aarch64_kteatime}"
SRC_URI[aarch64_kteatime.sha256sum] = "06873655f5a006a6ebd42062327e2fd78ee878431681304adaec866a1a32dd09"

RDEPENDS:kteatime = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
