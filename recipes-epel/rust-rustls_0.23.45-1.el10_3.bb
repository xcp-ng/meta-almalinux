# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls"
PV = "0.23.45"
PR = "1.el10_3"
PACKAGES = " \
 rust-rustls+brotli-devel \
 rust-rustls+custom-provider-devel \
 rust-rustls+default-devel \
 rust-rustls+hashbrown-devel \
 rust-rustls+log-devel \
 rust-rustls+logging-devel \
 rust-rustls+read_buf-devel \
 rust-rustls+ring-devel \
 rust-rustls+rustversion-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls+zlib-devel \
 rust-rustls-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-0.23.45-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9fe1000266f7b7b80cc15f73805fd2d2a4903f052df4a8df052c9cbc5745822d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+brotli-devel-0.23.45-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+brotli-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+brotli-devel.sha256sum] = "110e52a069aae1e0f6a0b75f8b6c4b12390ff93239b7793cc4ba9dad61807b78"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+custom-provider-devel-0.23.45-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+custom-provider-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+custom-provider-devel.sha256sum] = "a298c9536e35e7e78301652c5a19de5d790d10f6eab472cc3d50b730436e3ff2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+default-devel-0.23.45-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+default-devel.sha256sum] = "a99688e5cba30bd93992637a1d18b258aa04ae43ce653dcc1bb8b43a4f2df251"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+hashbrown-devel-0.23.45-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+hashbrown-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+hashbrown-devel.sha256sum] = "71855007de145960cc740d8586483ccaa18837f5b0631023332944e04936c7d2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+log-devel-0.23.45-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+log-devel.sha256sum] = "80a6e98878934d123dc84bef27d74688063bf137acdbad86dcc5533437680b04"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+logging-devel-0.23.45-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+logging-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+logging-devel.sha256sum] = "9933e1c579e9531f6ecfb98bea46498b77b77b3022334c4d1cda147d547b7f4e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+read_buf-devel-0.23.45-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+read_buf-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+read_buf-devel.sha256sum] = "28dc1570721d45c4ae37f776234c36eb041f02d4578800adfc2caab4fc17b79d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+ring-devel-0.23.45-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+ring-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+ring-devel.sha256sum] = "a0835e72ba0fa658e947f6f4470cfb4bab0df212a5e5b500ddfdbca25553745b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+rustversion-devel-0.23.45-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+rustversion-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+rustversion-devel.sha256sum] = "32ccf3c3dca4655e48f7f6682f23507ac15551da1aa1f7c06f029b4198e9ef2b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+std-devel-0.23.45-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+std-devel.sha256sum] = "c9135df02348e55eff60bac917aaca066f20ca53efc426f19297e99ea777f3b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+tls12-devel-0.23.45-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+tls12-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+tls12-devel.sha256sum] = "103ec8a1023d7e54ac41c1f8b821addcc9169314a1790a8f865ae7763500bf55"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+zlib-devel-0.23.45-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+zlib-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+zlib-devel.sha256sum] = "48f8efead07a0608771428553e465dc367e9d0513824752ceb83d2d1e7db9622"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-devel-0.23.45-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-devel.sha256sum] = "7c1b0ad54311c0492331be4149b05a795463d866606675462252bc2edc603239"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+brotli-devel-0.23.45-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+brotli-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+brotli-devel.sha256sum] = "140d0e68c77f96005ae8c396ed81e3a0e29f4a029109985c6dcfc64a1a437cbe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+custom-provider-devel-0.23.45-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+custom-provider-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+custom-provider-devel.sha256sum] = "211a5ce86b69f3d20641a3f7585c3be506a2f6f79de2c45fb7d342ce670f968a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+default-devel-0.23.45-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+default-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+default-devel.sha256sum] = "62e6e68e659e354add133fb7f6f0036dae142597b7fc0f56df72613db9dff3c9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+hashbrown-devel-0.23.45-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+hashbrown-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+hashbrown-devel.sha256sum] = "d405f6e7c5a83d8b070da3c5a0d4372c13e5c112c82a48c86c4e6b9987eb4f72"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+log-devel-0.23.45-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+log-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+log-devel.sha256sum] = "e7141cab556a918f741fa01e55aaedbfb1a9cd852bcf750b302f88b70905a199"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+logging-devel-0.23.45-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+logging-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+logging-devel.sha256sum] = "556dd78f5f1525db660e4f73183c814ced3db5f49d66f6dec7c2ee2d4260113b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+read_buf-devel-0.23.45-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+read_buf-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+read_buf-devel.sha256sum] = "f8fec9c3741bb61c3a26663763a93bb47031b788c846daf87284de905d08d287"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+ring-devel-0.23.45-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+ring-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+ring-devel.sha256sum] = "f1aa077dd955880918a7771b9e70fbb6be1c6772eb870723e4c1ccbd5d4a6c1c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+rustversion-devel-0.23.45-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+rustversion-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+rustversion-devel.sha256sum] = "dbd9d0ae8be6f905ca293d243487b3f581e79234ab5ff7e469cd842bda32fca0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+std-devel-0.23.45-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+std-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+std-devel.sha256sum] = "58adc318c45902b561b34ee93ecfe7dccbb31bcae4ba604e7a4f1f39075d3f84"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+tls12-devel-0.23.45-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+tls12-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+tls12-devel.sha256sum] = "a6215dd2016068d5108adc48120165cd26df7382938ab727dd13bda4c0f358b8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+zlib-devel-0.23.45-1.el10_3.noarch.rpm;name=aarch64_rust-rustls+zlib-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+zlib-devel.sha256sum] = "ca4808cf93d4db152a7b6bb0f067ce9b2614df0b6c7c88d7153b9becc89fc111"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-devel-0.23.45-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-devel.sha256sum] = "78878f39d0ef7edb9af291517a1260a1e4576d455633dad020268d169a8cf7aa"

RDEPENDS:rust-rustls+brotli-devel = " \
 cargo \
 rust-brotli+std-devel \
 rust-brotli-decompressor+default-devel \
 rust-brotli-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+custom-provider-devel = " \
 cargo \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+default-devel = " \
 cargo \
 rust-rustls+logging-devel \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+hashbrown-devel = " \
 cargo \
 rust-hashbrown0.15+default-hasher-devel \
 rust-hashbrown0.15+inline-more-devel \
 rust-hashbrown0.15-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+logging-devel = " \
 cargo \
 rust-rustls+log-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+read_buf-devel = " \
 cargo \
 rust-rustls+rustversion-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+ring-devel = " \
 cargo \
 rust-ring+default-devel \
 rust-rustls-devel \
 rust-rustls-webpki+ring-devel \
 "
RDEPENDS:rust-rustls+rustversion-devel = " \
 cargo \
 rust-rustls-devel \
 rust-rustversion+default-devel \
 "
RDEPENDS:rust-rustls+std-devel = " \
 cargo \
 rust-once_cell+std-devel \
 rust-rustls-devel \
 rust-rustls-pki-types+std-devel \
 rust-rustls-webpki+std-devel \
 "
RDEPENDS:rust-rustls+tls12-devel = " \
 cargo \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+zlib-devel = " \
 cargo \
 rust-rustls-devel \
 rust-zlib-rs+default-devel \
 "
RDEPENDS:rust-rustls-devel = " \
 cargo \
 rust \
 rust-once_cell+alloc-devel \
 rust-once_cell+race-devel \
 rust-once_cell-devel \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki-devel \
 rust-subtle-devel \
 rust-zeroize+default-devel \
 "
