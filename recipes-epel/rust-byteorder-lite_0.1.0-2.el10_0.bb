# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-byteorder-lite"
PV = "0.1.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-byteorder-lite+default-devel \
 rust-byteorder-lite+std-devel \
 rust-byteorder-lite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-byteorder-lite-0.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b13348899c9fc0045d3e92bd95e3ed9aac34e4a355be26acf60aa059cddfa33"

URI_x86_64_v2_rust-byteorder-lite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byteorder-lite+default-devel-0.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byteorder-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byteorder-lite+default-devel}"
SRC_URI[x86_64_v2_rust-byteorder-lite+default-devel.sha256sum] = "b511eb37e08ca30af8a4d8f6f279af8958ddef7db66ed97c0d06f5b924b7c123"

URI_x86_64_v2_rust-byteorder-lite+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byteorder-lite+std-devel-0.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byteorder-lite+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byteorder-lite+std-devel}"
SRC_URI[x86_64_v2_rust-byteorder-lite+std-devel.sha256sum] = "6b22e51edc424d6d03ea5fad02e27a417b94fc77893231f5ead85717b3c2372c"

URI_x86_64_v2_rust-byteorder-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byteorder-lite-devel-0.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byteorder-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byteorder-lite-devel}"
SRC_URI[x86_64_v2_rust-byteorder-lite-devel.sha256sum] = "0c0a4d9ad2355ed32ebcf550d5af79fd7e4c9c2249f97cbca2e649d38b85a4c7"

URI_aarch64_rust-byteorder-lite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byteorder-lite+default-devel-0.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-byteorder-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byteorder-lite+default-devel}"
SRC_URI[aarch64_rust-byteorder-lite+default-devel.sha256sum] = "9c06134f45e56735b1f0e488e904423c1717477ecf3d3c21fffdc5986f6ecff1"

URI_aarch64_rust-byteorder-lite+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byteorder-lite+std-devel-0.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-byteorder-lite+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byteorder-lite+std-devel}"
SRC_URI[aarch64_rust-byteorder-lite+std-devel.sha256sum] = "570f678c71ff7791e149f9752d85684b0d21545ff11d4ff09c42cbafba931b9e"

URI_aarch64_rust-byteorder-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byteorder-lite-devel-0.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-byteorder-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byteorder-lite-devel}"
SRC_URI[aarch64_rust-byteorder-lite-devel.sha256sum] = "1699ab7c09424bf1164e01d8b8a616585033533813327e8f33d8f22ac7bd0f65"

RDEPENDS:rust-byteorder-lite+default-devel = " \
 cargo \
 rust-byteorder-lite+std-devel \
 rust-byteorder-lite-devel \
 "
RDEPENDS:rust-byteorder-lite+std-devel = " \
 cargo \
 rust-byteorder-lite-devel \
 "
RDEPENDS:rust-byteorder-lite-devel = " \
 cargo \
 rust \
 "
