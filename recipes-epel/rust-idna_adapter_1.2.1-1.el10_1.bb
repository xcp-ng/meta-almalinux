# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-idna_adapter"
PV = "1.2.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-idna_adapter+compiled_data-devel \
 rust-idna_adapter+default-devel \
 rust-idna_adapter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-idna_adapter-1.2.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f702765f56187129cb68b1d989b0782b5fac941732a4df9364333faca80bb91d"

URI_x86_64_v2_rust-idna_adapter+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna_adapter+compiled_data-devel-1.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna_adapter+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna_adapter+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-idna_adapter+compiled_data-devel.sha256sum] = "53ee627825a39d9dbe91a7c2e1b5df92d6f9c4b5e969cc50f76034dd0e413746"

URI_x86_64_v2_rust-idna_adapter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna_adapter+default-devel-1.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna_adapter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna_adapter+default-devel}"
SRC_URI[x86_64_v2_rust-idna_adapter+default-devel.sha256sum] = "7fe2fe1a6324b7615ffc668f254e7ed71147e1062417022df36aabec0d516edb"

URI_x86_64_v2_rust-idna_adapter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna_adapter-devel-1.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna_adapter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna_adapter-devel}"
SRC_URI[x86_64_v2_rust-idna_adapter-devel.sha256sum] = "4116b02c154eda29f49804304d0edaab09461103e7611b83d91a72c37ebcc3f4"

URI_aarch64_rust-idna_adapter+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna_adapter+compiled_data-devel-1.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-idna_adapter+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna_adapter+compiled_data-devel}"
SRC_URI[aarch64_rust-idna_adapter+compiled_data-devel.sha256sum] = "f7f2fd93fccf3a4ce9b8ec19b03299fa21de3da77c42cfbcd1daa8aea40dc1ff"

URI_aarch64_rust-idna_adapter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna_adapter+default-devel-1.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-idna_adapter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna_adapter+default-devel}"
SRC_URI[aarch64_rust-idna_adapter+default-devel.sha256sum] = "96e05985a475171f4b7138f3e718330450136db19b923017785a61db7fa83141"

URI_aarch64_rust-idna_adapter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna_adapter-devel-1.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-idna_adapter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna_adapter-devel}"
SRC_URI[aarch64_rust-idna_adapter-devel.sha256sum] = "cd6418fe50b86ae0222ab6235c946b82c6dcd3a4587b40f87db3c7eb9350ab76"

RDEPENDS:rust-idna_adapter+compiled_data-devel = " \
 cargo \
 rust-icu_normalizer+compiled_data-devel \
 rust-icu_properties+compiled_data-devel \
 rust-idna_adapter-devel \
 "
RDEPENDS:rust-idna_adapter+default-devel = " \
 cargo \
 rust-idna_adapter-devel \
 "
RDEPENDS:rust-idna_adapter-devel = " \
 cargo \
 rust \
 rust-icu_normalizer-devel \
 rust-icu_properties-devel \
 "
