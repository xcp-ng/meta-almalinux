# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-patchwork-jsqueeze"
PV = "2.0.5"
PR = "20.el10_0"
PACKAGES = " \
 php-patchwork-jsqueeze \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-patchwork-jsqueeze-2.0.5-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc2175644f673aff86566eb454b2c0dfc23b780f79ffba00f29a2c9fa5099bb1"

URI_x86_64_v2_php-patchwork-jsqueeze = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-patchwork-jsqueeze-2.0.5-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_php-patchwork-jsqueeze;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-patchwork-jsqueeze}"
SRC_URI[x86_64_v2_php-patchwork-jsqueeze.sha256sum] = "7921e293262d73a35636df6cc9a35761ab7eb9e6629a1fd0a7fefa004bcea511"

URI_aarch64_php-patchwork-jsqueeze = "${EPEL_MIRROR}/aarch64/Packages/p/php-patchwork-jsqueeze-2.0.5-20.el10_0.noarch.rpm;name=aarch64_php-patchwork-jsqueeze;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-patchwork-jsqueeze}"
SRC_URI[aarch64_php-patchwork-jsqueeze.sha256sum] = "61f5d38e5e90fba0679d636d53df205cd8c07bcd6bf6cd1269d5f70bf79304a3"

RDEPENDS:php-patchwork-jsqueeze = " \
 php-common \
 "
