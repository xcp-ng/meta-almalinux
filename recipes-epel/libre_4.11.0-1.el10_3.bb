# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libre"
PV = "4.11.0"
PR = "1.el10_3"
PACKAGES = " \
 libre \
 libre-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libre-4.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "eb6bfb15ba2cad71e61bd7f7dffa9dd83cbe4b91c27cbc72e1d6ebe6d4db8c5f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libre-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libre;unpack=0"
SRC_URI[x86_64_v2_libre.sha256sum] = "a6aaf6fa2fb297d53adcd5e505734142e012464d3636a2f88b381047f1fe156d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libre-devel-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libre-devel;unpack=0"
SRC_URI[x86_64_v2_libre-devel.sha256sum] = "f2d8c611bbba52350008158096479b2edb1b3199505284fdb72f1d508a646437"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libre-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_libre;unpack=0"
SRC_URI[aarch64_libre.sha256sum] = "15c5596a1ff00ee899f98e3b2a77aa218a14ebab15cca89f47ba9f5930960087"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libre-devel-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_libre-devel;unpack=0"
SRC_URI[aarch64_libre-devel.sha256sum] = "943fd06078f83aa918d1e011527c0cc99feae02ff29a4a1da2e47832be50b7af"

RDEPENDS:libre = " \
 glibc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libre-devel = " \
 cmake-filesystem \
 libre \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
