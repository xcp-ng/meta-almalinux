# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs22"
PE = "1"
PV = "22.22.2"
PR = "1.el10_1"
PACKAGES = " \
 nodejs \
 nodejs-devel \
 nodejs-docs \
 nodejs-full-i18n \
 nodejs-libs \
 nodejs-npm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs22-22.22.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3dcaacf2a7c81f8201155c7764072d801beb650fad03f578b6aa230a51ca1ef"

URI_x86_64_v2_nodejs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-22.22.2-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_nodejs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs}"
SRC_URI[x86_64_v2_nodejs.sha256sum] = "4954eb35e744c2bff98f9e289ce024cc1b33f1c6fcf179be04fc9ba2b3474baa"
RPROVIDES:nodejs:append:x86_64_v2 = " virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

URI_x86_64_v2_nodejs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-devel-22.22.2-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_nodejs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-devel}"
SRC_URI[x86_64_v2_nodejs-devel.sha256sum] = "d5e8b1c7cd253c090652a8e520b4551e296eda4097c79df110c6f09c85c70682"

URI_x86_64_v2_nodejs-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-docs-22.22.2-1.el10_1.noarch.rpm;name=x86_64_v2_nodejs-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-docs}"
SRC_URI[x86_64_v2_nodejs-docs.sha256sum] = "547cb79e3b62135ee07d7ceadfcb33a607f541e4de7eb56922baaee82e7a240d"

URI_x86_64_v2_nodejs-full-i18n = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-full-i18n-22.22.2-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_nodejs-full-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-full-i18n}"
SRC_URI[x86_64_v2_nodejs-full-i18n.sha256sum] = "1bce56cc2e103caf7bd4b939c14cecf546f87c61b86b597431f5ac1ab15fcd10"

URI_x86_64_v2_nodejs-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-libs-22.22.2-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_nodejs-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-libs}"
SRC_URI[x86_64_v2_nodejs-libs.sha256sum] = "47a2a25a842cf45979e2ccb4851c7b00fbbde58f3350b9b68ba9df4fe37a3c72"

URI_x86_64_v2_nodejs-npm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-npm-10.9.7-1.22.22.2.1.el10_1.x86_64_v2.rpm;name=x86_64_v2_nodejs-npm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-npm}"
SRC_URI[x86_64_v2_nodejs-npm.sha256sum] = "cd52cdf2dd4cb3505912d4de1151017ab66294566e1d2f0a3db833a176022a46"

URI_aarch64_nodejs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-22.22.2-1.el10_1.aarch64.rpm;name=aarch64_nodejs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs}"
SRC_URI[aarch64_nodejs.sha256sum] = "edaef184cd012f9e97a01112aa0acba1d9b10a459c4c80ad3af2bc1d780b2cdf"
RPROVIDES:nodejs:append:aarch64 = " virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

URI_aarch64_nodejs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-devel-22.22.2-1.el10_1.aarch64.rpm;name=aarch64_nodejs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-devel}"
SRC_URI[aarch64_nodejs-devel.sha256sum] = "919a9f4750014dadb574a6960c5319fc7e5bb16c44b65b8859619694ccf786af"

URI_aarch64_nodejs-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-docs-22.22.2-1.el10_1.noarch.rpm;name=aarch64_nodejs-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-docs}"
SRC_URI[aarch64_nodejs-docs.sha256sum] = "547cb79e3b62135ee07d7ceadfcb33a607f541e4de7eb56922baaee82e7a240d"

URI_aarch64_nodejs-full-i18n = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-full-i18n-22.22.2-1.el10_1.aarch64.rpm;name=aarch64_nodejs-full-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-full-i18n}"
SRC_URI[aarch64_nodejs-full-i18n.sha256sum] = "61047f78a7761d22e5f3440e8af1b49f303fb6daf3a8c9e5adfad07c51ad5f23"

URI_aarch64_nodejs-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-libs-22.22.2-1.el10_1.aarch64.rpm;name=aarch64_nodejs-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-libs}"
SRC_URI[aarch64_nodejs-libs.sha256sum] = "36bc54a2c9d123e30b9c6633602b8b3d03a01fbc7285fe497fd43830a61982d3"

URI_aarch64_nodejs-npm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-npm-10.9.7-1.22.22.2.1.el10_1.aarch64.rpm;name=aarch64_nodejs-npm;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-npm}"
SRC_URI[aarch64_nodejs-npm.sha256sum] = "33df2dcbd748692bce24b2a1563ab7d2038f82e135177f3081fc18d223df5933"

RDEPENDS:nodejs = " \
 ca-certificates \
 glibc \
 libuv \
 nodejs-libs \
 openssl \
 "
RDEPENDS:nodejs-devel = " \
 bash \
 brotli-devel \
 libuv-devel \
 nodejs \
 nodejs-libs \
 nodejs-packaging \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:nodejs-docs = " \
 nodejs \
 "
RDEPENDS:nodejs-full-i18n = " \
 nodejs \
 "
RDEPENDS:nodejs-libs = " \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 libuv \
 openssl-libs \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:nodejs-npm = " \
 bash \
 nodejs \
 "
