# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "policycoreutils"
PV = "3.10"
PR = "2.el10_2"
PACKAGES = " \
 policycoreutils \
 policycoreutils-dbus \
 policycoreutils-devel \
 policycoreutils-gui \
 policycoreutils-newrole \
 policycoreutils-python-utils \
 policycoreutils-restorecond \
 policycoreutils-sandbox \
 python3-policycoreutils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/policycoreutils-3.10-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b219c924de8affe193d2cd065f80a692878eb8f59ce35f1a76a7f5e2acffcafe"

URI_x86_64_v2_policycoreutils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/policycoreutils-3.10-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_policycoreutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils}"
SRC_URI[x86_64_v2_policycoreutils.sha256sum] = "f6e7dda1666f57c84abe257399620c83b6e76cf6ce8a3775a12dc888fe4f7aac"

URI_x86_64_v2_policycoreutils-dbus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/policycoreutils-dbus-3.10-2.el10_2.noarch.rpm;name=x86_64_v2_policycoreutils-dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-dbus}"
SRC_URI[x86_64_v2_policycoreutils-dbus.sha256sum] = "855eb4cdc945ca93bd2ffad67b6630a0b6073523805f2ece850e5f1e725c0335"

URI_x86_64_v2_policycoreutils-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/policycoreutils-devel-3.10-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_policycoreutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-devel}"
SRC_URI[x86_64_v2_policycoreutils-devel.sha256sum] = "1dd8200479cf08c2576217a0aed104c490429f728e4eb467cd1d196ed0c140e6"

URI_x86_64_v2_policycoreutils-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/policycoreutils-gui-3.10-2.el10_2.noarch.rpm;name=x86_64_v2_policycoreutils-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-gui}"
SRC_URI[x86_64_v2_policycoreutils-gui.sha256sum] = "4b6f8ec4e49458ec9565f14e39a09279e0d01eaa6b4c84bfd4e192569840b34f"

URI_x86_64_v2_policycoreutils-newrole = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/policycoreutils-newrole-3.10-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_policycoreutils-newrole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-newrole}"
SRC_URI[x86_64_v2_policycoreutils-newrole.sha256sum] = "7d8783ad7cc2ff2c37503f91ec977336c9a08974918c8f27e31b0cc816cb0ce1"

URI_x86_64_v2_policycoreutils-python-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/policycoreutils-python-utils-3.10-2.el10_2.noarch.rpm;name=x86_64_v2_policycoreutils-python-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-python-utils}"
SRC_URI[x86_64_v2_policycoreutils-python-utils.sha256sum] = "3f60bbb1fb4b09b33481dc531302fc5d334c297b379b7c96a28aeb9a8f33cf5d"

URI_x86_64_v2_policycoreutils-restorecond = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/policycoreutils-restorecond-3.10-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_policycoreutils-restorecond;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-restorecond}"
SRC_URI[x86_64_v2_policycoreutils-restorecond.sha256sum] = "511d362a3b52ccc6345598897269c2558babd1e2746b20a35d381053f8a74b27"

URI_x86_64_v2_policycoreutils-sandbox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/policycoreutils-sandbox-3.10-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_policycoreutils-sandbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-sandbox}"
SRC_URI[x86_64_v2_policycoreutils-sandbox.sha256sum] = "55d7a1d1d0c84413401eebbf69a40539b8e20cc6f0348417f1727fefe28b6dce"

URI_x86_64_v2_python3-policycoreutils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-policycoreutils-3.10-2.el10_2.noarch.rpm;name=x86_64_v2_python3-policycoreutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-policycoreutils}"
SRC_URI[x86_64_v2_python3-policycoreutils.sha256sum] = "5a065bb2c468089c8271d913933a6f484289f7b5de74f6711cd717ff8fa753d0"

URI_aarch64_policycoreutils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/policycoreutils-3.10-2.el10_2.aarch64.rpm;name=aarch64_policycoreutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils}"
SRC_URI[aarch64_policycoreutils.sha256sum] = "df12d4d4884d073770675c951d950cf005a661074feedf0c8ea0959903defe48"

URI_aarch64_policycoreutils-dbus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/policycoreutils-dbus-3.10-2.el10_2.noarch.rpm;name=aarch64_policycoreutils-dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-dbus}"
SRC_URI[aarch64_policycoreutils-dbus.sha256sum] = "855eb4cdc945ca93bd2ffad67b6630a0b6073523805f2ece850e5f1e725c0335"

URI_aarch64_policycoreutils-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/policycoreutils-devel-3.10-2.el10_2.aarch64.rpm;name=aarch64_policycoreutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-devel}"
SRC_URI[aarch64_policycoreutils-devel.sha256sum] = "7ba2001154ea71fb335ccbae28839a9e99f304006db3ed061a08fa554a0a2a9f"

URI_aarch64_policycoreutils-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/policycoreutils-gui-3.10-2.el10_2.noarch.rpm;name=aarch64_policycoreutils-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-gui}"
SRC_URI[aarch64_policycoreutils-gui.sha256sum] = "4b6f8ec4e49458ec9565f14e39a09279e0d01eaa6b4c84bfd4e192569840b34f"

URI_aarch64_policycoreutils-newrole = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/policycoreutils-newrole-3.10-2.el10_2.aarch64.rpm;name=aarch64_policycoreutils-newrole;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-newrole}"
SRC_URI[aarch64_policycoreutils-newrole.sha256sum] = "199b99760fc020e556cefb12f3c5f23bc61e9ff36c335e56419d2b9c2a572aaa"

URI_aarch64_policycoreutils-python-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/policycoreutils-python-utils-3.10-2.el10_2.noarch.rpm;name=aarch64_policycoreutils-python-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-python-utils}"
SRC_URI[aarch64_policycoreutils-python-utils.sha256sum] = "3f60bbb1fb4b09b33481dc531302fc5d334c297b379b7c96a28aeb9a8f33cf5d"

URI_aarch64_policycoreutils-restorecond = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/policycoreutils-restorecond-3.10-2.el10_2.aarch64.rpm;name=aarch64_policycoreutils-restorecond;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-restorecond}"
SRC_URI[aarch64_policycoreutils-restorecond.sha256sum] = "ddcfc56459736f71a7f605e3b3fd5e9038a6e29cf6d0a75dd46a92f520bc15f8"

URI_aarch64_policycoreutils-sandbox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/policycoreutils-sandbox-3.10-2.el10_2.aarch64.rpm;name=aarch64_policycoreutils-sandbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-sandbox}"
SRC_URI[aarch64_policycoreutils-sandbox.sha256sum] = "2b319e46f0860e4e85a25f51ce8cc8074bba183f48434796decfe7ffad18f5e7"

URI_aarch64_python3-policycoreutils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-policycoreutils-3.10-2.el10_2.noarch.rpm;name=aarch64_python3-policycoreutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-policycoreutils}"
SRC_URI[aarch64_python3-policycoreutils.sha256sum] = "5a065bb2c468089c8271d913933a6f484289f7b5de74f6711cd717ff8fa753d0"

RDEPENDS:policycoreutils = " \
 audit-libs \
 bash \
 diffutils \
 gawk \
 glibc \
 grep \
 libselinux \
 libselinux-utils \
 libsemanage \
 libsepol \
 sed \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:policycoreutils-dbus = " \
 polkit \
 python3 \
 python3-gobject-base \
 python3-policycoreutils \
 "
RDEPENDS:policycoreutils-devel = " \
 glibc \
 libselinux \
 make \
 policycoreutils-python-utils \
 python3 \
 python3-dnf \
 selinux-policy-devel \
 "
RDEPENDS:policycoreutils-gui = " \
 bash \
 gtk3 \
 policycoreutils-dbus \
 policycoreutils-devel \
 python3 \
 python3-gobject \
 python3-policycoreutils \
 "
RDEPENDS:policycoreutils-newrole = " \
 audit-libs \
 glibc \
 libcap-ng \
 libselinux \
 pam-libs \
 policycoreutils \
 "
RDEPENDS:policycoreutils-python-utils = " \
 python3 \
 python3-policycoreutils \
 "
RDEPENDS:policycoreutils-restorecond = " \
 bash \
 glib2 \
 glibc \
 libselinux \
 "
RDEPENDS:policycoreutils-sandbox = " \
 bash \
 glibc \
 libcap-ng \
 libselinux \
 python3 \
 python3-policycoreutils \
 rsync \
 "
RDEPENDS:python3-policycoreutils = " \
 checkpolicy \
 policycoreutils \
 python3 \
 python3-audit \
 python3-distro \
 python3-libselinux \
 python3-libsemanage \
 python3-setools \
 "
