# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-yaml-3"
PV = "3.0.1"
PR = "10.el10_0"
PACKAGES = " \
 golang-gopkg-yaml-3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-yaml-3-3.0.1-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da5117561d5925f9a7305fc9a7b72b039a0d34cc8abe912654981568188efc72"

URI_x86_64_v2_golang-gopkg-yaml-3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gopkg-yaml-3-devel-3.0.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gopkg-yaml-3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gopkg-yaml-3-devel}"
SRC_URI[x86_64_v2_golang-gopkg-yaml-3-devel.sha256sum] = "7f9d7adf47704f748e01823db4650803ba77dfa12c539ea9451f7f819eb3aaed"

URI_aarch64_golang-gopkg-yaml-3-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-yaml-3-devel-3.0.1-10.el10_0.noarch.rpm;name=aarch64_golang-gopkg-yaml-3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-yaml-3-devel}"
SRC_URI[aarch64_golang-gopkg-yaml-3-devel.sha256sum] = "ea63aec984d5fe8b0cf6848584602ce1f8ed9d33fb0d780b63b3c314a07dde0f"

RDEPENDS:golang-gopkg-yaml-3-devel = " \
 go-filesystem \
 "
