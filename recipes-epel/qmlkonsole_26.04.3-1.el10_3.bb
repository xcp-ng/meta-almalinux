# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qmlkonsole"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 qmlkonsole \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qmlkonsole-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c73fbd10e000ba0f27d65601390253a076aea934d1d3c0af19e38f703b06281"

URI_x86_64_v2_qmlkonsole = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qmlkonsole-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qmlkonsole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qmlkonsole}"
SRC_URI[x86_64_v2_qmlkonsole.sha256sum] = "b1f38e1cdd41d9a28ebf40df27707cdbf000e2529f7163ad129d972db01ace15"

URI_aarch64_qmlkonsole = "${EPEL_MIRROR}/aarch64/Packages/q/qmlkonsole-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_qmlkonsole;unpack=0"
SRC_URI:append = " ${URI_aarch64_qmlkonsole}"
SRC_URI[aarch64_qmlkonsole.sha256sum] = "fa74e62bbecea8703af3c2c07541a9dfe155738d2f40bdead338f233ee806d1d"

RDEPENDS:qmlkonsole = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kpty \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
