# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmbox"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kmbox \
 kmbox-devel \
 kmbox-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmbox-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1082f121212f24e2210660bf8d5674177a6dfc3052f7b60220a487bfd5e29681"

URI_x86_64_v2_kmbox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmbox-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmbox}"
SRC_URI[x86_64_v2_kmbox.sha256sum] = "07351e5c5e83a3381094d7aadeb7743c0de161decdefa07012af559452565f18"

URI_x86_64_v2_kmbox-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmbox-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmbox-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmbox-devel}"
SRC_URI[x86_64_v2_kmbox-devel.sha256sum] = "57e2e6e253e351a10bcb457505f4eb1b25d95aab9bf372f2379a7b99fc14d680"

URI_x86_64_v2_kmbox-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmbox-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kmbox-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmbox-doc}"
SRC_URI[x86_64_v2_kmbox-doc.sha256sum] = "2203b0e15157399ae8a2baa1c9140a23dcd311517561e0082e6111071dbac0f9"

URI_aarch64_kmbox = "${EPEL_MIRROR}/aarch64/Packages/k/kmbox-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmbox}"
SRC_URI[aarch64_kmbox.sha256sum] = "72470d56b3bcd5792313f4c7745b29cd824f4dde522c3cc05ba33146a827546e"

URI_aarch64_kmbox-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kmbox-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmbox-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmbox-devel}"
SRC_URI[aarch64_kmbox-devel.sha256sum] = "7ff782af6205e174786fdd6d78018d2bec54fdefdc32cf920d51bce1532b09ba"

URI_aarch64_kmbox-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kmbox-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kmbox-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmbox-doc}"
SRC_URI[aarch64_kmbox-doc.sha256sum] = "5f85a2128edc90858ef4f6eb19ec2428b9bdb0b1736d6f6db1d308df1703e88d"

RDEPENDS:kmbox = " \
 glibc \
 kmime \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kmbox-devel = " \
 cmake-filesystem \
 kmbox \
 kmime-devel \
 "
RDEPENDS:kmbox-doc = " \
 "
