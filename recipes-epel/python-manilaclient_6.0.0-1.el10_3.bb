# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-manilaclient"
PV = "6.0.0"
PR = "1.el10_3"
PACKAGES = " \
 python-manilaclient-doc \
 python3-manilaclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-manilaclient-6.0.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf20591328ce8fa9a6cbe93ffd1edbab559f4887811ceb5d7139490b4e3fa74a"

URI_x86_64_v2_python-manilaclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-manilaclient-doc-6.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-manilaclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-manilaclient-doc}"
SRC_URI[x86_64_v2_python-manilaclient-doc.sha256sum] = "a7d7cda4d6188005166c7375a705ee720c1e969c0ae824206112372569ff9988"

URI_x86_64_v2_python3-manilaclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-manilaclient-6.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-manilaclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-manilaclient}"
SRC_URI[x86_64_v2_python3-manilaclient.sha256sum] = "21bb4026282d7ee6cebabb2344e4c9e8cb8b5a9c0cf0eb508b9bc827e05e741d"

URI_aarch64_python-manilaclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-manilaclient-doc-6.0.0-1.el10_3.noarch.rpm;name=aarch64_python-manilaclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-manilaclient-doc}"
SRC_URI[aarch64_python-manilaclient-doc.sha256sum] = "d393f892e2e0ef8633200a22bf4beae3985df6b8569bc26b9c9e14ff9bf60064"

URI_aarch64_python3-manilaclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-manilaclient-6.0.0-1.el10_3.noarch.rpm;name=aarch64_python3-manilaclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-manilaclient}"
SRC_URI[aarch64_python3-manilaclient.sha256sum] = "ae1d65abaec1a368ce692ad9e980471a8eb364639371befe52468ac4036b928d"

RDEPENDS:python-manilaclient-doc = " \
 "
RDEPENDS:python3-manilaclient = " \
 python3 \
 python3-debtcollector \
 python3-keystoneauth1 \
 python3-osc-lib \
 python3-oslo-config \
 python3-oslo-log \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-prettytable \
 python3-requests \
 "
