# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-filepath-bytestring"
PV = "1.4.2.1.13"
PR = "4.el10_0"
PACKAGES = " \
 ghc-filepath-bytestring \
 ghc-filepath-bytestring-devel \
 ghc-filepath-bytestring-doc \
 ghc-filepath-bytestring-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-filepath-bytestring-1.4.2.1.13-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce510a6bd04b685d14f205f526172092109eb5500dd768bda2c7c4faee71b021"

URI_x86_64_v2_ghc-filepath-bytestring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filepath-bytestring-1.4.2.1.13-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-filepath-bytestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filepath-bytestring}"
SRC_URI[x86_64_v2_ghc-filepath-bytestring.sha256sum] = "6f70da6ec541be463444b3cb8aae9feaf2bf9820a6b4460962ccbbd162349c38"

URI_x86_64_v2_ghc-filepath-bytestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filepath-bytestring-devel-1.4.2.1.13-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-filepath-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filepath-bytestring-devel}"
SRC_URI[x86_64_v2_ghc-filepath-bytestring-devel.sha256sum] = "d7b2cee6605d56b3639c7da01d324d77516a11e91ec225918ea71c5dc471a039"

URI_x86_64_v2_ghc-filepath-bytestring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filepath-bytestring-doc-1.4.2.1.13-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-filepath-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filepath-bytestring-doc}"
SRC_URI[x86_64_v2_ghc-filepath-bytestring-doc.sha256sum] = "3de4bba32d8570d08d5eea428d84fe13f512e7e8ce6f4b6c6250873d7ad6c1ad"

URI_x86_64_v2_ghc-filepath-bytestring-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filepath-bytestring-prof-1.4.2.1.13-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-filepath-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filepath-bytestring-prof}"
SRC_URI[x86_64_v2_ghc-filepath-bytestring-prof.sha256sum] = "baf1486bb36efb0fa3cdf78c7ed9603250d58cc5f27b5623de64d05632bf9334"

URI_aarch64_ghc-filepath-bytestring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filepath-bytestring-1.4.2.1.13-4.el10_0.aarch64.rpm;name=aarch64_ghc-filepath-bytestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filepath-bytestring}"
SRC_URI[aarch64_ghc-filepath-bytestring.sha256sum] = "e9af986368938503d27e848dc52be6957bea9a88421038c103e17f16ac0c0f18"

URI_aarch64_ghc-filepath-bytestring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filepath-bytestring-devel-1.4.2.1.13-4.el10_0.aarch64.rpm;name=aarch64_ghc-filepath-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filepath-bytestring-devel}"
SRC_URI[aarch64_ghc-filepath-bytestring-devel.sha256sum] = "8870f2da3c9ebad7afb86f8302b614870164f35fe8a73db8ae071226be22e525"

URI_aarch64_ghc-filepath-bytestring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filepath-bytestring-doc-1.4.2.1.13-4.el10_0.noarch.rpm;name=aarch64_ghc-filepath-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filepath-bytestring-doc}"
SRC_URI[aarch64_ghc-filepath-bytestring-doc.sha256sum] = "666089f78c20304374ac68c63377700a62c94d32f11e1165234f8b2c0a898e83"

URI_aarch64_ghc-filepath-bytestring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filepath-bytestring-prof-1.4.2.1.13-4.el10_0.aarch64.rpm;name=aarch64_ghc-filepath-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filepath-bytestring-prof}"
SRC_URI[aarch64_ghc-filepath-bytestring-prof.sha256sum] = "95004b83f31bc414fa7262156395e59c6624e38cb302c4036adb10cbf662b519"

RDEPENDS:ghc-filepath-bytestring = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-filepath-bytestring-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-filepath-bytestring \
 ghc-unix-devel \
 "
RDEPENDS:ghc-filepath-bytestring-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-filepath-bytestring-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-filepath-bytestring-devel \
 ghc-unix-prof \
 "
