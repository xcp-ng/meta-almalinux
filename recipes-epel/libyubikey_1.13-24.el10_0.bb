# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libyubikey"
PV = "1.13"
PR = "24.el10_0"
PACKAGES = " \
 libyubikey \
 libyubikey-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libyubikey-1.13-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7f871f3ab378f13685febdebc22f769ffd8e86c21f17423ad71f0fda2507c6a"

URI_x86_64_v2_libyubikey = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libyubikey-1.13-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libyubikey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libyubikey}"
SRC_URI[x86_64_v2_libyubikey.sha256sum] = "6582620f1999f85293cb2ff912294e4e2dabddd483c5498ebaa830a50aa5fc96"

URI_x86_64_v2_libyubikey-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libyubikey-devel-1.13-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libyubikey-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libyubikey-devel}"
SRC_URI[x86_64_v2_libyubikey-devel.sha256sum] = "807b453f3b612f012dffe60559b58fc7df2e395a8db5c3aae0aa160bab33b09d"

URI_aarch64_libyubikey = "${EPEL_MIRROR}/aarch64/Packages/l/libyubikey-1.13-24.el10_0.aarch64.rpm;name=aarch64_libyubikey;unpack=0"
SRC_URI:append = " ${URI_aarch64_libyubikey}"
SRC_URI[aarch64_libyubikey.sha256sum] = "dcd7909e551a068b75305ebb9a2876f0b2b46a4402b10295e0eecec78016996e"

URI_aarch64_libyubikey-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libyubikey-devel-1.13-24.el10_0.aarch64.rpm;name=aarch64_libyubikey-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libyubikey-devel}"
SRC_URI[aarch64_libyubikey-devel.sha256sum] = "0d0f0f40d76c3b474a1aae4c8c41802b29e18f2be6c54385f74e8a18e83e7b27"

RDEPENDS:libyubikey = " \
 glibc \
 "
RDEPENDS:libyubikey-devel = " \
 libyubikey \
 "
