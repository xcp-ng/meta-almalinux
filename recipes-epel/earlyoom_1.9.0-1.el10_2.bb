# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "earlyoom"
PV = "1.9.0"
PR = "1.el10_2"
PACKAGES = " \
 earlyoom \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/earlyoom-1.9.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7cc944493a1c7a0fe00494bfc154d44c371f9a3e42e0b5ac73ec1d9359e6615"

URI_x86_64_v2_earlyoom = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/earlyoom-1.9.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_earlyoom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_earlyoom}"
SRC_URI[x86_64_v2_earlyoom.sha256sum] = "7da9913d678712051748c05145e21340ae12b89f1a5927ffb782597d46d52408"

URI_aarch64_earlyoom = "${EPEL_MIRROR}/aarch64/Packages/e/earlyoom-1.9.0-1.el10_2.aarch64.rpm;name=aarch64_earlyoom;unpack=0"
SRC_URI:append = " ${URI_aarch64_earlyoom}"
SRC_URI[aarch64_earlyoom.sha256sum] = "36461c4232f8abbb87714e07d436675b520acfb63780e5c364892f96424936a4"

RDEPENDS:earlyoom = " \
 bash \
 glibc \
 systemd \
 "
