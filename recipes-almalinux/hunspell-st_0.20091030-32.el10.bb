# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-st"
PV = "0.20091030"
PR = "32.el10"
PACKAGES = " \
 hunspell-st \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-st-0.20091030-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fbcfa592d1e13a55c8f9d0d34778db71790f31edb3456577eb7e0fc99a17870"

URI_x86_64_v2_hunspell-st = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-st-0.20091030-32.el10.noarch.rpm;name=x86_64_v2_hunspell-st;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-st}"
SRC_URI[x86_64_v2_hunspell-st.sha256sum] = "82b1555fdd30f3804ba09ea65bb35947ca412e9e36cd04974ed7c0dd4699d4d9"

URI_aarch64_hunspell-st = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-st-0.20091030-32.el10.noarch.rpm;name=aarch64_hunspell-st;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-st}"
SRC_URI[aarch64_hunspell-st.sha256sum] = "82b1555fdd30f3804ba09ea65bb35947ca412e9e36cd04974ed7c0dd4699d4d9"

RDEPENDS:hunspell-st = " \
 hunspell \
 "
