# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_logger"
PV = "0.11.8"
PR = "1.el10_0"
PACKAGES = " \
 rust-env_logger+auto-color-devel \
 rust-env_logger+color-devel \
 rust-env_logger+default-devel \
 rust-env_logger+humantime-devel \
 rust-env_logger+kv-devel \
 rust-env_logger+regex-devel \
 rust-env_logger+unstable-kv-devel \
 rust-env_logger-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_logger-0.11.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8dcf07fcbc3c5682b516008227d18afe1cdba50e0c6e5167c039b2ccc80cb822"

URI_x86_64_v2_rust-env_logger+auto-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+auto-color-devel-0.11.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+auto-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+auto-color-devel}"
SRC_URI[x86_64_v2_rust-env_logger+auto-color-devel.sha256sum] = "bf92b3e24d1cc861677a23244c2ae2a5d53a2b28c6c8867c544fa425e9c1150f"

URI_x86_64_v2_rust-env_logger+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+color-devel-0.11.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+color-devel}"
SRC_URI[x86_64_v2_rust-env_logger+color-devel.sha256sum] = "e9c6d934d5896b39fd66bb57c582c6609f77cc5d63ddce991b9573cc6c726c02"

URI_x86_64_v2_rust-env_logger+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+default-devel-0.11.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+default-devel}"
SRC_URI[x86_64_v2_rust-env_logger+default-devel.sha256sum] = "010d7403e03805707fbb32cb1a63a59d0a6f736a31b495019cd3b47280fd546c"

URI_x86_64_v2_rust-env_logger+humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+humantime-devel-0.11.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+humantime-devel}"
SRC_URI[x86_64_v2_rust-env_logger+humantime-devel.sha256sum] = "bcfaaabfcee7edb86cadd00afda60c1c5c9b1a5d54cb786d820ab15ea0a947c1"

URI_x86_64_v2_rust-env_logger+kv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+kv-devel-0.11.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+kv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+kv-devel}"
SRC_URI[x86_64_v2_rust-env_logger+kv-devel.sha256sum] = "c11a7b96a186f21bd600742fc2a9aaba7758a620138521352012b79455a5bdbc"

URI_x86_64_v2_rust-env_logger+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+regex-devel-0.11.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+regex-devel}"
SRC_URI[x86_64_v2_rust-env_logger+regex-devel.sha256sum] = "b757d692b7ac949ca23bf02bdfba7f2c5e5fd8f87bcc7c2cd9459df82a367e6c"

URI_x86_64_v2_rust-env_logger+unstable-kv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+unstable-kv-devel-0.11.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+unstable-kv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+unstable-kv-devel}"
SRC_URI[x86_64_v2_rust-env_logger+unstable-kv-devel.sha256sum] = "9fd3b18afec2f0748fda4a98a6e057b48b2306231b34a519bc7b3c9ec6e6fd12"

URI_x86_64_v2_rust-env_logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger-devel-0.11.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger-devel}"
SRC_URI[x86_64_v2_rust-env_logger-devel.sha256sum] = "bf3dd40f7773c7a5bc368849386a90e2033a124b0c3967ad960dffcab370b135"
RPROVIDES:rust-env_logger-devel:x86_64_v2 = "virtual/crate_env_logger__ge_0.6.1"

URI_aarch64_rust-env_logger+auto-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+auto-color-devel-0.11.8-1.el10_0.noarch.rpm;name=aarch64_rust-env_logger+auto-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+auto-color-devel}"
SRC_URI[aarch64_rust-env_logger+auto-color-devel.sha256sum] = "d1c7b23093fa80c454ae35029f42857a753192ce52115062bda1c98d8badb9ba"

URI_aarch64_rust-env_logger+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+color-devel-0.11.8-1.el10_0.noarch.rpm;name=aarch64_rust-env_logger+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+color-devel}"
SRC_URI[aarch64_rust-env_logger+color-devel.sha256sum] = "ec5dac21c71cfcacae9e7fe2a6a81624c1730b37e02640cc58ceb14fa75058fe"

URI_aarch64_rust-env_logger+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+default-devel-0.11.8-1.el10_0.noarch.rpm;name=aarch64_rust-env_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+default-devel}"
SRC_URI[aarch64_rust-env_logger+default-devel.sha256sum] = "be811bf424096adbe149b88a6e56ff4e3c306a6f83b6239c651c34559aa909d6"

URI_aarch64_rust-env_logger+humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+humantime-devel-0.11.8-1.el10_0.noarch.rpm;name=aarch64_rust-env_logger+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+humantime-devel}"
SRC_URI[aarch64_rust-env_logger+humantime-devel.sha256sum] = "0dc10bbc258dae278da1c47de2202e40f732a2845e51ad87b4cfc96700898e3e"

URI_aarch64_rust-env_logger+kv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+kv-devel-0.11.8-1.el10_0.noarch.rpm;name=aarch64_rust-env_logger+kv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+kv-devel}"
SRC_URI[aarch64_rust-env_logger+kv-devel.sha256sum] = "408da618d69ce2e4b673b66ef5a3e9ca03c23e0ad5612f9e2ee61145c99ba28a"

URI_aarch64_rust-env_logger+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+regex-devel-0.11.8-1.el10_0.noarch.rpm;name=aarch64_rust-env_logger+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+regex-devel}"
SRC_URI[aarch64_rust-env_logger+regex-devel.sha256sum] = "e8d44ea2b795824b4a62b0cc263bfeb5589ffa5714c1320eb0aebcea852a0485"

URI_aarch64_rust-env_logger+unstable-kv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+unstable-kv-devel-0.11.8-1.el10_0.noarch.rpm;name=aarch64_rust-env_logger+unstable-kv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+unstable-kv-devel}"
SRC_URI[aarch64_rust-env_logger+unstable-kv-devel.sha256sum] = "4be385f10ba33470e11309f4141498fd99fc35e28db55ef13656d89e83fa73f0"

URI_aarch64_rust-env_logger-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger-devel-0.11.8-1.el10_0.noarch.rpm;name=aarch64_rust-env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger-devel}"
SRC_URI[aarch64_rust-env_logger-devel.sha256sum] = "aa4fdbfb7d688a69c029812e7aba29cb589e9b59d2bea54bf782a1fbbffa57c5"
RPROVIDES:rust-env_logger-devel:aarch64 = "virtual/crate_env_logger__ge_0.6.1"

RDEPENDS:rust-env_logger+auto-color-devel = " \
 cargo \
 rust-anstream+auto-devel \
 rust-anstream+wincon-devel \
 rust-anstream-devel \
 rust-env_logger+color-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+color-devel = " \
 cargo \
 rust-anstream+wincon-devel \
 rust-anstream-devel \
 rust-anstyle+default-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+default-devel = " \
 cargo \
 rust-env_logger+auto-color-devel \
 rust-env_logger+humantime-devel \
 rust-env_logger+regex-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+humantime-devel = " \
 cargo \
 rust-env_logger-devel \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-env_logger+kv-devel = " \
 cargo \
 rust-env_logger-devel \
 rust-log+kv-devel \
 "
RDEPENDS:rust-env_logger+regex-devel = " \
 cargo \
 rust-env_filter+regex-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+unstable-kv-devel = " \
 cargo \
 rust-env_logger+kv-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger-devel = " \
 cargo \
 rust \
 rust-env_filter-devel \
 rust-log+default-devel \
 rust-log+std-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_env_logger__ge_0.6.1"

PROVIDES:append:aarch64 = " rpm/virtual/crate_env_logger__ge_0.6.1"
