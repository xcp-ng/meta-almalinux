# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openssh"
PV = "9.9p1"
PR = "27.el10.alma.1"
PACKAGES = " \
 openssh \
 openssh-askpass \
 openssh-clients \
 openssh-keycat \
 openssh-keysign \
 openssh-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openssh-9.9p1-27.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5576d82b5325661565a737c15a7c267b9415eb0e607a8fdca7c53f8a11133490"

URI_x86_64_v2_openssh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-9.9p1-27.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh}"
SRC_URI[x86_64_v2_openssh.sha256sum] = "aa121d70149e6f05921264388668ac97602fd58e028133fcc36322a48319763a"

URI_x86_64_v2_openssh-askpass = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssh-askpass-9.9p1-27.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-askpass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-askpass}"
SRC_URI[x86_64_v2_openssh-askpass.sha256sum] = "4a049ff55d870ba4df7b3c1bf36d6474746b7446a7a158ea58a2446f72f5b5b9"

URI_x86_64_v2_openssh-clients = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-clients-9.9p1-27.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-clients}"
SRC_URI[x86_64_v2_openssh-clients.sha256sum] = "c0713b16859b2e7eaf8a168d06d2318bb0c7f3b0352188325d1464c5947b51c3"

URI_x86_64_v2_openssh-keycat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-keycat-9.9p1-27.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-keycat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-keycat}"
SRC_URI[x86_64_v2_openssh-keycat.sha256sum] = "e073d0c094956767782cf5960038ef85322852f99959905d575a73299e047f2d"

URI_x86_64_v2_openssh-keysign = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssh-keysign-9.9p1-27.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-keysign}"
SRC_URI[x86_64_v2_openssh-keysign.sha256sum] = "100213dd84caa188ecd8d7c1cf423760554006326b3f0b26faf8d21b8b464619"

URI_x86_64_v2_openssh-server = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-server-9.9p1-27.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-server}"
SRC_URI[x86_64_v2_openssh-server.sha256sum] = "22897b68b98a2b21a821122a437e6e452a11c66d0cadb0fba711a0760bba3ebb"

URI_aarch64_openssh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-9.9p1-27.el10.alma.1.aarch64.rpm;name=aarch64_openssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh}"
SRC_URI[aarch64_openssh.sha256sum] = "241e74a5298ee848e9cedf12179e9a1da34c70750e7bd94def50c7489936b845"

URI_aarch64_openssh-askpass = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssh-askpass-9.9p1-27.el10.alma.1.aarch64.rpm;name=aarch64_openssh-askpass;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-askpass}"
SRC_URI[aarch64_openssh-askpass.sha256sum] = "f65a0662afa2e5c3d6afb21dbc7c07e76e19dce19cbf7dd2e6c77a4c1e73bb06"

URI_aarch64_openssh-clients = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-clients-9.9p1-27.el10.alma.1.aarch64.rpm;name=aarch64_openssh-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-clients}"
SRC_URI[aarch64_openssh-clients.sha256sum] = "8ba1785135690f65f236f6e03068cbd0324e23869f51561ff74b7093cce999e9"

URI_aarch64_openssh-keycat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-keycat-9.9p1-27.el10.alma.1.aarch64.rpm;name=aarch64_openssh-keycat;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-keycat}"
SRC_URI[aarch64_openssh-keycat.sha256sum] = "8035a328e2c34728d79d028d9c0647abd430d233b738362302855ee85dc23efc"

URI_aarch64_openssh-keysign = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssh-keysign-9.9p1-27.el10.alma.1.aarch64.rpm;name=aarch64_openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-keysign}"
SRC_URI[aarch64_openssh-keysign.sha256sum] = "f3bd1e55589fd59e6a46bd1aa88249c2d0fb6cd973c7486c25fa27512c92a2cd"

URI_aarch64_openssh-server = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-server-9.9p1-27.el10.alma.1.aarch64.rpm;name=aarch64_openssh-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-server}"
SRC_URI[aarch64_openssh-server.sha256sum] = "25fa069c973ac2c0baa8f267324bee0bd7d907f0cb596fa79e968de699ef195d"

RDEPENDS:openssh = " \
 audit-libs \
 glibc \
 libselinux \
 openssl-libs \
 util-linux \
 "
RDEPENDS:openssh-askpass = " \
 glib2 \
 glibc \
 gtk3 \
 openssh \
 "
RDEPENDS:openssh-clients = " \
 bash \
 crypto-policies \
 glibc \
 krb5-libs \
 libedit \
 libfido2 \
 libselinux \
 openssh \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:openssh-keycat = " \
 glibc \
 openssh \
 pam-libs \
 "
RDEPENDS:openssh-keysign = " \
 glibc \
 openssh \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:openssh-server = " \
 audit-libs \
 bash \
 crypto-policies \
 glibc \
 krb5-libs \
 libcom_err \
 libselinux \
 libxcrypt \
 openssh \
 openssl-libs \
 pam \
 pam-libs \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
