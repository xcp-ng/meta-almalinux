# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kweathercore"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kweathercore \
 kweathercore-devel \
 kweathercore-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kweathercore-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "623d427c23ab5012b1237dddcb8c4dccc60d5e3bee58f392ac7a579fbfb96db7"

URI_x86_64_v2_kweathercore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweathercore-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweathercore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweathercore}"
SRC_URI[x86_64_v2_kweathercore.sha256sum] = "1e3e48f024a704411e4d257dac873618b79ff0b63a0bb8158fed42a287b99377"

URI_x86_64_v2_kweathercore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweathercore-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweathercore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweathercore-devel}"
SRC_URI[x86_64_v2_kweathercore-devel.sha256sum] = "d477b90c88c6ca7068280ba59b241016b375dbe2438cf6e15c8e8ac5ed80bcf2"

URI_x86_64_v2_kweathercore-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweathercore-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kweathercore-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweathercore-doc}"
SRC_URI[x86_64_v2_kweathercore-doc.sha256sum] = "ffadc9f4c7b2f3ca6b462826ea3ae272075c18f0b6cf3c5e2935ff4576fb6022"

URI_aarch64_kweathercore = "${EPEL_MIRROR}/aarch64/Packages/k/kweathercore-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kweathercore;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweathercore}"
SRC_URI[aarch64_kweathercore.sha256sum] = "a3760629066b552e9cd3c9b8925234212dad9c1ee5ab891e340554776a6c4e2a"

URI_aarch64_kweathercore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kweathercore-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kweathercore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweathercore-devel}"
SRC_URI[aarch64_kweathercore-devel.sha256sum] = "7dd2d0e0d7a032064016c90b796fb4922e260ee853c1d0bc0289978e87ef4e8c"

URI_aarch64_kweathercore-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kweathercore-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kweathercore-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweathercore-doc}"
SRC_URI[aarch64_kweathercore-doc.sha256sum] = "531c4e566e52b92f18f9169d21ff0eb43c2a65cb3a03016af09887cfc272d453"

RDEPENDS:kweathercore = " \
 glibc \
 kf6-kholidays \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtpositioning \
 "
RDEPENDS:kweathercore-devel = " \
 cmake-filesystem \
 kweathercore \
 "
RDEPENDS:kweathercore-doc = " \
 "
