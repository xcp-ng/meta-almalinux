# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "micro"
PV = "2.0.15"
PR = "1.el10_2"
PACKAGES = " \
 micro \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/micro-2.0.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6af6cc61729859f956b8b657cecbd9e10a6c831efc4a15a2db969734d66a051d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/micro-2.0.15-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_micro;unpack=0"
SRC_URI[x86_64_v2_micro.sha256sum] = "50a72d4a25b07a780499075f564cc2e5933a9b45148ebfc9f2a3a4974dac4245"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/micro-2.0.15-1.el10_2.aarch64.rpm;name=aarch64_micro;unpack=0"
SRC_URI[aarch64_micro.sha256sum] = "7126b288d5bcc5ac262fbee0fda1237fced8a60cce23da24e4eecf7f65bec8ff"

RDEPENDS:micro = " \
 glibc \
 "
