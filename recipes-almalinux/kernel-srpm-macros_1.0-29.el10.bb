# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kernel-srpm-macros"
PV = "1.0"
PR = "29.el10"
PACKAGES = " \
 kernel-rpm-macros \
 kernel-srpm-macros \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/kernel-srpm-macros-1.0-29.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0012507d1a090c6ba4bac2a9efa4beb7ebebaccc4c6405a18dc174a1f0c98dbf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-rpm-macros-206-29.el10.noarch.rpm;name=x86_64_v2_kernel-rpm-macros;unpack=0"
SRC_URI[x86_64_v2_kernel-rpm-macros.sha256sum] = "f63ee957c6979616722ed29f7dfa4fffabc67cc028bafad0e8fe1a8f7862e210"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-srpm-macros-1.0-29.el10.noarch.rpm;name=x86_64_v2_kernel-srpm-macros;unpack=0"
SRC_URI[x86_64_v2_kernel-srpm-macros.sha256sum] = "7c901fa014f719a182cd631d6f3d18b7abb8e6ea60ac9de6649090f007505028"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-rpm-macros-206-29.el10.noarch.rpm;name=aarch64_kernel-rpm-macros;unpack=0"
SRC_URI[aarch64_kernel-rpm-macros.sha256sum] = "f63ee957c6979616722ed29f7dfa4fffabc67cc028bafad0e8fe1a8f7862e210"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-srpm-macros-1.0-29.el10.noarch.rpm;name=aarch64_kernel-srpm-macros;unpack=0"
SRC_URI[aarch64_kernel-srpm-macros.sha256sum] = "7c901fa014f719a182cd631d6f3d18b7abb8e6ea60ac9de6649090f007505028"

RDEPENDS:kernel-rpm-macros = " \
 bash \
 binutils \
 findutils \
 gawk \
 grep \
 kmod \
 perl-interpreter \
 redhat-rpm-config \
 sed \
 which \
 xz \
 "
RDEPENDS:kernel-srpm-macros = " \
 "
