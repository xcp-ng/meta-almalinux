# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aiofiles"
PV = "25.1.0"
PR = "2.el10_2"
PACKAGES = " \
 python3-aiofiles \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aiofiles-25.1.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9bee23ca2f5f2a41ba5b6c2ffe3cb0f2a9da8556fcf60bfceffdd7d161435db"

URI_x86_64_v2_python3-aiofiles = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiofiles-25.1.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aiofiles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiofiles}"
SRC_URI[x86_64_v2_python3-aiofiles.sha256sum] = "9abb862161c405b9200c231a76f5f2df9e3c3ae49c294a08e499ff5af482d5b9"

URI_aarch64_python3-aiofiles = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiofiles-25.1.0-2.el10_2.noarch.rpm;name=aarch64_python3-aiofiles;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiofiles}"
SRC_URI[aarch64_python3-aiofiles.sha256sum] = "d47c89a903c080d82d4b31723c0cc560a5a3b3abc1e4a954ce6a206fb79c5f35"

RDEPENDS:python3-aiofiles = " \
 python3 \
 "
