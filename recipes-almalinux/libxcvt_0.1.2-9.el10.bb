# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxcvt"
PV = "0.1.2"
PR = "9.el10"
PACKAGES = " \
 libxcvt \
 libxcvt-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libxcvt-0.1.2-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "830c31c81c128f3f6c0b5e4474ba16f7d7992d2eaba483324abeeb1a6bd54c71"

URI_x86_64_v2_libxcvt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxcvt-0.1.2-9.el10.x86_64_v2.rpm;name=x86_64_v2_libxcvt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxcvt}"
SRC_URI[x86_64_v2_libxcvt.sha256sum] = "fce8fb8615256e6c7e8b88dd375d580ba3d97f3520155b59b025baba85c690a2"

URI_x86_64_v2_libxcvt-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxcvt-devel-0.1.2-9.el10.x86_64_v2.rpm;name=x86_64_v2_libxcvt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxcvt-devel}"
SRC_URI[x86_64_v2_libxcvt-devel.sha256sum] = "c1f4639f5b63f85f010101de22111645131f16d0d68db8fc9c7f21a10c45f128"

URI_aarch64_libxcvt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxcvt-0.1.2-9.el10.aarch64.rpm;name=aarch64_libxcvt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxcvt}"
SRC_URI[aarch64_libxcvt.sha256sum] = "e90ebf540fe863cd1f76a2fe7ac9d011fee3bb9b273cddc6e119fdd1632feec2"

URI_aarch64_libxcvt-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxcvt-devel-0.1.2-9.el10.aarch64.rpm;name=aarch64_libxcvt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxcvt-devel}"
SRC_URI[aarch64_libxcvt-devel.sha256sum] = "28ddb9d1b3c15d1899b85b889d852bfb337742f02a3e984c2733612e97d7d1f5"

RDEPENDS:libxcvt = " \
 glibc \
 "
RDEPENDS:libxcvt-devel = " \
 libxcvt \
 pkgconf-pkg-config \
 "
