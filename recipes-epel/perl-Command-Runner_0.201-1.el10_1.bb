# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Command-Runner"
PV = "0.201"
PR = "1.el10_1"
PACKAGES = " \
 perl-Command-Runner \
 perl-Command-Runner-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Command-Runner-0.201-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c540f7bbc05014d991f6108ec6e207b314d09f2a25e910cb7ea38294610ab16a"

URI_x86_64_v2_perl-Command-Runner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Command-Runner-0.201-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Command-Runner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Command-Runner}"
SRC_URI[x86_64_v2_perl-Command-Runner.sha256sum] = "2fb3f1103f2f9333fc82f7e9b7524fc853833a56793fda4256fd8994a9114e23"

URI_x86_64_v2_perl-Command-Runner-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Command-Runner-tests-0.201-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Command-Runner-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Command-Runner-tests}"
SRC_URI[x86_64_v2_perl-Command-Runner-tests.sha256sum] = "f6bdd48ab8022c0ec3c96049fb399d21e8dd3395653dc21e9ff6bf1571b8843c"

URI_aarch64_perl-Command-Runner = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Command-Runner-0.201-1.el10_1.noarch.rpm;name=aarch64_perl-Command-Runner;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Command-Runner}"
SRC_URI[aarch64_perl-Command-Runner.sha256sum] = "c55abc2c0fb6375196ed8d3a1a6f841003bc5663dfb52d5e414c521670af7090"

URI_aarch64_perl-Command-Runner-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Command-Runner-tests-0.201-1.el10_1.noarch.rpm;name=aarch64_perl-Command-Runner-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Command-Runner-tests}"
SRC_URI[aarch64_perl-Command-Runner-tests.sha256sum] = "74949a25128ea242e0a0e79bac78f687fbf71fd9aeba991457d561fb1a7a8d65"

RDEPENDS:perl-Command-Runner = " \
 perl-Capture-Tiny \
 perl-Exporter \
 perl-File-pushd \
 perl-IO \
 perl-POSIX \
 perl-String-ShellQuote \
 perl-Time-HiRes \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Command-Runner-tests = " \
 bash \
 perl-Command-Runner \
 perl-File-Temp \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
