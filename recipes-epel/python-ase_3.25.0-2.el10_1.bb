# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ase"
PV = "3.25.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-ase \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ase-3.25.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9c52c7225d98033c3a56b2b78cfae789ab6f9938c905cc4555c44374befeabc"

URI_x86_64_v2_python3-ase = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ase-3.25.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ase}"
SRC_URI[x86_64_v2_python3-ase.sha256sum] = "e8ac617d85ae596c483d59b89fd5815e79e1e181f9a864396c82ff4a4e0a4d0d"

URI_aarch64_python3-ase = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ase-3.25.0-2.el10_1.noarch.rpm;name=aarch64_python3-ase;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ase}"
SRC_URI[aarch64_python3-ase.sha256sum] = "b12431d1e17ae5812ada93c116c651b794d3b075d9abff2271465d3be4473ebc"

RDEPENDS:python3-ase = " \
 python3 \
 python3-matplotlib \
 python3-numpy \
 python3-scipy \
 "
