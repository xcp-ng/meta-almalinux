# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-faster-hex"
PV = "0.9.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-faster-hex+alloc-devel \
 rust-faster-hex+default-devel \
 rust-faster-hex+serde-devel \
 rust-faster-hex+std-devel \
 rust-faster-hex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-faster-hex-0.9.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2f5048b127ecbe3d8df29984fd21cd16d1ecde35b19ba5a09c41b60cdc52900"

URI_x86_64_v2_rust-faster-hex+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-faster-hex+alloc-devel-0.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-faster-hex+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-faster-hex+alloc-devel}"
SRC_URI[x86_64_v2_rust-faster-hex+alloc-devel.sha256sum] = "125ed00e9c9e6290bbf0f0fbc19328654419192828bbccbd476053d295c07aab"

URI_x86_64_v2_rust-faster-hex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-faster-hex+default-devel-0.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-faster-hex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-faster-hex+default-devel}"
SRC_URI[x86_64_v2_rust-faster-hex+default-devel.sha256sum] = "0f77bed1189dbd2f1a58a57b696d4dc2dd8d4c3bdb344cf3ffa67033912196dc"

URI_x86_64_v2_rust-faster-hex+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-faster-hex+serde-devel-0.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-faster-hex+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-faster-hex+serde-devel}"
SRC_URI[x86_64_v2_rust-faster-hex+serde-devel.sha256sum] = "6883a60345d2e3c11505571721aabfde88ec0a50a1ec4cfa26c983a4d606d381"

URI_x86_64_v2_rust-faster-hex+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-faster-hex+std-devel-0.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-faster-hex+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-faster-hex+std-devel}"
SRC_URI[x86_64_v2_rust-faster-hex+std-devel.sha256sum] = "6d689a8af23cf2b45bd7c2bcaecdf4b3d196606762b8b4e8b41e6851cc070d49"

URI_x86_64_v2_rust-faster-hex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-faster-hex-devel-0.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-faster-hex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-faster-hex-devel}"
SRC_URI[x86_64_v2_rust-faster-hex-devel.sha256sum] = "33011b9e75c6b21824fb8d6b881e67c3ae9b252361bf179a47d48daa7415f704"

URI_aarch64_rust-faster-hex+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-faster-hex+alloc-devel-0.9.0-2.el10_0.noarch.rpm;name=aarch64_rust-faster-hex+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-faster-hex+alloc-devel}"
SRC_URI[aarch64_rust-faster-hex+alloc-devel.sha256sum] = "25e5d0e2700a81c1a564d67c8311157217f1d5ad51d49480fa20d4690cbcb1cb"

URI_aarch64_rust-faster-hex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-faster-hex+default-devel-0.9.0-2.el10_0.noarch.rpm;name=aarch64_rust-faster-hex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-faster-hex+default-devel}"
SRC_URI[aarch64_rust-faster-hex+default-devel.sha256sum] = "b96eb7a58285e0653437e5506b8cba29faac9f4ded6650652c2247ed8086eb98"

URI_aarch64_rust-faster-hex+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-faster-hex+serde-devel-0.9.0-2.el10_0.noarch.rpm;name=aarch64_rust-faster-hex+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-faster-hex+serde-devel}"
SRC_URI[aarch64_rust-faster-hex+serde-devel.sha256sum] = "24443e9d0497f7dbd10338ccbee5d2e02a5b3ca42dec0a5de564c071de07aed6"

URI_aarch64_rust-faster-hex+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-faster-hex+std-devel-0.9.0-2.el10_0.noarch.rpm;name=aarch64_rust-faster-hex+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-faster-hex+std-devel}"
SRC_URI[aarch64_rust-faster-hex+std-devel.sha256sum] = "b2585f3dab7b8b214cb18c4faeb8d883d269da463264b03cd6bf6c1953e1d7b2"

URI_aarch64_rust-faster-hex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-faster-hex-devel-0.9.0-2.el10_0.noarch.rpm;name=aarch64_rust-faster-hex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-faster-hex-devel}"
SRC_URI[aarch64_rust-faster-hex-devel.sha256sum] = "e46fe506bbd2754c3bd671a9fc24c4839dca73cd78e522fd45d9dbddd54604d5"

RDEPENDS:rust-faster-hex+alloc-devel = " \
 cargo \
 rust-faster-hex-devel \
 "
RDEPENDS:rust-faster-hex+default-devel = " \
 cargo \
 rust-faster-hex+serde-devel \
 rust-faster-hex+std-devel \
 rust-faster-hex-devel \
 "
RDEPENDS:rust-faster-hex+serde-devel = " \
 cargo \
 rust-faster-hex-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-faster-hex+std-devel = " \
 cargo \
 rust-faster-hex+alloc-devel \
 rust-faster-hex-devel \
 "
RDEPENDS:rust-faster-hex-devel = " \
 cargo \
 "
