# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-block-padding"
PV = "0.3.3"
PR = "4.el10_0"
PACKAGES = " \
 rust-block-padding+default-devel \
 rust-block-padding+std-devel \
 rust-block-padding-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-block-padding-0.3.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb1091fa795e52045315bdcab4b3b6278bab28da619f8950a28a70d5ba2a060a"

URI_x86_64_v2_rust-block-padding+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-padding+default-devel-0.3.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-padding+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-padding+default-devel}"
SRC_URI[x86_64_v2_rust-block-padding+default-devel.sha256sum] = "d7474e395e77aade82aaaf6a7a7b7f788c69ed163af6c2ef23da2bf3b25db131"

URI_x86_64_v2_rust-block-padding+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-padding+std-devel-0.3.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-padding+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-padding+std-devel}"
SRC_URI[x86_64_v2_rust-block-padding+std-devel.sha256sum] = "f4edde9f15f58a7e30c9905f53ba634a02515d04227740e986f2f59c1d8db3b6"

URI_x86_64_v2_rust-block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-padding-devel-0.3.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-padding-devel}"
SRC_URI[x86_64_v2_rust-block-padding-devel.sha256sum] = "ae5e860d8fbbda26983466a6a3199bcdc15fa5f8319b2304e29d0b67e3575472"

URI_aarch64_rust-block-padding+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-padding+default-devel-0.3.3-4.el10_0.noarch.rpm;name=aarch64_rust-block-padding+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-padding+default-devel}"
SRC_URI[aarch64_rust-block-padding+default-devel.sha256sum] = "eec49aba5946f3faf35b881fb8c5014e9ff5de44287351ce234d915b92079700"

URI_aarch64_rust-block-padding+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-padding+std-devel-0.3.3-4.el10_0.noarch.rpm;name=aarch64_rust-block-padding+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-padding+std-devel}"
SRC_URI[aarch64_rust-block-padding+std-devel.sha256sum] = "6e7119f402c0b3937140294bc37a14cf94a1e371c75f127058628a781ddc4798"

URI_aarch64_rust-block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-padding-devel-0.3.3-4.el10_0.noarch.rpm;name=aarch64_rust-block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-padding-devel}"
SRC_URI[aarch64_rust-block-padding-devel.sha256sum] = "78d96ae0a7e7929fa1bf155298416ada8213b5dcfec05d888b64ce0618c7e70f"

RDEPENDS:rust-block-padding+default-devel = " \
 cargo \
 rust-block-padding-devel \
 "
RDEPENDS:rust-block-padding+std-devel = " \
 cargo \
 rust-block-padding-devel \
 "
RDEPENDS:rust-block-padding-devel = " \
 cargo \
 rust \
 rust-generic-array+default-devel \
 "
