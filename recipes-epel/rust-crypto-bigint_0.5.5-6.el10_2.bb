# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crypto-bigint"
PV = "0.5.5"
PR = "6.el10_2"
PACKAGES = " \
 rust-crypto-bigint+alloc-devel \
 rust-crypto-bigint+default-devel \
 rust-crypto-bigint+der-devel \
 rust-crypto-bigint+extra-sizes-devel \
 rust-crypto-bigint+generic-array-devel \
 rust-crypto-bigint+rand-devel \
 rust-crypto-bigint+rand_core-devel \
 rust-crypto-bigint+serde-devel \
 rust-crypto-bigint+zeroize-devel \
 rust-crypto-bigint-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crypto-bigint-0.5.5-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37850a60d33444877ea7cb01081663f886ab5c595bccd02ef00587c0d1258f67"

URI_x86_64_v2_rust-crypto-bigint+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+alloc-devel-0.5.5-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+alloc-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+alloc-devel.sha256sum] = "9e153e69d7426e5df4b6e483b7f5612313a35271d3c7a5837c42e2ca3395861a"

URI_x86_64_v2_rust-crypto-bigint+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+default-devel-0.5.5-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+default-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+default-devel.sha256sum] = "132075fcaaa9d7526c3d8d15f5d570a9e78afca73d5ab7e2908145b746cdef06"

URI_x86_64_v2_rust-crypto-bigint+der-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+der-devel-0.5.5-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+der-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+der-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+der-devel.sha256sum] = "bc70cefd48d6df3c2fefba06d713f4a5f8217f02d84c61e1271ada0958982914"

URI_x86_64_v2_rust-crypto-bigint+extra-sizes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+extra-sizes-devel-0.5.5-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+extra-sizes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+extra-sizes-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+extra-sizes-devel.sha256sum] = "9c719c2a080124ef891ce045483759e673d1adec945f10f69fd43bf9cf5f5c66"

URI_x86_64_v2_rust-crypto-bigint+generic-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+generic-array-devel-0.5.5-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+generic-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+generic-array-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+generic-array-devel.sha256sum] = "78a0cc7b5526b401a1c02576a6e74e39c896159f02a1c9f454bd0a101f6a3347"

URI_x86_64_v2_rust-crypto-bigint+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+rand-devel-0.5.5-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+rand-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+rand-devel.sha256sum] = "a0318e4ea8e4c77d29767ab4774aab3504e14f929440fbb39a0c702d582843f1"

URI_x86_64_v2_rust-crypto-bigint+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+rand_core-devel-0.5.5-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+rand_core-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+rand_core-devel.sha256sum] = "58d060a32cc37494bedc792996b55bc041e7f9d25f96fea417975c6ab649be20"

URI_x86_64_v2_rust-crypto-bigint+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+serde-devel-0.5.5-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+serde-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+serde-devel.sha256sum] = "fd2dd46ca47aa240de3301a1ba84551d23facda71c518a9c3cff1350c22b5ea7"

URI_x86_64_v2_rust-crypto-bigint+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+zeroize-devel-0.5.5-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+zeroize-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+zeroize-devel.sha256sum] = "b5b7908ac851783c3bf428926187d6f7f32757f540cd0684a7e1e4b3bee68991"

URI_x86_64_v2_rust-crypto-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint-devel-0.5.5-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint-devel.sha256sum] = "8538b952f0dca24d5b0315a44535052f995cf842fd6f689f90e8422f9f85ed27"

URI_aarch64_rust-crypto-bigint+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+alloc-devel-0.5.5-6.el10_2.noarch.rpm;name=aarch64_rust-crypto-bigint+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+alloc-devel}"
SRC_URI[aarch64_rust-crypto-bigint+alloc-devel.sha256sum] = "b710b034687a0020d432308b36f7f413e9abd31e06b1e3c77dcbe5c4319ef006"

URI_aarch64_rust-crypto-bigint+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+default-devel-0.5.5-6.el10_2.noarch.rpm;name=aarch64_rust-crypto-bigint+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+default-devel}"
SRC_URI[aarch64_rust-crypto-bigint+default-devel.sha256sum] = "6f7abbefd9468b71d09872f2e81ed5760ed13c72c9a99a12ee5bc7efa25a95fe"

URI_aarch64_rust-crypto-bigint+der-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+der-devel-0.5.5-6.el10_2.noarch.rpm;name=aarch64_rust-crypto-bigint+der-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+der-devel}"
SRC_URI[aarch64_rust-crypto-bigint+der-devel.sha256sum] = "1efce93fc385d400384bd4980c1361a292e296080e362b41a5d3b977f2c72130"

URI_aarch64_rust-crypto-bigint+extra-sizes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+extra-sizes-devel-0.5.5-6.el10_2.noarch.rpm;name=aarch64_rust-crypto-bigint+extra-sizes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+extra-sizes-devel}"
SRC_URI[aarch64_rust-crypto-bigint+extra-sizes-devel.sha256sum] = "770dc1df05d4a8a82bdcfc8b4dd7751eb151bf57ec23ee4a3998c01511541d79"

URI_aarch64_rust-crypto-bigint+generic-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+generic-array-devel-0.5.5-6.el10_2.noarch.rpm;name=aarch64_rust-crypto-bigint+generic-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+generic-array-devel}"
SRC_URI[aarch64_rust-crypto-bigint+generic-array-devel.sha256sum] = "1ee51541ec112d216d1b56c3eadfcbc15aacf85a20ac44398a60f65b6f30a68e"

URI_aarch64_rust-crypto-bigint+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+rand-devel-0.5.5-6.el10_2.noarch.rpm;name=aarch64_rust-crypto-bigint+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+rand-devel}"
SRC_URI[aarch64_rust-crypto-bigint+rand-devel.sha256sum] = "6e96ab8e6a71b2aea936dca6859f74489e9ced137b9cdc26bfaa52ce9d2f7c75"

URI_aarch64_rust-crypto-bigint+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+rand_core-devel-0.5.5-6.el10_2.noarch.rpm;name=aarch64_rust-crypto-bigint+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+rand_core-devel}"
SRC_URI[aarch64_rust-crypto-bigint+rand_core-devel.sha256sum] = "1465457a42edfc9ff6941a19adcf81d384cfdef2092f198c2612def74749c110"

URI_aarch64_rust-crypto-bigint+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+serde-devel-0.5.5-6.el10_2.noarch.rpm;name=aarch64_rust-crypto-bigint+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+serde-devel}"
SRC_URI[aarch64_rust-crypto-bigint+serde-devel.sha256sum] = "d4c64cd81258f401d6b89cf1ce9b4be39791b16054936ae356f4c3393302b8ac"

URI_aarch64_rust-crypto-bigint+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+zeroize-devel-0.5.5-6.el10_2.noarch.rpm;name=aarch64_rust-crypto-bigint+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+zeroize-devel}"
SRC_URI[aarch64_rust-crypto-bigint+zeroize-devel.sha256sum] = "3eb45a848bbe38d0c7ab8e50488731a9108c81d4e090090ba4bd7309d223b3e1"

URI_aarch64_rust-crypto-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint-devel-0.5.5-6.el10_2.noarch.rpm;name=aarch64_rust-crypto-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint-devel}"
SRC_URI[aarch64_rust-crypto-bigint-devel.sha256sum] = "db21799719729d5a2aef5081489443ef8cd886c97c9096a3c50913f6974eec21"

RDEPENDS:rust-crypto-bigint+alloc-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-serdect+alloc-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-crypto-bigint+default-devel = " \
 cargo \
 rust-crypto-bigint+rand-devel \
 rust-crypto-bigint-devel \
 "
RDEPENDS:rust-crypto-bigint+der-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-der-devel \
 "
RDEPENDS:rust-crypto-bigint+extra-sizes-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 "
RDEPENDS:rust-crypto-bigint+generic-array-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-generic-array+default-devel \
 "
RDEPENDS:rust-crypto-bigint+rand-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-rand_core0.6+default-devel \
 rust-rand_core0.6+std-devel \
 "
RDEPENDS:rust-crypto-bigint+rand_core-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-rand_core0.6+default-devel \
 "
RDEPENDS:rust-crypto-bigint+serde-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-crypto-bigint+zeroize-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-crypto-bigint-devel = " \
 cargo \
 rust \
 rust-subtle-devel \
 "
