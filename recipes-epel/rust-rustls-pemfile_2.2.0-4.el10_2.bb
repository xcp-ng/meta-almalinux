# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-pemfile"
PV = "2.2.0"
PR = "4.el10_2"
PACKAGES = " \
 rust-rustls-pemfile+default-devel \
 rust-rustls-pemfile+std-devel \
 rust-rustls-pemfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-pemfile-2.2.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58870470ab6e466b4cbde2d221dd96b716aa2769c31b9ba0d0f13df85314837d"

URI_x86_64_v2_rust-rustls-pemfile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pemfile+default-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pemfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pemfile+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-pemfile+default-devel.sha256sum] = "b20af2b4be366785b007af9c36019c7ab74873b401c62f178b528189ef9ca595"

URI_x86_64_v2_rust-rustls-pemfile+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pemfile+std-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pemfile+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pemfile+std-devel}"
SRC_URI[x86_64_v2_rust-rustls-pemfile+std-devel.sha256sum] = "7d81988d45cf70880893b083827d7cb7160e1faf9f350634958326179d20f574"

URI_x86_64_v2_rust-rustls-pemfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pemfile-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pemfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pemfile-devel}"
SRC_URI[x86_64_v2_rust-rustls-pemfile-devel.sha256sum] = "9b1d46a4c8e33bd5bbb22b194d35e8aab331afb530e8e84de670c0c96a26474a"

URI_aarch64_rust-rustls-pemfile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pemfile+default-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-rustls-pemfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pemfile+default-devel}"
SRC_URI[aarch64_rust-rustls-pemfile+default-devel.sha256sum] = "588c59f75cbf5dfbe926487f46d90c6bf77e6a813de26e6263067f9a80ecb3f7"

URI_aarch64_rust-rustls-pemfile+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pemfile+std-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-rustls-pemfile+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pemfile+std-devel}"
SRC_URI[aarch64_rust-rustls-pemfile+std-devel.sha256sum] = "90f9488e9dc6a3377e686282587e70a0eceab3d4c00e301cf66d0c982fefc2a0"

URI_aarch64_rust-rustls-pemfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pemfile-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-rustls-pemfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pemfile-devel}"
SRC_URI[aarch64_rust-rustls-pemfile-devel.sha256sum] = "d22d28ad6c5d9358772dbef82200555331e9a023678cde48ea161d8f7770f3f7"

RDEPENDS:rust-rustls-pemfile+default-devel = " \
 cargo \
 rust-rustls-pemfile+std-devel \
 rust-rustls-pemfile-devel \
 "
RDEPENDS:rust-rustls-pemfile+std-devel = " \
 cargo \
 rust-rustls-pemfile-devel \
 rust-rustls-pki-types+std-devel \
 "
RDEPENDS:rust-rustls-pemfile-devel = " \
 cargo \
 rust-rustls-pki-types+default-devel \
 "
