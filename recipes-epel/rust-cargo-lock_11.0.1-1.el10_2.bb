# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-lock"
PV = "11.0.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-cargo-lock+default-devel \
 rust-cargo-lock+dependency-tree-devel \
 rust-cargo-lock+petgraph-devel \
 rust-cargo-lock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-lock-11.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37420d6034c2e8e65908ffe4825df3f1fa1a06091695469002a75b843dbe158e"

URI_x86_64_v2_rust-cargo-lock+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-lock+default-devel-11.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-lock+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-lock+default-devel.sha256sum] = "efcc24979b1b92ff30fda7b3777e986d5ddd4c153f06aa897a5388ca8832b806"

URI_x86_64_v2_rust-cargo-lock+dependency-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-lock+dependency-tree-devel-11.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-lock+dependency-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-lock+dependency-tree-devel}"
SRC_URI[x86_64_v2_rust-cargo-lock+dependency-tree-devel.sha256sum] = "2bef27cb5c3ff40c5a781317bd5fd50adbd1f1e260733b546840bafd00b83b3c"

URI_x86_64_v2_rust-cargo-lock+petgraph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-lock+petgraph-devel-11.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-lock+petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-lock+petgraph-devel}"
SRC_URI[x86_64_v2_rust-cargo-lock+petgraph-devel.sha256sum] = "1c0263812518fced38e07ec06cfccdea40bf1e5bf50bcb3af9d56099fafac0da"

URI_x86_64_v2_rust-cargo-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-lock-devel-11.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-lock-devel}"
SRC_URI[x86_64_v2_rust-cargo-lock-devel.sha256sum] = "fdf051264e97b3f0e1e8545bcd272224ccd45db36d14c6743b8eaf7998a17e4d"

URI_aarch64_rust-cargo-lock+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-lock+default-devel-11.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-lock+default-devel}"
SRC_URI[aarch64_rust-cargo-lock+default-devel.sha256sum] = "91f5c0b81090aff4d0f12cd928de1c75af0f5c6c8ed8fb7d1a30fe8a4b390641"

URI_aarch64_rust-cargo-lock+dependency-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-lock+dependency-tree-devel-11.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-lock+dependency-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-lock+dependency-tree-devel}"
SRC_URI[aarch64_rust-cargo-lock+dependency-tree-devel.sha256sum] = "1dee9d49ff37546b3ffdad99aca86f9182f416c665dff8caa9b4c224ef3c3d0a"

URI_aarch64_rust-cargo-lock+petgraph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-lock+petgraph-devel-11.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-lock+petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-lock+petgraph-devel}"
SRC_URI[aarch64_rust-cargo-lock+petgraph-devel.sha256sum] = "4f697fe1737183d55be2732423f6c95cbd1f1c9858c2045b7db1a3e69814d320"

URI_aarch64_rust-cargo-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-lock-devel-11.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-lock-devel}"
SRC_URI[aarch64_rust-cargo-lock-devel.sha256sum] = "42fadcf00e3fbb02bf3d583780a937002444f216147802aa17eb0ea1cda28732"

RDEPENDS:rust-cargo-lock+default-devel = " \
 cargo \
 rust-cargo-lock-devel \
 "
RDEPENDS:rust-cargo-lock+dependency-tree-devel = " \
 cargo \
 rust-cargo-lock+petgraph-devel \
 rust-cargo-lock-devel \
 "
RDEPENDS:rust-cargo-lock+petgraph-devel = " \
 cargo \
 rust-cargo-lock-devel \
 rust-petgraph+default-devel \
 "
RDEPENDS:rust-cargo-lock-devel = " \
 cargo \
 rust \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+serde_derive-devel \
 rust-toml0.9+default-devel \
 rust-url+default-devel \
 "
