# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql18-pgvector"
PV = "0.8.0"
PR = "1.el10"
PACKAGES = " \
 postgresql18-pgvector \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql18-pgvector-0.8.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "403b9d92874e1c404e322a6f03244b2c3bcf4a9a1caaf45e912cd60e48fccbda"

URI_x86_64_v2_postgresql18-pgvector = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-pgvector-0.8.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-pgvector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-pgvector}"
SRC_URI[x86_64_v2_postgresql18-pgvector.sha256sum] = "6cf9349c4f3920076dde93745f4b216eb73b2739188e0854253e06bd01503f74"

URI_aarch64_postgresql18-pgvector = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-pgvector-0.8.0-1.el10.aarch64.rpm;name=aarch64_postgresql18-pgvector;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-pgvector}"
SRC_URI[aarch64_postgresql18-pgvector.sha256sum] = "4269d6596a677fa23e8d4cf5a46de5f2f9c453fcac1cb92b21d8d72c25988090"

RDEPENDS:postgresql18-pgvector = " \
 glibc \
 postgresql18-server \
 "
