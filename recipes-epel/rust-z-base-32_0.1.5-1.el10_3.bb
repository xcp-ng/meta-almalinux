# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-z-base-32"
PV = "0.1.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-z-base-32+default-devel \
 rust-z-base-32-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-z-base-32-0.1.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa32cc14a270ee8f92bd6347399fbb4011a24fb247f1e0175bab7346e8613ce3"

URI_x86_64_v2_rust-z-base-32+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-z-base-32+default-devel-0.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-z-base-32+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-z-base-32+default-devel}"
SRC_URI[x86_64_v2_rust-z-base-32+default-devel.sha256sum] = "2144d75506921e2150f57db9cae3c832fdeb7ecc7356a75abbf592066a81a728"

URI_x86_64_v2_rust-z-base-32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-z-base-32-devel-0.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-z-base-32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-z-base-32-devel}"
SRC_URI[x86_64_v2_rust-z-base-32-devel.sha256sum] = "d20d610692c38c87ff87aa38d0b92713446965e32550b24dc9dd1881bd911e41"

URI_aarch64_rust-z-base-32+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-z-base-32+default-devel-0.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-z-base-32+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-z-base-32+default-devel}"
SRC_URI[aarch64_rust-z-base-32+default-devel.sha256sum] = "c01fb0251a7294bb1c96ca04bf2178daaa8ec2b76e645b8db0cc86b3d2af2230"

URI_aarch64_rust-z-base-32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-z-base-32-devel-0.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-z-base-32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-z-base-32-devel}"
SRC_URI[aarch64_rust-z-base-32-devel.sha256sum] = "10361e4faadd46238dad580f0f9c1f0c5d4ed6787e4b274b94bd92a22f801c86"

RDEPENDS:rust-z-base-32+default-devel = " \
 cargo \
 rust-z-base-32-devel \
 "
RDEPENDS:rust-z-base-32-devel = " \
 cargo \
 "
