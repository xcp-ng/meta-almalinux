# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-minimal-lexical"
PV = "0.2.1"
PR = "8.el10_0"
PACKAGES = " \
 rust-minimal-lexical+alloc-devel \
 rust-minimal-lexical+compact-devel \
 rust-minimal-lexical+default-devel \
 rust-minimal-lexical+lint-devel \
 rust-minimal-lexical+nightly-devel \
 rust-minimal-lexical+std-devel \
 rust-minimal-lexical-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-minimal-lexical-0.2.1-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42f74bb2402d64daa019394232e450a49fe1557fe3780eec27896a58c0e13213"

URI_x86_64_v2_rust-minimal-lexical+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minimal-lexical+alloc-devel-0.2.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minimal-lexical+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minimal-lexical+alloc-devel}"
SRC_URI[x86_64_v2_rust-minimal-lexical+alloc-devel.sha256sum] = "bead46384e31f9c314061a338ac7c45d8f19429826e91c60a9636d68b42d4a66"

URI_x86_64_v2_rust-minimal-lexical+compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minimal-lexical+compact-devel-0.2.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minimal-lexical+compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minimal-lexical+compact-devel}"
SRC_URI[x86_64_v2_rust-minimal-lexical+compact-devel.sha256sum] = "05a0aeaf064e22ccb43d688b2830a694ccb94f0fe70e740438fd3c442369bb5b"

URI_x86_64_v2_rust-minimal-lexical+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minimal-lexical+default-devel-0.2.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minimal-lexical+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minimal-lexical+default-devel}"
SRC_URI[x86_64_v2_rust-minimal-lexical+default-devel.sha256sum] = "e740ff9381e81fa02d6012e110d703b2297fbd4256a07bc8abb39c7aeb88bcad"

URI_x86_64_v2_rust-minimal-lexical+lint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minimal-lexical+lint-devel-0.2.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minimal-lexical+lint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minimal-lexical+lint-devel}"
SRC_URI[x86_64_v2_rust-minimal-lexical+lint-devel.sha256sum] = "130a7e77f42954178a7ebe3635e5305b99be10d41d8f2202fedd5381baae710c"

URI_x86_64_v2_rust-minimal-lexical+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minimal-lexical+nightly-devel-0.2.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minimal-lexical+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minimal-lexical+nightly-devel}"
SRC_URI[x86_64_v2_rust-minimal-lexical+nightly-devel.sha256sum] = "a2941c9c57c96e5420e32e6bc06b41ac68d4da8084aee3dd124925dbfda07445"

URI_x86_64_v2_rust-minimal-lexical+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minimal-lexical+std-devel-0.2.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minimal-lexical+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minimal-lexical+std-devel}"
SRC_URI[x86_64_v2_rust-minimal-lexical+std-devel.sha256sum] = "475cb914612e31c30381c6ca2f36c89e0a0e3e52f7f4f8afa8072ed754041e43"

URI_x86_64_v2_rust-minimal-lexical-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minimal-lexical-devel-0.2.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minimal-lexical-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minimal-lexical-devel}"
SRC_URI[x86_64_v2_rust-minimal-lexical-devel.sha256sum] = "4aa086f846e052d2a1a8fef8f82e312c884d2c2621d34f48ee3d3a140f366bcf"

URI_aarch64_rust-minimal-lexical+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minimal-lexical+alloc-devel-0.2.1-8.el10_0.noarch.rpm;name=aarch64_rust-minimal-lexical+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minimal-lexical+alloc-devel}"
SRC_URI[aarch64_rust-minimal-lexical+alloc-devel.sha256sum] = "84823e5200941baf7a3c96c51439b8b5b36a0cfa2c0752f7c81aea84f7c44e36"

URI_aarch64_rust-minimal-lexical+compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minimal-lexical+compact-devel-0.2.1-8.el10_0.noarch.rpm;name=aarch64_rust-minimal-lexical+compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minimal-lexical+compact-devel}"
SRC_URI[aarch64_rust-minimal-lexical+compact-devel.sha256sum] = "3b91db9aaf7188bcb85d804eb149de2f40e2e11ec881dd7345021625bbe37f6f"

URI_aarch64_rust-minimal-lexical+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minimal-lexical+default-devel-0.2.1-8.el10_0.noarch.rpm;name=aarch64_rust-minimal-lexical+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minimal-lexical+default-devel}"
SRC_URI[aarch64_rust-minimal-lexical+default-devel.sha256sum] = "714ef5c8a13d91b8517ab1a510879c1e153e9ab4e413e7a4b5c6294eb0c27f1e"

URI_aarch64_rust-minimal-lexical+lint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minimal-lexical+lint-devel-0.2.1-8.el10_0.noarch.rpm;name=aarch64_rust-minimal-lexical+lint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minimal-lexical+lint-devel}"
SRC_URI[aarch64_rust-minimal-lexical+lint-devel.sha256sum] = "22616a72c27b227700b4ea94009fc9e03c8193e9bd929ef14d1fa5285172dfbd"

URI_aarch64_rust-minimal-lexical+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minimal-lexical+nightly-devel-0.2.1-8.el10_0.noarch.rpm;name=aarch64_rust-minimal-lexical+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minimal-lexical+nightly-devel}"
SRC_URI[aarch64_rust-minimal-lexical+nightly-devel.sha256sum] = "8f4f75e0e1c4878b113a767f290ba228e9f7615aa6d10d5bdbbfb2a1622a4232"

URI_aarch64_rust-minimal-lexical+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minimal-lexical+std-devel-0.2.1-8.el10_0.noarch.rpm;name=aarch64_rust-minimal-lexical+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minimal-lexical+std-devel}"
SRC_URI[aarch64_rust-minimal-lexical+std-devel.sha256sum] = "b9575c7db0425f90f4d4c2c93f169c1a0bdb0638fd94130504e709127ffa6ad9"

URI_aarch64_rust-minimal-lexical-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minimal-lexical-devel-0.2.1-8.el10_0.noarch.rpm;name=aarch64_rust-minimal-lexical-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minimal-lexical-devel}"
SRC_URI[aarch64_rust-minimal-lexical-devel.sha256sum] = "197db8af64f7790dacaf5d9df79e0d0ecfe95a36dde869032ee1681cfea4d0dd"

RDEPENDS:rust-minimal-lexical+alloc-devel = " \
 cargo \
 rust-minimal-lexical-devel \
 "
RDEPENDS:rust-minimal-lexical+compact-devel = " \
 cargo \
 rust-minimal-lexical-devel \
 "
RDEPENDS:rust-minimal-lexical+default-devel = " \
 cargo \
 rust-minimal-lexical+std-devel \
 rust-minimal-lexical-devel \
 "
RDEPENDS:rust-minimal-lexical+lint-devel = " \
 cargo \
 rust-minimal-lexical-devel \
 "
RDEPENDS:rust-minimal-lexical+nightly-devel = " \
 cargo \
 rust-minimal-lexical-devel \
 "
RDEPENDS:rust-minimal-lexical+std-devel = " \
 cargo \
 rust-minimal-lexical-devel \
 "
RDEPENDS:rust-minimal-lexical-devel = " \
 cargo \
 "
