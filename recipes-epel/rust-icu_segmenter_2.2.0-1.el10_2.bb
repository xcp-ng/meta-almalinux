# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_segmenter"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_segmenter+auto-devel \
 rust-icu_segmenter+compiled_data-devel \
 rust-icu_segmenter+datagen-devel \
 rust-icu_segmenter+default-devel \
 rust-icu_segmenter+lstm-devel \
 rust-icu_segmenter+serde-devel \
 rust-icu_segmenter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_segmenter-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12dcd5014b25fba2d484bd344c1f3ef3dfa1a86c505b1a2af516e91158fbaf2e"

URI_x86_64_v2_rust-icu_segmenter+auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_segmenter+auto-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_segmenter+auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_segmenter+auto-devel}"
SRC_URI[x86_64_v2_rust-icu_segmenter+auto-devel.sha256sum] = "0f5d264bcf1e4e94f5a6582f919820af58c9fd5601ef7a0d2173cd4af8ca1f62"

URI_x86_64_v2_rust-icu_segmenter+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_segmenter+compiled_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_segmenter+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_segmenter+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_segmenter+compiled_data-devel.sha256sum] = "aac9633bd09a22674088698a8833423d44a29ff579900741fbc1e1bf5775bc02"

URI_x86_64_v2_rust-icu_segmenter+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_segmenter+datagen-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_segmenter+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_segmenter+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_segmenter+datagen-devel.sha256sum] = "123182d3890b77a16b8d12911168b3b253f04c1dc394eadbe0fec99afae0ad14"

URI_x86_64_v2_rust-icu_segmenter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_segmenter+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_segmenter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_segmenter+default-devel}"
SRC_URI[x86_64_v2_rust-icu_segmenter+default-devel.sha256sum] = "c0a6bc225bb22144a7713f824c3920c40a10e281aae980d0746f171852038cfd"

URI_x86_64_v2_rust-icu_segmenter+lstm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_segmenter+lstm-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_segmenter+lstm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_segmenter+lstm-devel}"
SRC_URI[x86_64_v2_rust-icu_segmenter+lstm-devel.sha256sum] = "1c4e7d4648b1ec522937fc9d3da50a757c592fb4759278d9e648cffac2edeb5d"

URI_x86_64_v2_rust-icu_segmenter+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_segmenter+serde-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_segmenter+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_segmenter+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_segmenter+serde-devel.sha256sum] = "3d605e944649c7ac84bcb80e78cb199247f5dacc2a41df0a4b42ff0f573b656f"

URI_x86_64_v2_rust-icu_segmenter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_segmenter-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_segmenter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_segmenter-devel}"
SRC_URI[x86_64_v2_rust-icu_segmenter-devel.sha256sum] = "8b2ca0e4fd2cb665a9666435a6634dd8d3a2d9ca41c27f60c658e4a7f1a40437"

URI_aarch64_rust-icu_segmenter+auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_segmenter+auto-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_segmenter+auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_segmenter+auto-devel}"
SRC_URI[aarch64_rust-icu_segmenter+auto-devel.sha256sum] = "8765ea3e50374dfd193eb97fd6b00a632e87e131a42bca3f5332741391cfc7c6"

URI_aarch64_rust-icu_segmenter+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_segmenter+compiled_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_segmenter+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_segmenter+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_segmenter+compiled_data-devel.sha256sum] = "326fad9958cd96d92a265bbe448ac4441d3e907afd24074c261e1756bdb50df4"

URI_aarch64_rust-icu_segmenter+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_segmenter+datagen-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_segmenter+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_segmenter+datagen-devel}"
SRC_URI[aarch64_rust-icu_segmenter+datagen-devel.sha256sum] = "611963caa187326db3103b70799d5099e747a8a035867defcd76112715e670f5"

URI_aarch64_rust-icu_segmenter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_segmenter+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_segmenter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_segmenter+default-devel}"
SRC_URI[aarch64_rust-icu_segmenter+default-devel.sha256sum] = "1c7da6a1d5ac9b4f4a4bdad72d8d7d2ff42461be1edf3be9040a402517711e03"

URI_aarch64_rust-icu_segmenter+lstm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_segmenter+lstm-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_segmenter+lstm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_segmenter+lstm-devel}"
SRC_URI[aarch64_rust-icu_segmenter+lstm-devel.sha256sum] = "fa57c10005ba6ac0bc4a43b86af64477bad14ae12e4c49716c72e7078ffbd302"

URI_aarch64_rust-icu_segmenter+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_segmenter+serde-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_segmenter+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_segmenter+serde-devel}"
SRC_URI[aarch64_rust-icu_segmenter+serde-devel.sha256sum] = "9b16c472b250531ce6bff44fa61f64872a102b76f073a2a2368ba4113f7d59f5"

URI_aarch64_rust-icu_segmenter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_segmenter-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_segmenter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_segmenter-devel}"
SRC_URI[aarch64_rust-icu_segmenter-devel.sha256sum] = "5cc48fba2de5fecb555359ebae0f48e3d8295a9bb23b780c0da763af983d3807"

RDEPENDS:rust-icu_segmenter+auto-devel = " \
 cargo \
 rust-icu_segmenter+lstm-devel \
 rust-icu_segmenter-devel \
 "
RDEPENDS:rust-icu_segmenter+compiled_data-devel = " \
 cargo \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale-devel \
 rust-icu_provider+baked-devel \
 rust-icu_segmenter-devel \
 rust-icu_segmenter_data-devel \
 "
RDEPENDS:rust-icu_segmenter+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collections+databake-devel \
 rust-icu_provider+export-devel \
 rust-icu_segmenter+serde-devel \
 rust-icu_segmenter-devel \
 rust-potential_utf+databake-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_segmenter+default-devel = " \
 cargo \
 rust-icu_segmenter+auto-devel \
 rust-icu_segmenter+compiled_data-devel \
 rust-icu_segmenter-devel \
 "
RDEPENDS:rust-icu_segmenter+lstm-devel = " \
 cargo \
 rust-core_maths-devel \
 rust-icu_segmenter-devel \
 "
RDEPENDS:rust-icu_segmenter+serde-devel = " \
 cargo \
 rust-icu_collections+serde-devel \
 rust-icu_provider+serde-devel \
 rust-icu_segmenter-devel \
 rust-potential_utf+serde-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_segmenter-devel = " \
 cargo \
 rust \
 rust-icu_collections-devel \
 rust-icu_provider-devel \
 rust-potential_utf+alloc-devel \
 rust-potential_utf+zerovec-devel \
 rust-potential_utf-devel \
 rust-utf8_iter-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
