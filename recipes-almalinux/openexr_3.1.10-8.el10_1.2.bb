# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openexr"
PV = "3.1.10"
PR = "8.el10_1.2"
PACKAGES = " \
 openexr \
 openexr-devel \
 openexr-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openexr-3.1.10-8.el10_1.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76538eb07fec8f2be2a7194e8c69fb2311821651b13b90ae55d391355e1ea6f4"

URI_x86_64_v2_openexr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openexr-3.1.10-8.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_openexr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openexr}"
SRC_URI[x86_64_v2_openexr.sha256sum] = "2795be8a0af08f5c74614cfbf8cd0c857b551207ea0b2ad08d619a0b33889b0b"

URI_x86_64_v2_openexr-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openexr-devel-3.1.10-8.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_openexr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openexr-devel}"
SRC_URI[x86_64_v2_openexr-devel.sha256sum] = "142ad5c7b9d8050c1aab3ded921f2ea8b4a927811f9896f7101fcbe398447476"

URI_x86_64_v2_openexr-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openexr-libs-3.1.10-8.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_openexr-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openexr-libs}"
SRC_URI[x86_64_v2_openexr-libs.sha256sum] = "7245fc0ef790b24e4fa41e0375feb5e5ce701ac4b61e1224539f0245d6ec0f68"

URI_aarch64_openexr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openexr-3.1.10-8.el10_1.2.aarch64.rpm;name=aarch64_openexr;unpack=0"
SRC_URI:append = " ${URI_aarch64_openexr}"
SRC_URI[aarch64_openexr.sha256sum] = "fca2e4f96f0b7da672347ca5c87391a0d0badf8481a58f044534ad3703bbf868"

URI_aarch64_openexr-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openexr-devel-3.1.10-8.el10_1.2.aarch64.rpm;name=aarch64_openexr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openexr-devel}"
SRC_URI[aarch64_openexr-devel.sha256sum] = "ff2ecec2216fc5a2e98cfea93d59993bdd547a08282625d05f200f45c16b5b4b"

URI_aarch64_openexr-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openexr-libs-3.1.10-8.el10_1.2.aarch64.rpm;name=aarch64_openexr-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_openexr-libs}"
SRC_URI[aarch64_openexr-libs.sha256sum] = "c7afd053395899765db636a17c72935e7b8329b445450ea2e68d01bab5bb6003"

RDEPENDS:openexr = " \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 openexr-libs \
 "
RDEPENDS:openexr-devel = " \
 cmake-filesystem \
 imath-devel \
 openexr-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openexr-libs = " \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
