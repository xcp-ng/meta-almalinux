# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-slog-term"
PV = "2.9.1"
PR = "3.el10_1"
PACKAGES = " \
 rust-slog-term+default-devel \
 rust-slog-term+erased-serde-devel \
 rust-slog-term+nested-values-devel \
 rust-slog-term+serde-devel \
 rust-slog-term+serde_json-devel \
 rust-slog-term-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-slog-term-2.9.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60836dfd58cd62cd013277b48c52e7097d94e73db230df8243c7b953dc8075b0"

URI_x86_64_v2_rust-slog-term+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term+default-devel-2.9.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term+default-devel}"
SRC_URI[x86_64_v2_rust-slog-term+default-devel.sha256sum] = "fab1fe2c5ffc4dcf0ff0dcad5f3b8e5a071aa293ab35a68166c10498b90e4a90"

URI_x86_64_v2_rust-slog-term+erased-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term+erased-serde-devel-2.9.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term+erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term+erased-serde-devel}"
SRC_URI[x86_64_v2_rust-slog-term+erased-serde-devel.sha256sum] = "91f5b6d9a6465a8bae9f33df5da5ae922f3a13bf0077cad519062b343285a337"

URI_x86_64_v2_rust-slog-term+nested-values-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term+nested-values-devel-2.9.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term+nested-values-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term+nested-values-devel}"
SRC_URI[x86_64_v2_rust-slog-term+nested-values-devel.sha256sum] = "d6d0303b8a6d6fa99be2ce3fb9b5fdf79e4fd5c6a0c6919b407e1e86b4a8e365"

URI_x86_64_v2_rust-slog-term+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term+serde-devel-2.9.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term+serde-devel}"
SRC_URI[x86_64_v2_rust-slog-term+serde-devel.sha256sum] = "ce414f88d63f9af2ae4aaa01951c9f6e2fb7356269f068d8cbebe0ad27366f07"

URI_x86_64_v2_rust-slog-term+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term+serde_json-devel-2.9.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term+serde_json-devel}"
SRC_URI[x86_64_v2_rust-slog-term+serde_json-devel.sha256sum] = "2bc5049120a5a614de5e26ae43080bbdc4fa2694c0f09561c08afbce5cfd8144"

URI_x86_64_v2_rust-slog-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term-devel-2.9.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term-devel}"
SRC_URI[x86_64_v2_rust-slog-term-devel.sha256sum] = "e5f80c76a00edc151a7da660584b4c65418a4b8dcbbdc115df3a41f266f729b0"

URI_aarch64_rust-slog-term+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term+default-devel-2.9.1-3.el10_1.noarch.rpm;name=aarch64_rust-slog-term+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term+default-devel}"
SRC_URI[aarch64_rust-slog-term+default-devel.sha256sum] = "2b8b110b983aa2d4ffdcde33051af8a3645607d57f5802ede880d1573e12cc8e"

URI_aarch64_rust-slog-term+erased-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term+erased-serde-devel-2.9.1-3.el10_1.noarch.rpm;name=aarch64_rust-slog-term+erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term+erased-serde-devel}"
SRC_URI[aarch64_rust-slog-term+erased-serde-devel.sha256sum] = "e599cbf3d2c3f611556e71b7388cafdb9ee32993cfd5a64ee393506ddeea9695"

URI_aarch64_rust-slog-term+nested-values-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term+nested-values-devel-2.9.1-3.el10_1.noarch.rpm;name=aarch64_rust-slog-term+nested-values-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term+nested-values-devel}"
SRC_URI[aarch64_rust-slog-term+nested-values-devel.sha256sum] = "40a2ace35f1f6a92eaa74b784062688fb04153f3c787ebb88eb20ec99ea0fb93"

URI_aarch64_rust-slog-term+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term+serde-devel-2.9.1-3.el10_1.noarch.rpm;name=aarch64_rust-slog-term+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term+serde-devel}"
SRC_URI[aarch64_rust-slog-term+serde-devel.sha256sum] = "cf3c4ba3cf54c0d7cf26856e3cf6f5771428596c9d96965287e00cc2ab199c0d"

URI_aarch64_rust-slog-term+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term+serde_json-devel-2.9.1-3.el10_1.noarch.rpm;name=aarch64_rust-slog-term+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term+serde_json-devel}"
SRC_URI[aarch64_rust-slog-term+serde_json-devel.sha256sum] = "530dd93620f8f881c159d39a38d0d1ffe8a80fc17aff687eebff4d32f6f19256"

URI_aarch64_rust-slog-term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term-devel-2.9.1-3.el10_1.noarch.rpm;name=aarch64_rust-slog-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term-devel}"
SRC_URI[aarch64_rust-slog-term-devel.sha256sum] = "53a6da46632bba16053d491ac88cf538fb1f1cfe9838244c1cbb64aa2fea8755"

RDEPENDS:rust-slog-term+default-devel = " \
 cargo \
 rust-slog-term-devel \
 "
RDEPENDS:rust-slog-term+erased-serde-devel = " \
 cargo \
 rust-erased-serde0.3+default-devel \
 rust-slog-term-devel \
 "
RDEPENDS:rust-slog-term+nested-values-devel = " \
 cargo \
 rust-slog+nested-values-devel \
 rust-slog-term+erased-serde-devel \
 rust-slog-term+serde-devel \
 rust-slog-term+serde_json-devel \
 rust-slog-term-devel \
 "
RDEPENDS:rust-slog-term+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-slog-term-devel \
 "
RDEPENDS:rust-slog-term+serde_json-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-slog-term-devel \
 "
RDEPENDS:rust-slog-term-devel = " \
 cargo \
 rust \
 rust-is-terminal+default-devel \
 rust-slog+default-devel \
 rust-term+default-devel \
 rust-thread_local+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time-devel \
 "
