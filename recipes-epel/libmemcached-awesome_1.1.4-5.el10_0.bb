# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmemcached-awesome"
PV = "1.1.4"
PR = "5.el10_0"
PACKAGES = " \
 libmemcached-awesome \
 libmemcached-awesome-devel \
 libmemcached-awesome-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmemcached-awesome-1.1.4-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe65997996444a7e6ad7034fce2be912ee612dd2861c90950b33c7bc8e0c8c6a"

URI_x86_64_v2_libmemcached-awesome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmemcached-awesome-1.1.4-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmemcached-awesome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmemcached-awesome}"
SRC_URI[x86_64_v2_libmemcached-awesome.sha256sum] = "e4b9c1eaa457df92d45dc3562d28d757cdde3e04e74e9de0357697de09192a3e"

URI_x86_64_v2_libmemcached-awesome-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmemcached-awesome-devel-1.1.4-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmemcached-awesome-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmemcached-awesome-devel}"
SRC_URI[x86_64_v2_libmemcached-awesome-devel.sha256sum] = "50bad449ed07d50d1b2c7cabd4c995f1e9433abaedea2c908cf6f59def10aca5"

URI_x86_64_v2_libmemcached-awesome-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmemcached-awesome-tools-1.1.4-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmemcached-awesome-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmemcached-awesome-tools}"
SRC_URI[x86_64_v2_libmemcached-awesome-tools.sha256sum] = "70d828666fa246de336994d47b33a65e975a0c9500f4a3c3fddbf8595e92b47d"

URI_aarch64_libmemcached-awesome = "${EPEL_MIRROR}/aarch64/Packages/l/libmemcached-awesome-1.1.4-5.el10_0.aarch64.rpm;name=aarch64_libmemcached-awesome;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmemcached-awesome}"
SRC_URI[aarch64_libmemcached-awesome.sha256sum] = "2ce2eea8ad4bb73864c7648099fa2b9ec029eae21f1312f3331ad3cc87be2aa6"

URI_aarch64_libmemcached-awesome-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmemcached-awesome-devel-1.1.4-5.el10_0.aarch64.rpm;name=aarch64_libmemcached-awesome-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmemcached-awesome-devel}"
SRC_URI[aarch64_libmemcached-awesome-devel.sha256sum] = "e57029f6b568050f278aaa5e8da421edcb72a550d7f72cf850bf3ba2140dfe3b"

URI_aarch64_libmemcached-awesome-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libmemcached-awesome-tools-1.1.4-5.el10_0.aarch64.rpm;name=aarch64_libmemcached-awesome-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmemcached-awesome-tools}"
SRC_URI[aarch64_libmemcached-awesome-tools.sha256sum] = "98ed2e99bfea568fa1895945992dc244e8b37299e27c69494e0f689bedc64e3e"

RDEPENDS:libmemcached-awesome = " \
 cyrus-sasl-lib \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 "
RDEPENDS:libmemcached-awesome-devel = " \
 cmake-filesystem \
 cyrus-sasl-devel \
 libmemcached-awesome \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libmemcached-awesome-tools = " \
 glibc \
 libevent \
 libgcc \
 libmemcached-awesome \
 libstdc++ \
 "
