# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ppp"
PV = "2.5.0"
PR = "13.el10"
PACKAGES = " \
 ppp \
 ppp-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ppp-2.5.0-13.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fe7ae15a5ba09058da10acf5603e45ea3c639626e35887d47741c322ff580359"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ppp-2.5.0-13.el10.x86_64_v2.rpm;name=x86_64_v2_ppp;unpack=0"
SRC_URI[x86_64_v2_ppp.sha256sum] = "9b2216740345182d4aca32ba12d02811d0a8cba787fbd1012d2e2c965ff69413"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ppp-devel-2.5.0-13.el10.x86_64_v2.rpm;name=x86_64_v2_ppp-devel;unpack=0"
SRC_URI[x86_64_v2_ppp-devel.sha256sum] = "1b2241cc01c777868a0dc2e46238f583b7be1cd924ee2d25262bb15d928c8f9e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ppp-2.5.0-13.el10.aarch64.rpm;name=aarch64_ppp;unpack=0"
SRC_URI[aarch64_ppp.sha256sum] = "aaefa9402445098a4670b9e03a7b4ff4e290a23699ada0e219ab6553eb0b32e3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ppp-devel-2.5.0-13.el10.aarch64.rpm;name=aarch64_ppp-devel;unpack=0"
SRC_URI[aarch64_ppp-devel.sha256sum] = "0841b598a985e1ab46b2ec480389c7c4659a685d32be921b5b1adc467ee700d3"

RDEPENDS:ppp = " \
 authselect-libs \
 bash \
 glib2 \
 glibc \
 glibc-common \
 libpcap \
 libxcrypt \
 openssl-libs \
 pam-libs \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:ppp-devel = " \
 pkgconf-pkg-config \
 ppp \
 "
