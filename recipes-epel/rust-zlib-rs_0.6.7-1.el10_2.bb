# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zlib-rs"
PV = "0.6.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-zlib-rs+__internal-api-devel \
 rust-zlib-rs+avx512-devel \
 rust-zlib-rs+c-allocator-devel \
 rust-zlib-rs+default-devel \
 rust-zlib-rs+lsx-devel \
 rust-zlib-rs+rust-allocator-devel \
 rust-zlib-rs+std-devel \
 rust-zlib-rs+vpclmulqdq-devel \
 rust-zlib-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zlib-rs-0.6.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "172bda5695d07ce881e85471a2342228e85f38449a9104122d4a4a8d01b434b2"

URI_x86_64_v2_rust-zlib-rs+__internal-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+__internal-api-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+__internal-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+__internal-api-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+__internal-api-devel.sha256sum] = "0e9e53240a70ed3c90a78cf50f10cdaa8d788e213649d4e5fa67668c194ed3da"

URI_x86_64_v2_rust-zlib-rs+avx512-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+avx512-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+avx512-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+avx512-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+avx512-devel.sha256sum] = "35255dfe4485dc32be85785a15feb818aee31791c89c5c79594902d830e73390"

URI_x86_64_v2_rust-zlib-rs+c-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+c-allocator-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+c-allocator-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+c-allocator-devel.sha256sum] = "ea0720e755d063393db7b0abbb3ef60d3e0257dd189751bd8f00f239fd9671e1"

URI_x86_64_v2_rust-zlib-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+default-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+default-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+default-devel.sha256sum] = "d1dae5b7780a323e64ea2eff120b51b4c1e245a715dd11eb13abc6e16c6af567"

URI_x86_64_v2_rust-zlib-rs+lsx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+lsx-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+lsx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+lsx-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+lsx-devel.sha256sum] = "fd4b02a0dbf773ef6ff1a8ac829354e0731b69c744400ffdc2e54857fe953438"

URI_x86_64_v2_rust-zlib-rs+rust-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+rust-allocator-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+rust-allocator-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+rust-allocator-devel.sha256sum] = "6091b842e471e201ce95148c9fb750414ef1f822a2f426fabfa1a33a713f886c"

URI_x86_64_v2_rust-zlib-rs+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+std-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+std-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+std-devel.sha256sum] = "ca15bafa251033c7eee5defbc3e05b751ec74f498a103166eb32ee62c70e81e1"

URI_x86_64_v2_rust-zlib-rs+vpclmulqdq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+vpclmulqdq-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+vpclmulqdq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+vpclmulqdq-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+vpclmulqdq-devel.sha256sum] = "93eb5427ecd401a92377f003c8b5f31f443000eeab887910d283337b8dd875ab"

URI_x86_64_v2_rust-zlib-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs-devel.sha256sum] = "dda99befab98b9f806cbff789e53b3f8779c5adf0d6f98c6bda7475698eb688d"

URI_aarch64_rust-zlib-rs+__internal-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+__internal-api-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-zlib-rs+__internal-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+__internal-api-devel}"
SRC_URI[aarch64_rust-zlib-rs+__internal-api-devel.sha256sum] = "c164333d853be4cfae0e85a4a5f574a204a4b4c6c496281a9c0aa58d5e6101fc"

URI_aarch64_rust-zlib-rs+avx512-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+avx512-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-zlib-rs+avx512-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+avx512-devel}"
SRC_URI[aarch64_rust-zlib-rs+avx512-devel.sha256sum] = "085e7c68bb45cb3b62b42151b131535f7ec847dd55527d3c2a9629382bc8b7fb"

URI_aarch64_rust-zlib-rs+c-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+c-allocator-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-zlib-rs+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+c-allocator-devel}"
SRC_URI[aarch64_rust-zlib-rs+c-allocator-devel.sha256sum] = "fc9dd2a9e8b4f03b9b906f774596138146a6d2416385738f6994c1559aefd7e5"

URI_aarch64_rust-zlib-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+default-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-zlib-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+default-devel}"
SRC_URI[aarch64_rust-zlib-rs+default-devel.sha256sum] = "48fa4b8f2f7a7d1e035d89e08f1caf259dec88299f27f488ea14bd46074708c1"

URI_aarch64_rust-zlib-rs+lsx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+lsx-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-zlib-rs+lsx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+lsx-devel}"
SRC_URI[aarch64_rust-zlib-rs+lsx-devel.sha256sum] = "760c780e4bf547571371d1de8559a60630fe14960201b222371babb68e2f9e90"

URI_aarch64_rust-zlib-rs+rust-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+rust-allocator-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-zlib-rs+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+rust-allocator-devel}"
SRC_URI[aarch64_rust-zlib-rs+rust-allocator-devel.sha256sum] = "ea5c0eb99795f80d81ae08ca1c03ffaa761cccf22144eeeac51352517aa2ef57"

URI_aarch64_rust-zlib-rs+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+std-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-zlib-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+std-devel}"
SRC_URI[aarch64_rust-zlib-rs+std-devel.sha256sum] = "ee02070b01eb2ae34feec7c60d433905f496ca87e3c44c31be6a25af46e9b858"

URI_aarch64_rust-zlib-rs+vpclmulqdq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+vpclmulqdq-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-zlib-rs+vpclmulqdq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+vpclmulqdq-devel}"
SRC_URI[aarch64_rust-zlib-rs+vpclmulqdq-devel.sha256sum] = "21fc27f8baa4fabed13af170b165fbebfd8ce2c34eec34d54a0d1cb4add7e66d"

URI_aarch64_rust-zlib-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs-devel}"
SRC_URI[aarch64_rust-zlib-rs-devel.sha256sum] = "be026d6153bf3c04d1b775bb308ad8595921bd6201394c9a813f36d2a4a5222b"

RDEPENDS:rust-zlib-rs+__internal-api-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+avx512-devel = " \
 cargo \
 rust-zlib-rs+vpclmulqdq-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+c-allocator-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+default-devel = " \
 cargo \
 rust-zlib-rs+c-allocator-devel \
 rust-zlib-rs+std-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+lsx-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+rust-allocator-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+std-devel = " \
 cargo \
 rust-zlib-rs+rust-allocator-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+vpclmulqdq-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs-devel = " \
 cargo \
 rust \
 "
