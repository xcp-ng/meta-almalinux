# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pipewire"
PV = "1.2.7"
PR = "1.el10"
PACKAGES = " \
 pipewire \
 pipewire-alsa \
 pipewire-devel \
 pipewire-gstreamer \
 pipewire-jack-audio-connection-kit \
 pipewire-jack-audio-connection-kit-devel \
 pipewire-jack-audio-connection-kit-libs \
 pipewire-libs \
 pipewire-module-x11 \
 pipewire-plugin-libcamera \
 pipewire-pulseaudio \
 pipewire-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pipewire-1.2.7-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "130a8a5b69d0edf823424879c982e0fdcbb330620a9956cbbb40ba48823f6c1e"

URI_x86_64_v2_pipewire = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-1.2.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire}"
SRC_URI[x86_64_v2_pipewire.sha256sum] = "377d107614f6e058e8cc3417e157055356e551af63f811531c94d90a35d585da"

URI_x86_64_v2_pipewire-alsa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-alsa-1.2.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-alsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-alsa}"
SRC_URI[x86_64_v2_pipewire-alsa.sha256sum] = "6b40eb51ae69c926e1dda48c6fda61c34edd1b12ff83b7935eaab0fcffc6d65e"

URI_x86_64_v2_pipewire-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-devel-1.2.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-devel}"
SRC_URI[x86_64_v2_pipewire-devel.sha256sum] = "18f09516865091717582d124e4b745f85d36d46e3104ed84d0c4d1fcaab027ad"

URI_x86_64_v2_pipewire-gstreamer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-gstreamer-1.2.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-gstreamer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-gstreamer}"
SRC_URI[x86_64_v2_pipewire-gstreamer.sha256sum] = "0fda051db8f781c45896583a9ab510079cb9d6e949cb812a5e0b97ccc3be7e5d"

URI_x86_64_v2_pipewire-jack-audio-connection-kit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-1.2.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-jack-audio-connection-kit}"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit.sha256sum] = "7cd1e89514714fda14518ac42dbce56d00bd55b4b75dc6ee67bf0ae902edf93f"

URI_x86_64_v2_pipewire-jack-audio-connection-kit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-devel-1.2.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-jack-audio-connection-kit-devel}"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit-devel.sha256sum] = "dee76509a72b516f9853412570f6f2c09b2eb40715a82e6e16ad394008d94aa8"

URI_x86_64_v2_pipewire-jack-audio-connection-kit-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-libs-1.2.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-jack-audio-connection-kit-libs}"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit-libs.sha256sum] = "4fe0776dd435c9ed36bc7f4acc2fe3ef48919f6c7d2383768005120e9721d3ce"

URI_x86_64_v2_pipewire-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-libs-1.2.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-libs}"
SRC_URI[x86_64_v2_pipewire-libs.sha256sum] = "7426fa50a7de168fa7819a7d4a7712c2122da39754392becd7f7aa5e95f92ee1"

URI_x86_64_v2_pipewire-module-x11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-module-x11-1.2.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-module-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-module-x11}"
SRC_URI[x86_64_v2_pipewire-module-x11.sha256sum] = "de03712f4a8239225bbce2675dabb06d8895f5b39f57d0a79f51b152e12999ad"

URI_x86_64_v2_pipewire-plugin-libcamera = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-plugin-libcamera-1.2.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-plugin-libcamera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-plugin-libcamera}"
SRC_URI[x86_64_v2_pipewire-plugin-libcamera.sha256sum] = "24eecbb2122edf22c4beaa3c96ec8af8400f9bba04936a1acfcca180d2306343"

URI_x86_64_v2_pipewire-pulseaudio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-pulseaudio-1.2.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-pulseaudio}"
SRC_URI[x86_64_v2_pipewire-pulseaudio.sha256sum] = "09dae8cab7a36865dcd6ffd922b275f97e04ac2ad1b547bc7516294059d4de4a"

URI_x86_64_v2_pipewire-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-utils-1.2.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-utils}"
SRC_URI[x86_64_v2_pipewire-utils.sha256sum] = "d46467e7779c3c493653a3f79ebfffdfa60a70c41081630a287ffea3a9d15f8b"

URI_aarch64_pipewire = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-1.2.7-1.el10.aarch64.rpm;name=aarch64_pipewire;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire}"
SRC_URI[aarch64_pipewire.sha256sum] = "3fd55fe7aed14a7ed6741a1cbd97fee5f37ca2a0e033c2d0a2d13f66c45ba041"

URI_aarch64_pipewire-alsa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-alsa-1.2.7-1.el10.aarch64.rpm;name=aarch64_pipewire-alsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-alsa}"
SRC_URI[aarch64_pipewire-alsa.sha256sum] = "5c1518f8b1150fa47be80da8da39a90ba705feaacf987e1dc719199b91667554"

URI_aarch64_pipewire-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-devel-1.2.7-1.el10.aarch64.rpm;name=aarch64_pipewire-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-devel}"
SRC_URI[aarch64_pipewire-devel.sha256sum] = "f0b9477b031c7b9b2766b4f11434f651b30ed513dde90b1686345a82d361a68d"

URI_aarch64_pipewire-gstreamer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-gstreamer-1.2.7-1.el10.aarch64.rpm;name=aarch64_pipewire-gstreamer;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-gstreamer}"
SRC_URI[aarch64_pipewire-gstreamer.sha256sum] = "73b4e871a8e21881da4b14a941903ea1fcdf2a6e891b7bb47157e66d43402689"

URI_aarch64_pipewire-jack-audio-connection-kit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-1.2.7-1.el10.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-jack-audio-connection-kit}"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit.sha256sum] = "04aa68dda266f57833074d518d5ef2c95474e166d6513405fa6ad16037b39595"

URI_aarch64_pipewire-jack-audio-connection-kit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-devel-1.2.7-1.el10.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-jack-audio-connection-kit-devel}"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit-devel.sha256sum] = "6620b5635cc2b63777e2918dd4251c3ec107e95d167c93b1dfce2aa6da52fd4b"

URI_aarch64_pipewire-jack-audio-connection-kit-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-libs-1.2.7-1.el10.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-jack-audio-connection-kit-libs}"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit-libs.sha256sum] = "0b116cab5c240e01aa936dc16bbf2d384a60814b2543816c0bf19e68801e4c8b"

URI_aarch64_pipewire-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-libs-1.2.7-1.el10.aarch64.rpm;name=aarch64_pipewire-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-libs}"
SRC_URI[aarch64_pipewire-libs.sha256sum] = "6b21cd653bb99ddc1750f4887277e37f73d716b03d3622fb16492bf7b57421d5"

URI_aarch64_pipewire-module-x11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-module-x11-1.2.7-1.el10.aarch64.rpm;name=aarch64_pipewire-module-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-module-x11}"
SRC_URI[aarch64_pipewire-module-x11.sha256sum] = "2148ed199efd188fe5f49899de3fc4e8c751134bdfe45d8c0e637d2f95b327b1"

URI_aarch64_pipewire-plugin-libcamera = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-plugin-libcamera-1.2.7-1.el10.aarch64.rpm;name=aarch64_pipewire-plugin-libcamera;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-plugin-libcamera}"
SRC_URI[aarch64_pipewire-plugin-libcamera.sha256sum] = "12abb889210abb77bbf331b48282a2e60b111887ee31283addf7a91aec1f1811"

URI_aarch64_pipewire-pulseaudio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-pulseaudio-1.2.7-1.el10.aarch64.rpm;name=aarch64_pipewire-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-pulseaudio}"
SRC_URI[aarch64_pipewire-pulseaudio.sha256sum] = "2f6119e05a45c34a02d15e93c54e6d81218bcf01b570d33cdf5706fa011dfc70"

URI_aarch64_pipewire-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-utils-1.2.7-1.el10.aarch64.rpm;name=aarch64_pipewire-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-utils}"
SRC_URI[aarch64_pipewire-utils.sha256sum] = "39bf96f3377c945874e6e742665e4da0f4ff0d9a01be58c44eaecb2434a0e93c"

RDEPENDS:pipewire = " \
 bash \
 glibc \
 pipewire-libs \
 rtkit \
 shadow-utils \
 systemd \
 wireplumber \
 "
RDEPENDS:pipewire-alsa = " \
 alsa-lib \
 glibc \
 pipewire-libs \
 "
RDEPENDS:pipewire-devel = " \
 pipewire-devel \
 pipewire-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pipewire-gstreamer = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libgcc \
 pipewire-libs \
 "
RDEPENDS:pipewire-jack-audio-connection-kit = " \
 pipewire-jack-audio-connection-kit-libs \
 "
RDEPENDS:pipewire-jack-audio-connection-kit-devel = " \
 pipewire-jack-audio-connection-kit-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pipewire-jack-audio-connection-kit-libs = " \
 bash \
 glibc \
 pipewire-jack-audio-connection-kit \
 pipewire-libs \
 "
RDEPENDS:pipewire-libs = " \
 alsa-lib \
 avahi-libs \
 bluez-libs \
 dbus-libs \
 fdk-aac-free \
 glib2 \
 glibc \
 libgcc \
 liblc3 \
 libldac \
 libsbc \
 libselinux \
 libsndfile \
 libstdc++ \
 libusb1 \
 openssl-libs \
 opus \
 pulseaudio-libs \
 systemd-libs \
 webrtc-audio-processing \
 "
RDEPENDS:pipewire-module-x11 = " \
 glibc \
 libX11 \
 libXfixes \
 libcanberra \
 pipewire-libs \
 "
RDEPENDS:pipewire-plugin-libcamera = " \
 glibc \
 libcamera \
 libdrm \
 libgcc \
 libstdc++ \
 pipewire-libs \
 "
RDEPENDS:pipewire-pulseaudio = " \
 avahi-libs \
 bash \
 dbus-libs \
 glib2 \
 glibc \
 libgcc \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:pipewire-utils = " \
 alsa-lib \
 dbus-libs \
 glibc \
 libgcc \
 libsndfile \
 ncurses-libs \
 pipewire \
 pipewire-libs \
 readline \
 "
