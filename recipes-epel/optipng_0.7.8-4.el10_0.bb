# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "optipng"
PV = "0.7.8"
PR = "4.el10_0"
PACKAGES = " \
 optipng \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/optipng-0.7.8-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "960a0ea4f7847db8750e3e07949339b85b2f2230c385fb2ab2b55bc262b57fd0"

URI_x86_64_v2_optipng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/optipng-0.7.8-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_optipng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_optipng}"
SRC_URI[x86_64_v2_optipng.sha256sum] = "97e4f9f8ebcb47b5ed1a94cffd7aa7bed90835a90c3ca0c91f7c30df2279cd80"

URI_aarch64_optipng = "${EPEL_MIRROR}/aarch64/Packages/o/optipng-0.7.8-4.el10_0.aarch64.rpm;name=aarch64_optipng;unpack=0"
SRC_URI:append = " ${URI_aarch64_optipng}"
SRC_URI[aarch64_optipng.sha256sum] = "2a993843f45b60683e373c6c34a5e659a5499e25b865ba5c098cd2fd4e6bdd2e"

RDEPENDS:optipng = " \
 glibc \
 libpng \
 zlib-ng-compat \
 "
