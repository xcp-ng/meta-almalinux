# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "svgpart"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 svgpart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/svgpart-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff3920cac56e89abbf9fbd953ed14563e440b4851b5aa890009f896a14fa213a"

URI_x86_64_v2_svgpart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/svgpart-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_svgpart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_svgpart}"
SRC_URI[x86_64_v2_svgpart.sha256sum] = "c69c43acfb2c69a3272fb23c376aad79216abaf8c1a89a4821da0a24b6ce2e37"

URI_aarch64_svgpart = "${EPEL_MIRROR}/aarch64/Packages/s/svgpart-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_svgpart;unpack=0"
SRC_URI:append = " ${URI_aarch64_svgpart}"
SRC_URI[aarch64_svgpart.sha256sum] = "3da70fca69375e7d4b2b58e942a04831992dd4580fe3629c19452727ebfa2d82"

RDEPENDS:svgpart = " \
 glibc \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kparts \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
