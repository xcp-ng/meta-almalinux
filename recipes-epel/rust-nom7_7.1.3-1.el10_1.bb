# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nom7"
PV = "7.1.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-nom7+alloc-devel \
 rust-nom7+default-devel \
 rust-nom7+docsrs-devel \
 rust-nom7+std-devel \
 rust-nom7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nom7-7.1.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c7f03bc15a2dac5c7230f38de9aa26e93473c25ff041c26d76220b4dcfe36ac"

URI_x86_64_v2_rust-nom7+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nom7+alloc-devel-7.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nom7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nom7+alloc-devel}"
SRC_URI[x86_64_v2_rust-nom7+alloc-devel.sha256sum] = "0846ce318bc610dbd62c1c251b9722baa467946823cc3b20fbae59cced739f2d"

URI_x86_64_v2_rust-nom7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nom7+default-devel-7.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nom7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nom7+default-devel}"
SRC_URI[x86_64_v2_rust-nom7+default-devel.sha256sum] = "4749c25a51f42173233be0bf5e58941b4daf6d26d49a4222efd3cac1334ef674"

URI_x86_64_v2_rust-nom7+docsrs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nom7+docsrs-devel-7.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nom7+docsrs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nom7+docsrs-devel}"
SRC_URI[x86_64_v2_rust-nom7+docsrs-devel.sha256sum] = "f0acd67681cb30ba25fb12ff3dea8550426a78e0980ed9faa07b8a0190e5816a"

URI_x86_64_v2_rust-nom7+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nom7+std-devel-7.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nom7+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nom7+std-devel}"
SRC_URI[x86_64_v2_rust-nom7+std-devel.sha256sum] = "619a3b257de98a71ce702087b48f5625b5cc0d949d612f1314b12cfacf43966b"

URI_x86_64_v2_rust-nom7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nom7-devel-7.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nom7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nom7-devel}"
SRC_URI[x86_64_v2_rust-nom7-devel.sha256sum] = "eab767dfabf0e23ee9a3ed420fa24f9ad72535f26ca0e9ae2551613be4be5ad4"

URI_aarch64_rust-nom7+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nom7+alloc-devel-7.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-nom7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nom7+alloc-devel}"
SRC_URI[aarch64_rust-nom7+alloc-devel.sha256sum] = "6cdb4602322410b2b24ba7052007a6d6e868eba66d68687678f1c94f09328bc9"

URI_aarch64_rust-nom7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nom7+default-devel-7.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-nom7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nom7+default-devel}"
SRC_URI[aarch64_rust-nom7+default-devel.sha256sum] = "8cc319bd53590c21813a55802f73b21940150398dfbdc463947061e4c39a69ac"

URI_aarch64_rust-nom7+docsrs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nom7+docsrs-devel-7.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-nom7+docsrs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nom7+docsrs-devel}"
SRC_URI[aarch64_rust-nom7+docsrs-devel.sha256sum] = "6814ec1c54ac9e40e1d72f1b1e036782092e51c15d2794657dc14948a726b1c0"

URI_aarch64_rust-nom7+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nom7+std-devel-7.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-nom7+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nom7+std-devel}"
SRC_URI[aarch64_rust-nom7+std-devel.sha256sum] = "c925cd994312192279180130d9ba71f98e50c863d9a31bb59c27591e14071598"

URI_aarch64_rust-nom7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nom7-devel-7.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-nom7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nom7-devel}"
SRC_URI[aarch64_rust-nom7-devel.sha256sum] = "2ecb275575283e186e0413da4444c7262b46b19a538b4feeaaf0e8379a6ef417"

RDEPENDS:rust-nom7+alloc-devel = " \
 cargo \
 rust-nom7-devel \
 "
RDEPENDS:rust-nom7+default-devel = " \
 cargo \
 rust-nom7+std-devel \
 rust-nom7-devel \
 "
RDEPENDS:rust-nom7+docsrs-devel = " \
 cargo \
 rust-nom7-devel \
 "
RDEPENDS:rust-nom7+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-minimal-lexical+std-devel \
 rust-nom7+alloc-devel \
 rust-nom7-devel \
 "
RDEPENDS:rust-nom7-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 rust-minimal-lexical-devel \
 "
