# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-lua"
PV = "0.5.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-lua+default-devel \
 rust-tree-sitter-lua-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-lua-0.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c1500ae3bce88132642033beb9e83f3c4809a35179dcf2abdaada6dfb5ad69e"

URI_x86_64_v2_rust-tree-sitter-lua+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-lua+default-devel-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-lua+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-lua+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-lua+default-devel.sha256sum] = "92fb1c0654f33f6aa04e9c59b261e93fb5cd7d461df06421934ced4666c21226"

URI_x86_64_v2_rust-tree-sitter-lua-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-lua-devel-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-lua-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-lua-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-lua-devel.sha256sum] = "765b389217db018be05303cbdc2ae7a3d981b3d0fba1bcae360f41fb5e4c13cc"

URI_aarch64_rust-tree-sitter-lua+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-lua+default-devel-0.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-lua+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-lua+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-lua+default-devel.sha256sum] = "663f9d2fd950888863281231dc3d9ca011c8e7f4c7df340e4281ec50954e20f0"

URI_aarch64_rust-tree-sitter-lua-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-lua-devel-0.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-lua-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-lua-devel}"
SRC_URI[aarch64_rust-tree-sitter-lua-devel.sha256sum] = "5998b4de4b12a457b8ca659f902405b5e48739fc597834415409788e854b83a3"

RDEPENDS:rust-tree-sitter-lua+default-devel = " \
 cargo \
 rust-tree-sitter-lua-devel \
 "
RDEPENDS:rust-tree-sitter-lua-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
