# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cmd2"
PV = "3.4.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-cmd2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cmd2-3.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f57f11d3409ca7ebee63133ab8b8736363791178aeba61d5f72a1aa62a950b05"

URI_x86_64_v2_python3-cmd2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cmd2-3.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cmd2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cmd2}"
SRC_URI[x86_64_v2_python3-cmd2.sha256sum] = "dd98b991a608231e8fd3b1034c6251204c28ac47e37b8dc4ba27d2453e1ba7bc"

URI_aarch64_python3-cmd2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cmd2-3.4.0-1.el10_3.noarch.rpm;name=aarch64_python3-cmd2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cmd2}"
SRC_URI[aarch64_python3-cmd2.sha256sum] = "bbc2d129f5bd1727af7b7a87e6d30398522f4f6316f83ce99dc6375c524c04af"

RDEPENDS:python3-cmd2 = " \
 python3 \
 python3-pyperclip \
 python3-rich \
 python3-rich-argparse \
 which \
 "
