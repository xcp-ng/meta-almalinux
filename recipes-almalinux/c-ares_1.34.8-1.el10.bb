# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c-ares"
PV = "1.34.8"
PR = "1.el10"
PACKAGES = " \
 c-ares \
 c-ares-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/c-ares-1.34.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7200f614a91f6a00fc899432b9aa144237f22ef65d7dd70343289ab0af2507b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/c-ares-1.34.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_c-ares;unpack=0"
SRC_URI[x86_64_v2_c-ares.sha256sum] = "891490946748c85a9d39cb4de29471d2c948e483847e078ad7f64e683a2faa78"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/c-ares-devel-1.34.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_c-ares-devel;unpack=0"
SRC_URI[x86_64_v2_c-ares-devel.sha256sum] = "3168ec8534a6443fc8a8d9d556019b185997dbc1d31050ce0cbbab4081d4b9bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/c-ares-1.34.8-1.el10.aarch64.rpm;name=aarch64_c-ares;unpack=0"
SRC_URI[aarch64_c-ares.sha256sum] = "4edc5c6f6c91f91a6f0f41ab45c203745cac6ff8e6916adafd3ca46d0ab34b58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/c-ares-devel-1.34.8-1.el10.aarch64.rpm;name=aarch64_c-ares-devel;unpack=0"
SRC_URI[aarch64_c-ares-devel.sha256sum] = "6cc517790b3eb253b5f9f92821490f42327dff4d3ededcb33298cc0da8d6befc"

RDEPENDS:c-ares = " \
 glibc \
 "
RDEPENDS:c-ares-devel = " \
 c-ares \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
