# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_sum"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_sum+default-devel \
 rust-uu_sum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_sum-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "921e2d08c42b65ca7e3acf850e1939a2824941d9655db52a8b5d4d5a29778490"

URI_x86_64_v2_rust-uu_sum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_sum+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_sum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_sum+default-devel}"
SRC_URI[x86_64_v2_rust-uu_sum+default-devel.sha256sum] = "2b957b6b8d294ad5a99d6c0f3de66aa886393e9d915988fe5a6039ef5f1d616b"

URI_x86_64_v2_rust-uu_sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_sum-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_sum-devel}"
SRC_URI[x86_64_v2_rust-uu_sum-devel.sha256sum] = "957cc6f538fddd8b4feef48140a3bdd2139a09dd49f1620d990beab3e604ef37"

URI_aarch64_rust-uu_sum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_sum+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_sum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_sum+default-devel}"
SRC_URI[aarch64_rust-uu_sum+default-devel.sha256sum] = "580bed82f595a3508511ede8720c9901c7ce8b458d02d70f8645dc5276b103da"

URI_aarch64_rust-uu_sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_sum-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_sum-devel}"
SRC_URI[aarch64_rust-uu_sum-devel.sha256sum] = "8a30671594edc79ccfd0fb2541d28d790cb3e958d160c6ac87ad9551518e16f8"

RDEPENDS:rust-uu_sum+default-devel = " \
 cargo \
 rust-uu_sum-devel \
 "
RDEPENDS:rust-uu_sum-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 "
