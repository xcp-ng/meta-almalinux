# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdialog"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kdialog \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdialog-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8de25ae560d950607a7fcfd534335783d825c4491c5a58bdd16d577c2e446868"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdialog-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdialog;unpack=0"
SRC_URI[x86_64_v2_kdialog.sha256sum] = "a0a2776e808d6a357dc91fb1f72c4b6739b0163dcc1dbc8291c955d650177307"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdialog-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdialog;unpack=0"
SRC_URI[aarch64_kdialog.sha256sum] = "adf9aa92f3b73b9975cba4d54a75628a59ba8acf8aaaae62fc856aec03fdf269"

RDEPENDS:kdialog = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libX11 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
