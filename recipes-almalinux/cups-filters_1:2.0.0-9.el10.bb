# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cups-filters"
PE = "1"
PV = "2.0.0"
PR = "9.el10"
PACKAGES = " \
 cups-filters \
 cups-filters-driverless \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cups-filters-2.0.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b305105a8f244574d377085bf731e85414d0165d4310f7eb0ebf111655a448b4"

URI_x86_64_v2_cups-filters = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-filters-2.0.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_cups-filters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-filters}"
SRC_URI[x86_64_v2_cups-filters.sha256sum] = "b5b4d76fb7acd25ae4e99f9326c688e353942a9771fcdecb48e34ed72b90cc12"

URI_x86_64_v2_cups-filters-driverless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-filters-driverless-2.0.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_cups-filters-driverless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-filters-driverless}"
SRC_URI[x86_64_v2_cups-filters-driverless.sha256sum] = "16ff05284b1e0b21b4468c6e0f4fac166322790594f563612642df978dab269a"

URI_aarch64_cups-filters = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-filters-2.0.0-9.el10.aarch64.rpm;name=aarch64_cups-filters;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-filters}"
SRC_URI[aarch64_cups-filters.sha256sum] = "01f4b191d1eff8ab0ecf6e7fd268bf2aa8d25e3158b21ca1f1bfe075ea1098c3"

URI_aarch64_cups-filters-driverless = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-filters-driverless-2.0.0-9.el10.aarch64.rpm;name=aarch64_cups-filters-driverless;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-filters-driverless}"
SRC_URI[aarch64_cups-filters-driverless.sha256sum] = "91959b79cf43d3e2c96778e1a889d2f01b292a05573e48b7e52456929ec12095"

RDEPENDS:cups-filters = " \
 bash \
 cups-filesystem \
 cups-libs \
 glibc \
 libcupsfilters \
 libppd \
 "
RDEPENDS:cups-filters-driverless = " \
 avahi \
 bash \
 cups-filesystem \
 cups-ipptool \
 cups-libs \
 glibc \
 libcupsfilters \
 libppd \
 "
