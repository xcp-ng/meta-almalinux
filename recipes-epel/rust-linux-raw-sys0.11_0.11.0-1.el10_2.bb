# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-linux-raw-sys0.11"
PV = "0.11.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-linux-raw-sys0.11+auxvec-devel \
 rust-linux-raw-sys0.11+bootparam-devel \
 rust-linux-raw-sys0.11+btrfs-devel \
 rust-linux-raw-sys0.11+default-devel \
 rust-linux-raw-sys0.11+elf-devel \
 rust-linux-raw-sys0.11+elf_uapi-devel \
 rust-linux-raw-sys0.11+errno-devel \
 rust-linux-raw-sys0.11+general-devel \
 rust-linux-raw-sys0.11+if_arp-devel \
 rust-linux-raw-sys0.11+if_ether-devel \
 rust-linux-raw-sys0.11+if_packet-devel \
 rust-linux-raw-sys0.11+image-devel \
 rust-linux-raw-sys0.11+io_uring-devel \
 rust-linux-raw-sys0.11+ioctl-devel \
 rust-linux-raw-sys0.11+landlock-devel \
 rust-linux-raw-sys0.11+loop_device-devel \
 rust-linux-raw-sys0.11+mempolicy-devel \
 rust-linux-raw-sys0.11+net-devel \
 rust-linux-raw-sys0.11+netlink-devel \
 rust-linux-raw-sys0.11+no_std-devel \
 rust-linux-raw-sys0.11+prctl-devel \
 rust-linux-raw-sys0.11+ptrace-devel \
 rust-linux-raw-sys0.11+std-devel \
 rust-linux-raw-sys0.11+system-devel \
 rust-linux-raw-sys0.11+xdp-devel \
 rust-linux-raw-sys0.11-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-linux-raw-sys0.11-0.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a00da68a0f450b5333c4a4d4a23d7e6c730faa1b0e172ef385f0d2105f20dd6"

URI_x86_64_v2_rust-linux-raw-sys0.11+auxvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+auxvec-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+auxvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+auxvec-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+auxvec-devel.sha256sum] = "1028a9b736023d7973d6de2be0dd39530dc60bfe7ed320da47e3c9bf077ae872"

URI_x86_64_v2_rust-linux-raw-sys0.11+bootparam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+bootparam-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+bootparam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+bootparam-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+bootparam-devel.sha256sum] = "b95dba0278f36fa26ef5ad5b1f28c38b53d3429c2b0e064ecbef9dc81e738baa"

URI_x86_64_v2_rust-linux-raw-sys0.11+btrfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+btrfs-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+btrfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+btrfs-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+btrfs-devel.sha256sum] = "467afdf6f206fbfa681e2fe67d25cb84f9ff88766faeee6d644da1bcd75d4cd8"

URI_x86_64_v2_rust-linux-raw-sys0.11+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+default-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+default-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+default-devel.sha256sum] = "0a1cdf31dff19e07b071575f0e65e5dc4d6f73797ce42333751ffacf5eb09ce7"

URI_x86_64_v2_rust-linux-raw-sys0.11+elf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+elf-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+elf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+elf-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+elf-devel.sha256sum] = "842f7cd69ed3811b5ca4072ebe57a934acbf65a1dc11f7bcde446b491daa0267"

URI_x86_64_v2_rust-linux-raw-sys0.11+elf_uapi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+elf_uapi-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+elf_uapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+elf_uapi-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+elf_uapi-devel.sha256sum] = "d6f7f757ac6fa3568eabd13e8a86862421b1fa35a83073205a198c73ed34706f"

URI_x86_64_v2_rust-linux-raw-sys0.11+errno-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+errno-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+errno-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+errno-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+errno-devel.sha256sum] = "1d8e296e6b03f0babee04c3c77ac443b3673f61a915691bed071cc69bbc59a28"

URI_x86_64_v2_rust-linux-raw-sys0.11+general-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+general-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+general-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+general-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+general-devel.sha256sum] = "59088557acff3899074b11afd125c9e754ec784f68a64579948b2811518e0416"

URI_x86_64_v2_rust-linux-raw-sys0.11+if_arp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+if_arp-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+if_arp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+if_arp-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+if_arp-devel.sha256sum] = "ae01705b6c09dd9198e359a12809688096de8dc12925b4479591c43be906de62"

URI_x86_64_v2_rust-linux-raw-sys0.11+if_ether-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+if_ether-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+if_ether-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+if_ether-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+if_ether-devel.sha256sum] = "cf9cb85019beda57c26928501c6cf85f56cf1c30ed5bcdfb20f7371dc6050fc5"

URI_x86_64_v2_rust-linux-raw-sys0.11+if_packet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+if_packet-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+if_packet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+if_packet-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+if_packet-devel.sha256sum] = "58cefcd531d9a4ce78620eba75c34761e97a16f9a3aa5b7663d899b9c33eb25d"

URI_x86_64_v2_rust-linux-raw-sys0.11+image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+image-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+image-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+image-devel.sha256sum] = "4599ff61f0e760991d54440fcf84580072c6c0ea6025f5ad8e941eebb49e1d06"

URI_x86_64_v2_rust-linux-raw-sys0.11+io_uring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+io_uring-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+io_uring-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+io_uring-devel.sha256sum] = "ab9bbac0ac93b690b962020fa78541b29d2f3d099ecd5d990945940c47153812"

URI_x86_64_v2_rust-linux-raw-sys0.11+ioctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+ioctl-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+ioctl-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+ioctl-devel.sha256sum] = "2375387123fc5f7e257258ae7e998c6e42fdfecc6597e76d868667dd88210ee9"

URI_x86_64_v2_rust-linux-raw-sys0.11+landlock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+landlock-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+landlock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+landlock-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+landlock-devel.sha256sum] = "91939e1d1dac7dbdbe91b0f63e759af5c33dab3366b7b7a43c935545760ea8b1"

URI_x86_64_v2_rust-linux-raw-sys0.11+loop_device-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+loop_device-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+loop_device-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+loop_device-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+loop_device-devel.sha256sum] = "729fc280bfe7196f02f1ea3bd2509c791da8f72cdd0c3cd0cdedcbbcb804a6a9"

URI_x86_64_v2_rust-linux-raw-sys0.11+mempolicy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+mempolicy-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+mempolicy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+mempolicy-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+mempolicy-devel.sha256sum] = "b63d5e47aea2814878d0cf627574bb5b73085baa1e527e3e9061a2c66e26720c"

URI_x86_64_v2_rust-linux-raw-sys0.11+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+net-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+net-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+net-devel.sha256sum] = "f7c04ae9b9c4f4164d4a5ae068aacafb2bab488b3363149faaeb52908d674ee0"

URI_x86_64_v2_rust-linux-raw-sys0.11+netlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+netlink-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+netlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+netlink-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+netlink-devel.sha256sum] = "3a5077737722adbf05aa32999ed270607cdc6406c8606469b39fb2ee61f3dba1"

URI_x86_64_v2_rust-linux-raw-sys0.11+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+no_std-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+no_std-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+no_std-devel.sha256sum] = "1b83f369144606402f7f754d125125e079ec6ea71b88b66e9c61648e674cd04d"

URI_x86_64_v2_rust-linux-raw-sys0.11+prctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+prctl-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+prctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+prctl-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+prctl-devel.sha256sum] = "7890daf5d22e5cdede1cea3a2ba0c38beb0099bc1706418275252542cc8f096f"

URI_x86_64_v2_rust-linux-raw-sys0.11+ptrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+ptrace-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+ptrace-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+ptrace-devel.sha256sum] = "251ead891f9b68673ade3673c92004326403bf798bfd26f459d88153f7e7077d"

URI_x86_64_v2_rust-linux-raw-sys0.11+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+std-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+std-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+std-devel.sha256sum] = "9556763035bba3cf121e4e237d70af39914fbfc0b1343373b3eae9f85d9f598f"

URI_x86_64_v2_rust-linux-raw-sys0.11+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+system-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+system-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+system-devel.sha256sum] = "8f4d22c9bb67a8f7bc0e92c40ccf78d4d59a673fca38da30adc29336f7184ff6"

URI_x86_64_v2_rust-linux-raw-sys0.11+xdp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11+xdp-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11+xdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11+xdp-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11+xdp-devel.sha256sum] = "91f1b18de1237af060f4dcbbd94972a25e73d4f7b75489572b8271c1900f22eb"

URI_x86_64_v2_rust-linux-raw-sys0.11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.11-devel-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.11-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.11-devel.sha256sum] = "ff4285604c2a8d309aa0c262858396b1605c12b7cede3fc2a899ed5cd39bcbae"

URI_aarch64_rust-linux-raw-sys0.11+auxvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+auxvec-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+auxvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+auxvec-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+auxvec-devel.sha256sum] = "3620a06116b7e1030f5773c44bce61c4632eb3c9176cae9e887ae595e4399201"

URI_aarch64_rust-linux-raw-sys0.11+bootparam-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+bootparam-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+bootparam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+bootparam-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+bootparam-devel.sha256sum] = "ac517c447ea3d1628f62a4c6545559f35ed322211eaef549fc0064cac515ef45"

URI_aarch64_rust-linux-raw-sys0.11+btrfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+btrfs-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+btrfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+btrfs-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+btrfs-devel.sha256sum] = "defd10ec4f4b1b02ea19c55df52f63989668a6b19cecd64c5c12a073093d2eef"

URI_aarch64_rust-linux-raw-sys0.11+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+default-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+default-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+default-devel.sha256sum] = "6d913c515cedaacb15eddcd3e01e7d559d42affe472dfabe8bce777cf5db27fb"

URI_aarch64_rust-linux-raw-sys0.11+elf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+elf-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+elf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+elf-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+elf-devel.sha256sum] = "4d612985dbd159bb513ac61978efb9a3a8aead0da5f93477886762f5d56235c5"

URI_aarch64_rust-linux-raw-sys0.11+elf_uapi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+elf_uapi-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+elf_uapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+elf_uapi-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+elf_uapi-devel.sha256sum] = "3e8733f9f3d69d2a0e30355818be2af41396b94a459e86a8f0a6d4bd33749304"

URI_aarch64_rust-linux-raw-sys0.11+errno-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+errno-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+errno-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+errno-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+errno-devel.sha256sum] = "b3ebdf7f0e9c8bfde8221f25ec6782bbd73a04aa47d95cb07244ef956b91042f"

URI_aarch64_rust-linux-raw-sys0.11+general-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+general-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+general-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+general-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+general-devel.sha256sum] = "e822d2cdbcda49bd273fb1344d8fc023b08b142ce1f0740c4c7fb0dc1a9ab2e8"

URI_aarch64_rust-linux-raw-sys0.11+if_arp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+if_arp-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+if_arp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+if_arp-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+if_arp-devel.sha256sum] = "441354aaf0a2c6086909dd391d29a5710e7b8c4c42e2fbaf57908f97cf9a7942"

URI_aarch64_rust-linux-raw-sys0.11+if_ether-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+if_ether-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+if_ether-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+if_ether-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+if_ether-devel.sha256sum] = "d392ea897f5950d0d8eda98eb35c0d929d033407f79a8d5dc031eacf0b962598"

URI_aarch64_rust-linux-raw-sys0.11+if_packet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+if_packet-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+if_packet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+if_packet-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+if_packet-devel.sha256sum] = "24e2e19913c44c948a8b0def8d66fab86e23446c6fcbecb0c8d383a1315a9988"

URI_aarch64_rust-linux-raw-sys0.11+image-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+image-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+image-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+image-devel.sha256sum] = "8d664eb8f42f28084f77eedff61104f05aef67c251a5c4f63d0c51a415f9c388"

URI_aarch64_rust-linux-raw-sys0.11+io_uring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+io_uring-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+io_uring-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+io_uring-devel.sha256sum] = "c57757a99486faa3761300cd18cfe1d0e5b4bb7f9db2b759e6a7af634d864a3d"

URI_aarch64_rust-linux-raw-sys0.11+ioctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+ioctl-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+ioctl-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+ioctl-devel.sha256sum] = "080c335639d96a5ab5d1505b2ad368e7891646f05dc7ae230e9029fc351fc7ae"

URI_aarch64_rust-linux-raw-sys0.11+landlock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+landlock-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+landlock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+landlock-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+landlock-devel.sha256sum] = "040c64d6a89c3e27795384220be6c136654d5734bd10fa245ba91e09be5ca6a3"

URI_aarch64_rust-linux-raw-sys0.11+loop_device-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+loop_device-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+loop_device-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+loop_device-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+loop_device-devel.sha256sum] = "45aa3c99f2343390081d5367d6bcc820a7d47a2fee07b44e7932c93210addce5"

URI_aarch64_rust-linux-raw-sys0.11+mempolicy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+mempolicy-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+mempolicy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+mempolicy-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+mempolicy-devel.sha256sum] = "b3bb4e1877914ac2c1029770ebfb01754937935a7731f975345135f2cd89a05d"

URI_aarch64_rust-linux-raw-sys0.11+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+net-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+net-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+net-devel.sha256sum] = "7a44b24064a3dca2b64edb05afae5350ff2de4e686afa8ef6136b8033d6e7a2d"

URI_aarch64_rust-linux-raw-sys0.11+netlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+netlink-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+netlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+netlink-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+netlink-devel.sha256sum] = "b720fa151d27ca36142a45ed856ed925a68211978840ad8864343573dc790f97"

URI_aarch64_rust-linux-raw-sys0.11+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+no_std-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+no_std-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+no_std-devel.sha256sum] = "9d4fec82d0564fe372e54ca32417f0a0cce0575c51a26ea92cf89363dcb1cd45"

URI_aarch64_rust-linux-raw-sys0.11+prctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+prctl-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+prctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+prctl-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+prctl-devel.sha256sum] = "a1d0d4ca95156b7c3ea7533ca908d0aa44e779aac32640cacdbd1b369a70d852"

URI_aarch64_rust-linux-raw-sys0.11+ptrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+ptrace-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+ptrace-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+ptrace-devel.sha256sum] = "45073805058465cf9bcf2b13c375e83417ff95c4ec8f3a5df4f8eabd6c1b071e"

URI_aarch64_rust-linux-raw-sys0.11+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+std-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+std-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+std-devel.sha256sum] = "5fe2550fbdbfd8d5551ce577aeda5e6ff4d68e265fcff0aff1dc9659456ca182"

URI_aarch64_rust-linux-raw-sys0.11+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+system-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+system-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+system-devel.sha256sum] = "85b6b4e0f491e846a6fef1b3a1c7ca4aad82fccc7ae659f8e34995417f305934"

URI_aarch64_rust-linux-raw-sys0.11+xdp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11+xdp-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11+xdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11+xdp-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11+xdp-devel.sha256sum] = "f31fd5b4bcb31fbf216935002415f4aaecc12c4ec134124081e315ba48667f2a"

URI_aarch64_rust-linux-raw-sys0.11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.11-devel-0.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys0.11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.11-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.11-devel.sha256sum] = "b812e6d642e86770542da25e1db8c488d3aa4208af663a6d821ec7e93e2a892a"

RDEPENDS:rust-linux-raw-sys0.11+auxvec-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+bootparam-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+btrfs-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+default-devel = " \
 cargo \
 rust-linux-raw-sys0.11+errno-devel \
 rust-linux-raw-sys0.11+general-devel \
 rust-linux-raw-sys0.11+std-devel \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+elf-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+elf_uapi-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+errno-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+general-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+if_arp-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+if_ether-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+if_packet-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+image-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+io_uring-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+ioctl-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+landlock-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+loop_device-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+mempolicy-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+net-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+netlink-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+no_std-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+prctl-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+ptrace-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+std-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+system-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11+xdp-devel = " \
 cargo \
 rust-linux-raw-sys0.11-devel \
 "
RDEPENDS:rust-linux-raw-sys0.11-devel = " \
 cargo \
 rust \
 "
