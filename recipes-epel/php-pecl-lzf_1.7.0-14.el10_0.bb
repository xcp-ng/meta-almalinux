# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-lzf"
PV = "1.7.0"
PR = "14.el10_0"
PACKAGES = " \
 php-pecl-lzf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-lzf-1.7.0-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63ccbebfa2160ae30290312f5aebb549e8517aa2d2743ad90d130197e0acfe48"

URI_x86_64_v2_php-pecl-lzf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-lzf-1.7.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-lzf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-lzf}"
SRC_URI[x86_64_v2_php-pecl-lzf.sha256sum] = "a01cf14826c986ceff0fd6dfc01a23885c067ca4fd97b98bfa682041730ffc59"

URI_aarch64_php-pecl-lzf = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-lzf-1.7.0-14.el10_0.aarch64.rpm;name=aarch64_php-pecl-lzf;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-lzf}"
SRC_URI[aarch64_php-pecl-lzf.sha256sum] = "5af5951cf2ec75175ae6097d8b60b2c79f6462cceff0c93e5db8888fa38affde"

RDEPENDS:php-pecl-lzf = " \
 glibc \
 liblzf \
 php-common \
 "
