# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kjobwidgets"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kjobwidgets \
 kf6-kjobwidgets-devel \
 kf6-kjobwidgets-doc \
 kf6-kjobwidgets-html \
 python3-kf6-kjobwidgets \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kjobwidgets-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dca3b8b11e7872771df0fb2e83d00bf8306e52fb527df1ed969a67be7f518e0e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kjobwidgets;unpack=0"
SRC_URI[x86_64_v2_kf6-kjobwidgets.sha256sum] = "30c914fa15158de554780f49ac10666d5989203e5cf0bcd0e15a9e47d213f7e3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kjobwidgets-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kjobwidgets-devel.sha256sum] = "159be2e72e8ee5f96a2dd463d0aba4eca1628462fe7bc375c528a6eab89c8e89"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kjobwidgets-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kjobwidgets-doc.sha256sum] = "5cd89ca4dfdd091cc876dfd9e9c3358f3a96f8303a6b357fac0821aae66b9c19"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kjobwidgets-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kjobwidgets-html.sha256sum] = "7737fa2e244b33f7eb7df6d6cfe4a8870ed005fb850745bfb8e98da9ad4c9ec5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kjobwidgets-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kjobwidgets;unpack=0"
SRC_URI[x86_64_v2_python3-kf6-kjobwidgets.sha256sum] = "fb82436c57f3307615be8b0e6fb56e901afd38a4ec75e8de8163418a84c540fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kjobwidgets;unpack=0"
SRC_URI[aarch64_kf6-kjobwidgets.sha256sum] = "c4ddf045c18f7882d5d540f3dfeb39abcc60aace77864295ca1fcc840ff67e30"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kjobwidgets-devel;unpack=0"
SRC_URI[aarch64_kf6-kjobwidgets-devel.sha256sum] = "8a78560168f8bfc7b2b125179734eab8b4e3e5697fe4d71975379544fbb708df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kjobwidgets-doc;unpack=0"
SRC_URI[aarch64_kf6-kjobwidgets-doc.sha256sum] = "7b1d26eff59cccc0f6c3138520fddeab4d088e88b0a9d140cb90d68cbbce9003"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kjobwidgets-html;unpack=0"
SRC_URI[aarch64_kf6-kjobwidgets-html.sha256sum] = "951bc7b07ec7467a8e325ccc77259151c3c84b55327055524544fd09bdb82369"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kjobwidgets-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kjobwidgets;unpack=0"
SRC_URI[aarch64_python3-kf6-kjobwidgets.sha256sum] = "3fbabfc24c292f6f045f478c31013fd1c2f536d8427ad84b763c289fd8452fb1"

RDEPENDS:kf6-kjobwidgets = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kjobwidgets-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kjobwidgets \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kjobwidgets-doc = " \
 "
RDEPENDS:kf6-kjobwidgets-html = " \
 "
RDEPENDS:python3-kf6-kjobwidgets = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kjobwidgets \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 "
