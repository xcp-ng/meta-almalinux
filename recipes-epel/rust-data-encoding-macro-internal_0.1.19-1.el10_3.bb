# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-data-encoding-macro-internal"
PV = "0.1.19"
PR = "1.el10_3"
PACKAGES = " \
 rust-data-encoding-macro-internal+default-devel \
 rust-data-encoding-macro-internal-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-data-encoding-macro-internal-0.1.19-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "706e581669261382f44376fb854f139e4788c13daac3a61aff4720e7161ccb24"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding-macro-internal+default-devel-0.1.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding-macro-internal+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-data-encoding-macro-internal+default-devel.sha256sum] = "9378c1f800d72d6d7662beefb122408255162992898af3381561850c5654ad02"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding-macro-internal-devel-0.1.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding-macro-internal-devel;unpack=0"
SRC_URI[x86_64_v2_rust-data-encoding-macro-internal-devel.sha256sum] = "9858ed58a407962237b251dd7575ba9ee4471d5b0d9852cb82d77b37d2934656"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding-macro-internal+default-devel-0.1.19-1.el10_3.noarch.rpm;name=aarch64_rust-data-encoding-macro-internal+default-devel;unpack=0"
SRC_URI[aarch64_rust-data-encoding-macro-internal+default-devel.sha256sum] = "075fbb27fa6847588b84a2de08f2e13d3305969cdd86e0b167a30ad0ea0a48b3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding-macro-internal-devel-0.1.19-1.el10_3.noarch.rpm;name=aarch64_rust-data-encoding-macro-internal-devel;unpack=0"
SRC_URI[aarch64_rust-data-encoding-macro-internal-devel.sha256sum] = "d30cd08e753cb2942a82a311e19500a4e817649a6eed784c1b84747ec9bfd674"

RDEPENDS:rust-data-encoding-macro-internal+default-devel = " \
 cargo \
 rust-data-encoding-macro-internal-devel \
 "
RDEPENDS:rust-data-encoding-macro-internal-devel = " \
 cargo \
 rust \
 rust-data-encoding+alloc-devel \
 rust-data-encoding-devel \
 virtual/crate_syn/parsing__ge_1.0.0_with_crate_syn/parsing__lt_4.0.0~ \
 virtual/crate_syn/proc-macro__ge_1.0.0_with_crate_syn/proc-macro__lt_4.0.0~ \
 virtual/crate_syn__ge_1.0.0_with_crate_syn__lt_4.0.0~ \
 "
