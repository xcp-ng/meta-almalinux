# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "todocli"
PV = "0.1"
PR = "37.20171025gitab9bbbd.el10_2"
PACKAGES = " \
 todocli \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/todocli-0.1-37.20171025gitab9bbbd.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6f56ee6c70c1a89120508f8772a84e051ea91cd3d02c344cd2843405d72f6fec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/todocli-0.1-37.20171025gitab9bbbd.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_todocli;unpack=0"
SRC_URI[x86_64_v2_todocli.sha256sum] = "08eb3ddf3e1141c8d90d849741f2f1f213867a053518988f26cb10ba643d49b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/todocli-0.1-37.20171025gitab9bbbd.el10_2.noarch.rpm;name=aarch64_todocli;unpack=0"
SRC_URI[aarch64_todocli.sha256sum] = "0653c17e063ea8954422f135a309976528f0100232ddfe4ce38f0513dfa85914"

RDEPENDS:todocli = " \
 python3 \
 "
