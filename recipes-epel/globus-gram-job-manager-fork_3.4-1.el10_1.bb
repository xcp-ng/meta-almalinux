# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager-fork"
PV = "3.4"
PR = "1.el10_1"
PACKAGES = " \
 globus-gram-job-manager-fork \
 globus-gram-job-manager-fork-setup-poll \
 globus-gram-job-manager-fork-setup-seg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-fork-3.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7063bc9964c42cdf5651995d2eafd106c204b77abe83c66410e2bba1ab92684"

URI_x86_64_v2_globus-gram-job-manager-fork = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-fork-3.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-fork;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-fork}"
SRC_URI[x86_64_v2_globus-gram-job-manager-fork.sha256sum] = "dfd2bb7ee082dc0e5505f1cda10f5d19e9fecfabca57000eb393cf5689cdd1d9"

URI_x86_64_v2_globus-gram-job-manager-fork-setup-poll = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-fork-setup-poll-3.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-job-manager-fork-setup-poll;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-fork-setup-poll}"
SRC_URI[x86_64_v2_globus-gram-job-manager-fork-setup-poll.sha256sum] = "0a2b3b1c508ca32233119fbfa4fe4c3a788df9b0572d1256423ee6e79f051a6a"
RPROVIDES:globus-gram-job-manager-fork-setup-poll:x86_64_v2 = "virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_1.alma_altarch"

URI_x86_64_v2_globus-gram-job-manager-fork-setup-seg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-fork-setup-seg-3.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-fork-setup-seg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-fork-setup-seg}"
SRC_URI[x86_64_v2_globus-gram-job-manager-fork-setup-seg.sha256sum] = "0d59184d83feb96ac8f901a09a809098a8a92afbd0fc2a753000c18e5dd57c94"
RPROVIDES:globus-gram-job-manager-fork-setup-seg:x86_64_v2 = "virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_1.alma_altarch"

URI_aarch64_globus-gram-job-manager-fork = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-fork-3.4-1.el10_1.aarch64.rpm;name=aarch64_globus-gram-job-manager-fork;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-fork}"
SRC_URI[aarch64_globus-gram-job-manager-fork.sha256sum] = "83835f812bb1d82ba0bd63993ea66c0bec11dbefdb8bd473962e8db6cccb9d33"

URI_aarch64_globus-gram-job-manager-fork-setup-poll = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-fork-setup-poll-3.4-1.el10_1.noarch.rpm;name=aarch64_globus-gram-job-manager-fork-setup-poll;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-fork-setup-poll}"
SRC_URI[aarch64_globus-gram-job-manager-fork-setup-poll.sha256sum] = "caa280379d1ef8a7c0c18defb8dfb0b49b9fa0fcb845e59d3c2fa00596dd9fff"
RPROVIDES:globus-gram-job-manager-fork-setup-poll:aarch64 = "virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_1"

URI_aarch64_globus-gram-job-manager-fork-setup-seg = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-fork-setup-seg-3.4-1.el10_1.aarch64.rpm;name=aarch64_globus-gram-job-manager-fork-setup-seg;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-fork-setup-seg}"
SRC_URI[aarch64_globus-gram-job-manager-fork-setup-seg.sha256sum] = "6e98d5b0855f38234ebc5e8e667fac644d1f77108cd8c251defb92190a15d1cc"
RPROVIDES:globus-gram-job-manager-fork-setup-seg:aarch64 = "virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_1"

RDEPENDS:globus-gram-job-manager-fork:x86_64_v2 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_1.alma_altarch \
"
RDEPENDS:globus-gram-job-manager-fork:aarch64 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_1 \
"
RDEPENDS:globus-gram-job-manager-fork-setup-poll = " \
 bash \
 globus-gram-job-manager-fork \
 globus-gram-job-manager-scripts \
 "
RDEPENDS:globus-gram-job-manager-fork-setup-seg = " \
 bash \
 glibc \
 globus-common \
 globus-gram-job-manager-fork \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 globus-scheduler-event-generator \
 globus-scheduler-event-generator-progs \
 globus-xio \
 systemd \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_1.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_1"
