# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmodtool"
PV = "1.2.1"
PR = "1.el10_2"
PACKAGES = " \
 kmodtool \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmodtool-1.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "725c25e52ea45984278796177c19323f739851dc7ea7b09575fd55c51fbf284e"

URI_x86_64_v2_kmodtool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmodtool-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kmodtool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmodtool}"
SRC_URI[x86_64_v2_kmodtool.sha256sum] = "5c522b62aa852203a1ac123596d282e6b78f48a20a806ba04a95a2a7cc53afe9"

URI_aarch64_kmodtool = "${EPEL_MIRROR}/aarch64/Packages/k/kmodtool-1.2.1-1.el10_2.noarch.rpm;name=aarch64_kmodtool;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmodtool}"
SRC_URI[aarch64_kmodtool.sha256sum] = "99c14bec104a3515ac2f83c56ca2e3d8b1bacf0ca3c77ab34f9e2aa33c22ebd2"

RDEPENDS:kmodtool = " \
 bash \
 "
