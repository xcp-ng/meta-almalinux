# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "seabios"
PV = "1.17.0"
PR = "1.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 seabios \
 seabios-bin \
 seavgabios-bin \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/seabios-1.17.0-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46501b486222f9d9ab4841f968c477170226fcc2cdd10d8cacc541f043e9851e"

URI_x86_64_v2_seabios = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/seabios-1.17.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_seabios;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_seabios}"
SRC_URI[x86_64_v2_seabios.sha256sum] = "e79b76c1cb75994d091f17cbfc5b1d8e07737799ef694d0385bcf61e04828ae4"

URI_x86_64_v2_seabios-bin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/seabios-bin-1.17.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_seabios-bin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_seabios-bin}"
SRC_URI[x86_64_v2_seabios-bin.sha256sum] = "27df43c68fd0cbc5f17783be0eac80844228e24e516e413d714ab06aa63dffed"

URI_x86_64_v2_seavgabios-bin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/seavgabios-bin-1.17.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_seavgabios-bin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_seavgabios-bin}"
SRC_URI[x86_64_v2_seavgabios-bin.sha256sum] = "ce8085491b94ec3b0861cded2afcf3c66fc628081b56a817510f210d8fb23ac7"

RDEPENDS:seabios = " \
 seabios-bin \
 seavgabios-bin \
 "
RDEPENDS:seabios-bin = " \
 "
RDEPENDS:seavgabios-bin = " \
 "
