# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cc"
PV = "1.2.34"
PR = "1.el10_0"
PACKAGES = " \
 rust-cc+default-devel \
 rust-cc+jobserver-devel \
 rust-cc+parallel-devel \
 rust-cc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cc-1.2.34-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec7f1b7c16a0da245154c0af37d31d5ba1d1b158464de7040dda3e9bcb9f3cc1"

URI_x86_64_v2_rust-cc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc+default-devel-1.2.34-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc+default-devel}"
SRC_URI[x86_64_v2_rust-cc+default-devel.sha256sum] = "3589394216a10a1b1a46daf73a201375ca7dc9e536cf33042443532e7ec14104"

URI_x86_64_v2_rust-cc+jobserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc+jobserver-devel-1.2.34-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc+jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc+jobserver-devel}"
SRC_URI[x86_64_v2_rust-cc+jobserver-devel.sha256sum] = "beaaa109781948f62b70adef9ca68d9836a06cd677cb18f568ca88039659de9c"

URI_x86_64_v2_rust-cc+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc+parallel-devel-1.2.34-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc+parallel-devel}"
SRC_URI[x86_64_v2_rust-cc+parallel-devel.sha256sum] = "39e96ee2762cbce1ae9221469a3026b31d79cef208223c7824c3a16b7eb2f555"

URI_x86_64_v2_rust-cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc-devel-1.2.34-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc-devel}"
SRC_URI[x86_64_v2_rust-cc-devel.sha256sum] = "3e86fe82b6a59ef8820985284960b97ec283fdbac394dd49a07234ec26f3f6dc"

URI_aarch64_rust-cc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc+default-devel-1.2.34-1.el10_0.noarch.rpm;name=aarch64_rust-cc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc+default-devel}"
SRC_URI[aarch64_rust-cc+default-devel.sha256sum] = "2e0415209f652037fc701be76be621fefad343ae5d482851580693b8e5f9bd24"

URI_aarch64_rust-cc+jobserver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc+jobserver-devel-1.2.34-1.el10_0.noarch.rpm;name=aarch64_rust-cc+jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc+jobserver-devel}"
SRC_URI[aarch64_rust-cc+jobserver-devel.sha256sum] = "8c09159ed29fe93165eef333cfb4ed977a31520387bbf3f68999098b893770fd"

URI_aarch64_rust-cc+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc+parallel-devel-1.2.34-1.el10_0.noarch.rpm;name=aarch64_rust-cc+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc+parallel-devel}"
SRC_URI[aarch64_rust-cc+parallel-devel.sha256sum] = "7e94019f568316e901481ee947fb2fa872f2c110e1e788dd89b850e3d1449f4c"

URI_aarch64_rust-cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc-devel-1.2.34-1.el10_0.noarch.rpm;name=aarch64_rust-cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc-devel}"
SRC_URI[aarch64_rust-cc-devel.sha256sum] = "a725b63eb5c1a4c6413190f6de5e2e5c6ff9fbd33e96ac6913effbe116f4ca8a"

RDEPENDS:rust-cc+default-devel = " \
 cargo \
 rust-cc-devel \
 "
RDEPENDS:rust-cc+jobserver-devel = " \
 cargo \
 rust-cc-devel \
 "
RDEPENDS:rust-cc+parallel-devel = " \
 cargo \
 rust-cc-devel \
 rust-jobserver-devel \
 rust-libc-devel \
 "
RDEPENDS:rust-cc-devel = " \
 cargo \
 gcc \
 gcc-c++ \
 rust \
 rust-shlex+default-devel \
 "
