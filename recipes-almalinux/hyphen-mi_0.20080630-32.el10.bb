# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-mi"
PV = "0.20080630"
PR = "32.el10"
PACKAGES = " \
 hyphen-mi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-mi-0.20080630-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19f87f238171449bf161858f731771b002b3c2d4afdb2b70b9355677e11c4827"

URI_x86_64_v2_hyphen-mi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-mi-0.20080630-32.el10.noarch.rpm;name=x86_64_v2_hyphen-mi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-mi}"
SRC_URI[x86_64_v2_hyphen-mi.sha256sum] = "91dff29e427d2859d59e1e59e63f0cc56aee2c1d7bf581b66e069172cd4b3f1d"

URI_aarch64_hyphen-mi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-mi-0.20080630-32.el10.noarch.rpm;name=aarch64_hyphen-mi;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-mi}"
SRC_URI[aarch64_hyphen-mi.sha256sum] = "91dff29e427d2859d59e1e59e63f0cc56aee2c1d7bf581b66e069172cd4b3f1d"

RDEPENDS:hyphen-mi = " \
 hyphen \
 "
