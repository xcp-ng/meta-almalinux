# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mattn-shellwords"
PV = "1.0.12"
PR = "11.el10_0"
PACKAGES = " \
 golang-github-mattn-shellwords-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-mattn-shellwords-1.0.12-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3a0f88985050e296f5711ffc6a883d079af859d5fabe7d6a1f477c097b679e5"

URI_x86_64_v2_golang-github-mattn-shellwords-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-mattn-shellwords-devel-1.0.12-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-mattn-shellwords-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-mattn-shellwords-devel}"
SRC_URI[x86_64_v2_golang-github-mattn-shellwords-devel.sha256sum] = "76708794334169fa5d741eddb79c93c8bc5dfabf1dc1d6566bdd4b6b270c9e76"

URI_aarch64_golang-github-mattn-shellwords-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mattn-shellwords-devel-1.0.12-11.el10_0.noarch.rpm;name=aarch64_golang-github-mattn-shellwords-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mattn-shellwords-devel}"
SRC_URI[aarch64_golang-github-mattn-shellwords-devel.sha256sum] = "51f272163840a1292876f88ebafba51f43857ecc95c36067e1154ed70e5f7587"

RDEPENDS:golang-github-mattn-shellwords-devel = " \
 go-filesystem \
 "
