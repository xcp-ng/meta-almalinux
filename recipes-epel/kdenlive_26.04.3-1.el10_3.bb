# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdenlive"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdenlive \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdenlive-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea4329bacf837350727c31ed51f41b545c020e8dbf33a0e682d0fb7abadc7a00"

URI_x86_64_v2_kdenlive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdenlive-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdenlive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdenlive}"
SRC_URI[x86_64_v2_kdenlive.sha256sum] = "14542a41519572642d7720b47bba468e685dc24023da86429535e22b6bd851ba"

URI_aarch64_kdenlive = "${EPEL_MIRROR}/aarch64/Packages/k/kdenlive-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdenlive;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdenlive}"
SRC_URI[aarch64_kdenlive.sha256sum] = "392516cc84d377105f2dd56a22a44f3e9934678f51b2ef97348eedbad6f0892d"

RDEPENDS:kdenlive = " \
 OpenTimelineIO \
 dvdauthor \
 ffmpeg-free \
 frei0r-plugins \
 glibc \
 kddockwidgets-qt6 \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kitemviews \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 kf6-qqc2-desktop-style \
 kf6-solid \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libstdc++ \
 libswresample-free \
 mlt \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qt6-qtnetworkauth \
 qt6-qtsvg \
 "
