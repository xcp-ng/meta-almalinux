# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerovec-derive"
PV = "0.11.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-zerovec-derive+default-devel \
 rust-zerovec-derive-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-zerovec-derive-0.11.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8d7923dcb9ccb05b69e60a5cb7a982539713790c2681059d6aa9060d4fbea23a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec-derive+default-devel-0.11.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec-derive+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerovec-derive+default-devel.sha256sum] = "72a14e7d4ed5f2f6e5c27800c92cc37e1864c198c45b9d92b67dd8aaebcbc3b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec-derive-devel-0.11.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec-derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerovec-derive-devel.sha256sum] = "7ab12a591dba018ce7909b6747a882149273e46e14e06e6c9a5d22bccae19914"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec-derive+default-devel-0.11.6-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec-derive+default-devel;unpack=0"
SRC_URI[aarch64_rust-zerovec-derive+default-devel.sha256sum] = "351c1d3b7538d75a62cf2491c8eae15499932e7e8a59e1543cbe3e12de0293c4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec-derive-devel-0.11.6-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec-derive-devel;unpack=0"
SRC_URI[aarch64_rust-zerovec-derive-devel.sha256sum] = "1724c8c9ed22fbce757622dd9a4cfe7d050126e557eae7a93b00b1e59ecf463f"

RDEPENDS:rust-zerovec-derive+default-devel = " \
 cargo \
 rust-zerovec-derive-devel \
 "
RDEPENDS:rust-zerovec-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 "
