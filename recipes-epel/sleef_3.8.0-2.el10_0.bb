# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sleef"
PV = "3.8.0"
PR = "2.el10_0"
PACKAGES = " \
 sleef \
 sleef-devel \
 sleef-dft \
 sleef-dft-devel \
 sleef-doc \
 sleef-gnuabi \
 sleef-gnuabi-devel \
 sleef-quad \
 sleef-quad-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sleef-3.8.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eec95b85b8ff191289890d5b07475dc3c4d86b1459e83e381350a32fa0de8cb7"

URI_x86_64_v2_sleef = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-3.8.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef}"
SRC_URI[x86_64_v2_sleef.sha256sum] = "1a1b1e723ce14f80bb2a0cee47073e928ea28fe2818220a555e2b013d0aa504e"

URI_x86_64_v2_sleef-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-devel-3.8.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-devel}"
SRC_URI[x86_64_v2_sleef-devel.sha256sum] = "db4189d024a6caceb837ec1eefd8a74bc66a0482a779e9aed2466e050945e809"

URI_x86_64_v2_sleef-dft = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-dft-3.8.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef-dft;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-dft}"
SRC_URI[x86_64_v2_sleef-dft.sha256sum] = "877acf1c2d842fd2618cc3809df6aeda52248e858dcdbffcf248634d054da108"

URI_x86_64_v2_sleef-dft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-dft-devel-3.8.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef-dft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-dft-devel}"
SRC_URI[x86_64_v2_sleef-dft-devel.sha256sum] = "c7ed0947272c8f758befbae11b79b4056049f356bd470ea99affb1e1c33a2003"

URI_x86_64_v2_sleef-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-doc-3.8.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_sleef-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-doc}"
SRC_URI[x86_64_v2_sleef-doc.sha256sum] = "e26ddbfd30cf3801219b50ad23a1ebf979d273a7ac5a78904779b44b2e3d8050"

URI_x86_64_v2_sleef-gnuabi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-gnuabi-3.8.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef-gnuabi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-gnuabi}"
SRC_URI[x86_64_v2_sleef-gnuabi.sha256sum] = "d0380d12d94607f3a9523f48547903774bd4d220099104a0cdbdde5836ff44b6"

URI_x86_64_v2_sleef-gnuabi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-gnuabi-devel-3.8.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef-gnuabi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-gnuabi-devel}"
SRC_URI[x86_64_v2_sleef-gnuabi-devel.sha256sum] = "59f874c555120c56176aafb66d2cd784f442976216057523a5a76c00883e2c9b"

URI_x86_64_v2_sleef-quad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-quad-3.8.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef-quad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-quad}"
SRC_URI[x86_64_v2_sleef-quad.sha256sum] = "8ddd638352217f24778a6b320d08cb8aa007e22b06f7a27242fdbdd2906c1e0e"

URI_x86_64_v2_sleef-quad-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-quad-devel-3.8.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef-quad-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-quad-devel}"
SRC_URI[x86_64_v2_sleef-quad-devel.sha256sum] = "8d8851020133066ddd524183462487d2613f26821a8fb13f33c8c5d18ac5dd58"

URI_aarch64_sleef = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-3.8.0-2.el10_0.aarch64.rpm;name=aarch64_sleef;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef}"
SRC_URI[aarch64_sleef.sha256sum] = "6bd1f72e4064a343e33cde1ef431ac1ac812058820e1eb287fe0b6d072605d09"

URI_aarch64_sleef-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-devel-3.8.0-2.el10_0.aarch64.rpm;name=aarch64_sleef-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-devel}"
SRC_URI[aarch64_sleef-devel.sha256sum] = "77976d5dab7565c498d2d541171fec14c7e26cd3f1260dbe741d0d234ece8945"

URI_aarch64_sleef-dft = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-dft-3.8.0-2.el10_0.aarch64.rpm;name=aarch64_sleef-dft;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-dft}"
SRC_URI[aarch64_sleef-dft.sha256sum] = "651fdce03d933e225d5695f767e568847fe82248ea8085e2c6f5a190ebcb1712"

URI_aarch64_sleef-dft-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-dft-devel-3.8.0-2.el10_0.aarch64.rpm;name=aarch64_sleef-dft-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-dft-devel}"
SRC_URI[aarch64_sleef-dft-devel.sha256sum] = "14b46301e801a883cb3af20c657a8f05fb70408a1615b39359bb833edc2d1f36"

URI_aarch64_sleef-doc = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-doc-3.8.0-2.el10_0.noarch.rpm;name=aarch64_sleef-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-doc}"
SRC_URI[aarch64_sleef-doc.sha256sum] = "344b70f875b320bba638a7516d607f261bd719271b5aa76efb45b98953f07998"

URI_aarch64_sleef-gnuabi = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-gnuabi-3.8.0-2.el10_0.aarch64.rpm;name=aarch64_sleef-gnuabi;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-gnuabi}"
SRC_URI[aarch64_sleef-gnuabi.sha256sum] = "84cb79f1092e66adb58605c81c1b70fae4ddcb2457ba285987eae64fb6e65ca3"

URI_aarch64_sleef-gnuabi-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-gnuabi-devel-3.8.0-2.el10_0.aarch64.rpm;name=aarch64_sleef-gnuabi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-gnuabi-devel}"
SRC_URI[aarch64_sleef-gnuabi-devel.sha256sum] = "fd7c03afa85705494bc9c7310f3f10f1292a802d7315cd538dce8ca4eae694cf"

URI_aarch64_sleef-quad = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-quad-3.8.0-2.el10_0.aarch64.rpm;name=aarch64_sleef-quad;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-quad}"
SRC_URI[aarch64_sleef-quad.sha256sum] = "de0db07103b1595f98d13bc9fd6a769e3f1cd887813934deefa6984d3f237690"

URI_aarch64_sleef-quad-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-quad-devel-3.8.0-2.el10_0.aarch64.rpm;name=aarch64_sleef-quad-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-quad-devel}"
SRC_URI[aarch64_sleef-quad-devel.sha256sum] = "dc03a03c804241b6ababff5294d91a53b244b0ff401cc3f05e0823dfdef477c6"

RDEPENDS:sleef = " \
 glibc \
 "
RDEPENDS:sleef-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 sleef \
 "
RDEPENDS:sleef-dft = " \
 glibc \
 libgcc \
 libgomp \
 sleef \
 "
RDEPENDS:sleef-dft-devel = " \
 sleef-dft \
 "
RDEPENDS:sleef-doc = " \
 "
RDEPENDS:sleef-gnuabi = " \
 glibc \
 "
RDEPENDS:sleef-gnuabi-devel = " \
 sleef-gnuabi \
 "
RDEPENDS:sleef-quad = " \
 glibc \
 "
RDEPENDS:sleef-quad-devel = " \
 sleef-quad \
 "
