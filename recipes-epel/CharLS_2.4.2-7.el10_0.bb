# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "CharLS"
PV = "2.4.2"
PR = "7.el10_0"
PACKAGES = " \
 CharLS \
 CharLS-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/CharLS-2.4.2-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e308d0434a1b0e70e3ec7edc7c242a6718a1110c70279d8843771c61f1b62ecb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CharLS-2.4.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CharLS;unpack=0"
SRC_URI[x86_64_v2_CharLS.sha256sum] = "b7ae1e41544cd2b390612a2b637670de44690be256ecc474e7f45984bc6f0f88"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CharLS-devel-2.4.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CharLS-devel;unpack=0"
SRC_URI[x86_64_v2_CharLS-devel.sha256sum] = "f56af9d09fbc8ff858930b251856e1792319e79b45be4c5b79954904a9b47f31"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/CharLS-2.4.2-7.el10_0.aarch64.rpm;name=aarch64_CharLS;unpack=0"
SRC_URI[aarch64_CharLS.sha256sum] = "7eb770831a8bc5852a64337545847471848a760fe4715c3c405cc245cb928918"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/CharLS-devel-2.4.2-7.el10_0.aarch64.rpm;name=aarch64_CharLS-devel;unpack=0"
SRC_URI[aarch64_CharLS-devel.sha256sum] = "eb06d8c880f8e3ecc868ee3e973784106787494e6de4b5408d874d44dfcee031"

RDEPENDS:CharLS = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:CharLS-devel = " \
 CharLS \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
