# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXmu"
PV = "1.1.4"
PR = "8.el10"
PACKAGES = " \
 libXmu \
 libXmu-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libXmu-1.1.4-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82ada8036269a1b157c748997c59043651d87ef02bd2c2cb88a7c8105ff96be9"

URI_x86_64_v2_libXmu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXmu-1.1.4-8.el10.x86_64_v2.rpm;name=x86_64_v2_libXmu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXmu}"
SRC_URI[x86_64_v2_libXmu.sha256sum] = "2429ce9ce0979add7ceeba6664353a42632cae1a64fe64979fd6737126306394"

URI_x86_64_v2_libXmu-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXmu-devel-1.1.4-8.el10.x86_64_v2.rpm;name=x86_64_v2_libXmu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXmu-devel}"
SRC_URI[x86_64_v2_libXmu-devel.sha256sum] = "f5a3f2f2970d134979f94f7f2308ee56d89bc3016f7965c02da204840f457a0b"

URI_aarch64_libXmu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXmu-1.1.4-8.el10.aarch64.rpm;name=aarch64_libXmu;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXmu}"
SRC_URI[aarch64_libXmu.sha256sum] = "b77ed7272d68aa52e725e76f7a1d90b07b83c6dea086e3aaedd36db45cd3d1e8"

URI_aarch64_libXmu-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXmu-devel-1.1.4-8.el10.aarch64.rpm;name=aarch64_libXmu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXmu-devel}"
SRC_URI[aarch64_libXmu-devel.sha256sum] = "c97789438250bb99f77d89976a94adbbe585e56691271c6499401489c2af9c65"

RDEPENDS:libXmu = " \
 glibc \
 libX11 \
 libXext \
 libXt \
 "
RDEPENDS:libXmu-devel = " \
 libX11-devel \
 libXext-devel \
 libXmu \
 libXt-devel \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
