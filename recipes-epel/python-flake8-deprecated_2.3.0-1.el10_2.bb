# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flake8-deprecated"
PV = "2.3.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-flake8-deprecated \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-flake8-deprecated-2.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "479eb095a644ede4f2ba42ddf6097baca2ef7c117ec3b9f8d09ec8bd295d5f61"

URI_x86_64_v2_python3-flake8-deprecated = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flake8-deprecated-2.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flake8-deprecated;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flake8-deprecated}"
SRC_URI[x86_64_v2_python3-flake8-deprecated.sha256sum] = "9110ee5219b2aeca86e394c62199e5cdee53f710b35085596ac5c0e1f9bf8201"

URI_aarch64_python3-flake8-deprecated = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flake8-deprecated-2.3.0-1.el10_2.noarch.rpm;name=aarch64_python3-flake8-deprecated;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flake8-deprecated}"
SRC_URI[aarch64_python3-flake8-deprecated.sha256sum] = "42b5ad6633114bd89ca1448c7124743b61cd7f667f97adcf6d958ec69936454e"

RDEPENDS:python3-flake8-deprecated = " \
 python3 \
 python3-flake8 \
 "
