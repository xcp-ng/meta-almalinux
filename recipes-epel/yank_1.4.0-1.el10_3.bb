# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yank"
PV = "1.4.0"
PR = "1.el10_3"
PACKAGES = " \
 yank \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yank-1.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d425da091d7a303128143b684d524004e170e47d2750170f6412503d87773b9"

URI_x86_64_v2_yank = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yank-1.4.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yank;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yank}"
SRC_URI[x86_64_v2_yank.sha256sum] = "f83c7a2030413525108cd3b5e761cf5542d302dfaf4a42e936f2f58f624b08ab"

URI_aarch64_yank = "${EPEL_MIRROR}/aarch64/Packages/y/yank-1.4.0-1.el10_3.aarch64.rpm;name=aarch64_yank;unpack=0"
SRC_URI:append = " ${URI_aarch64_yank}"
SRC_URI[aarch64_yank.sha256sum] = "5b3ee205c8d6a61c043f329c1048ac9e97b76bdd83117d057ee578da38f1cea9"

RDEPENDS:yank = " \
 bash \
 glibc \
 "
