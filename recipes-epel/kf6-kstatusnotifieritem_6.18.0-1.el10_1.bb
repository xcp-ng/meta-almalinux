# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kstatusnotifieritem"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kstatusnotifieritem \
 kf6-kstatusnotifieritem-devel \
 kf6-kstatusnotifieritem-doc \
 kf6-kstatusnotifieritem-html \
 python3-kf6-kstatusnotifieritem \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kstatusnotifieritem-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a31d234f0d897ab8402328fd9f03a1dab5d3e0566baed75bcfe5997b93d55ad0"

URI_x86_64_v2_kf6-kstatusnotifieritem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kstatusnotifieritem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kstatusnotifieritem}"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem.sha256sum] = "faf5f24bbacb257d4198329db4dd4420cb6f203ae783e6a41bc5fcd436907ef4"

URI_x86_64_v2_kf6-kstatusnotifieritem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kstatusnotifieritem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kstatusnotifieritem-devel}"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem-devel.sha256sum] = "a01ac84eeb5e9f9f16222034c099f4eef7b9729022c47842e55ff085a9483869"

URI_x86_64_v2_kf6-kstatusnotifieritem-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kstatusnotifieritem-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kstatusnotifieritem-doc}"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem-doc.sha256sum] = "01ff1d2e1c74f56d03032c6a86d8196c1e35eafa8abe79a9bbd3c9eed434a121"

URI_x86_64_v2_kf6-kstatusnotifieritem-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kstatusnotifieritem-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kstatusnotifieritem-html}"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem-html.sha256sum] = "d6209cb95d79c28f689f6f603eee04291d4b904b40e9aeffe518dc3af41cf482"

URI_x86_64_v2_python3-kf6-kstatusnotifieritem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kstatusnotifieritem-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kstatusnotifieritem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kstatusnotifieritem}"
SRC_URI[x86_64_v2_python3-kf6-kstatusnotifieritem.sha256sum] = "5e6faa58b5cc596941e634564451f646f9d2addb6ddcd6f85b97ed6ab0a2c9ef"

URI_aarch64_kf6-kstatusnotifieritem = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kstatusnotifieritem;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kstatusnotifieritem}"
SRC_URI[aarch64_kf6-kstatusnotifieritem.sha256sum] = "2a2e1c50259daf856c5a4a17a0b03b3ee8981c63d92ef36b406544ff734fb941"

URI_aarch64_kf6-kstatusnotifieritem-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kstatusnotifieritem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kstatusnotifieritem-devel}"
SRC_URI[aarch64_kf6-kstatusnotifieritem-devel.sha256sum] = "63af6eacc81981c940980c66de3a56dc49217742726815197824a0eb8b10b0f6"

URI_aarch64_kf6-kstatusnotifieritem-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kstatusnotifieritem-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kstatusnotifieritem-doc}"
SRC_URI[aarch64_kf6-kstatusnotifieritem-doc.sha256sum] = "646ee4c41ad3fc76a2823533a51717a02610d75c4dd9312986fc0bbfc3cc93ac"

URI_aarch64_kf6-kstatusnotifieritem-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kstatusnotifieritem-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kstatusnotifieritem-html}"
SRC_URI[aarch64_kf6-kstatusnotifieritem-html.sha256sum] = "0d33b799a0bb9608270ac3c6e5fa2f1d64476e4a64272b1951b0d10491d60f67"

URI_aarch64_python3-kf6-kstatusnotifieritem = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kstatusnotifieritem-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_python3-kf6-kstatusnotifieritem;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kstatusnotifieritem}"
SRC_URI[aarch64_python3-kf6-kstatusnotifieritem.sha256sum] = "84857eafe93b05c8af18424b45ce42a17f973a69747ae9c621e64c9a3303cdda"

RDEPENDS:kf6-kstatusnotifieritem = " \
 glibc \
 kf6-filesystem \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kstatusnotifieritem-devel = " \
 cmake-filesystem \
 kf6-kstatusnotifieritem \
 "
RDEPENDS:kf6-kstatusnotifieritem-doc = " \
 "
RDEPENDS:kf6-kstatusnotifieritem-html = " \
 "
RDEPENDS:python3-kf6-kstatusnotifieritem = " \
 glibc \
 kf6-kstatusnotifieritem \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
