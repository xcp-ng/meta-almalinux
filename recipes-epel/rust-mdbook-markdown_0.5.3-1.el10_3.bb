# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mdbook-markdown"
PV = "0.5.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-mdbook-markdown+default-devel \
 rust-mdbook-markdown-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mdbook-markdown-0.5.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fd72b86104984fad5bbd117c82d7ceb5934b0c33b5d488c0b1943a274511d09"

URI_x86_64_v2_rust-mdbook-markdown+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-markdown+default-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-markdown+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-markdown+default-devel}"
SRC_URI[x86_64_v2_rust-mdbook-markdown+default-devel.sha256sum] = "98b3ac64afc2b5913355b66cddca6ccdf46613b55a7a2967d8b3d09a2a0e9186"

URI_x86_64_v2_rust-mdbook-markdown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-markdown-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-markdown-devel}"
SRC_URI[x86_64_v2_rust-mdbook-markdown-devel.sha256sum] = "bd29fc8d74b23d3a5cbcddb9e82016748131cb28d1505208b1bda3f9dd78c24e"

URI_aarch64_rust-mdbook-markdown+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-markdown+default-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-markdown+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-markdown+default-devel}"
SRC_URI[aarch64_rust-mdbook-markdown+default-devel.sha256sum] = "9e432f4fabc58a09a137e421b70aa664048ba287900431aa34f1594498ef571d"

URI_aarch64_rust-mdbook-markdown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-markdown-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-markdown-devel}"
SRC_URI[aarch64_rust-mdbook-markdown-devel.sha256sum] = "1dd6305eaf4797d1509d906bfc2670f5acf193533a3a19a737ce48a1b559001c"

RDEPENDS:rust-mdbook-markdown+default-devel = " \
 cargo \
 rust-mdbook-markdown-devel \
 "
RDEPENDS:rust-mdbook-markdown-devel = " \
 cargo \
 rust \
 rust-pulldown-cmark+html-devel \
 rust-pulldown-cmark-devel \
 rust-regex+default-devel \
 rust-tracing+default-devel \
 "
