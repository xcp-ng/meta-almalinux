# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-spur"
PV = "0.3.23"
PR = "9.el10_0"
PACKAGES = " \
 python3-spur \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-spur-0.3.23-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d296b8f9a1784f4ad470bd6299d788825140619f3fb2f00c2a8cb5cf6d053c1"

URI_x86_64_v2_python3-spur = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-spur-0.3.23-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-spur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-spur}"
SRC_URI[x86_64_v2_python3-spur.sha256sum] = "cde03bb9a1484cd66497a9c34f4a5c821d19ca4d1eb010e06eb0e95eead0ba56"

URI_aarch64_python3-spur = "${EPEL_MIRROR}/aarch64/Packages/p/python3-spur-0.3.23-9.el10_0.noarch.rpm;name=aarch64_python3-spur;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-spur}"
SRC_URI[aarch64_python3-spur.sha256sum] = "8a65a072fb307d11583a901fa50d84011f8ec16cd000a95c45e0f5049f41e274"

RDEPENDS:python3-spur = " \
 python3 \
 python3-paramiko \
 "
