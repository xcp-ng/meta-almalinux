# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Getopt-Tabular"
PV = "0.3"
PR = "40.el10_3"
PACKAGES = " \
 perl-Getopt-Tabular \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Getopt-Tabular-0.3-40.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4f12373f3cfcd3cbeac72940adbc3872ccde1307c0a7f0482534ebf436cffd3e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Getopt-Tabular-0.3-40.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Getopt-Tabular;unpack=0"
SRC_URI[x86_64_v2_perl-Getopt-Tabular.sha256sum] = "fbd934f218795da809142fc6a11db36c5f44d2bb033f1eb3bfd9d0f7d66c0f86"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Getopt-Tabular-0.3-40.el10_3.noarch.rpm;name=aarch64_perl-Getopt-Tabular;unpack=0"
SRC_URI[aarch64_perl-Getopt-Tabular.sha256sum] = "403e620c4408c9611a4d4a613b8b2f9281bf08fb4a621d926146d5dbee02ca3a"

RDEPENDS:perl-Getopt-Tabular = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
