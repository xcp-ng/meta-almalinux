# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flake8-comprehensions"
PV = "3.17.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-flake8-comprehensions \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-flake8-comprehensions-3.17.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4da32889f4e6966052ffb2ee28cb0bc9dd16c3f3f9701b40be3262bfcdf476af"

URI_x86_64_v2_python3-flake8-comprehensions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flake8-comprehensions-3.17.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flake8-comprehensions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flake8-comprehensions}"
SRC_URI[x86_64_v2_python3-flake8-comprehensions.sha256sum] = "4e343c5862d4121f11b42108f2bcefbd2349d1b74ac10ac380195e2382acf9dd"

URI_aarch64_python3-flake8-comprehensions = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flake8-comprehensions-3.17.0-2.el10_1.noarch.rpm;name=aarch64_python3-flake8-comprehensions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flake8-comprehensions}"
SRC_URI[aarch64_python3-flake8-comprehensions.sha256sum] = "b5066c565d18306a5b62faac04709cabb614b8048399e14a03ca269898711757"

RDEPENDS:python3-flake8-comprehensions = " \
 python3 \
 python3-flake8 \
 "
