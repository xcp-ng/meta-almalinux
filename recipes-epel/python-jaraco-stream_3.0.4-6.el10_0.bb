# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jaraco-stream"
PV = "3.0.4"
PR = "6.el10_0"
PACKAGES = " \
 python3-jaraco-stream \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jaraco-stream-3.0.4-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f081be561077117b1ff6411087368cb85b05e5f4176891fe9125f4b3b8703e4"

URI_x86_64_v2_python3-jaraco-stream = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jaraco-stream-3.0.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jaraco-stream;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jaraco-stream}"
SRC_URI[x86_64_v2_python3-jaraco-stream.sha256sum] = "9359ee03ae3760b67b15a8a4fc4a2c54192876f761ca46e583ac9d23cfbfc585"

URI_aarch64_python3-jaraco-stream = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jaraco-stream-3.0.4-6.el10_0.noarch.rpm;name=aarch64_python3-jaraco-stream;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jaraco-stream}"
SRC_URI[aarch64_python3-jaraco-stream.sha256sum] = "7ba98d1f823c2df0641f1be6d18a7665e2b88694524cefab1dc7df0354e5df57"

RDEPENDS:python3-jaraco-stream = " \
 python3 \
 python3-more-itertools \
 "
