# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akregator"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 akregator \
 akregator-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akregator-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbfa70f6ec2c2123f4adcb0a9bf8715257a25adfbb5f748fbe008d0bd1483a93"

URI_x86_64_v2_akregator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akregator-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akregator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akregator}"
SRC_URI[x86_64_v2_akregator.sha256sum] = "0fb3f78aa05ebe7fc2527efa10f8732d5b2f33bce65d60915e95d4eb1eadb1e5"

URI_x86_64_v2_akregator-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akregator-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akregator-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akregator-libs}"
SRC_URI[x86_64_v2_akregator-libs.sha256sum] = "4bee124aa9595de93dc6dee5baeaa3cecb693dce210cfc0c248bc71f4ff80a34"

URI_aarch64_akregator = "${EPEL_MIRROR}/aarch64/Packages/a/akregator-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_akregator;unpack=0"
SRC_URI:append = " ${URI_aarch64_akregator}"
SRC_URI[aarch64_akregator.sha256sum] = "29f9fe7e965b39aa3d0255d65d22a9986c8d80c62c045277535de747119265bf"

URI_aarch64_akregator-libs = "${EPEL_MIRROR}/aarch64/Packages/a/akregator-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_akregator-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_akregator-libs}"
SRC_URI[aarch64_akregator-libs.sha256sum] = "bc595a30a72bf1479c4c0915166874a6425ecabee4c8a4cbeda7f7973270930a"

RDEPENDS:akregator = " \
 akregator-libs \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syndication \
 kontactinterface \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akregator-libs = " \
 akregator \
 glibc \
 grantleetheme \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-ktexttemplate \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syndication \
 kontactinterface \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 messagelib \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
