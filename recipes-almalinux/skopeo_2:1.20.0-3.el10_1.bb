# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skopeo"
PE = "2"
PV = "1.20.0"
PR = "3.el10_1"
PACKAGES = " \
 skopeo \
 skopeo-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/skopeo-1.20.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07caae654a2c5ed827fe94c73a56255b859a700690d986fe53a9d1f68716d5b2"

URI_x86_64_v2_skopeo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/skopeo-1.20.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_skopeo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skopeo}"
SRC_URI[x86_64_v2_skopeo.sha256sum] = "233a5e1c89f5010e47e50d04dbdd7774c1ef32732e0bd8f97694aff4a327ccd5"

URI_x86_64_v2_skopeo-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/skopeo-tests-1.20.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_skopeo-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skopeo-tests}"
SRC_URI[x86_64_v2_skopeo-tests.sha256sum] = "743b5428a405e0d190e013412b4035eae4d20cbaef038bc852fa65c42d5b23b7"

URI_aarch64_skopeo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/skopeo-1.20.0-3.el10_1.aarch64.rpm;name=aarch64_skopeo;unpack=0"
SRC_URI:append = " ${URI_aarch64_skopeo}"
SRC_URI[aarch64_skopeo.sha256sum] = "f52fc23718f13ece5e0a4e307b46356f22e08ba72ceb522570bb148293a93ab5"

URI_aarch64_skopeo-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/skopeo-tests-1.20.0-3.el10_1.aarch64.rpm;name=aarch64_skopeo-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_skopeo-tests}"
SRC_URI[aarch64_skopeo-tests.sha256sum] = "607b98cf2c3e6eb9e7b22365e1e4a1fcfad9cb3509ff612e2800eb2368a3ddf1"

RDEPENDS:skopeo = " \
 containers-common \
 glibc \
 gpgme \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:skopeo-tests = " \
 bash \
 crun \
 gnupg2 \
 golang \
 httpd-tools \
 jq \
 openssl \
 podman \
 skopeo \
 squashfs-tools \
 virtual//usr/bin/env \
 "
