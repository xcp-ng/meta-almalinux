# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libphonenumber"
PV = "8.13.55"
PR = "2.el10_1"
PACKAGES = " \
 libphonenumber \
 libphonenumber-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libphonenumber-8.13.55-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a6096720bafcd24c97d2a33b35a19765cb56f058a28e6f7a1f8284952a0ce4a3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libphonenumber-8.13.55-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libphonenumber;unpack=0"
SRC_URI[x86_64_v2_libphonenumber.sha256sum] = "5f0eb0f35e94aaf4112903ce10285ffa8a218ae48423a8678280bb6bb32950b9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libphonenumber-devel-8.13.55-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libphonenumber-devel;unpack=0"
SRC_URI[x86_64_v2_libphonenumber-devel.sha256sum] = "d7ab766eb55fede349bffea75cbdcd986cad21b6401a4cb136085fac57c6d74a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libphonenumber-8.13.55-2.el10_1.aarch64.rpm;name=aarch64_libphonenumber;unpack=0"
SRC_URI[aarch64_libphonenumber.sha256sum] = "a4efe0223878a099bfc923be0ab379a8e96ab43821cd6f213bffff517939d1c2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libphonenumber-devel-8.13.55-2.el10_1.aarch64.rpm;name=aarch64_libphonenumber-devel;unpack=0"
SRC_URI[aarch64_libphonenumber-devel.sha256sum] = "40bbca312fb580df342535cdbbafed8a7ef03a411dc21ced2212055e2665f363"

RDEPENDS:libphonenumber = " \
 abseil-cpp \
 boost-thread \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 protobuf \
 "
RDEPENDS:libphonenumber-devel = " \
 abseil-cpp-devel \
 cmake-filesystem \
 libphonenumber \
 "
