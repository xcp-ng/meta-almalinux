# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fonts-compare"
PV = "1.5.3"
PR = "1.el10_0"
PACKAGES = " \
 fonts-compare \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fonts-compare-1.5.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1dfac416a6c08db4ec9cca4f8618b202e07a1907e0fb2f11157825177a5d783"

URI_x86_64_v2_fonts-compare = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fonts-compare-1.5.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fonts-compare;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fonts-compare}"
SRC_URI[x86_64_v2_fonts-compare.sha256sum] = "c96bcc825fdd73e0e5261143259ace5e0aaa72f761bb70388f17f9e4125703e0"

URI_aarch64_fonts-compare = "${EPEL_MIRROR}/aarch64/Packages/f/fonts-compare-1.5.3-1.el10_0.noarch.rpm;name=aarch64_fonts-compare;unpack=0"
SRC_URI:append = " ${URI_aarch64_fonts-compare}"
SRC_URI[aarch64_fonts-compare.sha256sum] = "d342845464eac5025d4a389a6b53ae83aede602b2fa2ba39c0e76ad06a9eda6a"

RDEPENDS:fonts-compare = " \
 bash \
 fontconfig \
 gtk4 \
 hicolor-icon-theme \
 libadwaita \
 python3 \
 python3-freetype \
 python3-gobject \
 python3-langdetect \
 python3-langtable \
 "
