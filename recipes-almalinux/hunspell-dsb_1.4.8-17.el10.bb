# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-dsb"
PV = "1.4.8"
PR = "17.el10"
PACKAGES = " \
 hunspell-dsb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-dsb-1.4.8-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30d95bb1e25dd198eb01816806a355d97ba9927c46112b5e883995f8e47c5394"

URI_x86_64_v2_hunspell-dsb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-dsb-1.4.8-17.el10.noarch.rpm;name=x86_64_v2_hunspell-dsb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-dsb}"
SRC_URI[x86_64_v2_hunspell-dsb.sha256sum] = "3e3c99b9cb667cfee1a29b5e203a429d925501926c42ddc808ae3a784264e749"

URI_aarch64_hunspell-dsb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-dsb-1.4.8-17.el10.noarch.rpm;name=aarch64_hunspell-dsb;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-dsb}"
SRC_URI[aarch64_hunspell-dsb.sha256sum] = "3e3c99b9cb667cfee1a29b5e203a429d925501926c42ddc808ae3a784264e749"

RDEPENDS:hunspell-dsb = " \
 hunspell-filesystem \
 "
