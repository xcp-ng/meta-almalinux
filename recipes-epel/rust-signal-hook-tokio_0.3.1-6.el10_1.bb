# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-signal-hook-tokio"
PV = "0.3.1"
PR = "6.el10_1"
PACKAGES = " \
 rust-signal-hook-tokio+default-devel \
 rust-signal-hook-tokio+futures-core-0_3-devel \
 rust-signal-hook-tokio+futures-v0_3-devel \
 rust-signal-hook-tokio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-signal-hook-tokio-0.3.1-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11f6ed3b21c98894ac42b2aa7e57093f66abb0fe0c25aeb526627659d8434390"

URI_x86_64_v2_rust-signal-hook-tokio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-tokio+default-devel-0.3.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-tokio+default-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-tokio+default-devel.sha256sum] = "25a2ff102ed18945b31a4d3621e2981b509f0b50294d21be366d4c4ab761586b"

URI_x86_64_v2_rust-signal-hook-tokio+futures-core-0_3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-tokio+futures-core-0_3-devel-0.3.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-tokio+futures-core-0_3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-tokio+futures-core-0_3-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-tokio+futures-core-0_3-devel.sha256sum] = "b892a7ebadabbc2090f912cba3feba1f0866c4c5f8fe920ded80ddc73247a40c"

URI_x86_64_v2_rust-signal-hook-tokio+futures-v0_3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-tokio+futures-v0_3-devel-0.3.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-tokio+futures-v0_3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-tokio+futures-v0_3-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-tokio+futures-v0_3-devel.sha256sum] = "808f207d66c0ba883e3af42fc13896cd049b608e112edfc0f26e0f1d9d08f100"

URI_x86_64_v2_rust-signal-hook-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-tokio-devel-0.3.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-tokio-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-tokio-devel.sha256sum] = "2a0db4a57a9479f79542202cafa93846485778194d2a31686a8d2dd67d9ff4f8"

URI_aarch64_rust-signal-hook-tokio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-tokio+default-devel-0.3.1-6.el10_1.noarch.rpm;name=aarch64_rust-signal-hook-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-tokio+default-devel}"
SRC_URI[aarch64_rust-signal-hook-tokio+default-devel.sha256sum] = "cb47eeb337b106eb24419deaf9348a8da72072ada2b0b5bc64a144e8788f1d47"

URI_aarch64_rust-signal-hook-tokio+futures-core-0_3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-tokio+futures-core-0_3-devel-0.3.1-6.el10_1.noarch.rpm;name=aarch64_rust-signal-hook-tokio+futures-core-0_3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-tokio+futures-core-0_3-devel}"
SRC_URI[aarch64_rust-signal-hook-tokio+futures-core-0_3-devel.sha256sum] = "0861b34c8c0fba0c415b42ea1ba4d620b5fee1b8496cda2d7bb063f55f6feb6f"

URI_aarch64_rust-signal-hook-tokio+futures-v0_3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-tokio+futures-v0_3-devel-0.3.1-6.el10_1.noarch.rpm;name=aarch64_rust-signal-hook-tokio+futures-v0_3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-tokio+futures-v0_3-devel}"
SRC_URI[aarch64_rust-signal-hook-tokio+futures-v0_3-devel.sha256sum] = "a4fb4661277ca19ae0cb89006f01880ef2bca552dbd7c523b9a78960b9981a5e"

URI_aarch64_rust-signal-hook-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-tokio-devel-0.3.1-6.el10_1.noarch.rpm;name=aarch64_rust-signal-hook-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-tokio-devel}"
SRC_URI[aarch64_rust-signal-hook-tokio-devel.sha256sum] = "ef010fb68a92e1a1ab352523a6d8a90d5cf54f2c9f4b226c920b5120b25129ed"

RDEPENDS:rust-signal-hook-tokio+default-devel = " \
 cargo \
 rust-signal-hook-tokio-devel \
 "
RDEPENDS:rust-signal-hook-tokio+futures-core-0_3-devel = " \
 cargo \
 rust-futures-core+default-devel \
 rust-signal-hook-tokio-devel \
 "
RDEPENDS:rust-signal-hook-tokio+futures-v0_3-devel = " \
 cargo \
 rust-signal-hook-tokio+futures-core-0_3-devel \
 rust-signal-hook-tokio-devel \
 "
RDEPENDS:rust-signal-hook-tokio-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-signal-hook+default-devel \
 rust-tokio+default-devel \
 rust-tokio+net-devel \
 "
