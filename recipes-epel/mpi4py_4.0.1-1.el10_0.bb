# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mpi4py"
PV = "4.0.1"
PR = "1.el10_0"
PACKAGES = " \
 mpi4py-common \
 mpi4py-docs \
 python3-mpi4py-mpich \
 python3-mpi4py-openmpi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mpi4py-4.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca4de281449bf440c8065343e541711202f4b5f09b6d1aa0f3fa2a4e3e38645a"

URI_x86_64_v2_mpi4py-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mpi4py-common-4.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mpi4py-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpi4py-common}"
SRC_URI[x86_64_v2_mpi4py-common.sha256sum] = "3bc09b8dca5dc12221d4298a963e04c13e112a6d7fee72bca67db3c692f5b892"

URI_x86_64_v2_mpi4py-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mpi4py-docs-4.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mpi4py-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpi4py-docs}"
SRC_URI[x86_64_v2_mpi4py-docs.sha256sum] = "9ecf33efa144c54ad2682086fce37fde1a0e61b15f397daed50294d543b96e24"

URI_x86_64_v2_python3-mpi4py-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mpi4py-mpich-4.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-mpi4py-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mpi4py-mpich}"
SRC_URI[x86_64_v2_python3-mpi4py-mpich.sha256sum] = "2df30b5e838f0eac141e58bdd1fb1f76e9ca327445cc538555659973adf46bb9"

URI_x86_64_v2_python3-mpi4py-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mpi4py-openmpi-4.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-mpi4py-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mpi4py-openmpi}"
SRC_URI[x86_64_v2_python3-mpi4py-openmpi.sha256sum] = "1d56ecfd2a1dfd9f0b8a067a8404e564ae21f4de82bbfa7d69ce700c69264a49"

URI_aarch64_mpi4py-common = "${EPEL_MIRROR}/aarch64/Packages/m/mpi4py-common-4.0.1-1.el10_0.noarch.rpm;name=aarch64_mpi4py-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpi4py-common}"
SRC_URI[aarch64_mpi4py-common.sha256sum] = "bf6874af338330eb37933e031ad916a7c50a3e1a0c0c20929f212d24ec8f197d"

URI_aarch64_mpi4py-docs = "${EPEL_MIRROR}/aarch64/Packages/m/mpi4py-docs-4.0.1-1.el10_0.noarch.rpm;name=aarch64_mpi4py-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpi4py-docs}"
SRC_URI[aarch64_mpi4py-docs.sha256sum] = "019beaa43375b23912c514f60e331a4e463dc37938913d58aeefd25e147add31"

URI_aarch64_python3-mpi4py-mpich = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mpi4py-mpich-4.0.1-1.el10_0.aarch64.rpm;name=aarch64_python3-mpi4py-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mpi4py-mpich}"
SRC_URI[aarch64_python3-mpi4py-mpich.sha256sum] = "780721f0d94d42be58c7def6617e638752ed7fbde565acc0ba6474706a41b22c"

URI_aarch64_python3-mpi4py-openmpi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mpi4py-openmpi-4.0.1-1.el10_0.aarch64.rpm;name=aarch64_python3-mpi4py-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mpi4py-openmpi}"
SRC_URI[aarch64_python3-mpi4py-openmpi.sha256sum] = "dc52c65b7657ff0d232e0a0b233f50b90d879c5a3d4470d461dc1dd4fc35b81a"

RDEPENDS:mpi4py-common = " \
 "
RDEPENDS:mpi4py-docs = " \
 mpi4py-common \
 "
RDEPENDS:python3-mpi4py-mpich = " \
 glibc \
 mpi4py-common \
 mpich \
 python3 \
 python3-mpich \
 "
RDEPENDS:python3-mpi4py-openmpi = " \
 glibc \
 mpi4py-common \
 openmpi \
 python3 \
 python3-openmpi \
 "
