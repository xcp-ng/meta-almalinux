# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcsc-cyberjack"
PV = "3.99.5final.SP16"
PR = "1.el10_0"
PACKAGES = " \
 pcsc-cyberjack \
 pcsc-cyberjack-cjflash \
 pcsc-cyberjack-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pcsc-cyberjack-3.99.5final.SP16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13b3f482febf6d70b546dbd343d6251449ed9ff9147abbbb30773634b97044eb"

URI_x86_64_v2_pcsc-cyberjack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcsc-cyberjack-3.99.5final.SP16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pcsc-cyberjack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcsc-cyberjack}"
SRC_URI[x86_64_v2_pcsc-cyberjack.sha256sum] = "8d6336b4fc5c0f65ac89f3a64ace22867c5973e1a39e48775156b789fde1bb50"

URI_x86_64_v2_pcsc-cyberjack-cjflash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcsc-cyberjack-cjflash-3.99.5final.SP16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pcsc-cyberjack-cjflash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcsc-cyberjack-cjflash}"
SRC_URI[x86_64_v2_pcsc-cyberjack-cjflash.sha256sum] = "782f0cd71cc60a3e7bc5f9e280d656b5aefe2186f2ad68340ba0e108d7603163"

URI_x86_64_v2_pcsc-cyberjack-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcsc-cyberjack-examples-3.99.5final.SP16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pcsc-cyberjack-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcsc-cyberjack-examples}"
SRC_URI[x86_64_v2_pcsc-cyberjack-examples.sha256sum] = "393d67dfb683b6a8dfae44c295a0448bc5f838d7f9a1c0808b7135f37dc90689"

URI_aarch64_pcsc-cyberjack = "${EPEL_MIRROR}/aarch64/Packages/p/pcsc-cyberjack-3.99.5final.SP16-1.el10_0.aarch64.rpm;name=aarch64_pcsc-cyberjack;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcsc-cyberjack}"
SRC_URI[aarch64_pcsc-cyberjack.sha256sum] = "34967785a178e2515197689616656cc9e6cbb85c31403bf97e03d2a2e9ca17b8"

URI_aarch64_pcsc-cyberjack-cjflash = "${EPEL_MIRROR}/aarch64/Packages/p/pcsc-cyberjack-cjflash-3.99.5final.SP16-1.el10_0.aarch64.rpm;name=aarch64_pcsc-cyberjack-cjflash;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcsc-cyberjack-cjflash}"
SRC_URI[aarch64_pcsc-cyberjack-cjflash.sha256sum] = "a88ac814db494f2d5f64dfebceec3ff362756f7718820cfed0238b9ced9b8f44"

URI_aarch64_pcsc-cyberjack-examples = "${EPEL_MIRROR}/aarch64/Packages/p/pcsc-cyberjack-examples-3.99.5final.SP16-1.el10_0.noarch.rpm;name=aarch64_pcsc-cyberjack-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcsc-cyberjack-examples}"
SRC_URI[aarch64_pcsc-cyberjack-examples.sha256sum] = "ea0edd57971f68b433de893c273373de0de551757574564061ceb2035425449c"

RDEPENDS:pcsc-cyberjack = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 libusb1 \
 pcsc-lite \
 systemd \
 systemd-udev \
 "
RDEPENDS:pcsc-cyberjack-cjflash = " \
 glibc \
 libgcc \
 libstdc++ \
 libusb1 \
 pcsc-cyberjack \
 "
RDEPENDS:pcsc-cyberjack-examples = " \
 pcsc-cyberjack \
 "
