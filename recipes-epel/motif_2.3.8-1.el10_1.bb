# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "motif"
PV = "2.3.8"
PR = "1.el10_1"
PACKAGES = " \
 motif \
 motif-devel \
 motif-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/motif-2.3.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a411705047f631229347dcf6c1592cf47290a4618beeef23a0fdffa377e1284e"

URI_x86_64_v2_motif = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/motif-2.3.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_motif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_motif}"
SRC_URI[x86_64_v2_motif.sha256sum] = "b4945703029c6fa7cdbbe2cc1b81f992fafdeeff58ac354a6c14396b686bd513"

URI_x86_64_v2_motif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/motif-devel-2.3.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_motif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_motif-devel}"
SRC_URI[x86_64_v2_motif-devel.sha256sum] = "79e00e2e03bc5826b566535c835451ef360d1049e23e142b8d3fe834563594c4"

URI_x86_64_v2_motif-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/motif-static-2.3.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_motif-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_motif-static}"
SRC_URI[x86_64_v2_motif-static.sha256sum] = "dc7aaecc855125318c304e48611d3226612ff65c30aa383b57abf230e00fd031"

URI_aarch64_motif = "${EPEL_MIRROR}/aarch64/Packages/m/motif-2.3.8-1.el10_1.aarch64.rpm;name=aarch64_motif;unpack=0"
SRC_URI:append = " ${URI_aarch64_motif}"
SRC_URI[aarch64_motif.sha256sum] = "822ec95ecf08b0110d17b93839df30fd2900fa000313c7c69ee09e7c8b2cfc5a"

URI_aarch64_motif-devel = "${EPEL_MIRROR}/aarch64/Packages/m/motif-devel-2.3.8-1.el10_1.aarch64.rpm;name=aarch64_motif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_motif-devel}"
SRC_URI[aarch64_motif-devel.sha256sum] = "9ea2b522c71840daa75a44298c47496d4bc47e0b991a6e0b35f3301af8f31b0a"

URI_aarch64_motif-static = "${EPEL_MIRROR}/aarch64/Packages/m/motif-static-2.3.8-1.el10_1.aarch64.rpm;name=aarch64_motif-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_motif-static}"
SRC_URI[aarch64_motif-static.sha256sum] = "a4905227df3398ff7f4603b089cf78023a4a297df5e49a4d234db37a9c6a4c2a"

RDEPENDS:motif = " \
 bash \
 fontconfig \
 freetype \
 glibc \
 libICE \
 libSM \
 libX11 \
 libXext \
 libXft \
 libXmu \
 libXp \
 libXt \
 libjpeg-turbo \
 libpng \
 xorg-x11-xbitmaps \
 "
RDEPENDS:motif-devel = " \
 glibc \
 libXext-devel \
 libXft-devel \
 libXmu-devel \
 libXp-devel \
 libXt \
 libXt-devel \
 libjpeg-turbo-devel \
 libpng-devel \
 motif \
 "
RDEPENDS:motif-static = " \
 motif-devel \
 "
