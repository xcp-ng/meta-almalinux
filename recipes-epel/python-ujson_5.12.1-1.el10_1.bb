# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ujson"
PV = "5.12.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-ujson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ujson-5.12.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba53f9255de7e1a8165c9b6183e52ddb0acc909fde3f20233aa8691031d1bbc2"

URI_x86_64_v2_python3-ujson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ujson-5.12.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-ujson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ujson}"
SRC_URI[x86_64_v2_python3-ujson.sha256sum] = "f868ca0f08239461cce3a9e5bef68e82b2f167d27592c7f31d72705383049098"

URI_aarch64_python3-ujson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ujson-5.12.1-1.el10_1.aarch64.rpm;name=aarch64_python3-ujson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ujson}"
SRC_URI[aarch64_python3-ujson.sha256sum] = "54db699013dcfce5bc7b1fcb5d0d21dfe387b2fda1162333a93f82bd2dddce8e"

RDEPENDS:python3-ujson = " \
 double-conversion \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
