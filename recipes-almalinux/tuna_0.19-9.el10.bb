# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tuna"
PV = "0.19"
PR = "9.el10"
PACKAGES = " \
 tuna \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tuna-0.19-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0a09330ea1bd77aa3c634e9e164187edb3621308a122702de24d781260c5ac6f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tuna-0.19-9.el10.noarch.rpm;name=x86_64_v2_tuna;unpack=0"
SRC_URI[x86_64_v2_tuna.sha256sum] = "c4df69d66d6337ac75d3cae2e593f4728d65e868e0bb350ce2b3c8684f44b17f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tuna-0.19-9.el10.noarch.rpm;name=aarch64_tuna;unpack=0"
SRC_URI[aarch64_tuna.sha256sum] = "c4df69d66d6337ac75d3cae2e593f4728d65e868e0bb350ce2b3c8684f44b17f"

RDEPENDS:tuna = " \
 python3 \
 python3-linux-procfs \
 "
