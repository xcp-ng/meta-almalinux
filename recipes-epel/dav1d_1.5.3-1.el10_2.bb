# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dav1d"
PV = "1.5.3"
PR = "1.el10_2"
PACKAGES = " \
 dav1d \
 libdav1d \
 libdav1d-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dav1d-1.5.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b87ae6c46affbb0232d08f0675d3bb84bfd2feab7c3ecbe082efed2159854a59"

URI_x86_64_v2_dav1d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dav1d-1.5.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dav1d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dav1d}"
SRC_URI[x86_64_v2_dav1d.sha256sum] = "ed1182ad81282ab92786900acdbaa44b5068be671d33630fba652503e636c532"

URI_x86_64_v2_libdav1d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdav1d-1.5.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdav1d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdav1d}"
SRC_URI[x86_64_v2_libdav1d.sha256sum] = "eaff2a00e22ed97da4b0a68200efe84cdc743631164b5a80e45389d629c7a0fa"

URI_x86_64_v2_libdav1d-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdav1d-devel-1.5.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdav1d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdav1d-devel}"
SRC_URI[x86_64_v2_libdav1d-devel.sha256sum] = "5e6487f4240d38a1935a21a3d58a3ddd148cbf619522beff9bad33c3884dc768"

URI_aarch64_dav1d = "${EPEL_MIRROR}/aarch64/Packages/d/dav1d-1.5.3-1.el10_2.aarch64.rpm;name=aarch64_dav1d;unpack=0"
SRC_URI:append = " ${URI_aarch64_dav1d}"
SRC_URI[aarch64_dav1d.sha256sum] = "4088571bde0fbf3f18935dad9574b4dcbb7b9bfd995ada9759f6178a5669c83b"

URI_aarch64_libdav1d = "${EPEL_MIRROR}/aarch64/Packages/l/libdav1d-1.5.3-1.el10_2.aarch64.rpm;name=aarch64_libdav1d;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdav1d}"
SRC_URI[aarch64_libdav1d.sha256sum] = "a67027a4aeb53a507c1efd32ce9489187f15b58e7f2b5444b29dd25b9ca0bbce"

URI_aarch64_libdav1d-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdav1d-devel-1.5.3-1.el10_2.aarch64.rpm;name=aarch64_libdav1d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdav1d-devel}"
SRC_URI[aarch64_libdav1d-devel.sha256sum] = "8821021095d1aa0916d0a8c0b1da10d1262ae9f88c4b979f12c7d4e8d3d7006e"

RDEPENDS:dav1d = " \
 glibc \
 libdav1d \
 "
RDEPENDS:libdav1d = " \
 glibc \
 "
RDEPENDS:libdav1d-devel = " \
 libdav1d \
 pkgconf-pkg-config \
 "
