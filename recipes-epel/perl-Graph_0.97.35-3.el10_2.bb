# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Graph"
PV = "0.97.35"
PR = "3.el10_2"
PACKAGES = " \
 perl-Graph \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Graph-0.97.35-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bf44074019bd3fdc31a40bac43bda504e478b295519d38480da95aaa7d1ff90"

URI_x86_64_v2_perl-Graph = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Graph-0.97.35-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Graph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Graph}"
SRC_URI[x86_64_v2_perl-Graph.sha256sum] = "2b3e1cd0508b5d5c0373e5a8d6f72c31a42c8765af73488e69e7a8d4fcd4fd42"

URI_aarch64_perl-Graph = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Graph-0.97.35-3.el10_2.noarch.rpm;name=aarch64_perl-Graph;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Graph}"
SRC_URI[aarch64_perl-Graph.sha256sum] = "6e991b0633c50faffe7711f3027dee7fed1b77fe3cf8af43197d9ad64f1dbcc1"

RDEPENDS:perl-Graph = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-Graph \
 perl-Heap \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Set-Object \
 perl-base \
 perl-libs \
 perl-overload \
 perl-vars \
 "
