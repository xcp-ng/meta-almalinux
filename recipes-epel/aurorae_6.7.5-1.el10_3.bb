# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aurorae"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 aurorae \
 aurorae-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/aurorae-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "58e22716daf017902ba2d66bedb50742c6bd4bab2255e794ef9e8f70a5562b31"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aurorae-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aurorae;unpack=0"
SRC_URI[x86_64_v2_aurorae.sha256sum] = "a48c8ef471a749a5a5d1f9dca98bf35e41aa984a01e2c8560d2394ee1bdfdcec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aurorae-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aurorae-devel;unpack=0"
SRC_URI[x86_64_v2_aurorae-devel.sha256sum] = "286ea9dd0c1dca40bef70c9be70fec52944553e20aa6e77bbc064227aa4ddde4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/aurorae-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_aurorae;unpack=0"
SRC_URI[aarch64_aurorae.sha256sum] = "116af3a6d36e2da86d0c27a7014614b37269ef312d066b7d326e818ee5e15ab1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/aurorae-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_aurorae-devel;unpack=0"
SRC_URI[aarch64_aurorae-devel.sha256sum] = "a5a6c33fc04f5cfa3fd064bdd90d9e10e45841492369dae97fe4eb2decafc307"

RDEPENDS:aurorae = " \
 bash \
 glibc \
 kdecoration \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-ksvg \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools \
 "
RDEPENDS:aurorae-devel = " \
 aurorae \
 cmake-filesystem \
 "
