# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "trustee-guest-components"
PV = "0.13.0"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 trustee-guest-components \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/trustee-guest-components-0.13.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0c3fa0eeb625d1ac761fc40e02f156dd1afdc6f493c0ff0bb98dba07f617eccf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/trustee-guest-components-0.13.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_trustee-guest-components;unpack=0"
SRC_URI[x86_64_v2_trustee-guest-components.sha256sum] = "ee375188922e3be5e4943469244cb8b65051302048f79274545535b1c7020efc"

RDEPENDS:trustee-guest-components = " \
 glibc \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
