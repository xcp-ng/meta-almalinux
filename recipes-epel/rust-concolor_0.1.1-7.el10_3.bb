# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-concolor"
PV = "0.1.1"
PR = "7.el10_3"
PACKAGES = " \
 rust-concolor+api-devel \
 rust-concolor+auto-devel \
 rust-concolor+clicolor-devel \
 rust-concolor+core-devel \
 rust-concolor+default-devel \
 rust-concolor+interactive-devel \
 rust-concolor+no_color-devel \
 rust-concolor+std-devel \
 rust-concolor+term-devel \
 rust-concolor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-concolor-0.1.1-7.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f425640c75291c8dd5d06999e7551778a7f595236cb471fd0d510c7a323d180"

URI_x86_64_v2_rust-concolor+api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concolor+api-devel-0.1.1-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concolor+api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concolor+api-devel}"
SRC_URI[x86_64_v2_rust-concolor+api-devel.sha256sum] = "28022d2d6a283b88b73442a9f94e66acd78bc98a47e4d3e3d069b668dc684a06"

URI_x86_64_v2_rust-concolor+auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concolor+auto-devel-0.1.1-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concolor+auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concolor+auto-devel}"
SRC_URI[x86_64_v2_rust-concolor+auto-devel.sha256sum] = "f05911915e6171db652321044d942e89bd250946656355b7f03ad9a571b4881f"

URI_x86_64_v2_rust-concolor+clicolor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concolor+clicolor-devel-0.1.1-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concolor+clicolor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concolor+clicolor-devel}"
SRC_URI[x86_64_v2_rust-concolor+clicolor-devel.sha256sum] = "c1b6bfde7fcb9ee8aa113f95cbd33e2895eed021240f312372e0481af5bec398"

URI_x86_64_v2_rust-concolor+core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concolor+core-devel-0.1.1-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concolor+core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concolor+core-devel}"
SRC_URI[x86_64_v2_rust-concolor+core-devel.sha256sum] = "f3ad22885c53771b7dc52d45e7c80b176dbe52b3f346908fc392551338fe6962"

URI_x86_64_v2_rust-concolor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concolor+default-devel-0.1.1-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concolor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concolor+default-devel}"
SRC_URI[x86_64_v2_rust-concolor+default-devel.sha256sum] = "4e047f9a28cd64e2aec19298a661ea2c7cfe5e6ee86bd4ec3114901a729862a0"

URI_x86_64_v2_rust-concolor+interactive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concolor+interactive-devel-0.1.1-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concolor+interactive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concolor+interactive-devel}"
SRC_URI[x86_64_v2_rust-concolor+interactive-devel.sha256sum] = "83605d7a29ed8e8ce2758272a42dbb24bf16a2179f98fb1b69dfd4f26de7102e"

URI_x86_64_v2_rust-concolor+no_color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concolor+no_color-devel-0.1.1-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concolor+no_color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concolor+no_color-devel}"
SRC_URI[x86_64_v2_rust-concolor+no_color-devel.sha256sum] = "a088e4fb2077341a28770d0b18b4e81b57b3512b193af298ff361c6e9820585c"

URI_x86_64_v2_rust-concolor+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concolor+std-devel-0.1.1-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concolor+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concolor+std-devel}"
SRC_URI[x86_64_v2_rust-concolor+std-devel.sha256sum] = "0e5ab29a6db06cfc4d2b00be7f310625b32c4cf43022b3f984f64d01c7ff10c3"

URI_x86_64_v2_rust-concolor+term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concolor+term-devel-0.1.1-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concolor+term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concolor+term-devel}"
SRC_URI[x86_64_v2_rust-concolor+term-devel.sha256sum] = "491436ea80552e1718ef014329d2bdb7eab7eb15f80b7852728add1aff4a8249"

URI_x86_64_v2_rust-concolor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concolor-devel-0.1.1-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concolor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concolor-devel}"
SRC_URI[x86_64_v2_rust-concolor-devel.sha256sum] = "eef1ef495f6fbc57e18af66563fa66c7da0f070afb71a905ec62e6295243e0a9"

URI_aarch64_rust-concolor+api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concolor+api-devel-0.1.1-7.el10_3.noarch.rpm;name=aarch64_rust-concolor+api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concolor+api-devel}"
SRC_URI[aarch64_rust-concolor+api-devel.sha256sum] = "0d0056c8bf130b048e049c2fb3294f0c7cbc270a216731f377b61332573c377a"

URI_aarch64_rust-concolor+auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concolor+auto-devel-0.1.1-7.el10_3.noarch.rpm;name=aarch64_rust-concolor+auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concolor+auto-devel}"
SRC_URI[aarch64_rust-concolor+auto-devel.sha256sum] = "2de1617af15559e55a3580f9331e152a4acd3683af227df641b4d4e14b461c95"

URI_aarch64_rust-concolor+clicolor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concolor+clicolor-devel-0.1.1-7.el10_3.noarch.rpm;name=aarch64_rust-concolor+clicolor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concolor+clicolor-devel}"
SRC_URI[aarch64_rust-concolor+clicolor-devel.sha256sum] = "cdebfdc1d51f327409e8fbc528fb274f61c283ab3fbc415b8f77a294d8d39c7b"

URI_aarch64_rust-concolor+core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concolor+core-devel-0.1.1-7.el10_3.noarch.rpm;name=aarch64_rust-concolor+core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concolor+core-devel}"
SRC_URI[aarch64_rust-concolor+core-devel.sha256sum] = "6b70b61975776f7224ae7eea73cd9bca4af53c08118e17253189743c6d811f58"

URI_aarch64_rust-concolor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concolor+default-devel-0.1.1-7.el10_3.noarch.rpm;name=aarch64_rust-concolor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concolor+default-devel}"
SRC_URI[aarch64_rust-concolor+default-devel.sha256sum] = "e0d2f390fabf8f2b2b81b5c90c12a871f7f1c647205d74faee7487c52a93b533"

URI_aarch64_rust-concolor+interactive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concolor+interactive-devel-0.1.1-7.el10_3.noarch.rpm;name=aarch64_rust-concolor+interactive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concolor+interactive-devel}"
SRC_URI[aarch64_rust-concolor+interactive-devel.sha256sum] = "7192a9636e4bb730a0dc710f4e61536299096a453c16f2a6d417daf7406e8d28"

URI_aarch64_rust-concolor+no_color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concolor+no_color-devel-0.1.1-7.el10_3.noarch.rpm;name=aarch64_rust-concolor+no_color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concolor+no_color-devel}"
SRC_URI[aarch64_rust-concolor+no_color-devel.sha256sum] = "72f390df63323fdeba536aa3edd7c6d41a5f40a589dfca65ca99e7af4cb7cf8d"

URI_aarch64_rust-concolor+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concolor+std-devel-0.1.1-7.el10_3.noarch.rpm;name=aarch64_rust-concolor+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concolor+std-devel}"
SRC_URI[aarch64_rust-concolor+std-devel.sha256sum] = "f64f7b2813e9c157c9a89d001dbdea4b1e8a198417537125cda1ae241b60baad"

URI_aarch64_rust-concolor+term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concolor+term-devel-0.1.1-7.el10_3.noarch.rpm;name=aarch64_rust-concolor+term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concolor+term-devel}"
SRC_URI[aarch64_rust-concolor+term-devel.sha256sum] = "c0a9db4535009b6a683fe76208061982c1e1c90894e40929da2cc3e93ec67203"

URI_aarch64_rust-concolor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concolor-devel-0.1.1-7.el10_3.noarch.rpm;name=aarch64_rust-concolor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concolor-devel}"
SRC_URI[aarch64_rust-concolor-devel.sha256sum] = "08e7edb5dc256c205bcc8a4223101ab01f675e009a09ed6f4f64d3e0aea47ba5"

RDEPENDS:rust-concolor+api-devel = " \
 cargo \
 rust-concolor+core-devel \
 rust-concolor-devel \
 rust-concolor-override+default-devel \
 "
RDEPENDS:rust-concolor+auto-devel = " \
 cargo \
 rust-concolor+clicolor-devel \
 rust-concolor+interactive-devel \
 rust-concolor+no_color-devel \
 rust-concolor+term-devel \
 rust-concolor-devel \
 "
RDEPENDS:rust-concolor+clicolor-devel = " \
 cargo \
 rust-concolor+core-devel \
 rust-concolor-devel \
 rust-concolor-query+default-devel \
 "
RDEPENDS:rust-concolor+core-devel = " \
 cargo \
 rust-bitflags1+default-devel \
 rust-concolor+std-devel \
 rust-concolor-devel \
 "
RDEPENDS:rust-concolor+default-devel = " \
 cargo \
 rust-concolor-devel \
 "
RDEPENDS:rust-concolor+interactive-devel = " \
 cargo \
 rust-concolor+core-devel \
 rust-concolor-devel \
 rust-is-terminal+default-devel \
 "
RDEPENDS:rust-concolor+no_color-devel = " \
 cargo \
 rust-concolor+core-devel \
 rust-concolor-devel \
 rust-concolor-query+default-devel \
 "
RDEPENDS:rust-concolor+std-devel = " \
 cargo \
 rust-concolor-devel \
 "
RDEPENDS:rust-concolor+term-devel = " \
 cargo \
 rust-concolor+core-devel \
 rust-concolor-devel \
 rust-concolor-query+default-devel \
 "
RDEPENDS:rust-concolor-devel = " \
 cargo \
 rust \
 "
