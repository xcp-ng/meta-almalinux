# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sandogasa"
PV = "0.20.0"
PR = "1.el10_3"
PACKAGES = " \
 sandogasa \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sandogasa-0.20.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5528e312e4ca2b11e91e6bdf378e20216828a17e64ec4b5045f09cac94114c2e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sandogasa-0.20.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sandogasa;unpack=0"
SRC_URI[x86_64_v2_sandogasa.sha256sum] = "a35a35e4939ec21fa85e2984c61529c1bfbd49ce4ec38b5101ce8ff635f6c3bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sandogasa-0.20.0-1.el10_3.aarch64.rpm;name=aarch64_sandogasa;unpack=0"
SRC_URI[aarch64_sandogasa.sha256sum] = "0a2042b33901c994c7abc4404d49f21a457e594e95942c4647bb6ed933096499"

RDEPENDS:sandogasa = " \
 glibc \
 koji \
 libgcc \
 "
