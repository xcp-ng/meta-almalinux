# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "util-linux"
PV = "2.40.2"
PR = "18.el10"
PACKAGES = " \
 libblkid \
 libblkid-devel \
 libfdisk \
 libfdisk-devel \
 libmount \
 libmount-devel \
 libsmartcols \
 libsmartcols-devel \
 libuuid \
 libuuid-devel \
 python3-libmount \
 util-linux \
 util-linux-core \
 uuidd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/util-linux-2.40.2-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ded38e92ea0c75ab68f54c152002b784c429c134c985922f1e740c51d37c4bd"

URI_x86_64_v2_libblkid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libblkid-2.40.2-18.el10.x86_64_v2.rpm;name=x86_64_v2_libblkid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblkid}"
SRC_URI[x86_64_v2_libblkid.sha256sum] = "123c9467ffc3b5f03c91e192e07a4407e1e8bc6075ab62b7b7b0878e59cadd28"

URI_x86_64_v2_libblkid-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblkid-devel-2.40.2-18.el10.x86_64_v2.rpm;name=x86_64_v2_libblkid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblkid-devel}"
SRC_URI[x86_64_v2_libblkid-devel.sha256sum] = "fe5f44f6dac72657c79ff908c12886890dc3681313fe08c6a5850f84388a2c15"

URI_x86_64_v2_libfdisk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libfdisk-2.40.2-18.el10.x86_64_v2.rpm;name=x86_64_v2_libfdisk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfdisk}"
SRC_URI[x86_64_v2_libfdisk.sha256sum] = "f4e6c0087525674c5edf913673c79016d3eeb1893d8cb5b532572ec92ea0e11f"

URI_x86_64_v2_libfdisk-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libfdisk-devel-2.40.2-18.el10.x86_64_v2.rpm;name=x86_64_v2_libfdisk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfdisk-devel}"
SRC_URI[x86_64_v2_libfdisk-devel.sha256sum] = "ff34e764bfb110e6a104cc97c083896999a5c45ddef5dd0fed955a9dfe2b2889"

URI_x86_64_v2_libmount = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libmount-2.40.2-18.el10.x86_64_v2.rpm;name=x86_64_v2_libmount;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmount}"
SRC_URI[x86_64_v2_libmount.sha256sum] = "707474b4090a6e94ec4a2c214436c08f761bf079b6113aba69631ae8fed75d81"

URI_x86_64_v2_libmount-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libmount-devel-2.40.2-18.el10.x86_64_v2.rpm;name=x86_64_v2_libmount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmount-devel}"
SRC_URI[x86_64_v2_libmount-devel.sha256sum] = "e6a5ecacd82c8d57155c2c407611911b409fc5e10cfe6530dbdb2620fc952e7b"

URI_x86_64_v2_libsmartcols = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsmartcols-2.40.2-18.el10.x86_64_v2.rpm;name=x86_64_v2_libsmartcols;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmartcols}"
SRC_URI[x86_64_v2_libsmartcols.sha256sum] = "46750dac15dba3cebdfe25ae53338ede267c2cdec271069011fa6685dae57d7f"

URI_x86_64_v2_libsmartcols-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsmartcols-devel-2.40.2-18.el10.x86_64_v2.rpm;name=x86_64_v2_libsmartcols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmartcols-devel}"
SRC_URI[x86_64_v2_libsmartcols-devel.sha256sum] = "a38dd6e5290d5131a840244cbdbb365ef44273eacd08b24f8f68ea13c93ae68f"

URI_x86_64_v2_libuuid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libuuid-2.40.2-18.el10.x86_64_v2.rpm;name=x86_64_v2_libuuid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuuid}"
SRC_URI[x86_64_v2_libuuid.sha256sum] = "074b81731836f30ef3d950c6634069e41bf85de2668bc0c049a4905dc56dfcbf"

URI_x86_64_v2_libuuid-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libuuid-devel-2.40.2-18.el10.x86_64_v2.rpm;name=x86_64_v2_libuuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuuid-devel}"
SRC_URI[x86_64_v2_libuuid-devel.sha256sum] = "4d643a79ba0956e94120e4aaf8d09ddb26d03712492967da52feb0f08f2e6755"

URI_x86_64_v2_python3-libmount = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libmount-2.40.2-18.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libmount;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libmount}"
SRC_URI[x86_64_v2_python3-libmount.sha256sum] = "4cd6bd8f85b43a44407ae7a8b7dda5d24bd0e910fa78a4fe2fc98f4fb41b6333"

URI_x86_64_v2_util-linux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/util-linux-2.40.2-18.el10.x86_64_v2.rpm;name=x86_64_v2_util-linux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_util-linux}"
SRC_URI[x86_64_v2_util-linux.sha256sum] = "cb062928f23f812cf2bf2e57b01f1f2fc39ef773fbaac15583e62c8d04d983c9"
RPROVIDES:util-linux:x86_64_v2 = "virtual/util-linux-core_or_util-linux"

URI_x86_64_v2_util-linux-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/util-linux-core-2.40.2-18.el10.x86_64_v2.rpm;name=x86_64_v2_util-linux-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_util-linux-core}"
SRC_URI[x86_64_v2_util-linux-core.sha256sum] = "b7952438f7a23d4f7ceba44d54fcf47a913fb95e7ee4ffa2774ad989be69c153"
RPROVIDES:util-linux-core:x86_64_v2 = "virtual/util-linux-core_or_util-linux"

URI_x86_64_v2_uuidd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/uuidd-2.40.2-18.el10.x86_64_v2.rpm;name=x86_64_v2_uuidd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uuidd}"
SRC_URI[x86_64_v2_uuidd.sha256sum] = "14e3b8f7e0bf0c7b8758c584a6776488543945262e6f757836bd6be89f35929f"

URI_aarch64_libblkid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libblkid-2.40.2-18.el10.aarch64.rpm;name=aarch64_libblkid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblkid}"
SRC_URI[aarch64_libblkid.sha256sum] = "834481ac65e722ed1628ccd72dbf9c0347f5093f859416b40a75203a9a5b5565"

URI_aarch64_libblkid-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblkid-devel-2.40.2-18.el10.aarch64.rpm;name=aarch64_libblkid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblkid-devel}"
SRC_URI[aarch64_libblkid-devel.sha256sum] = "355155af230d816a737dc718bad2d642e61c23ade5cc0b9252514b4689f7c1d9"

URI_aarch64_libfdisk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libfdisk-2.40.2-18.el10.aarch64.rpm;name=aarch64_libfdisk;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfdisk}"
SRC_URI[aarch64_libfdisk.sha256sum] = "c7f6517ec915741bf0f4cf080ace2fae899d79580398ff95e43125a462566eae"

URI_aarch64_libfdisk-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libfdisk-devel-2.40.2-18.el10.aarch64.rpm;name=aarch64_libfdisk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfdisk-devel}"
SRC_URI[aarch64_libfdisk-devel.sha256sum] = "a7eb23a47faf4f9ebdaac0220b2af4811ed5512db2dd11a964dfc085be388395"

URI_aarch64_libmount = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libmount-2.40.2-18.el10.aarch64.rpm;name=aarch64_libmount;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmount}"
SRC_URI[aarch64_libmount.sha256sum] = "8dda8db2f682e4d50e56a7c9454683e7c2a18c0e0958a58590a1dd47951beee8"

URI_aarch64_libmount-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libmount-devel-2.40.2-18.el10.aarch64.rpm;name=aarch64_libmount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmount-devel}"
SRC_URI[aarch64_libmount-devel.sha256sum] = "3237728043c8cb062480ec3ea759e07815c581aa1d8bb139b3849649263743d8"

URI_aarch64_libsmartcols = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsmartcols-2.40.2-18.el10.aarch64.rpm;name=aarch64_libsmartcols;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmartcols}"
SRC_URI[aarch64_libsmartcols.sha256sum] = "747f2dd86cd78e7fa48aa16eff46b983ae20719efa6b4808b1ab50a82a1cc98c"

URI_aarch64_libsmartcols-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsmartcols-devel-2.40.2-18.el10.aarch64.rpm;name=aarch64_libsmartcols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmartcols-devel}"
SRC_URI[aarch64_libsmartcols-devel.sha256sum] = "9698413067c24266699ca008a6db91405ef782997c7c19579bfe62e3c24d878c"

URI_aarch64_libuuid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libuuid-2.40.2-18.el10.aarch64.rpm;name=aarch64_libuuid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuuid}"
SRC_URI[aarch64_libuuid.sha256sum] = "fbdb384a243f19b772d1f2f44ac7c5ca362d0c75fd2049351478fa63152dd989"

URI_aarch64_libuuid-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libuuid-devel-2.40.2-18.el10.aarch64.rpm;name=aarch64_libuuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuuid-devel}"
SRC_URI[aarch64_libuuid-devel.sha256sum] = "71d17d34b197b818e733202fdd29aeeeac79d9b5ed612f55a278a9ba6d9b1015"

URI_aarch64_python3-libmount = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libmount-2.40.2-18.el10.aarch64.rpm;name=aarch64_python3-libmount;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libmount}"
SRC_URI[aarch64_python3-libmount.sha256sum] = "79bd4c894f8d9b6d3d3b6da73e88c7d35a50e0ec8ec67833b2626ea927ac487f"

URI_aarch64_util-linux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/util-linux-2.40.2-18.el10.aarch64.rpm;name=aarch64_util-linux;unpack=0"
SRC_URI:append = " ${URI_aarch64_util-linux}"
SRC_URI[aarch64_util-linux.sha256sum] = "20ae6621b5d3baa0ec4e88719922f16a7adedacd31ce3ff6dbca65c51e1fde7d"
RPROVIDES:util-linux:aarch64 = "virtual/util-linux-core_or_util-linux"

URI_aarch64_util-linux-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/util-linux-core-2.40.2-18.el10.aarch64.rpm;name=aarch64_util-linux-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_util-linux-core}"
SRC_URI[aarch64_util-linux-core.sha256sum] = "53755e78ad4a0a981ddea2ff4303801e94ff23b61bb2426085595c1fbcf6875c"
RPROVIDES:util-linux-core:aarch64 = "virtual/util-linux-core_or_util-linux"

URI_aarch64_uuidd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/uuidd-2.40.2-18.el10.aarch64.rpm;name=aarch64_uuidd;unpack=0"
SRC_URI:append = " ${URI_aarch64_uuidd}"
SRC_URI[aarch64_uuidd.sha256sum] = "2883af921af6384ea98b7a237eeac3a26e30953f343d91cf8355d756826726fe"

RDEPENDS:libblkid = " \
 glibc \
 libuuid \
 "
RDEPENDS:libblkid-devel = " \
 libblkid \
 pkgconf-pkg-config \
 "
RDEPENDS:libfdisk = " \
 glibc \
 libblkid \
 libuuid \
 "
RDEPENDS:libfdisk-devel = " \
 libblkid-devel \
 libfdisk \
 libuuid-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libmount = " \
 glibc \
 libblkid \
 libselinux \
 libuuid \
 "
RDEPENDS:libmount-devel = " \
 libblkid-devel \
 libmount \
 libselinux-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libsmartcols = " \
 glibc \
 "
RDEPENDS:libsmartcols-devel = " \
 libsmartcols \
 pkgconf-pkg-config \
 "
RDEPENDS:libuuid = " \
 glibc \
 "
RDEPENDS:libuuid-devel = " \
 libuuid \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libmount = " \
 glibc \
 libblkid \
 libmount \
 libselinux \
 python3 \
 "
RDEPENDS:util-linux = " \
 audit-libs \
 authselect-libs \
 bash \
 glibc \
 libblkid \
 libcap-ng \
 libfdisk \
 libmount \
 libselinux \
 libsmartcols \
 libutempter \
 libuuid \
 ncurses-libs \
 pam \
 pam-libs \
 readline \
 shadow-utils \
 systemd-libs \
 util-linux-core \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:util-linux-core = " \
 glibc \
 libblkid \
 libmount \
 libselinux \
 libsmartcols \
 libuuid \
 libxcrypt \
 ncurses-libs \
 systemd-libs \
 "
RDEPENDS:uuidd = " \
 bash \
 glibc \
 libuuid \
 shadow-utils \
 systemd-libs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/util-linux-core_or_util-linux"

PROVIDES:append:aarch64 = " rpm/virtual/util-linux-core_or_util-linux"
