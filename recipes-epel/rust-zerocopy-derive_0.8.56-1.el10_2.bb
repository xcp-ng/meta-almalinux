# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerocopy-derive"
PV = "0.8.56"
PR = "1.el10_2"
PACKAGES = " \
 rust-zerocopy-derive+default-devel \
 rust-zerocopy-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerocopy-derive-0.8.56-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a74d193e68354bb6cf43ae385fdeb78e831b3389c2f398b2f3d94a136e86d738"

URI_x86_64_v2_rust-zerocopy-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-derive+default-devel-0.8.56-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy-derive+default-devel}"
SRC_URI[x86_64_v2_rust-zerocopy-derive+default-devel.sha256sum] = "49637878e59df08c9eef8b010f9176d37047625acabf9cd275692a6695ed1fbd"

URI_x86_64_v2_rust-zerocopy-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-derive-devel-0.8.56-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy-derive-devel}"
SRC_URI[x86_64_v2_rust-zerocopy-derive-devel.sha256sum] = "ceee044c34ef6a1ec57a2b768683b0edc9646f5fd9f6f3579b015b09e88a73db"

URI_aarch64_rust-zerocopy-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-derive+default-devel-0.8.56-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy-derive+default-devel}"
SRC_URI[aarch64_rust-zerocopy-derive+default-devel.sha256sum] = "b846dea802d7118e1eed3d92d2fafb577b31c44ed3de92f4f99e29f67be4e8e0"

URI_aarch64_rust-zerocopy-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-derive-devel-0.8.56-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy-derive-devel}"
SRC_URI[aarch64_rust-zerocopy-derive-devel.sha256sum] = "6c8bf74dec3fbb5324517b592a97b3a3d485ca4614823952ed52f2c1709f6aa9"

RDEPENDS:rust-zerocopy-derive+default-devel = " \
 cargo \
 rust-zerocopy-derive-devel \
 "
RDEPENDS:rust-zerocopy-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
