# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "roundcubemail"
PV = "1.6.18"
PR = "1.el10_3"
PACKAGES = " \
 roundcubemail \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/roundcubemail-1.6.18-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "214720667939a2131f172ca1a3e668b697313f2dc1142013b103b5a7c8250c10"

URI_x86_64_v2_roundcubemail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/roundcubemail-1.6.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_roundcubemail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_roundcubemail}"
SRC_URI[x86_64_v2_roundcubemail.sha256sum] = "5f83e5cdd90f5fb0ea355246f9483ee810dcc809dcfa83c37f1f3a3fbf6cdb1c"

URI_aarch64_roundcubemail = "${EPEL_MIRROR}/aarch64/Packages/r/roundcubemail-1.6.18-1.el10_3.noarch.rpm;name=aarch64_roundcubemail;unpack=0"
SRC_URI:append = " ${URI_aarch64_roundcubemail}"
SRC_URI[aarch64_roundcubemail.sha256sum] = "50f37325a8822a6b90a922db7b5c6a3669a5e9e6a590af8ac376db907811b9dc"

RDEPENDS:roundcubemail = " \
 bash \
 httpd-filesystem \
 mailcap \
 nginx-filesystem \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-date \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-hash \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-libxml \
 virtual/php-mbstring \
 virtual/php-openssl \
 virtual/php-pcre \
 virtual/php-pdo \
 virtual/php-posix \
 virtual/php-reflection \
 virtual/php-session \
 virtual/php-simplexml \
 virtual/php-sockets \
 virtual/php-spl \
 virtual/php-tokenizer \
 virtual/php-zip \
 virtual/php_httpd_ \
 virtual/php_language__ge_7.3 \
 virtual/webserver \
 "
