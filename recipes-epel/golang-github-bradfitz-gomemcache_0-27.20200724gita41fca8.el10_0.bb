# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-bradfitz-gomemcache"
PV = "0"
PR = "27.20200724gita41fca8.el10_0"
PACKAGES = " \
 compat-golang-gopkg-bradfitz-gomemcache-1-devel \
 golang-github-bradfitz-gomemcache-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-bradfitz-gomemcache-0-27.20200724gita41fca8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "712732459bdd0ed960a9c3780b9f40462ac2d082320386234705c083be0c608b"

URI_aarch64_compat-golang-gopkg-bradfitz-gomemcache-1-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-gopkg-bradfitz-gomemcache-1-devel-0-27.20200724gita41fca8.el10_0.noarch.rpm;name=aarch64_compat-golang-gopkg-bradfitz-gomemcache-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-gopkg-bradfitz-gomemcache-1-devel}"
SRC_URI[aarch64_compat-golang-gopkg-bradfitz-gomemcache-1-devel.sha256sum] = "a5af34410ca22499587bf8fb752004fad2122bc6a27e1b14c90b04058c17961c"

URI_aarch64_golang-github-bradfitz-gomemcache-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-bradfitz-gomemcache-devel-0-27.20200724gita41fca8.el10_0.noarch.rpm;name=aarch64_golang-github-bradfitz-gomemcache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-bradfitz-gomemcache-devel}"
SRC_URI[aarch64_golang-github-bradfitz-gomemcache-devel.sha256sum] = "d439394a8b49e7c0c2ac736101c92ac675ed568a8b138cbfd190dc2b6570510a"

RDEPENDS:compat-golang-gopkg-bradfitz-gomemcache-1-devel = " \
 go-filesystem \
 golang-github-bradfitz-gomemcache-devel \
 "
RDEPENDS:golang-github-bradfitz-gomemcache-devel = " \
 go-filesystem \
 "
