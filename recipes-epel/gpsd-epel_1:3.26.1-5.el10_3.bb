# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpsd-epel"
PE = "1"
PV = "3.26.1"
PR = "5.el10_3"
PACKAGES = " \
 gpsd-devel \
 gpsd-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gpsd-epel-3.26.1-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b2abe37ec9047e8c8d44dafa03df3a3c4319c22cebe73310d6304f572fd93149"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpsd-devel-3.26.1-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpsd-devel;unpack=0"
SRC_URI[x86_64_v2_gpsd-devel.sha256sum] = "f4d6a9deeb7a4231e94db2ace27cd2eda6d64d8bf35836dd2569c73aeb8f9940"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpsd-libs-3.26.1-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpsd-libs;unpack=0"
SRC_URI[x86_64_v2_gpsd-libs.sha256sum] = "4fe9fcd60c0d5009969b95ec4a60d1a83c61e5df26163f8d72bdd95b24f1f3ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gpsd-devel-3.26.1-5.el10_3.aarch64.rpm;name=aarch64_gpsd-devel;unpack=0"
SRC_URI[aarch64_gpsd-devel.sha256sum] = "e63a34bc6ded85210df444a9620671ee26d8efcaaddf1f75a1ad429fba8635b1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gpsd-libs-3.26.1-5.el10_3.aarch64.rpm;name=aarch64_gpsd-libs;unpack=0"
SRC_URI[aarch64_gpsd-libs.sha256sum] = "e135f1615ebf6000da2110d9af429f54c42b099cc0e120e4c6c747cef2775b58"

RDEPENDS:gpsd-devel = " \
 gpsd-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:gpsd-libs:x86_64_v2 = " \
 dbus-libs \
 glibc \
 libstdc++ \
"
RDEPENDS:gpsd-libs:aarch64 = " \
 dbus-libs \
 glibc \
"
