# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "syncthing"
PV = "2.1.1"
PR = "1.el10_3"
PACKAGES = " \
 syncthing \
 syncthing-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/syncthing-2.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1295778154b0d0de1960d720ade155a168dd24ba91c49c09cc72bc9dea024dd"

URI_x86_64_v2_syncthing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syncthing-2.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syncthing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syncthing}"
SRC_URI[x86_64_v2_syncthing.sha256sum] = "38d13f0cd6ef182cfd5dcfa8fede48f0b766d9512e42b536c7a051c9fbe56ffa"

URI_x86_64_v2_syncthing-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syncthing-tools-2.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syncthing-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syncthing-tools}"
SRC_URI[x86_64_v2_syncthing-tools.sha256sum] = "ba3e87f8a9a30907ddcfcbe76870d736124a28d5ff7439d8ed63cb8e275cca69"

URI_aarch64_syncthing = "${EPEL_MIRROR}/aarch64/Packages/s/syncthing-2.1.1-1.el10_3.aarch64.rpm;name=aarch64_syncthing;unpack=0"
SRC_URI:append = " ${URI_aarch64_syncthing}"
SRC_URI[aarch64_syncthing.sha256sum] = "a489da7c39f940710273878ae437522a1802af2053fa334a30d3a4231017122c"

URI_aarch64_syncthing-tools = "${EPEL_MIRROR}/aarch64/Packages/s/syncthing-tools-2.1.1-1.el10_3.aarch64.rpm;name=aarch64_syncthing-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_syncthing-tools}"
SRC_URI[aarch64_syncthing-tools.sha256sum] = "dcca60ba31762339a541e13e05e9803030b555260f53ac125a8bf1f5da240145"

RDEPENDS:syncthing = " \
 bash \
 glibc \
 hicolor-icon-theme \
 sqlite-libs \
 "
RDEPENDS:syncthing-tools = " \
 glibc \
 syncthing \
 "
