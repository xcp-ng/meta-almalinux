# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktnef"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 ktnef \
 ktnef-devel \
 ktnef-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ktnef-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2a25fe0d18c945029e4f4e5d15d7149dfa4444e7410a020623786026c88eeeff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktnef-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktnef;unpack=0"
SRC_URI[x86_64_v2_ktnef.sha256sum] = "2e7d0c3f1f494a99707abe74bfc20eacdffaea296049e77a87a15ffa4458326e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktnef-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktnef-devel;unpack=0"
SRC_URI[x86_64_v2_ktnef-devel.sha256sum] = "cdeab81848a9c78c9fa5eae2b005d318453e9a90785484617bfd3e4df0fae96e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktnef-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ktnef-doc;unpack=0"
SRC_URI[x86_64_v2_ktnef-doc.sha256sum] = "2b71dbff6e3021bfdc8fb021f72e5bd01d2eb915e5b8519d5a8388eeb1a5bc83"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktnef-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ktnef;unpack=0"
SRC_URI[aarch64_ktnef.sha256sum] = "428c6248a57ad16bc648406425293b6d9d68702fec0d12788b4275a6bca5b41c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktnef-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ktnef-devel;unpack=0"
SRC_URI[aarch64_ktnef-devel.sha256sum] = "76ac77bd98e681c36c916cf49f31f6d9a6fe22a7ecf728d560f12588a20a998b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktnef-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_ktnef-doc;unpack=0"
SRC_URI[aarch64_ktnef-doc.sha256sum] = "ac2eb81a12f7b6f39693a2502535cd9f21d752a18bf91f4125c9e7edf528be37"

RDEPENDS:ktnef = " \
 glibc \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcontacts \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:ktnef-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 ktnef \
 "
RDEPENDS:ktnef-doc = " \
 "
