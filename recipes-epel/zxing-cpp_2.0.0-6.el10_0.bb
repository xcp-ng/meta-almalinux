# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zxing-cpp"
PV = "2.0.0"
PR = "6.el10_0"
PACKAGES = " \
 python3-zxing-cpp \
 zxing-cpp \
 zxing-cpp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zxing-cpp-2.0.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c51400eb1af27124c716f52035f0cdbfdb0c6e705cda4af60f0c1b2afc3186f7"

URI_x86_64_v2_python3-zxing-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zxing-cpp-2.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-zxing-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zxing-cpp}"
SRC_URI[x86_64_v2_python3-zxing-cpp.sha256sum] = "246c2500be2c744dfcd19e6eb5848ba598be4531ba18088c9cd07a29a3ce1c06"

URI_x86_64_v2_zxing-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zxing-cpp-2.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zxing-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zxing-cpp}"
SRC_URI[x86_64_v2_zxing-cpp.sha256sum] = "564dcd164fcc6eae03353f6bda3efd26ee9f9d8e263216d126251d52edb1a84e"

URI_x86_64_v2_zxing-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zxing-cpp-devel-2.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zxing-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zxing-cpp-devel}"
SRC_URI[x86_64_v2_zxing-cpp-devel.sha256sum] = "e71acd2e960e91fc10dbbfffa8fa76e972dddb41d1d8e821e5968fb7adf2aab5"

URI_aarch64_python3-zxing-cpp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zxing-cpp-2.0.0-6.el10_0.aarch64.rpm;name=aarch64_python3-zxing-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zxing-cpp}"
SRC_URI[aarch64_python3-zxing-cpp.sha256sum] = "e96e2556afdc4471cc37e8ba9e00272345efd71d15ce53041c53dd2d84289f32"

URI_aarch64_zxing-cpp = "${EPEL_MIRROR}/aarch64/Packages/z/zxing-cpp-2.0.0-6.el10_0.aarch64.rpm;name=aarch64_zxing-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_zxing-cpp}"
SRC_URI[aarch64_zxing-cpp.sha256sum] = "463a24f90e9ba1cb9b847fa29b47b2d565e5cbda1adf9bc35b409a8231f6711f"

URI_aarch64_zxing-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/z/zxing-cpp-devel-2.0.0-6.el10_0.aarch64.rpm;name=aarch64_zxing-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zxing-cpp-devel}"
SRC_URI[aarch64_zxing-cpp-devel.sha256sum] = "b20ab741e9f0dea7d80a3fbb54e488add1b14afb0532ae3f10ff72c248984008"

RDEPENDS:python3-zxing-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-numpy \
 zxing-cpp \
 "
RDEPENDS:zxing-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:zxing-cpp-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 zxing-cpp \
 "
