# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-portend"
PV = "3.2.0"
PR = "6.el10_0"
PACKAGES = " \
 python3-portend \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-portend-3.2.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8547b3cf38ea259992b483111219b681a08885eabe0e9b42735cac2f4aca6ab7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-portend-3.2.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-portend;unpack=0"
SRC_URI[x86_64_v2_python3-portend.sha256sum] = "0ebae2b1dc33c983b3c6de05a8ab674a40752b08b2797372434788afec520e3c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-portend-3.2.0-6.el10_0.noarch.rpm;name=aarch64_python3-portend;unpack=0"
SRC_URI[aarch64_python3-portend.sha256sum] = "fac6cf30a2ec512ab95e4bc3fdebe51f46f7110ae4974f37ada7a839019aaec8"

RDEPENDS:python3-portend = " \
 python3 \
 python3-tempora \
 "
