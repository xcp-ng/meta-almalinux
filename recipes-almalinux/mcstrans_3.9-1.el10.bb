# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mcstrans"
PV = "3.9"
PR = "1.el10"
PACKAGES = " \
 mcstrans \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mcstrans-3.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49bedcbdd5b859816a8e90535312bd3d0e07ca34f5794f445cde2c0314113eca"

URI_x86_64_v2_mcstrans = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mcstrans-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_mcstrans;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mcstrans}"
SRC_URI[x86_64_v2_mcstrans.sha256sum] = "41d490b9ef2586144b5fab928dc92c78875e656675e1046c4602c7fcdbb0593b"

URI_aarch64_mcstrans = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mcstrans-3.9-1.el10.aarch64.rpm;name=aarch64_mcstrans;unpack=0"
SRC_URI:append = " ${URI_aarch64_mcstrans}"
SRC_URI[aarch64_mcstrans.sha256sum] = "e004206dd61eaec3e8ae099a3bd2f28bc36d15919439975dd4dbfa020edddb39"

RDEPENDS:mcstrans = " \
 bash \
 glibc \
 libcap \
 libselinux \
 pcre2 \
 systemd \
 "
