# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_ln"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_ln+default-devel \
 rust-uu_ln-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_ln-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25cd24f10625e6b66826e7fa6d7e641703846ffdec30c092d431f2c2b2d9e7d2"

URI_x86_64_v2_rust-uu_ln+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_ln+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_ln+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_ln+default-devel}"
SRC_URI[x86_64_v2_rust-uu_ln+default-devel.sha256sum] = "8be6a47f7196129dd6ebf7e6ef39307cb075036f6b1ff9a23b42f469aad1e7c6"

URI_x86_64_v2_rust-uu_ln-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_ln-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_ln-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_ln-devel}"
SRC_URI[x86_64_v2_rust-uu_ln-devel.sha256sum] = "83c42d241a2941f6f450bc822b883bff4c2d3bdeff810187773785fc47170bb1"

URI_aarch64_rust-uu_ln+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_ln+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_ln+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_ln+default-devel}"
SRC_URI[aarch64_rust-uu_ln+default-devel.sha256sum] = "4e42d1ba85b70ac9dac96f70aa89dbc1e550df051364a5a28078be584fa8f644"

URI_aarch64_rust-uu_ln-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_ln-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_ln-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_ln-devel}"
SRC_URI[aarch64_rust-uu_ln-devel.sha256sum] = "47f81fd7cc17cb19e29059841303ae7b0263c74ad481906184490cc53121cafc"

RDEPENDS:rust-uu_ln+default-devel = " \
 cargo \
 rust-uu_ln-devel \
 "
RDEPENDS:rust-uu_ln-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+backup-control-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 "
