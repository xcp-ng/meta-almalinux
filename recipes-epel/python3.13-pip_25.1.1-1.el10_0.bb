# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.13-pip"
PV = "25.1.1"
PR = "1.el10_0"
PACKAGES = " \
 python3.13-pip \
 python3.13-pip-wheel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3.13-pip-25.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61dd084c6f3a96b474948f751ef48a63ffb1bded0a12de026cf933d3b8fb8354"

URI_x86_64_v2_python3.13-pip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-pip-25.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3.13-pip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-pip}"
SRC_URI[x86_64_v2_python3.13-pip.sha256sum] = "8d4de7398c678d801d4b347fe5d01f4b8dca80b8682b46e3995b8a1b42e2b652"

URI_x86_64_v2_python3.13-pip-wheel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-pip-wheel-25.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3.13-pip-wheel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-pip-wheel}"
SRC_URI[x86_64_v2_python3.13-pip-wheel.sha256sum] = "2969daabdf4a499c39ddfcc05d340d450721a2c57410d9fc19417a0bb7989891"

URI_aarch64_python3.13-pip = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-pip-25.1.1-1.el10_0.noarch.rpm;name=aarch64_python3.13-pip;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-pip}"
SRC_URI[aarch64_python3.13-pip.sha256sum] = "2102a3b6edeb755c87f70313bae442d4e22047d0bc2cae0cc857b28cfcf9ee29"

URI_aarch64_python3.13-pip-wheel = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-pip-wheel-25.1.1-1.el10_0.noarch.rpm;name=aarch64_python3.13-pip-wheel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-pip-wheel}"
SRC_URI[aarch64_python3.13-pip-wheel.sha256sum] = "c77e5df4b293bdd9a0438cae329b5950334f5b22c871401f1499b9fab0e89ab8"

RDEPENDS:python3.13-pip = " \
 ca-certificates \
 python3.13 \
 "
RDEPENDS:python3.13-pip-wheel = " \
 ca-certificates \
 "
