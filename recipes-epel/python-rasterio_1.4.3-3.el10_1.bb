# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rasterio"
PV = "1.4.3"
PR = "3.el10_1"
PACKAGES = " \
 python3-rasterio \
 python3-rasterio+ipython \
 python3-rasterio+plot \
 python3-rasterio+s3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rasterio-1.4.3-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c98191a2c788ce8da47ba5f5472adccc9fdec457132530c3b8f24b390c33a061"

URI_x86_64_v2_python3-rasterio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rasterio-1.4.3-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-rasterio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rasterio}"
SRC_URI[x86_64_v2_python3-rasterio.sha256sum] = "05fa061c88f082faf157ffd894bd7ab910588d634d3754b446476e61e5f89a04"

URI_x86_64_v2_python3-rasterio+ipython = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rasterio+ipython-1.4.3-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-rasterio+ipython;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rasterio+ipython}"
SRC_URI[x86_64_v2_python3-rasterio+ipython.sha256sum] = "0d086d97c802ceddb1bc0b08fffd84c783a0a46c45376bf9dd4cf93297aa8033"

URI_x86_64_v2_python3-rasterio+plot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rasterio+plot-1.4.3-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-rasterio+plot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rasterio+plot}"
SRC_URI[x86_64_v2_python3-rasterio+plot.sha256sum] = "a891aee35f181ac4f995dc04a245ef6f38b17aa3258cf4bc21a329d4b26348ca"

URI_x86_64_v2_python3-rasterio+s3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rasterio+s3-1.4.3-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-rasterio+s3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rasterio+s3}"
SRC_URI[x86_64_v2_python3-rasterio+s3.sha256sum] = "1513a9212d6ccd40e443ab116944c9662a80fcddfb33895f952034a71e8f5d9a"

URI_aarch64_python3-rasterio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rasterio-1.4.3-3.el10_1.aarch64.rpm;name=aarch64_python3-rasterio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rasterio}"
SRC_URI[aarch64_python3-rasterio.sha256sum] = "cfa92fddb79830e8c339c6a0175d916208e657eb99aa736b78f8e08e5e37c362"

URI_aarch64_python3-rasterio+ipython = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rasterio+ipython-1.4.3-3.el10_1.aarch64.rpm;name=aarch64_python3-rasterio+ipython;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rasterio+ipython}"
SRC_URI[aarch64_python3-rasterio+ipython.sha256sum] = "e9bb00c2b72571f17a70d4f7ebd0f88d376c706aea913f02123b2a0b164e6816"

URI_aarch64_python3-rasterio+plot = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rasterio+plot-1.4.3-3.el10_1.aarch64.rpm;name=aarch64_python3-rasterio+plot;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rasterio+plot}"
SRC_URI[aarch64_python3-rasterio+plot.sha256sum] = "e4af621ed72f23cab9170ac3733f649a3d472681128dbd689006dd00707baee2"

URI_aarch64_python3-rasterio+s3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rasterio+s3-1.4.3-3.el10_1.aarch64.rpm;name=aarch64_python3-rasterio+s3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rasterio+s3}"
SRC_URI[aarch64_python3-rasterio+s3.sha256sum] = "c4198cb24ffdf690f93b706a5513852653cbbad6250ac35c11c66e5dd7398de5"

RDEPENDS:python3-rasterio = " \
 gdal-libs \
 glibc \
 libgcc \
 python3 \
 python3-affine \
 python3-attrs \
 python3-certifi \
 python3-click \
 python3-click-plugins \
 python3-cligj \
 python3-numpy \
 python3-pyparsing \
 "
RDEPENDS:python3-rasterio+ipython = " \
 python3 \
 python3-ipython \
 python3-rasterio \
 "
RDEPENDS:python3-rasterio+plot = " \
 python3 \
 python3-matplotlib \
 python3-rasterio \
 "
RDEPENDS:python3-rasterio+s3 = " \
 python3 \
 python3-boto3 \
 python3-rasterio \
 "
