# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXfont2"
PV = "2.0.6"
PR = "7.el10"
PACKAGES = " \
 libXfont2 \
 libXfont2-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libXfont2-2.0.6-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2550c2156646360c80a38c8d78c956e79e6de9dfda2ec80e6413cf991c825780"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXfont2-2.0.6-7.el10.x86_64_v2.rpm;name=x86_64_v2_libXfont2;unpack=0"
SRC_URI[x86_64_v2_libXfont2.sha256sum] = "91b0c6a95b0c42253b97d286bfc2dfc8b9c40a49ec72b3bd56cbb1e5b6bfc84b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libXfont2-devel-2.0.6-7.el10.x86_64_v2.rpm;name=x86_64_v2_libXfont2-devel;unpack=0"
SRC_URI[x86_64_v2_libXfont2-devel.sha256sum] = "9ce95a41be4d351a678bf3f30274e18961926137fcd728daa9070cf71307c91e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXfont2-2.0.6-7.el10.aarch64.rpm;name=aarch64_libXfont2;unpack=0"
SRC_URI[aarch64_libXfont2.sha256sum] = "e138f23f97fc560b6bcfbcd8dc11eff277ec0babd5170ff05b322e470ba46a93"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libXfont2-devel-2.0.6-7.el10.aarch64.rpm;name=aarch64_libXfont2-devel;unpack=0"
SRC_URI[aarch64_libXfont2-devel.sha256sum] = "7435462a58b08c5c88924a7f653dec30db4700f05fecadf8b76160a28be388ab"

RDEPENDS:libXfont2 = " \
 freetype \
 glibc \
 libfontenc \
 zlib-ng-compat \
 "
RDEPENDS:libXfont2-devel = " \
 freetype-devel \
 libXfont2 \
 libfontenc-devel \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 zlib-ng-compat-devel \
 "
