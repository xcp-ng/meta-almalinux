# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-karchive"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-karchive \
 kf6-karchive-devel \
 kf6-karchive-doc \
 kf6-karchive-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-karchive-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af02e8e65163385c8fbc2659d5e710abce1c621c19b9dbb5acdf603ca5282af7"

URI_x86_64_v2_kf6-karchive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-karchive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-karchive}"
SRC_URI[x86_64_v2_kf6-karchive.sha256sum] = "e32aa4e590c25cba21a68c06f9b3ba15a7fc83fb4a81e8e38aae79cc1c60a47b"

URI_x86_64_v2_kf6-karchive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-karchive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-karchive-devel}"
SRC_URI[x86_64_v2_kf6-karchive-devel.sha256sum] = "067dbe9333f0dc871eb46a1e3619fa978bfc20dad9f5b5fc6e672fb783a1686a"

URI_x86_64_v2_kf6-karchive-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-karchive-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-karchive-doc}"
SRC_URI[x86_64_v2_kf6-karchive-doc.sha256sum] = "d3ec7ea67d453d0f935a82a10255fd748e62b34a319d9de0009b720736f63eeb"

URI_x86_64_v2_kf6-karchive-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-karchive-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-karchive-html}"
SRC_URI[x86_64_v2_kf6-karchive-html.sha256sum] = "8b9c51d64a47c8b8503eb886ea8e16598c27755bb7d7cfd5552358743ed02446"

URI_aarch64_kf6-karchive = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-karchive;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-karchive}"
SRC_URI[aarch64_kf6-karchive.sha256sum] = "7a98c4ac9824ed231345faad2e04b78aec96850549f8341072bf430469942d9d"

URI_aarch64_kf6-karchive-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-karchive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-karchive-devel}"
SRC_URI[aarch64_kf6-karchive-devel.sha256sum] = "9357a993a339e5fc6045d9606a4ef435e3934a497bb4194fad0b9d8293605703"

URI_aarch64_kf6-karchive-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-karchive-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-karchive-doc}"
SRC_URI[aarch64_kf6-karchive-doc.sha256sum] = "b632ecc07ee66a6c1c4cedd3ce3b78f858e4afc1cba63d03614d301c00ff45bb"

URI_aarch64_kf6-karchive-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-karchive-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-karchive-html}"
SRC_URI[aarch64_kf6-karchive-html.sha256sum] = "56b4b7ac73d214d6699dd1519de21d33ea75be41f77794750270f307c02ebcb5"

RDEPENDS:kf6-karchive = " \
 bzip2-libs \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libzstd \
 openssl-libs \
 qt6-qtbase \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:kf6-karchive-devel = " \
 cmake-filesystem \
 kf6-karchive \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-karchive-doc = " \
 "
RDEPENDS:kf6-karchive-html = " \
 "
