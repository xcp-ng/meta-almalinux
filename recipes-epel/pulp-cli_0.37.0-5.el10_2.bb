# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pulp-cli"
PV = "0.37.0"
PR = "5.el10_2"
PACKAGES = " \
 pulp-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pulp-cli-0.37.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "130067efea132585b25ebcb12de4c3eb298e3e7cf58bb1183270d1669abb6f68"

URI_x86_64_v2_pulp-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulp-cli-0.37.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pulp-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulp-cli}"
SRC_URI[x86_64_v2_pulp-cli.sha256sum] = "fb644076afcc050f0248e1b973db7d6e6cd8edda09ec9786e0b04c67121681b1"

URI_aarch64_pulp-cli = "${EPEL_MIRROR}/aarch64/Packages/p/pulp-cli-0.37.0-5.el10_2.noarch.rpm;name=aarch64_pulp-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulp-cli}"
SRC_URI[aarch64_pulp-cli.sha256sum] = "231c387cb4b99a5a6f9d2f3c272eba713428cd1e81c37f1c0f54747b86a55394"

RDEPENDS:pulp-cli = " \
 python3 \
 python3-click \
 python3-pulp-glue \
 python3-pyyaml \
 python3-schema \
 python3-tomli-w \
 "
