# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 below \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12c9d0cece83c71f02047127b74ea5ce83f8f24927b6ffc9166e564dda2bc7c8"

URI_x86_64_v2_below = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/below-0.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_below;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_below}"
SRC_URI[x86_64_v2_below.sha256sum] = "c9d27484d942edcb52a9d15353696b71f72a690fb8ece589e670158b639e7af8"

URI_aarch64_below = "${EPEL_MIRROR}/aarch64/Packages/b/below-0.9.0-1.el10_0.aarch64.rpm;name=aarch64_below;unpack=0"
SRC_URI:append = " ${URI_aarch64_below}"
SRC_URI[aarch64_below.sha256sum] = "8de5301dcced6b0312775a379411149a0ee3dc3260a716f9b326673e711f8477"

RDEPENDS:below = " \
 bash \
 elfutils-libelf \
 glibc \
 libgcc \
 libzstd \
 zlib-ng-compat \
 "
