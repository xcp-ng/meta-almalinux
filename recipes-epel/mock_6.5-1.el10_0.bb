# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mock"
PV = "6.5"
PR = "1.el10_0"
PACKAGES = " \
 mock \
 mock-filesystem \
 mock-lvm \
 mock-rpmautospec \
 mock-scm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mock-6.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4133a4185fcb18558a8d7828c324f6e65d68b2554e8aa018217c60a0d161a1b"

URI_x86_64_v2_mock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock}"
SRC_URI[x86_64_v2_mock.sha256sum] = "468bceddb792758ba451945e944fb5ade0c6958d831b9053325a83d39d98b55f"

URI_x86_64_v2_mock-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-filesystem-6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mock-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-filesystem}"
SRC_URI[x86_64_v2_mock-filesystem.sha256sum] = "d5180024c9b140514874afbdffc8a0540d757f29afe66d997c86bda61223c181"

URI_x86_64_v2_mock-lvm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-lvm-6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mock-lvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-lvm}"
SRC_URI[x86_64_v2_mock-lvm.sha256sum] = "215ea87f60979b72253a8f00348b8c27aeba486b8b5dced4de8bf4aeeb8cd2f2"

URI_x86_64_v2_mock-rpmautospec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-rpmautospec-6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mock-rpmautospec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-rpmautospec}"
SRC_URI[x86_64_v2_mock-rpmautospec.sha256sum] = "de0d9aeedb4d4011f50ce7c6fd496d9928d919f02376fdc2cb284ab0d0d2835f"

URI_x86_64_v2_mock-scm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-scm-6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mock-scm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-scm}"
SRC_URI[x86_64_v2_mock-scm.sha256sum] = "3a3da120159f3d3a4f2a0e820c45b2dc1a256b385eb215703e252e0749141bb9"

URI_aarch64_mock = "${EPEL_MIRROR}/aarch64/Packages/m/mock-6.5-1.el10_0.noarch.rpm;name=aarch64_mock;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock}"
SRC_URI[aarch64_mock.sha256sum] = "c1145d8f369a706e4ee4e374181fcfdb738eb05ca0787a63123627dc3e474125"

URI_aarch64_mock-filesystem = "${EPEL_MIRROR}/aarch64/Packages/m/mock-filesystem-6.5-1.el10_0.noarch.rpm;name=aarch64_mock-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-filesystem}"
SRC_URI[aarch64_mock-filesystem.sha256sum] = "319e16b76b5d5a47cb55905eb07b5936ee9153c3989d9a127c952594f96d8a6a"

URI_aarch64_mock-lvm = "${EPEL_MIRROR}/aarch64/Packages/m/mock-lvm-6.5-1.el10_0.noarch.rpm;name=aarch64_mock-lvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-lvm}"
SRC_URI[aarch64_mock-lvm.sha256sum] = "cbe49b9e245c516e9a344f9a7ac3811dffa7dc2c2ff821b69d009e940af4b9c3"

URI_aarch64_mock-rpmautospec = "${EPEL_MIRROR}/aarch64/Packages/m/mock-rpmautospec-6.5-1.el10_0.noarch.rpm;name=aarch64_mock-rpmautospec;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-rpmautospec}"
SRC_URI[aarch64_mock-rpmautospec.sha256sum] = "5ddad846f990d3805ddf6dd72e0d1d0f733a432b89efaae3e1b13c6677b55bca"

URI_aarch64_mock-scm = "${EPEL_MIRROR}/aarch64/Packages/m/mock-scm-6.5-1.el10_0.noarch.rpm;name=aarch64_mock-scm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-scm}"
SRC_URI[aarch64_mock-scm.sha256sum] = "c6d426a9f56895a81854c6aeaccee01e5a436ebd648282dc17e5132dbf41a2e4"

RDEPENDS:mock = " \
 bash \
 createrepo_c \
 mock-core-configs \
 mock-filesystem \
 pigz \
 procps-ng \
 python3 \
 python3-backoff \
 python3-distro \
 python3-jinja2 \
 python3-pyroute2 \
 python3-requests \
 python3-rpm \
 python3-templated-dictionary \
 shadow-utils \
 systemd \
 systemd-container \
 tar \
 usermode \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:mock-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:mock-lvm = " \
 lvm2 \
 mock \
 python3 \
 "
RDEPENDS:mock-rpmautospec = " \
 mock \
 python3 \
 python3-rpmautospec-core \
 "
RDEPENDS:mock-scm = " \
 mock \
 python3 \
 "
