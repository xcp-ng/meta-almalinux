# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet10.0"
PV = "10.0.112"
PR = "1.el10_2"
PACKAGES = " \
 aspnetcore-runtime-10.0 \
 aspnetcore-runtime-dbg-10.0 \
 aspnetcore-targeting-pack-10.0 \
 dotnet-apphost-pack-10.0 \
 dotnet-host \
 dotnet-hostfxr-10.0 \
 dotnet-runtime-10.0 \
 dotnet-runtime-dbg-10.0 \
 dotnet-sdk-10.0 \
 dotnet-sdk-10.0-source-built-artifacts \
 dotnet-sdk-aot-10.0 \
 dotnet-sdk-dbg-10.0 \
 dotnet-targeting-pack-10.0 \
 dotnet-templates-10.0 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet10.0-10.0.112-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b7a3a784b6995aec5f0811af883887c4b3cbeb98e9caf02a0eba535ba646797e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-10.0-10.0.12-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-10.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-runtime-10.0.sha256sum] = "d87b78d3c0d3a784cd89004201ad19642c878a98d6253b3ac770537d1ee20c92"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-10.0-10.0.12-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-10.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-10.0.sha256sum] = "602284963a868a1b04a660407694ea390b6fe60911f82128b410acb01241e6e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-10.0-10.0.12-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-10.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-10.0.sha256sum] = "7431b21768ebe2cf2a94a0c90bca7396ecfaee50c230e6d106ef7992f46747ca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-10.0-10.0.12-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-apphost-pack-10.0.sha256sum] = "4f9c0fb1f8ebf0f3944b4f6d3eebe574fe1994194f279db9e45da1b6464cf1d4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-host-10.0.12-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-host;unpack=0"
SRC_URI[x86_64_v2_dotnet-host.sha256sum] = "04565972b08c99abb94c32b49fa919c7ca7f107a2483514b61c37eab6c822b04"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-10.0-10.0.12-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-hostfxr-10.0.sha256sum] = "7dd14c96532eca2971b7ddc6c853eb5e650bfba0a6a5366aea1de12ada8331f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-10.0-10.0.12-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-runtime-10.0.sha256sum] = "f1e7bd39a8737168d0f6e74903b08e032e5187e04595fb098cbecce79d8b5154"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-10.0-10.0.12-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-10.0.sha256sum] = "a1f2f3f443eeb490a7b4c0d49e2a2ed0cc41a54ff6dcb719474a25eb9b2a3214"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-10.0-10.0.112-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-10.0.sha256sum] = "181a9d7ce1b92a464222a6143f01b04ebb4f2ce0f559650611da5c6a86b5f96f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-10.0-source-built-artifacts-10.0.112-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-10.0-source-built-artifacts;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-10.0-source-built-artifacts.sha256sum] = "057bbb34f5b1e34731e2e8f39e33673c34ea6bed40b6a55f11c702426ac96310"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-aot-10.0-10.0.112-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-aot-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-aot-10.0.sha256sum] = "3c468d4e11ba756ecf2cafed51ee93fcade74c1a182d97a1884675c156a5ef17"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-10.0-10.0.112-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-10.0.sha256sum] = "3b7bd05451a4b12778919867bd426e2dedb25f9dc60adeae2cee451b0a63dbe6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-10.0-10.0.12-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-targeting-pack-10.0.sha256sum] = "a18f23192a40e646bf5b3fe882b0098f2149984b6dd0332b0b289173055eb779"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-10.0-10.0.112-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-templates-10.0.sha256sum] = "4f49c05b800cd49600516ec7ba44e27408c1e1c993c4d8f8139294d8c5143495"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-10.0-10.0.12-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-runtime-10.0;unpack=0"
SRC_URI[aarch64_aspnetcore-runtime-10.0.sha256sum] = "e317e4481221669db5fc8a96792878bee7eee59a9b159c1ef51f9d5ea1fe8c7b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-10.0-10.0.12-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-10.0;unpack=0"
SRC_URI[aarch64_aspnetcore-runtime-dbg-10.0.sha256sum] = "191a8dc7dfcc926f41883a106298838068be723fb61c1b913a7f4f3bf207fc15"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-10.0-10.0.12-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-10.0;unpack=0"
SRC_URI[aarch64_aspnetcore-targeting-pack-10.0.sha256sum] = "1f7245f01c9fdab8d47836b43b1cb5d365178ef230a4e54f8dfb4a0774931cb1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-10.0-10.0.12-1.el10_2.aarch64.rpm;name=aarch64_dotnet-apphost-pack-10.0;unpack=0"
SRC_URI[aarch64_dotnet-apphost-pack-10.0.sha256sum] = "c5b4d8ba06dc90d694f66e10af9a4acb8b0663d56e910a565ca860f90e93c4a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-host-10.0.12-1.el10_2.aarch64.rpm;name=aarch64_dotnet-host;unpack=0"
SRC_URI[aarch64_dotnet-host.sha256sum] = "2b2636ec9d747a9178813874e5fd549ab046417c1c0b0346a6a19cfc340ee276"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-10.0-10.0.12-1.el10_2.aarch64.rpm;name=aarch64_dotnet-hostfxr-10.0;unpack=0"
SRC_URI[aarch64_dotnet-hostfxr-10.0.sha256sum] = "cdf75472bb67e76e9130d0b799184b8e26fce6ed7b217a738154021aa0444a22"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-10.0-10.0.12-1.el10_2.aarch64.rpm;name=aarch64_dotnet-runtime-10.0;unpack=0"
SRC_URI[aarch64_dotnet-runtime-10.0.sha256sum] = "0f6b33155700445e268f6bedbff90efe5be651fe115a911147bbd960585238b6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-10.0-10.0.12-1.el10_2.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-10.0;unpack=0"
SRC_URI[aarch64_dotnet-runtime-dbg-10.0.sha256sum] = "ebec38fe9fdebbbea333079b300e3dfd38b12dc6ed3b9d9854d25d0aeb2fc2ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-10.0-10.0.112-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-10.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-10.0.sha256sum] = "8c7a8fcbd3edf5af5d7f59e0a5bf90759fbb4639d47f15488d1fa5a43f083fdf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-10.0-source-built-artifacts-10.0.112-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-10.0-source-built-artifacts;unpack=0"
SRC_URI[aarch64_dotnet-sdk-10.0-source-built-artifacts.sha256sum] = "e406d76b416dd88643280ebbf42f6c26b985cf693f0060a23f2413d36e73a95e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-aot-10.0-10.0.112-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-aot-10.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-aot-10.0.sha256sum] = "6e41c610e1c9ac857321e8cf4318dbb71a37b2db8b34fe016be11037258f3103"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-10.0-10.0.112-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-10.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-dbg-10.0.sha256sum] = "9952c6f0be1f9c52e645dcfa7c3a16806eb8b58b95d53b081f2fc41f85869072"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-10.0-10.0.12-1.el10_2.aarch64.rpm;name=aarch64_dotnet-targeting-pack-10.0;unpack=0"
SRC_URI[aarch64_dotnet-targeting-pack-10.0.sha256sum] = "8fd3a4297dfe09ecc121f6dfa48e0cffaf2052b90b0c2918c4b7c11bc86f1a6d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-10.0-10.0.112-1.el10_2.aarch64.rpm;name=aarch64_dotnet-templates-10.0;unpack=0"
SRC_URI[aarch64_dotnet-templates-10.0.sha256sum] = "b6438d7ad52b28ff08223b627880dc9dd331b8dd9a6066a02c561fd8035bc76e"

RDEPENDS:aspnetcore-runtime-10.0 = " \
 dotnet-runtime-10.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-10.0 = " \
 aspnetcore-runtime-10.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-10.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-10.0 = " \
 dotnet-host \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-host = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-hostfxr-10.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-10.0 = " \
 dotnet-hostfxr-10.0 \
 glibc \
 libbrotli \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-10.0 = " \
 dotnet-runtime-10.0 \
 "
RDEPENDS:dotnet-sdk-10.0 = " \
 aspnetcore-runtime-10.0 \
 aspnetcore-targeting-pack-10.0 \
 dotnet-apphost-pack-10.0 \
 dotnet-runtime-10.0 \
 dotnet-targeting-pack-10.0 \
 dotnet-templates-10.0 \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-sdk-10.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-aot-10.0 = " \
 brotli-devel \
 clang \
 dotnet-sdk-10.0 \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-devel \
 openssl-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:dotnet-sdk-dbg-10.0 = " \
 dotnet-sdk-10.0 \
 "
RDEPENDS:dotnet-targeting-pack-10.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-10.0 = " \
 dotnet-host \
 "
