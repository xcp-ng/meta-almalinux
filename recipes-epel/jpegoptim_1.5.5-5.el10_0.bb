# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jpegoptim"
PV = "1.5.5"
PR = "5.el10_0"
PACKAGES = " \
 jpegoptim \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/jpegoptim-1.5.5-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bbadd9a8f4d84dc7c1413b9f21208fef1e2a58b5afa15783110f3b36a995a4bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jpegoptim-1.5.5-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jpegoptim;unpack=0"
SRC_URI[x86_64_v2_jpegoptim.sha256sum] = "5d628d983f723d9b6b4a0b0089b06ccbc2ed1d3f64865be5816085c8a7202714"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/jpegoptim-1.5.5-5.el10_0.aarch64.rpm;name=aarch64_jpegoptim;unpack=0"
SRC_URI[aarch64_jpegoptim.sha256sum] = "27b9e5a8b1fd33ee7c598467ea1dab23a2b960eb8faab065f57f5fc7822fc84e"

RDEPENDS:jpegoptim = " \
 glibc \
 libjpeg-turbo \
 "
