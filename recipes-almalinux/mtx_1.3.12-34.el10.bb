# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mtx"
PV = "1.3.12"
PR = "34.el10"
PACKAGES = " \
 mtx \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mtx-1.3.12-34.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b08bf9ff06b646b80715e16229949927f69c97f88971d1873d90433325587e4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mtx-1.3.12-34.el10.x86_64_v2.rpm;name=x86_64_v2_mtx;unpack=0"
SRC_URI[x86_64_v2_mtx.sha256sum] = "1419e4b7bfc45d2289284581bfb600ad30a4fdc1cb4af74713eea7423f65bf91"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mtx-1.3.12-34.el10.aarch64.rpm;name=aarch64_mtx;unpack=0"
SRC_URI[aarch64_mtx.sha256sum] = "bda5668291a3d6bc9a25e7ba7dca6e26b2dcc31a90ed326a9f550da8911813fc"

RDEPENDS:mtx = " \
 glibc \
 "
