# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdu"
PV = "5.29.0"
PR = "1.el10_0"
PACKAGES = " \
 gdu \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gdu-5.29.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d694daf7be0075cca463a8446bb19695e48e3b20c2f5fa38976741e2b272a10a"

URI_x86_64_v2_gdu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdu-5.29.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdu}"
SRC_URI[x86_64_v2_gdu.sha256sum] = "78e867be5153452cec5cc27d247d1a44b4d77351537e67454990db27716d8477"

URI_aarch64_gdu = "${EPEL_MIRROR}/aarch64/Packages/g/gdu-5.29.0-1.el10_0.aarch64.rpm;name=aarch64_gdu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdu}"
SRC_URI[aarch64_gdu.sha256sum] = "1499c0873b0f254703a3c6483be8da183c14e551d74ef46355696b75a50dd8f9"

RDEPENDS:gdu = " \
 glibc \
 "
