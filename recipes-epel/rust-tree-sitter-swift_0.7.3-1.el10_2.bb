# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-swift"
PV = "0.7.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-swift+default-devel \
 rust-tree-sitter-swift-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-swift-0.7.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9c6033ef1574bfb5abd3a09b736179a806d476da433281983c05050e7531c7ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-swift+default-devel-0.7.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-swift+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tree-sitter-swift+default-devel.sha256sum] = "dfc4f2b11aef63b0ed760f4cb1d64be112498823e7538e961598be186a18a25e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-swift-devel-0.7.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-swift-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tree-sitter-swift-devel.sha256sum] = "05c072a7e59d4517b02adfeaab92c5c9463b80dd59e4ad38451b5ac4face4949"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-swift+default-devel-0.7.3-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-swift+default-devel;unpack=0"
SRC_URI[aarch64_rust-tree-sitter-swift+default-devel.sha256sum] = "2b89820c97b1f7f1631a08988ac245e5dd746b9f9c21f3713831b205b2603c62"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-swift-devel-0.7.3-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-swift-devel;unpack=0"
SRC_URI[aarch64_rust-tree-sitter-swift-devel.sha256sum] = "82dc330866de68eaf55927751b68cb223d96ad76ed1c369430be13442c2853e4"

RDEPENDS:rust-tree-sitter-swift+default-devel = " \
 cargo \
 rust-tree-sitter-swift-devel \
 "
RDEPENDS:rust-tree-sitter-swift-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
