# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "samtools"
PV = "1.24"
PR = "2.el10_3"
PACKAGES = " \
 samtools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/samtools-1.24-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e086454541a89b962d6bcd1c654deb55757a630a08662498e487eaeb625208b"

URI_x86_64_v2_samtools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/samtools-1.24-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_samtools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samtools}"
SRC_URI[x86_64_v2_samtools.sha256sum] = "9c008db82980bf13b4cc019cbb39ccdb3b1b485ad798add6a421a5ab9be6f81f"

URI_aarch64_samtools = "${EPEL_MIRROR}/aarch64/Packages/s/samtools-1.24-2.el10_3.aarch64.rpm;name=aarch64_samtools;unpack=0"
SRC_URI:append = " ${URI_aarch64_samtools}"
SRC_URI[aarch64_samtools.sha256sum] = "b05db1181a52b626c9a5573bf0b16fa7c18987ba563c516fb484083765c09e3a"

RDEPENDS:samtools = " \
 glibc \
 htslib \
 ncurses-libs \
 perl-File-Find \
 perl-interpreter \
 python3 \
 zlib-ng-compat \
 "
