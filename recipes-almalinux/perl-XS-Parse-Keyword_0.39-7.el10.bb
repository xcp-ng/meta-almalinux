# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XS-Parse-Keyword"
PV = "0.39"
PR = "7.el10"
PACKAGES = " \
 perl-XS-Parse-Keyword \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-XS-Parse-Keyword-0.39-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbf0d157054eb4f5a57b873ab8a2599e76b7bd3beb145d8eea7d22bdbaa8b63f"

URI_x86_64_v2_perl-XS-Parse-Keyword = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-XS-Parse-Keyword-0.39-7.el10.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Keyword;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Keyword}"
SRC_URI[x86_64_v2_perl-XS-Parse-Keyword.sha256sum] = "5d01f0479e80cbbf6b3a2a7bbbb0a176404367b4c019b5a43c7ef66aa30376c3"

URI_aarch64_perl-XS-Parse-Keyword = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-XS-Parse-Keyword-0.39-7.el10.aarch64.rpm;name=aarch64_perl-XS-Parse-Keyword;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Keyword}"
SRC_URI[aarch64_perl-XS-Parse-Keyword.sha256sum] = "d7d94e3f999c93ad7c2a5a8b86b7296cc4505c692deed26bf4b48de81306c68f"

RDEPENDS:perl-XS-Parse-Keyword = " \
 glibc \
 perl-XS-Parse-Keyword \
 perl-libs \
 "
