# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "txt2regex"
PV = "0.9"
PR = "12.el10_0"
PACKAGES = " \
 txt2regex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/txt2regex-0.9-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2aacadc41b289f6d1dfabea4bb5efaa76c51e67d832c9031d8b1744baa7859f"

URI_x86_64_v2_txt2regex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/txt2regex-0.9-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_txt2regex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_txt2regex}"
SRC_URI[x86_64_v2_txt2regex.sha256sum] = "bf375beac5d5850af7f10ff4a81290441ffeb0cf15938f464693895c1022f4f0"

URI_aarch64_txt2regex = "${EPEL_MIRROR}/aarch64/Packages/t/txt2regex-0.9-12.el10_0.noarch.rpm;name=aarch64_txt2regex;unpack=0"
SRC_URI:append = " ${URI_aarch64_txt2regex}"
SRC_URI[aarch64_txt2regex.sha256sum] = "5b752ceb9aa3d158d6b092b172fa4303f0d720c1f0cc3cdcaeac607ce1cc1768"

RDEPENDS:txt2regex = " \
 bash \
 "
