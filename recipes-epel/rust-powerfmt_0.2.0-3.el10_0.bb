# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-powerfmt"
PV = "0.2.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-powerfmt+alloc-devel \
 rust-powerfmt+default-devel \
 rust-powerfmt+macros-devel \
 rust-powerfmt+std-devel \
 rust-powerfmt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-powerfmt-0.2.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2133011f429d16d5bfd69a8167c652fea48f491505b5d275a83e840dd2de859e"

URI_x86_64_v2_rust-powerfmt+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-powerfmt+alloc-devel-0.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-powerfmt+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-powerfmt+alloc-devel}"
SRC_URI[x86_64_v2_rust-powerfmt+alloc-devel.sha256sum] = "89e3734c5094e8c1e4b6bc4c3abc478a2a7fb29809673be8c7ca25f75d13a7d2"

URI_x86_64_v2_rust-powerfmt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-powerfmt+default-devel-0.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-powerfmt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-powerfmt+default-devel}"
SRC_URI[x86_64_v2_rust-powerfmt+default-devel.sha256sum] = "fe4af001fa1f17e60fe9c3fe19f1e47a8ff2a99a4e14154b9c44a47dee17b712"

URI_x86_64_v2_rust-powerfmt+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-powerfmt+macros-devel-0.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-powerfmt+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-powerfmt+macros-devel}"
SRC_URI[x86_64_v2_rust-powerfmt+macros-devel.sha256sum] = "6217f56e4291171386d806befd6daf0f1ce4542afcb66f3d84d31a2a8b223714"

URI_x86_64_v2_rust-powerfmt+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-powerfmt+std-devel-0.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-powerfmt+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-powerfmt+std-devel}"
SRC_URI[x86_64_v2_rust-powerfmt+std-devel.sha256sum] = "201f46deaba1ea7b340c8d99eded6deff260e437cfdaea7556fbfc59a46e7f43"

URI_x86_64_v2_rust-powerfmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-powerfmt-devel-0.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-powerfmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-powerfmt-devel}"
SRC_URI[x86_64_v2_rust-powerfmt-devel.sha256sum] = "651fc336e3039f53c83fe80b6867555f35a02c7f01d6b1b3f477eae1db1bc8be"

URI_aarch64_rust-powerfmt+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-powerfmt+alloc-devel-0.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-powerfmt+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-powerfmt+alloc-devel}"
SRC_URI[aarch64_rust-powerfmt+alloc-devel.sha256sum] = "2b67b321f4e7b414355da9f79b9d1d851b7c6b230d50e2cbd8b2954b12a94982"

URI_aarch64_rust-powerfmt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-powerfmt+default-devel-0.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-powerfmt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-powerfmt+default-devel}"
SRC_URI[aarch64_rust-powerfmt+default-devel.sha256sum] = "5911e4dd1b67218b2ade933c8066fa6eb011ecd6e1caa5903980da79f9bdadb1"

URI_aarch64_rust-powerfmt+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-powerfmt+macros-devel-0.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-powerfmt+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-powerfmt+macros-devel}"
SRC_URI[aarch64_rust-powerfmt+macros-devel.sha256sum] = "fadc0b59d574587b2f1239ede3c1d5491c8769f24168962eb542824e7b897c6e"

URI_aarch64_rust-powerfmt+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-powerfmt+std-devel-0.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-powerfmt+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-powerfmt+std-devel}"
SRC_URI[aarch64_rust-powerfmt+std-devel.sha256sum] = "6378daf76ded9490d5c1e7967378a686047f8eb32c1497724b745fe4df3ba64c"

URI_aarch64_rust-powerfmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-powerfmt-devel-0.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-powerfmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-powerfmt-devel}"
SRC_URI[aarch64_rust-powerfmt-devel.sha256sum] = "0206ee229f5aff33e58d79d9dddfb66324c0a622911f3a06d087a83ca6ee52a3"

RDEPENDS:rust-powerfmt+alloc-devel = " \
 cargo \
 rust-powerfmt-devel \
 "
RDEPENDS:rust-powerfmt+default-devel = " \
 cargo \
 rust-powerfmt+macros-devel \
 rust-powerfmt+std-devel \
 rust-powerfmt-devel \
 "
RDEPENDS:rust-powerfmt+macros-devel = " \
 cargo \
 rust-powerfmt-devel \
 rust-powerfmt-macros+default-devel \
 "
RDEPENDS:rust-powerfmt+std-devel = " \
 cargo \
 rust-powerfmt+alloc-devel \
 rust-powerfmt-devel \
 "
RDEPENDS:rust-powerfmt-devel = " \
 cargo \
 rust \
 "
