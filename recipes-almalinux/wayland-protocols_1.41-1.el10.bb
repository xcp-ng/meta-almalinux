# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wayland-protocols"
PV = "1.41"
PR = "1.el10"
PACKAGES = " \
 wayland-protocols-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wayland-protocols-1.41-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb9cfe5b4ea80b20543a3d1b72985012b43ba06d6e64ec8dfc0ca686ecfc4d27"

URI_x86_64_v2_wayland-protocols-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wayland-protocols-devel-1.41-1.el10.noarch.rpm;name=x86_64_v2_wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wayland-protocols-devel}"
SRC_URI[x86_64_v2_wayland-protocols-devel.sha256sum] = "756d10f11e7abbbc31f91a8e83d4cf5867b807fd792f7482c5499875f90c817f"

URI_aarch64_wayland-protocols-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wayland-protocols-devel-1.41-1.el10.noarch.rpm;name=aarch64_wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wayland-protocols-devel}"
SRC_URI[aarch64_wayland-protocols-devel.sha256sum] = "756d10f11e7abbbc31f91a8e83d4cf5867b807fd792f7482c5499875f90c817f"

RDEPENDS:wayland-protocols-devel = " \
 pkgconf-pkg-config \
 "
