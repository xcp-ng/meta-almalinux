# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kiconthemes"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kiconthemes \
 kf6-kiconthemes-devel \
 kf6-kiconthemes-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kiconthemes-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3987b2cafc71bf7dfecc22419e777d020eca0ab62c6ef478c54dc9a14df9ce59"

URI_x86_64_v2_kf6-kiconthemes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kiconthemes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kiconthemes}"
SRC_URI[x86_64_v2_kf6-kiconthemes.sha256sum] = "c70afef986a48478574209853405f6751f4e81598b223ab8081480517a9c4938"

URI_x86_64_v2_kf6-kiconthemes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kiconthemes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kiconthemes-devel}"
SRC_URI[x86_64_v2_kf6-kiconthemes-devel.sha256sum] = "45aa9d361c562b738148393c7a491c461a6e0d422ba5050c00cd786c9e610917"

URI_x86_64_v2_kf6-kiconthemes-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kiconthemes-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kiconthemes-doc}"
SRC_URI[x86_64_v2_kf6-kiconthemes-doc.sha256sum] = "ffabb43e46e1706c3fdd334e1f565b29fb7da03dfa7c6cc20d2a4743d95221e7"

URI_aarch64_kf6-kiconthemes = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kiconthemes;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kiconthemes}"
SRC_URI[aarch64_kf6-kiconthemes.sha256sum] = "020330ad571bd0e6a5f2d6d067eae427c6e8578d6611cca0d0ee6681313d4713"

URI_aarch64_kf6-kiconthemes-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kiconthemes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kiconthemes-devel}"
SRC_URI[aarch64_kf6-kiconthemes-devel.sha256sum] = "37c0b85d779aa9a9fd8b010c2e114867a3e4f86e65b7183489711697c994af8a"

URI_aarch64_kf6-kiconthemes-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kiconthemes-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kiconthemes-doc}"
SRC_URI[aarch64_kf6-kiconthemes-doc.sha256sum] = "9216e68c2af2be866d53fe2c802788b348aff3659f81daec4dc093f63db98a8c"

RDEPENDS:kf6-kiconthemes = " \
 glibc \
 hicolor-icon-theme \
 kf6-breeze-icons \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kiconthemes-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kiconthemes \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kiconthemes-doc = " \
 "
