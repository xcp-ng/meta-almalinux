# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gfal2-util"
PV = "1.9.1"
PR = "1.el10_1"
PACKAGES = " \
 gfal2-util-scripts \
 python3-gfal2-util \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gfal2-util-1.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19fa8e5a711e292f37c7ed8bbf6e3094db650ed4502d9c20128c46988cccc8fc"

URI_x86_64_v2_gfal2-util-scripts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-util-scripts-1.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gfal2-util-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-util-scripts}"
SRC_URI[x86_64_v2_gfal2-util-scripts.sha256sum] = "f39e7db659d74fe28f2e6d0d2f9a4e271a27854ad2e421864e25f5b4167583b3"

URI_x86_64_v2_python3-gfal2-util = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gfal2-util-1.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gfal2-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gfal2-util}"
SRC_URI[x86_64_v2_python3-gfal2-util.sha256sum] = "20481dfad406e69c297bcf6c6058dce9c2179ff659e83791767ff0b9cd8d1e0c"

URI_aarch64_gfal2-util-scripts = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-util-scripts-1.9.1-1.el10_1.noarch.rpm;name=aarch64_gfal2-util-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-util-scripts}"
SRC_URI[aarch64_gfal2-util-scripts.sha256sum] = "88ff4e46f6d24ef689021ac705bc7d0ce9ee516ff92a234311b3c5c68be246f8"

URI_aarch64_python3-gfal2-util = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gfal2-util-1.9.1-1.el10_1.noarch.rpm;name=aarch64_python3-gfal2-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gfal2-util}"
SRC_URI[aarch64_python3-gfal2-util.sha256sum] = "a940f0c0861ec1d910704c0871e5158c617407fe3d5b35866891b302d245a2cb"

RDEPENDS:gfal2-util-scripts = " \
 bash \
 python3-gfal2-util \
 "
RDEPENDS:python3-gfal2-util = " \
 gfal2-plugin-file \
 gfal2-util-scripts \
 python3 \
 python3-gfal2 \
 "
