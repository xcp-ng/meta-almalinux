# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Log-Any-Adapter-TAP"
PV = "0.003003"
PR = "19.el10_1"
PACKAGES = " \
 perl-Log-Any-Adapter-TAP \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Log-Any-Adapter-TAP-0.003003-19.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0585720c864cc56bf16fa86eb8b3410b584cfab81bc6134ab68aa1da569c31c"

URI_x86_64_v2_perl-Log-Any-Adapter-TAP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Any-Adapter-TAP-0.003003-19.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Any-Adapter-TAP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Log-Any-Adapter-TAP}"
SRC_URI[x86_64_v2_perl-Log-Any-Adapter-TAP.sha256sum] = "5a07333faaaa2560871d97043031436a5c9c7f9c28eb30e0c583cfc8e935aadb"

URI_aarch64_perl-Log-Any-Adapter-TAP = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Any-Adapter-TAP-0.003003-19.el10_1.noarch.rpm;name=aarch64_perl-Log-Any-Adapter-TAP;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Log-Any-Adapter-TAP}"
SRC_URI[aarch64_perl-Log-Any-Adapter-TAP.sha256sum] = "a5f334178a680951b68d10e40a33e8ec0a59ab22fd0b567e10d1d30e71478a3d"

RDEPENDS:perl-Log-Any-Adapter-TAP = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Log-Any \
 perl-Scalar-List-Utils \
 perl-Try-Tiny \
 perl-libs \
 perl-parent \
 "
