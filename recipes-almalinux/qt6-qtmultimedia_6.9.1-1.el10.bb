# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtmultimedia"
PV = "6.9.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtmultimedia \
 qt6-qtmultimedia-devel \
 qt6-qtmultimedia-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtmultimedia-6.9.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7586226f85d9f6beee8c3e02afd528837a400d5969942f9aa2135e726143849c"

URI_x86_64_v2_qt6-qtmultimedia = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtmultimedia-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmultimedia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmultimedia}"
SRC_URI[x86_64_v2_qt6-qtmultimedia.sha256sum] = "9f6f94c1a4f4c213b3abd22b5812cc289330a7bb3ea35b981d10f6a43cd0f988"

URI_x86_64_v2_qt6-qtmultimedia-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtmultimedia-devel-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmultimedia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmultimedia-devel}"
SRC_URI[x86_64_v2_qt6-qtmultimedia-devel.sha256sum] = "9d9d034914545f4a4ff0e5f66057c4e8c5ea1ff819535f5d3416d66d35f78664"

URI_x86_64_v2_qt6-qtmultimedia-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtmultimedia-examples-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmultimedia-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmultimedia-examples}"
SRC_URI[x86_64_v2_qt6-qtmultimedia-examples.sha256sum] = "918c120b586f58123e8a553f9bbc38d973537b17b6d053e206e57a2f9c12f4f9"

URI_aarch64_qt6-qtmultimedia = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtmultimedia-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtmultimedia;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmultimedia}"
SRC_URI[aarch64_qt6-qtmultimedia.sha256sum] = "00816a38cb2e2d22761c23c5e0b26ab29e4de57a71a217c95d3e9a225f753739"

URI_aarch64_qt6-qtmultimedia-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtmultimedia-devel-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtmultimedia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmultimedia-devel}"
SRC_URI[aarch64_qt6-qtmultimedia-devel.sha256sum] = "8dd9c31de1fd9316ac21917684a84133ec9a76996cb1fcc87c8dbbbe907d2e5a"

URI_aarch64_qt6-qtmultimedia-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtmultimedia-examples-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtmultimedia-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmultimedia-examples}"
SRC_URI[aarch64_qt6-qtmultimedia-examples.sha256sum] = "716cb71008e5ae0ac520389e31a51161cd59fb25725353911e042f54c1ff5ba3"

RDEPENDS:qt6-qtmultimedia = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 libglvnd-egl \
 libstdc++ \
 pulseaudio-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 "
RDEPENDS:qt6-qtmultimedia-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 pulseaudio-libs-devel \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtmultimedia \
 qt6-qtmultimedia-devel \
 "
RDEPENDS:qt6-qtmultimedia-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
