# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kigo"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kigo \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kigo-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a621b596230a451f12e69f5f9e17324db486b161820923dfbfbad99da22d7952"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kigo-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kigo;unpack=0"
SRC_URI[x86_64_v2_kigo.sha256sum] = "49620526bd3961d7cb2b837a1094114de7dd4465d75366c7e7696cce1316d7f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kigo-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kigo;unpack=0"
SRC_URI[aarch64_kigo.sha256sum] = "215d01d2dfb1a3e5fbf99553defa68c38f3cedcc1c9c0ae4ba7a349c038f76ce"

RDEPENDS:kigo = " \
 glibc \
 gnugo \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
