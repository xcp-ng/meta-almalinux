# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nautilus"
PV = "47.6"
PR = "2.el10"
PACKAGES = " \
 nautilus \
 nautilus-devel \
 nautilus-extensions \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nautilus-47.6-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee6fc475a9da87bcdc8e11b947dd681392a24b7bd5f91ff1e9e9b291c2f97a50"

URI_x86_64_v2_nautilus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nautilus-47.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_nautilus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nautilus}"
SRC_URI[x86_64_v2_nautilus.sha256sum] = "5ca7778693b564a08778d6daaad0ff3431b0f90dac093df7e53737ff1f69968e"

URI_x86_64_v2_nautilus-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nautilus-devel-47.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_nautilus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nautilus-devel}"
SRC_URI[x86_64_v2_nautilus-devel.sha256sum] = "295d4e363ce758f1062fa8cef88015111a9f4c3467d5a0110e9e5c139251299d"

URI_x86_64_v2_nautilus-extensions = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nautilus-extensions-47.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_nautilus-extensions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nautilus-extensions}"
SRC_URI[x86_64_v2_nautilus-extensions.sha256sum] = "dad44ae3231176994be355028de971c3993949dd7e4ab2f6e97038a0532df5cd"

URI_aarch64_nautilus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nautilus-47.6-2.el10.aarch64.rpm;name=aarch64_nautilus;unpack=0"
SRC_URI:append = " ${URI_aarch64_nautilus}"
SRC_URI[aarch64_nautilus.sha256sum] = "42916e1236dac8b4444f03b76bc79667f1e966d83aeb50a2613e5ff2152a79e1"

URI_aarch64_nautilus-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nautilus-devel-47.6-2.el10.aarch64.rpm;name=aarch64_nautilus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nautilus-devel}"
SRC_URI[aarch64_nautilus-devel.sha256sum] = "1f2d7059045072b00e24f38a7800173b75d8ddfd7d331647912e22342009412e"

URI_aarch64_nautilus-extensions = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nautilus-extensions-47.6-2.el10.aarch64.rpm;name=aarch64_nautilus-extensions;unpack=0"
SRC_URI:append = " ${URI_aarch64_nautilus-extensions}"
SRC_URI[aarch64_nautilus-extensions.sha256sum] = "b8b4dfd4bc13866720d5a153eb016ad36cd1e165108e7c56d3c061041f491bd8"

RDEPENDS:nautilus = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-autoar \
 gnome-desktop4 \
 graphene \
 gsettings-desktop-schemas \
 gstreamer1 \
 gstreamer1-plugins-base \
 gtk4 \
 gvfs \
 libX11 \
 libadwaita \
 libgcc \
 libgexiv2 \
 libportal \
 libportal-gtk4 \
 libselinux \
 libtracker-sparql \
 libwayland-client \
 nautilus-extensions \
 pango \
 tracker-miners \
 "
RDEPENDS:nautilus-devel = " \
 glib2-devel \
 nautilus \
 nautilus-extensions \
 pkgconf-pkg-config \
 "
RDEPENDS:nautilus-extensions = " \
 glib2 \
 glibc \
 libgcc \
 "
