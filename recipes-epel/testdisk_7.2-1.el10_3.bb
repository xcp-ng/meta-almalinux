# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "testdisk"
PV = "7.2"
PR = "1.el10_3"
PACKAGES = " \
 qphotorec \
 testdisk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/testdisk-7.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69311ffe6001e8da9d71f4ece47eb62199be2638417e57a05444ec51b0bee958"

URI_x86_64_v2_qphotorec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qphotorec-7.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qphotorec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qphotorec}"
SRC_URI[x86_64_v2_qphotorec.sha256sum] = "382d10622bab2133c37b9d2144b6a3db0f0ebdcc0f74e0c5debcdb4a6a8a9752"

URI_x86_64_v2_testdisk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/testdisk-7.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_testdisk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_testdisk}"
SRC_URI[x86_64_v2_testdisk.sha256sum] = "77dd07eecd4000267b96fc1f23947bc971a31e0d5e837eda3cf6c1f3566d6641"

URI_aarch64_qphotorec = "${EPEL_MIRROR}/aarch64/Packages/q/qphotorec-7.2-1.el10_3.aarch64.rpm;name=aarch64_qphotorec;unpack=0"
SRC_URI:append = " ${URI_aarch64_qphotorec}"
SRC_URI[aarch64_qphotorec.sha256sum] = "643e16e6a9a970976a111250c9632904bb01e7acc5078f11b87395615b1db6ee"

URI_aarch64_testdisk = "${EPEL_MIRROR}/aarch64/Packages/t/testdisk-7.2-1.el10_3.aarch64.rpm;name=aarch64_testdisk;unpack=0"
SRC_URI:append = " ${URI_aarch64_testdisk}"
SRC_URI[aarch64_testdisk.sha256sum] = "bb3acf5888afbedbf775e13d4186ce530af8c798d943be72cde021e7c21a4edb"

RDEPENDS:qphotorec = " \
 e2fsprogs-libs \
 glibc \
 libewf \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 ntfs-3g-libs \
 qt5-qtbase \
 qt5-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:testdisk = " \
 e2fsprogs-libs \
 glibc \
 libewf \
 libjpeg-turbo \
 ncurses-libs \
 ntfs-3g-libs \
 zlib-ng-compat \
 "
