# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cfg_aliases"
PV = "0.2.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-cfg_aliases+default-devel \
 rust-cfg_aliases-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cfg_aliases-0.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebba81f7803215a854abd6b9b1382b4aef11d201e55ba95edf65bdd3ae4f3d17"

URI_x86_64_v2_rust-cfg_aliases+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg_aliases+default-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg_aliases+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg_aliases+default-devel}"
SRC_URI[x86_64_v2_rust-cfg_aliases+default-devel.sha256sum] = "2ab30b620d1de898b5ee79e2f0ab10b55b0ca98be7e8ff6a8c05dda116f7a739"

URI_x86_64_v2_rust-cfg_aliases-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg_aliases-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg_aliases-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg_aliases-devel}"
SRC_URI[x86_64_v2_rust-cfg_aliases-devel.sha256sum] = "17db859d602bef90fe3242bb504b07c2b7a26044d012644c1a7853ca51ba1e2a"

URI_aarch64_rust-cfg_aliases+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg_aliases+default-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-cfg_aliases+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg_aliases+default-devel}"
SRC_URI[aarch64_rust-cfg_aliases+default-devel.sha256sum] = "f28f53c7cefa461f56e14a62a1b544da8b1f2f280c1fc2544358a6d695ba7841"

URI_aarch64_rust-cfg_aliases-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg_aliases-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-cfg_aliases-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg_aliases-devel}"
SRC_URI[aarch64_rust-cfg_aliases-devel.sha256sum] = "836176c3c6342bdff5c067fc3a39be841a8f940e76e81f80abd05feceaecb831"

RDEPENDS:rust-cfg_aliases+default-devel = " \
 cargo \
 rust-cfg_aliases-devel \
 "
RDEPENDS:rust-cfg_aliases-devel = " \
 cargo \
 "
