# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_split"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_split+default-devel \
 rust-uu_split-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_split-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8f81ece9579e7dc26590d195a0e04ae437a94811da72b1af4914f159671c93e"

URI_x86_64_v2_rust-uu_split+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_split+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_split+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_split+default-devel}"
SRC_URI[x86_64_v2_rust-uu_split+default-devel.sha256sum] = "f750ae1711b8b50fed52adb8f75faf28f58da76790fd3c1bff8562d55e549042"

URI_x86_64_v2_rust-uu_split-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_split-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_split-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_split-devel}"
SRC_URI[x86_64_v2_rust-uu_split-devel.sha256sum] = "133febe803d258da7426b7c92e72e7ea1fd5d4a1eb1b069dda06fbeee9f8ef5e"

URI_aarch64_rust-uu_split+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_split+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_split+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_split+default-devel}"
SRC_URI[aarch64_rust-uu_split+default-devel.sha256sum] = "a1aa04a8e10ca69d293143a0c5063fb7b5b63ebb1938dd41472a82d5e2f35ae7"

URI_aarch64_rust-uu_split-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_split-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_split-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_split-devel}"
SRC_URI[aarch64_rust-uu_split-devel.sha256sum] = "9e429ff2e990a6af0b68713335d6a05da3bd5eae1ccfe4535bf1344163d7087e"

RDEPENDS:rust-uu_split+default-devel = " \
 cargo \
 rust-uu_split-devel \
 "
RDEPENDS:rust-uu_split-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-memchr+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 rust-uucore+parser-size-devel \
 "
