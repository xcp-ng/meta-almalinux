# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-empy"
PV = "4.2.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-empy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-empy-4.2.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e80298e94476674f53d95198db5e496c27135f647988b8e7d221f8e24960071c"

URI_x86_64_v2_python3-empy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-empy-4.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-empy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-empy}"
SRC_URI[x86_64_v2_python3-empy.sha256sum] = "c59ec357440c3fd6a54b9514003447fe83497a510037517641ab0625915b62ae"

URI_aarch64_python3-empy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-empy-4.2.1-1.el10_1.noarch.rpm;name=aarch64_python3-empy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-empy}"
SRC_URI[aarch64_python3-empy.sha256sum] = "c0deb69e27f35021e37876454962c675df83fe3b3cda88f6b7511e825642b64b"

RDEPENDS:python3-empy = " \
 python3 \
 "
