# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-setuptools-git-versioning"
PV = "2.1.0"
PR = "16.el10_2"
PACKAGES = " \
 python3-setuptools-git-versioning \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-setuptools-git-versioning-2.1.0-16.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b662ccb527fd8806b77607e238c04fc24cf309995907f0015498a885ea87a334"

URI_x86_64_v2_python3-setuptools-git-versioning = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-setuptools-git-versioning-2.1.0-16.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-setuptools-git-versioning;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-setuptools-git-versioning}"
SRC_URI[x86_64_v2_python3-setuptools-git-versioning.sha256sum] = "d20561864e45799542ee98dae1acd93fa3ac2d3ee1059fb4af1ef96209b0a496"

URI_aarch64_python3-setuptools-git-versioning = "${EPEL_MIRROR}/aarch64/Packages/p/python3-setuptools-git-versioning-2.1.0-16.el10_2.noarch.rpm;name=aarch64_python3-setuptools-git-versioning;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-setuptools-git-versioning}"
SRC_URI[aarch64_python3-setuptools-git-versioning.sha256sum] = "7bb58faf5f0e1b6ecb68eec92169b9d09b4a7fcda22fbaad9d51e31f46caf170"

RDEPENDS:python3-setuptools-git-versioning = " \
 python3 \
 python3-packaging \
 python3-setuptools \
 "
