# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-packager"
PV = "0.6.0.7"
PR = "11.el10_0"
PACKAGES = " \
 fedora-packager \
 fedora-packager-kerberos \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-packager-0.6.0.7-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cf22ee8ecac32eee8a0a39cc1bd20432f9a882049c5f3caa728aeb9fc5dbbee"

URI_x86_64_v2_fedora-packager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-packager-0.6.0.7-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-packager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-packager}"
SRC_URI[x86_64_v2_fedora-packager.sha256sum] = "3d8145e7892cbe5a43463a1f30231e138c9884c6b1c7ef02cbbde52bec8a8f84"

URI_x86_64_v2_fedora-packager-kerberos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-packager-kerberos-0.6.0.7-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-packager-kerberos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-packager-kerberos}"
SRC_URI[x86_64_v2_fedora-packager-kerberos.sha256sum] = "002d8e41c9fa403f970bced35a0750ad6d629f29fab17054eeec91d0071ed135"

URI_aarch64_fedora-packager = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-packager-0.6.0.7-11.el10_0.noarch.rpm;name=aarch64_fedora-packager;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-packager}"
SRC_URI[aarch64_fedora-packager.sha256sum] = "9755c5ae84f2fcfbd4351e6d476a036160f1a1824c168c7cf055446355a07d1c"

URI_aarch64_fedora-packager-kerberos = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-packager-kerberos-0.6.0.7-11.el10_0.noarch.rpm;name=aarch64_fedora-packager-kerberos;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-packager-kerberos}"
SRC_URI[aarch64_fedora-packager-kerberos.sha256sum] = "286927445bc59a94320e1902b3f2ec05bd72662dbc67ab6eb5cb109a18b53440"

RDEPENDS:fedora-packager = " \
 bash \
 bodhi-client \
 curl \
 fedpkg \
 koji \
 mock \
 openssh-clients \
 python3 \
 redhat-rpm-config \
 rpm-build \
 rpmautospec \
 rpmdevtools \
 rpmlint \
 "
RDEPENDS:fedora-packager-kerberos = " \
 bash \
 krb5-pkinit \
 krb5-workstation \
 "
