# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hwdata"
PV = "0.379"
PR = "10.8.el10"
PACKAGES = " \
 hwdata \
 hwdata-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/hwdata-0.379-10.8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9741b9d82edf82cfe1b7d11e123878c1f489314f838843c9c9bcc66148fe5554"

URI_x86_64_v2_hwdata = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/hwdata-0.379-10.8.el10.noarch.rpm;name=x86_64_v2_hwdata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hwdata}"
SRC_URI[x86_64_v2_hwdata.sha256sum] = "2ca362ecf3c57377c8a1b10b161a901b8f3504f5dfe03b2417578b7897825c8c"

URI_x86_64_v2_hwdata-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/hwdata-devel-0.379-10.8.el10.noarch.rpm;name=x86_64_v2_hwdata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hwdata-devel}"
SRC_URI[x86_64_v2_hwdata-devel.sha256sum] = "329dcdab85a0d812e566dcd501f8b266684f65cd7b205fa86e492ee4ed00a229"

URI_aarch64_hwdata = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/hwdata-0.379-10.8.el10.noarch.rpm;name=aarch64_hwdata;unpack=0"
SRC_URI:append = " ${URI_aarch64_hwdata}"
SRC_URI[aarch64_hwdata.sha256sum] = "2ca362ecf3c57377c8a1b10b161a901b8f3504f5dfe03b2417578b7897825c8c"

URI_aarch64_hwdata-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/hwdata-devel-0.379-10.8.el10.noarch.rpm;name=aarch64_hwdata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hwdata-devel}"
SRC_URI[aarch64_hwdata-devel.sha256sum] = "329dcdab85a0d812e566dcd501f8b266684f65cd7b205fa86e492ee4ed00a229"

RDEPENDS:hwdata = " \
 "
RDEPENDS:hwdata-devel = " \
 hwdata \
 pkgconf-pkg-config \
 "
