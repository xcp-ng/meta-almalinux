# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lv2-midi"
PV = "1.2.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-lv2-midi+default-devel \
 rust-lv2-midi+wmidi-devel \
 rust-lv2-midi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lv2-midi-1.2.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1dc30c9229c171c74a9495f1b3965dc22c746734a137f4b31df0b8779b2219a"

URI_x86_64_v2_rust-lv2-midi+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-midi+default-devel-1.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-midi+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-midi+default-devel}"
SRC_URI[x86_64_v2_rust-lv2-midi+default-devel.sha256sum] = "ecf75d027864587ea8775eee22d1f39ff05f7b98047b27a0f64b8f7ba08401af"

URI_x86_64_v2_rust-lv2-midi+wmidi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-midi+wmidi-devel-1.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-midi+wmidi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-midi+wmidi-devel}"
SRC_URI[x86_64_v2_rust-lv2-midi+wmidi-devel.sha256sum] = "61392532728c1409efd1f1524057c7acb131a83438ffb36da6f1e055f5dde9b3"

URI_x86_64_v2_rust-lv2-midi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-midi-devel-1.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-midi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-midi-devel}"
SRC_URI[x86_64_v2_rust-lv2-midi-devel.sha256sum] = "fce7926bba2c07b5e9ef145a4dfd572fcc20ae9ccad2f5248b5818a89ef3aa86"

URI_aarch64_rust-lv2-midi+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-midi+default-devel-1.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2-midi+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-midi+default-devel}"
SRC_URI[aarch64_rust-lv2-midi+default-devel.sha256sum] = "e769f1b6676e880c3e7d6bf3a773e8c1152938afc302585ce5dec5395a80c411"

URI_aarch64_rust-lv2-midi+wmidi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-midi+wmidi-devel-1.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2-midi+wmidi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-midi+wmidi-devel}"
SRC_URI[aarch64_rust-lv2-midi+wmidi-devel.sha256sum] = "4156ad1a6257d79f10fc097046310999c73ac6161bd5b9824a1becb19f698871"

URI_aarch64_rust-lv2-midi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-midi-devel-1.2.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2-midi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-midi-devel}"
SRC_URI[aarch64_rust-lv2-midi-devel.sha256sum] = "2f3ca6d4c537c388271fff5ab99eb8690e0eea1883ec285dc146f2f3ce9b41b8"

RDEPENDS:rust-lv2-midi+default-devel = " \
 cargo \
 rust-lv2-midi-devel \
 "
RDEPENDS:rust-lv2-midi+wmidi-devel = " \
 cargo \
 rust-lv2-midi-devel \
 rust-wmidi+default-devel \
 "
RDEPENDS:rust-lv2-midi-devel = " \
 cargo \
 rust-lv2-atom+default-devel \
 rust-lv2-sys+default-devel \
 rust-urid+default-devel \
 "
