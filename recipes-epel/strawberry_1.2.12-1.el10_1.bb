# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "strawberry"
PV = "1.2.12"
PR = "1.el10_1"
PACKAGES = " \
 strawberry \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/strawberry-1.2.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88a2c591d560081cc0941a4b37e072718d9f1abf0253a0ffce02b12b6dc9bafa"

URI_x86_64_v2_strawberry = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/strawberry-1.2.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_strawberry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_strawberry}"
SRC_URI[x86_64_v2_strawberry.sha256sum] = "454826fd3cc3575736411e3154dec7bc38eaf965de4e57bd042281379f7cb29b"

URI_aarch64_strawberry = "${EPEL_MIRROR}/aarch64/Packages/s/strawberry-1.2.12-1.el10_1.aarch64.rpm;name=aarch64_strawberry;unpack=0"
SRC_URI:append = " ${URI_aarch64_strawberry}"
SRC_URI[aarch64_strawberry.sha256sum] = "d124bc3d1e441b16417f6f3d748c8669b55846e8863ad46207e4a4e3ba89adc4"

RDEPENDS:strawberry = " \
 alsa-lib \
 fftw-libs-double \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gstreamer1-plugins-good \
 hicolor-icon-theme \
 kdsingleapplication-qt6 \
 libX11 \
 libcdio \
 libchromaprint \
 libebur128 \
 libgcc \
 libicu \
 libmtp \
 libstdc++ \
 pulseaudio-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 sqlite-libs \
 taglib \
 "
