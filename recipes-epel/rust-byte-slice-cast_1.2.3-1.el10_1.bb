# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-byte-slice-cast"
PV = "1.2.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-byte-slice-cast+default-devel \
 rust-byte-slice-cast+std-devel \
 rust-byte-slice-cast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-byte-slice-cast-1.2.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aea6e5676523816a7492e9e8464e86f631f1ea76185e76380499341a9bb2e4b6"

URI_x86_64_v2_rust-byte-slice-cast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-slice-cast+default-devel-1.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-slice-cast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-slice-cast+default-devel}"
SRC_URI[x86_64_v2_rust-byte-slice-cast+default-devel.sha256sum] = "f926ea32f553494fb4290878e27cc302ca513d67008842bd3bc5d54b4e06ccfa"

URI_x86_64_v2_rust-byte-slice-cast+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-slice-cast+std-devel-1.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-slice-cast+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-slice-cast+std-devel}"
SRC_URI[x86_64_v2_rust-byte-slice-cast+std-devel.sha256sum] = "1aaa58614e39672d9a510c767433d7c56c8ff240f679a6832f7ef7849ca312e9"

URI_x86_64_v2_rust-byte-slice-cast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-slice-cast-devel-1.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-slice-cast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-slice-cast-devel}"
SRC_URI[x86_64_v2_rust-byte-slice-cast-devel.sha256sum] = "0705bfa33a942b1cd430d9ac1aed80ef47f2a40446632814761c32ed6cebb47c"

URI_aarch64_rust-byte-slice-cast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-slice-cast+default-devel-1.2.3-1.el10_1.noarch.rpm;name=aarch64_rust-byte-slice-cast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-slice-cast+default-devel}"
SRC_URI[aarch64_rust-byte-slice-cast+default-devel.sha256sum] = "198ba314fc8b4d7cb8f2f675f45d7928e56f19d279fbe5ed46f5d5d69d500922"

URI_aarch64_rust-byte-slice-cast+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-slice-cast+std-devel-1.2.3-1.el10_1.noarch.rpm;name=aarch64_rust-byte-slice-cast+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-slice-cast+std-devel}"
SRC_URI[aarch64_rust-byte-slice-cast+std-devel.sha256sum] = "4a32082b73cf902f2ddea5543e0adaf2aea10148b0691b6e8f1f334408778345"

URI_aarch64_rust-byte-slice-cast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-slice-cast-devel-1.2.3-1.el10_1.noarch.rpm;name=aarch64_rust-byte-slice-cast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-slice-cast-devel}"
SRC_URI[aarch64_rust-byte-slice-cast-devel.sha256sum] = "7f5e51bddc04c83435e66cb74fbe2a9e3d7f4ec19ef4b8ce3122559e8377b9f2"

RDEPENDS:rust-byte-slice-cast+default-devel = " \
 cargo \
 rust-byte-slice-cast+std-devel \
 rust-byte-slice-cast-devel \
 "
RDEPENDS:rust-byte-slice-cast+std-devel = " \
 cargo \
 rust-byte-slice-cast-devel \
 "
RDEPENDS:rust-byte-slice-cast-devel = " \
 cargo \
 rust \
 "
