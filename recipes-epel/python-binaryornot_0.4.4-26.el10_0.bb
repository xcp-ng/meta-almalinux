# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-binaryornot"
PV = "0.4.4"
PR = "26.el10_0"
PACKAGES = " \
 python-binaryornot-docs \
 python3-binaryornot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-binaryornot-0.4.4-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa7762cc04edee0460c7778824fda00b7ce81204d9d018d1b0e93f4ed6558ff8"

URI_x86_64_v2_python-binaryornot-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-binaryornot-docs-0.4.4-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-binaryornot-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-binaryornot-docs}"
SRC_URI[x86_64_v2_python-binaryornot-docs.sha256sum] = "97c3357caec33ee2c2db6f5274d396f9cbb33fdb21fd505c547aaf0afe329277"

URI_x86_64_v2_python3-binaryornot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-binaryornot-0.4.4-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-binaryornot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-binaryornot}"
SRC_URI[x86_64_v2_python3-binaryornot.sha256sum] = "fe94eaad9092e2989e52ade2a4faabd7f6ed39cbfcde85e5f14b3a736c514e26"

URI_aarch64_python-binaryornot-docs = "${EPEL_MIRROR}/aarch64/Packages/p/python-binaryornot-docs-0.4.4-26.el10_0.noarch.rpm;name=aarch64_python-binaryornot-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-binaryornot-docs}"
SRC_URI[aarch64_python-binaryornot-docs.sha256sum] = "d0395d8d21a21670b2afc6499e6f29dd8b8a64fe056f2b6cbee2dbbd1bb93445"

URI_aarch64_python3-binaryornot = "${EPEL_MIRROR}/aarch64/Packages/p/python3-binaryornot-0.4.4-26.el10_0.noarch.rpm;name=aarch64_python3-binaryornot;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-binaryornot}"
SRC_URI[aarch64_python3-binaryornot.sha256sum] = "7e4d2e88bdf58825ff0b2ca9d1b3f3ec555e6faf066c383ed3e0435b1a980ff0"

RDEPENDS:python-binaryornot-docs = " \
 "
RDEPENDS:python3-binaryornot = " \
 python3 \
 python3-chardet \
 "
