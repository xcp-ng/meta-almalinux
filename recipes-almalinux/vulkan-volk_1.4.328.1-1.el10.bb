# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-volk"
PV = "1.4.328.1"
PR = "1.el10"
PACKAGES = " \
 vulkan-volk-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-volk-1.4.328.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2495ce59e3fdec5a9ce565579335a3e1efd85a19156d979a9dbffa8cd2b682f"

URI_x86_64_v2_vulkan-volk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-volk-devel-1.4.328.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-volk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-volk-devel}"
SRC_URI[x86_64_v2_vulkan-volk-devel.sha256sum] = "475cea23c87f774fc015f7bddefac5b7afc19d130d55d125f9f8e54364e36a76"

URI_aarch64_vulkan-volk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-volk-devel-1.4.328.1-1.el10.aarch64.rpm;name=aarch64_vulkan-volk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-volk-devel}"
SRC_URI[aarch64_vulkan-volk-devel.sha256sum] = "e203aef197b4243ebe5b2ac0220e884aec9d3682679c93a0b69b923e08f099b8"

RDEPENDS:vulkan-volk-devel = " \
 cmake-filesystem \
 vulkan-headers \
 "
