# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "prrte"
PV = "3.0.6"
PR = "4.el10"
PACKAGES = " \
 prrte \
 prrte-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/prrte-3.0.6-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "52f612e538126a6facdf39f09204c5556f5986e76dfbc0189d69f7f79efc74ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/prrte-3.0.6-4.el10.x86_64_v2.rpm;name=x86_64_v2_prrte;unpack=0"
SRC_URI[x86_64_v2_prrte.sha256sum] = "dfd7a882d036e87a24227f81eb37d44a9b63531c1cf7d2841f95c3bb4873f5a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/prrte-libs-3.0.6-4.el10.x86_64_v2.rpm;name=x86_64_v2_prrte-libs;unpack=0"
SRC_URI[x86_64_v2_prrte-libs.sha256sum] = "05756bb6168f64e22f4aef29b74372fb2c86d2574a4bc30f35303453cc7ef9a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/prrte-3.0.6-4.el10.aarch64.rpm;name=aarch64_prrte;unpack=0"
SRC_URI[aarch64_prrte.sha256sum] = "6d81e0c6e4bcb2d405a913105fa311f35afcdc6973fe7adad61cd4431c64829b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/prrte-libs-3.0.6-4.el10.aarch64.rpm;name=aarch64_prrte-libs;unpack=0"
SRC_URI[aarch64_prrte-libs.sha256sum] = "a795f555c4c1e77bdaf14f8dbcf5bdd2800bfc9c68a81f6c3f2eb64ace7d838a"

RDEPENDS:prrte = " \
 glibc \
 hwloc-libs \
 libevent \
 pmix \
 prrte-libs \
 "
RDEPENDS:prrte-libs = " \
 glibc \
 hwloc-libs \
 libevent \
 pmix \
 torque-libs \
 "
