# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "delve"
PV = "1.26.1"
PR = "2.el10_2"
PACKAGES = " \
 delve \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/delve-1.26.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61c7d565cec54c686b3a31791f73efc17def23570a12e31210795df1167f6605"

URI_x86_64_v2_delve = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/delve-1.26.1-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_delve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_delve}"
SRC_URI[x86_64_v2_delve.sha256sum] = "21157dd5c4d83a5c48d60bdb15a068277598c490870ebc319d08546f8bb3537c"

URI_aarch64_delve = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/delve-1.26.1-2.el10_2.aarch64.rpm;name=aarch64_delve;unpack=0"
SRC_URI:append = " ${URI_aarch64_delve}"
SRC_URI[aarch64_delve.sha256sum] = "20bb45812227a04090387bcbf186c820834fbb8e90bd1b9dbb65f7840b8bd983"

RDEPENDS:delve = " \
 glibc \
 "
