# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "v-hacd"
PV = "4.1.0"
PR = "15.el10_3"
PACKAGES = " \
 v-hacd-devel \
 v-hacd-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/v-hacd-4.1.0-15.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "feb18072b163385ab197d8753913a9a529cbfd06afd0caf1fec0511dd94a5af0"

URI_x86_64_v2_v-hacd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/v-hacd-devel-4.1.0-15.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_v-hacd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_v-hacd-devel}"
SRC_URI[x86_64_v2_v-hacd-devel.sha256sum] = "6dd1ef1ec8f975378a1e3efba5bae33e0d25d1d7ecf27b53081c89439455ac3a"

URI_x86_64_v2_v-hacd-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/v-hacd-tools-4.1.0-15.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_v-hacd-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_v-hacd-tools}"
SRC_URI[x86_64_v2_v-hacd-tools.sha256sum] = "a80e3782a461cd5e02689416a828f79270825f47d98a34b266d2f2f913705593"

URI_aarch64_v-hacd-devel = "${EPEL_MIRROR}/aarch64/Packages/v/v-hacd-devel-4.1.0-15.el10_3.noarch.rpm;name=aarch64_v-hacd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_v-hacd-devel}"
SRC_URI[aarch64_v-hacd-devel.sha256sum] = "cef89fff74a57cf1d2141c242e6279ee55daed37d64aec4abe3e758dc6b2fecc"

URI_aarch64_v-hacd-tools = "${EPEL_MIRROR}/aarch64/Packages/v/v-hacd-tools-4.1.0-15.el10_3.aarch64.rpm;name=aarch64_v-hacd-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_v-hacd-tools}"
SRC_URI[aarch64_v-hacd-tools.sha256sum] = "8e5b6e1cccad519a2bf773c9f7ef348d34399584e0f07c1b0a1a6f3ed7db549f"

RDEPENDS:v-hacd-devel = " \
 "
RDEPENDS:v-hacd-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 "
