# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Ima-DBI"
PV = "0.35"
PR = "52.el10_2"
PACKAGES = " \
 perl-Ima-DBI \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Ima-DBI-0.35-52.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d598481c070ea800c96247971ed0e9a9fd96617f51ea7b6b4764035075ff7f61"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Ima-DBI-0.35-52.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Ima-DBI;unpack=0"
SRC_URI[x86_64_v2_perl-Ima-DBI.sha256sum] = "0a11837d16b9e887ad24ee22850554ee1c620dfd742b9b140688c7a899caf91f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Ima-DBI-0.35-52.el10_2.noarch.rpm;name=aarch64_perl-Ima-DBI;unpack=0"
SRC_URI[aarch64_perl-Ima-DBI.sha256sum] = "1686bd02f0b34964edb72e6528e8c75dc08533eca9d4d2b2d596e29de59ff9e5"

RDEPENDS:perl-Ima-DBI = " \
 perl-Carp \
 perl-Class-Data-Inheritable \
 perl-DBI \
 perl-DBIx-ContextualFetch \
 perl-base \
 perl-libs \
 "
