# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mediainfo"
PV = "25.04"
PR = "1.el10_1"
PACKAGES = " \
 mediainfo \
 mediainfo-gui \
 mediainfo-qt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mediainfo-25.04-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b1db864d919f6cfd1fe18e5f52a9bdacb740f10ae710156aa1933e926a946a1"

URI_x86_64_v2_mediainfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mediainfo-25.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mediainfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mediainfo}"
SRC_URI[x86_64_v2_mediainfo.sha256sum] = "45889b688e705fe6a7273ced74a6f539d2ae648de21d6a4d64a149b8dea1eb1e"

URI_x86_64_v2_mediainfo-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mediainfo-gui-25.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mediainfo-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mediainfo-gui}"
SRC_URI[x86_64_v2_mediainfo-gui.sha256sum] = "764a74e85350362b53d58d39b7f2ed4323fffae32435ad615aa312126a8c3b53"

URI_x86_64_v2_mediainfo-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mediainfo-qt-25.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mediainfo-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mediainfo-qt}"
SRC_URI[x86_64_v2_mediainfo-qt.sha256sum] = "8517d9f54ec9879c773b1063163de89b5070e15b6b9fddbd2a1ac86d9a3acbd5"

URI_aarch64_mediainfo = "${EPEL_MIRROR}/aarch64/Packages/m/mediainfo-25.04-1.el10_1.aarch64.rpm;name=aarch64_mediainfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_mediainfo}"
SRC_URI[aarch64_mediainfo.sha256sum] = "ac4a336a993f6c3b102aa90c89fd61af93ac310a936481b9d588b75fe6bc39e0"

URI_aarch64_mediainfo-gui = "${EPEL_MIRROR}/aarch64/Packages/m/mediainfo-gui-25.04-1.el10_1.aarch64.rpm;name=aarch64_mediainfo-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_mediainfo-gui}"
SRC_URI[aarch64_mediainfo-gui.sha256sum] = "3bb815775dead71ebeaaac71bd36b91523923b3727ec9b69d62fc68364dddb9f"

URI_aarch64_mediainfo-qt = "${EPEL_MIRROR}/aarch64/Packages/m/mediainfo-qt-25.04-1.el10_1.aarch64.rpm;name=aarch64_mediainfo-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_mediainfo-qt}"
SRC_URI[aarch64_mediainfo-qt.sha256sum] = "38f2cad1ab6359acebbbfc2841ec710e7285482c73f98c22623459dbadfdcd74"

RDEPENDS:mediainfo = " \
 glibc \
 libgcc \
 libmediainfo \
 libstdc++ \
 libzen \
 "
RDEPENDS:mediainfo-gui = " \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libmediainfo \
 libstdc++ \
 libzen \
 wxBase \
 wxGTK \
 "
RDEPENDS:mediainfo-qt = " \
 glibc \
 libgcc \
 libmediainfo \
 libstdc++ \
 libzen \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
