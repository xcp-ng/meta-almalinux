# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-object"
PV = "0.37.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-object+all-devel \
 rust-object+archive-devel \
 rust-object+build-devel \
 rust-object+build_core-devel \
 rust-object+cargo-all-devel \
 rust-object+coff-devel \
 rust-object+compression-devel \
 rust-object+default-devel \
 rust-object+doc-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+read-devel \
 rust-object+read_core-devel \
 rust-object+std-devel \
 rust-object+unaligned-devel \
 rust-object+unstable-all-devel \
 rust-object+unstable-devel \
 rust-object+write-devel \
 rust-object+write_core-devel \
 rust-object+write_std-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-object-0.37.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "199aca92562a596690b28e49f89703667e80583c4a3347b5060fb1ee416ef181"

URI_x86_64_v2_rust-object+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+all-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+all-devel}"
SRC_URI[x86_64_v2_rust-object+all-devel.sha256sum] = "43b103ccd46439f97dcd07bb73fcd767161a4bd17029cf0fc480b4812069fb47"

URI_x86_64_v2_rust-object+archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+archive-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+archive-devel}"
SRC_URI[x86_64_v2_rust-object+archive-devel.sha256sum] = "a87f552889aee09e7faf99dbec11b01c22ae57512cc53b6825213dcd18cd5c1a"

URI_x86_64_v2_rust-object+build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+build-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+build-devel}"
SRC_URI[x86_64_v2_rust-object+build-devel.sha256sum] = "df37d03d469cfcd63f955dccc14342c3f706353b70b73a9addccff5abb637ad0"

URI_x86_64_v2_rust-object+build_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+build_core-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+build_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+build_core-devel}"
SRC_URI[x86_64_v2_rust-object+build_core-devel.sha256sum] = "fb682515e1ca2cea654d385ab204808e8b7ce04a7b8e3fb0780e1519a5a017f6"

URI_x86_64_v2_rust-object+cargo-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+cargo-all-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+cargo-all-devel}"
SRC_URI[x86_64_v2_rust-object+cargo-all-devel.sha256sum] = "c2e4da22e02f77101b2336bbe7ec40bfe652db1dd1bdf5046f89110c01c0b985"

URI_x86_64_v2_rust-object+coff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+coff-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+coff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+coff-devel}"
SRC_URI[x86_64_v2_rust-object+coff-devel.sha256sum] = "e8ac4593d8d001c7d09559a6b4b584912fc7f530fb2763592cf330c5c4d8e535"

URI_x86_64_v2_rust-object+compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+compression-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+compression-devel}"
SRC_URI[x86_64_v2_rust-object+compression-devel.sha256sum] = "b207d5ee98207f00b8ee484944c13e3243ed5dc46f22cf66aacb6d54af25b17f"

URI_x86_64_v2_rust-object+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+default-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+default-devel}"
SRC_URI[x86_64_v2_rust-object+default-devel.sha256sum] = "7b86fb3089750e0c69f6eb18125e09a11f3b1e2f0f23fcd70f466e088011fc94"

URI_x86_64_v2_rust-object+doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+doc-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+doc-devel}"
SRC_URI[x86_64_v2_rust-object+doc-devel.sha256sum] = "a264e5a637fe18540aee74f3955c9b40f3b6bf0d4fe8d853935da32a7cb4be39"

URI_x86_64_v2_rust-object+elf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+elf-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+elf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+elf-devel}"
SRC_URI[x86_64_v2_rust-object+elf-devel.sha256sum] = "50568175d93066800c570e8bb455c170bd23b47c4a3274c422953c1a2fce7520"

URI_x86_64_v2_rust-object+macho-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+macho-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+macho-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+macho-devel}"
SRC_URI[x86_64_v2_rust-object+macho-devel.sha256sum] = "71b66e3799772362185ca47efe27ba93eda01489f40a44e32d162472109e3187"

URI_x86_64_v2_rust-object+pe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+pe-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+pe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+pe-devel}"
SRC_URI[x86_64_v2_rust-object+pe-devel.sha256sum] = "f7778e3a4a2ed2138f40fc5aeef52ce4b3f50aea7e0ba099d6a1053223b56161"

URI_x86_64_v2_rust-object+read-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+read-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+read-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+read-devel}"
SRC_URI[x86_64_v2_rust-object+read-devel.sha256sum] = "c9666cc8d4be6dda260560e8790297914f8ec15b2d0fd17e572f48787f86fbee"

URI_x86_64_v2_rust-object+read_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+read_core-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+read_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+read_core-devel}"
SRC_URI[x86_64_v2_rust-object+read_core-devel.sha256sum] = "98ced20469ae91173e893efcf6994538e62ba01ee7d34d701894def78063217a"

URI_x86_64_v2_rust-object+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+std-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+std-devel}"
SRC_URI[x86_64_v2_rust-object+std-devel.sha256sum] = "b6535977b1e3b49918600bbb55aff7e0061d0fcb7db38f72d49ae193c0e94f71"

URI_x86_64_v2_rust-object+unaligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+unaligned-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+unaligned-devel}"
SRC_URI[x86_64_v2_rust-object+unaligned-devel.sha256sum] = "36dec337623bf58e4504dd47754bac90987756290598ce04628fbdacc1d75e0b"

URI_x86_64_v2_rust-object+unstable-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+unstable-all-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+unstable-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+unstable-all-devel}"
SRC_URI[x86_64_v2_rust-object+unstable-all-devel.sha256sum] = "af07bbe978102ddd5611bacd4520c0edea105774d658fac8d4cdca131f439719"

URI_x86_64_v2_rust-object+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+unstable-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+unstable-devel}"
SRC_URI[x86_64_v2_rust-object+unstable-devel.sha256sum] = "2b626889a3e63b6ceb43b14de6ca6c5f5bbc8bad8e3316676e45cc17c6d3250e"

URI_x86_64_v2_rust-object+write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+write-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+write-devel}"
SRC_URI[x86_64_v2_rust-object+write-devel.sha256sum] = "85f272e8af32ec8f37d59df15e6e2bb99fab98beb599e98d185ab4a7d117e17e"

URI_x86_64_v2_rust-object+write_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+write_core-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+write_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+write_core-devel}"
SRC_URI[x86_64_v2_rust-object+write_core-devel.sha256sum] = "b1cbbfd65a656f124e0e3490bf855b460be4749a1d04a55c09cd2846cdc612d7"

URI_x86_64_v2_rust-object+write_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+write_std-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+write_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+write_std-devel}"
SRC_URI[x86_64_v2_rust-object+write_std-devel.sha256sum] = "645f4510819703a9dd105c119fe3ce3b7305eca116b47b79e9a654dc148a429d"

URI_x86_64_v2_rust-object+xcoff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+xcoff-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+xcoff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+xcoff-devel}"
SRC_URI[x86_64_v2_rust-object+xcoff-devel.sha256sum] = "b82118b9c7ede1781a58b17b810b6299a45263a500fd467c469dcb38fbca73cf"

URI_x86_64_v2_rust-object-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object-devel-0.37.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object-devel}"
SRC_URI[x86_64_v2_rust-object-devel.sha256sum] = "66a9ee3028fe18d9430dab1986c583c0107e3c1c5be790dfa357dc57f2ed680a"

URI_aarch64_rust-object+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+all-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+all-devel}"
SRC_URI[aarch64_rust-object+all-devel.sha256sum] = "7dd8b077db64a6b7b983825b4aa8f611a7e808ca93878af85eda481853bd8baa"

URI_aarch64_rust-object+archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+archive-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+archive-devel}"
SRC_URI[aarch64_rust-object+archive-devel.sha256sum] = "a597b0ec35f8f62646dcd9399433a6210c2dfff0b574cfebd5c5269bb7ccabcd"

URI_aarch64_rust-object+build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+build-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+build-devel}"
SRC_URI[aarch64_rust-object+build-devel.sha256sum] = "17d37ac952cd98821d7545901361436bdfe618be60a6764a57a4bd080e962849"

URI_aarch64_rust-object+build_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+build_core-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+build_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+build_core-devel}"
SRC_URI[aarch64_rust-object+build_core-devel.sha256sum] = "4668f91756892b66f6de5d3c44cccd72f245bf3eda1d3d32006d53cbc8b0168c"

URI_aarch64_rust-object+cargo-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+cargo-all-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+cargo-all-devel}"
SRC_URI[aarch64_rust-object+cargo-all-devel.sha256sum] = "40cd2940bf34df852c3ea3d0d8cb93f2fb275bb4eb9971f2f1746cec5b28ab8c"

URI_aarch64_rust-object+coff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+coff-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+coff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+coff-devel}"
SRC_URI[aarch64_rust-object+coff-devel.sha256sum] = "a3aa3df9db08f3507800c93400a7bea2871f7f54fd539e0feeac24a31f80cb7b"

URI_aarch64_rust-object+compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+compression-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+compression-devel}"
SRC_URI[aarch64_rust-object+compression-devel.sha256sum] = "1d5fb9bac24bca86907327db8a927f98a72b07b0a5a6c7636d631279e19e789e"

URI_aarch64_rust-object+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+default-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+default-devel}"
SRC_URI[aarch64_rust-object+default-devel.sha256sum] = "1c2d12facfe3ba306206b38ce869f098ebe5b5c3258136e374180bb72d241451"

URI_aarch64_rust-object+doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+doc-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+doc-devel}"
SRC_URI[aarch64_rust-object+doc-devel.sha256sum] = "ed273354fff7d7b9c35f4c85bafd1f56f0ef22b78ad28c2777e27b26c83e3747"

URI_aarch64_rust-object+elf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+elf-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+elf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+elf-devel}"
SRC_URI[aarch64_rust-object+elf-devel.sha256sum] = "5f3a56f7d7d89b756bf13f56bc698e90fee2f69c77bdea40a454b7c27a9df983"

URI_aarch64_rust-object+macho-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+macho-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+macho-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+macho-devel}"
SRC_URI[aarch64_rust-object+macho-devel.sha256sum] = "727581ca398c677303c843bf10337aec0217f7267be73964342d7031072ef9f9"

URI_aarch64_rust-object+pe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+pe-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+pe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+pe-devel}"
SRC_URI[aarch64_rust-object+pe-devel.sha256sum] = "0700b845b554016c5b2b997d411b84393447e8daa1e51dc0b17eeb18749e38d1"

URI_aarch64_rust-object+read-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+read-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+read-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+read-devel}"
SRC_URI[aarch64_rust-object+read-devel.sha256sum] = "e74b4b25ca7505f4fdc549d4ad1dd611456fadf795eb470334baa7b0f5c83311"

URI_aarch64_rust-object+read_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+read_core-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+read_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+read_core-devel}"
SRC_URI[aarch64_rust-object+read_core-devel.sha256sum] = "32a94101eac2dda43647eb649edc05aa1893ce6279ff99f30b79472cad8f9a8a"

URI_aarch64_rust-object+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+std-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+std-devel}"
SRC_URI[aarch64_rust-object+std-devel.sha256sum] = "a2f40bc9057909fca9deece978a5280b87298253a34d10909c921a290997a2aa"

URI_aarch64_rust-object+unaligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+unaligned-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+unaligned-devel}"
SRC_URI[aarch64_rust-object+unaligned-devel.sha256sum] = "d119c5d70ff95c5ee8a5d3b861e04cd62c4734b7b227845f9c39fba2c487f36a"

URI_aarch64_rust-object+unstable-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+unstable-all-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+unstable-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+unstable-all-devel}"
SRC_URI[aarch64_rust-object+unstable-all-devel.sha256sum] = "d4afb3fe796e04b2b478b28f348dd5d80b0e964cae576ab77bec998e1a00ee3b"

URI_aarch64_rust-object+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+unstable-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+unstable-devel}"
SRC_URI[aarch64_rust-object+unstable-devel.sha256sum] = "ddd6a41471d1754a5f91a4b93a3c1a19f7258f599428c221647d33afaf36737d"

URI_aarch64_rust-object+write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+write-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+write-devel}"
SRC_URI[aarch64_rust-object+write-devel.sha256sum] = "3c67f46f3bbb191bfdb1e89a93a48dada690d17e8843301c247fd4096c9aa4c4"

URI_aarch64_rust-object+write_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+write_core-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+write_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+write_core-devel}"
SRC_URI[aarch64_rust-object+write_core-devel.sha256sum] = "0f207b8364651e7e043796a4620b97607a3c3d821a1e57f614fcd8f04ab0499b"

URI_aarch64_rust-object+write_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+write_std-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+write_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+write_std-devel}"
SRC_URI[aarch64_rust-object+write_std-devel.sha256sum] = "59a9971ba94c4065326c2042c0093106cde8b367a3aa3ec4c8a4867afb848a59"

URI_aarch64_rust-object+xcoff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+xcoff-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object+xcoff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+xcoff-devel}"
SRC_URI[aarch64_rust-object+xcoff-devel.sha256sum] = "efd1b8e6335aa017aff87c8c277a2d36b48f150e66f17949b44be3b3b4433036"

URI_aarch64_rust-object-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object-devel-0.37.3-1.el10_1.noarch.rpm;name=aarch64_rust-object-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object-devel}"
SRC_URI[aarch64_rust-object-devel.sha256sum] = "57f8be0c46282e8114421385586011d61fd383905841417ef4635375d83b7e37"

RDEPENDS:rust-object+all-devel = " \
 cargo \
 rust-object+build-devel \
 rust-object+compression-devel \
 rust-object+read-devel \
 rust-object+std-devel \
 rust-object+write-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+archive-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+build-devel = " \
 cargo \
 rust-object+build_core-devel \
 rust-object+elf-devel \
 rust-object+write_std-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+build_core-devel = " \
 cargo \
 rust-object+read_core-devel \
 rust-object+write_core-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+cargo-all-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+coff-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+compression-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-object+std-devel \
 rust-object-devel \
 rust-ruzstd+default-devel \
 "
RDEPENDS:rust-object+default-devel = " \
 cargo \
 rust-object+compression-devel \
 rust-object+read-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+doc-devel = " \
 cargo \
 rust-object+archive-devel \
 rust-object+build_core-devel \
 rust-object+coff-devel \
 rust-object+compression-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+read_core-devel \
 rust-object+std-devel \
 rust-object+write_std-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+elf-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+macho-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+pe-devel = " \
 cargo \
 rust-object+coff-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+read-devel = " \
 cargo \
 rust-object+archive-devel \
 rust-object+coff-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+read_core-devel \
 rust-object+unaligned-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+read_core-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+unaligned-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+unstable-all-devel = " \
 cargo \
 rust-object+all-devel \
 rust-object+unstable-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+unstable-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+write-devel = " \
 cargo \
 rust-object+coff-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+write_std-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+write_core-devel = " \
 cargo \
 rust-crc32fast-devel \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown-devel \
 rust-indexmap-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+write_std-devel = " \
 cargo \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-object+std-devel \
 rust-object+write_core-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+xcoff-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 "
