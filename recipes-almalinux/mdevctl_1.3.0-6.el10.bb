# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mdevctl"
PV = "1.3.0"
PR = "6.el10"
PACKAGES = " \
 mdevctl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mdevctl-1.3.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b240357694928e72a8fc09f3f2f346218a573e872ae99be0dff64b25b9481674"

URI_x86_64_v2_mdevctl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mdevctl-1.3.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_mdevctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mdevctl}"
SRC_URI[x86_64_v2_mdevctl.sha256sum] = "b5560235aa4a712bbf3f5aeeb7a798b974a04cd09a840c34c66aee2c88664967"

URI_aarch64_mdevctl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mdevctl-1.3.0-6.el10.aarch64.rpm;name=aarch64_mdevctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_mdevctl}"
SRC_URI[aarch64_mdevctl.sha256sum] = "76b49916c90d90e97215742223d524aa856181862a76bd654f21cf5486fd7ac6"

RDEPENDS:mdevctl = " \
 glibc \
 libgcc \
 systemd-udev \
 "
