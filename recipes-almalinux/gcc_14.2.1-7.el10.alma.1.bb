# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc"
PV = "14.2.1"
PR = "7.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 cpp \
 gcc \
 gcc-c++ \
 gcc-gfortran \
 gcc-offload-amdgcn \
 gcc-offload-nvptx \
 gcc-plugin-annobin \
 gcc-plugin-devel \
 libasan \
 libatomic \
 libgcc \
 libgccjit \
 libgccjit-devel \
 libgfortran \
 libgfortran-static \
 libgomp \
 libgomp-offload-amdgcn \
 libgomp-offload-nvptx \
 libhwasan \
 libitm \
 libitm-devel \
 liblsan \
 libquadmath \
 libquadmath-devel \
 libquadmath-static \
 libstdc++ \
 libstdc++-devel \
 libstdc++-docs \
 libstdc++-static \
 libtsan \
 libubsan \
"
PACKAGES:aarch64 = " \
 cpp \
 gcc \
 gcc-c++ \
 gcc-gfortran \
 gcc-plugin-annobin \
 gcc-plugin-devel \
 libasan \
 libatomic \
 libgcc \
 libgccjit \
 libgccjit-devel \
 libgfortran \
 libgfortran-static \
 libgomp \
 libhwasan \
 libitm \
 libitm-devel \
 liblsan \
 libstdc++ \
 libstdc++-devel \
 libstdc++-docs \
 libstdc++-static \
 libtsan \
 libubsan \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gcc-14.2.1-7.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e87913c821707393bebc144d6667d1cb9097785a200668428766eef9a6dc0d56"

URI_x86_64_v2_cpp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cpp-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cpp}"
SRC_URI[x86_64_v2_cpp.sha256sum] = "9a435faf811bbd6e83073d62c18a0fdf11f6aae65dfaaf323ccd7a042e73e512"

URI_x86_64_v2_gcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc}"
SRC_URI[x86_64_v2_gcc.sha256sum] = "74562c6c601c33de954c6582efe50830a8d3d5253cd82b09b05395c589141f93"

URI_x86_64_v2_gcc-c++ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-c++-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++}"
SRC_URI[x86_64_v2_gcc-c++.sha256sum] = "6683bb181b2c954c7838060ab709238d17831b2e4764b212917f7423275aced1"

URI_x86_64_v2_gcc-gfortran = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-gfortran-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-gfortran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-gfortran}"
SRC_URI[x86_64_v2_gcc-gfortran.sha256sum] = "940d23341a855e5344d3de29d821bcbf8d7684d756cc29d9ba19fb7da7b37308"

URI_x86_64_v2_gcc-offload-amdgcn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-offload-amdgcn-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-offload-amdgcn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-offload-amdgcn}"
SRC_URI[x86_64_v2_gcc-offload-amdgcn.sha256sum] = "3c3d1e5466e2b33c6deb523d6ddf7b05e1b5acd04df03656a3fda5435bcf70f5"

URI_x86_64_v2_gcc-offload-nvptx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-offload-nvptx-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-offload-nvptx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-offload-nvptx}"
SRC_URI[x86_64_v2_gcc-offload-nvptx.sha256sum] = "8b6a0433ba08ab813ab9822de28e399e9ebd1d50a3379ae5a3c9f2039a7b6894"

URI_x86_64_v2_gcc-plugin-annobin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-plugin-annobin-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-plugin-annobin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-plugin-annobin}"
SRC_URI[x86_64_v2_gcc-plugin-annobin.sha256sum] = "050467f0c0aa4f90d9ae6e160335eb80eddbb20c71b13796df82be25f1e3a509"

URI_x86_64_v2_gcc-plugin-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gcc-plugin-devel-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-plugin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-plugin-devel}"
SRC_URI[x86_64_v2_gcc-plugin-devel.sha256sum] = "120a018988db34841c6cc7df24697ae9d726b34ed27e842fcafa93b76b0e40d7"

URI_x86_64_v2_libasan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libasan-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libasan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libasan}"
SRC_URI[x86_64_v2_libasan.sha256sum] = "d861ff6606c8447e671b4826662dc62416bb7266d1089d93c9d5646264aa612d"

URI_x86_64_v2_libatomic = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libatomic-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libatomic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libatomic}"
SRC_URI[x86_64_v2_libatomic.sha256sum] = "f7209408de7d4e5c04699ce4ee5501b9bc4641c3257882870bbdb808812a6077"

URI_x86_64_v2_libgcc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgcc-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgcc}"
SRC_URI[x86_64_v2_libgcc.sha256sum] = "4946f476ee4ac5432da625bd0c91341b348db6843b55cbac3e3f4996d532deed"

URI_x86_64_v2_libgccjit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgccjit-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgccjit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgccjit}"
SRC_URI[x86_64_v2_libgccjit.sha256sum] = "52e5d30c889c64b72f9dc4abb4b8df7bddbf4564101366a328c5cfed70df9623"

URI_x86_64_v2_libgccjit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgccjit-devel-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgccjit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgccjit-devel}"
SRC_URI[x86_64_v2_libgccjit-devel.sha256sum] = "bb6331db28b91f3152fd65925b6c3f30ae72ecf0f0bce5f73ddb375c4ff49258"

URI_x86_64_v2_libgfortran = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgfortran-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgfortran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgfortran}"
SRC_URI[x86_64_v2_libgfortran.sha256sum] = "89ff209b8febd1e73e57588f4bc83c15ba7f8f48d67bf8a867a806f7e4a0c37b"

URI_x86_64_v2_libgfortran-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgfortran-static-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgfortran-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgfortran-static}"
SRC_URI[x86_64_v2_libgfortran-static.sha256sum] = "69afecc4dc278310c477ce07e9e27debb5540d5f0eda9532051cece4502460b0"

URI_x86_64_v2_libgomp = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgomp-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgomp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgomp}"
SRC_URI[x86_64_v2_libgomp.sha256sum] = "998c5c0b550e7990bb1ce543450ca1b40741d4b51c850e9f1f991f05bfdcd782"

URI_x86_64_v2_libgomp-offload-amdgcn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgomp-offload-amdgcn-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgomp-offload-amdgcn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgomp-offload-amdgcn}"
SRC_URI[x86_64_v2_libgomp-offload-amdgcn.sha256sum] = "d770a9bcc5ea65948c9ed77b0b5bfedef453c638f5d498fbc2bae67313658827"

URI_x86_64_v2_libgomp-offload-nvptx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgomp-offload-nvptx-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgomp-offload-nvptx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgomp-offload-nvptx}"
SRC_URI[x86_64_v2_libgomp-offload-nvptx.sha256sum] = "b6b5e2a80af31963fa7671c40647178158add0380307ed5e8a2e3caf5284a599"

URI_x86_64_v2_libhwasan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libhwasan-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libhwasan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libhwasan}"
SRC_URI[x86_64_v2_libhwasan.sha256sum] = "b0f230236cd7847a2e372f03f20824456ce090ca7982856bc8a7505519ff4092"

URI_x86_64_v2_libitm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libitm-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libitm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libitm}"
SRC_URI[x86_64_v2_libitm.sha256sum] = "4a934416fb4cb2bf5b3c58479994b2f6b956e9d356b95a5437d655c717d7f6b7"

URI_x86_64_v2_libitm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libitm-devel-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libitm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libitm-devel}"
SRC_URI[x86_64_v2_libitm-devel.sha256sum] = "792692e48af4c11f23ff4427c6152bfb00c6c741260f0f22c1054405d5c94ec4"

URI_x86_64_v2_liblsan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liblsan-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_liblsan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblsan}"
SRC_URI[x86_64_v2_liblsan.sha256sum] = "138060cfbde27532159701cdfc2d35969dafa291e6a0303bd37948237ce3cf0d"

URI_x86_64_v2_libquadmath = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libquadmath-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libquadmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquadmath}"
SRC_URI[x86_64_v2_libquadmath.sha256sum] = "5ba9e554822cc931db91f00dcec7bc2b72b23cea9e36815136bc9199b86fbbaf"

URI_x86_64_v2_libquadmath-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libquadmath-devel-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libquadmath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquadmath-devel}"
SRC_URI[x86_64_v2_libquadmath-devel.sha256sum] = "379dce553253b59a27009ae2c3a95b05b5a57f9e23da6b13468338344eba355f"

URI_x86_64_v2_libquadmath-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libquadmath-static-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libquadmath-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquadmath-static}"
SRC_URI[x86_64_v2_libquadmath-static.sha256sum] = "b83f0c10549b710186e08f9662af219776b2595fa108d3d2836b1f450fadfc81"

URI_x86_64_v2_libstdc++ = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libstdc++-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libstdc++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++}"
SRC_URI[x86_64_v2_libstdc++.sha256sum] = "dedbb1adca6d08569f33535bcf9a8f28f6c36d2865136e7d120fc97f03a85779"

URI_x86_64_v2_libstdc++-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstdc++-devel-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++-devel}"
SRC_URI[x86_64_v2_libstdc++-devel.sha256sum] = "b79fd9f04f684d7ab6f6b46e7b92c326399b994e41fc4002b511f8e2df696deb"

URI_x86_64_v2_libstdc++-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstdc++-docs-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libstdc++-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++-docs}"
SRC_URI[x86_64_v2_libstdc++-docs.sha256sum] = "7036986294693395fe77474b5ad890a75d5522b99216cea8b3db87a883b99402"

URI_x86_64_v2_libstdc++-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libstdc++-static-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libstdc++-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++-static}"
SRC_URI[x86_64_v2_libstdc++-static.sha256sum] = "3eec98603ea43e6142d7d1983c7963e4ffe0cdd41814ad2facac97f82a2f2ab6"

URI_x86_64_v2_libtsan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtsan-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libtsan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtsan}"
SRC_URI[x86_64_v2_libtsan.sha256sum] = "fdbf39af12eaa150fc21de2564b8b79c3ffa239e50a3861f7b1b186415c414e1"

URI_x86_64_v2_libubsan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libubsan-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libubsan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libubsan}"
SRC_URI[x86_64_v2_libubsan.sha256sum] = "ebd184d7821ad9af31d8dae5994b332d1377ac778a6677a9232cf8b1d42ecb81"

URI_aarch64_cpp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cpp-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_cpp}"
SRC_URI[aarch64_cpp.sha256sum] = "19ad919cb7e4d46e5279f7d305dacd4fdcaabf79ef518e9f3a38099da1ef6a5f"

URI_aarch64_gcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_gcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc}"
SRC_URI[aarch64_gcc.sha256sum] = "bc53eeee1d015241036dc42d6ff813b94e59238a7437b32d5853c8a375d3fef6"

URI_aarch64_gcc-c++ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-c++-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_gcc-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++}"
SRC_URI[aarch64_gcc-c++.sha256sum] = "c1fc653922accdc1f0b3f41b5d72c8670c38c5af320856adc6ff49d631039d14"

URI_aarch64_gcc-gfortran = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-gfortran-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_gcc-gfortran;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-gfortran}"
SRC_URI[aarch64_gcc-gfortran.sha256sum] = "52bc47d99bdc29eaef929eeb917e025e043bacd0c88970b04dba96f8a7b9ebcb"

URI_aarch64_gcc-plugin-annobin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-plugin-annobin-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_gcc-plugin-annobin;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-plugin-annobin}"
SRC_URI[aarch64_gcc-plugin-annobin.sha256sum] = "2241bc5991d90d700e58487624dfec773af8afc0f9eb637519a626d036fa5141"

URI_aarch64_gcc-plugin-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gcc-plugin-devel-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_gcc-plugin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-plugin-devel}"
SRC_URI[aarch64_gcc-plugin-devel.sha256sum] = "be51b64346e7adbab610f094b2875d9162ed00ddf36b2f5d48987b5175c913bb"

URI_aarch64_libasan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libasan-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libasan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libasan}"
SRC_URI[aarch64_libasan.sha256sum] = "5ca75180e77e59a890b0e1ec42a05c40b9564f34f0cc6b1bfae52d5ed1a31072"

URI_aarch64_libatomic = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libatomic-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libatomic;unpack=0"
SRC_URI:append = " ${URI_aarch64_libatomic}"
SRC_URI[aarch64_libatomic.sha256sum] = "a942f10490dc526e996f36307e4c3310bc85cc4fb1c78711fa9f60e7ef0dd66c"

URI_aarch64_libgcc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgcc-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libgcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgcc}"
SRC_URI[aarch64_libgcc.sha256sum] = "a1589a75090b3a056796ea363d2ea8822eb852db709a89d4c1098856b7677080"

URI_aarch64_libgccjit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgccjit-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libgccjit;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgccjit}"
SRC_URI[aarch64_libgccjit.sha256sum] = "2b32a03fce518840004128c8ab28248e5e7e033f15e2b2386e0c5a07b5118072"

URI_aarch64_libgccjit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgccjit-devel-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libgccjit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgccjit-devel}"
SRC_URI[aarch64_libgccjit-devel.sha256sum] = "4087611963e6078346e25ca97f64c0b33cf6be23a636af11200b483bcdc95dd7"

URI_aarch64_libgfortran = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgfortran-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libgfortran;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgfortran}"
SRC_URI[aarch64_libgfortran.sha256sum] = "23dc2dc55050c7226fe10b94493839722b058b296864ffa1e935c03fe1cec3f7"

URI_aarch64_libgfortran-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgfortran-static-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libgfortran-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgfortran-static}"
SRC_URI[aarch64_libgfortran-static.sha256sum] = "3b5f726e8f6c1029e10f4de12b4e90c48854af79a9e048b59a76c74ae516931c"

URI_aarch64_libgomp = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgomp-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libgomp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgomp}"
SRC_URI[aarch64_libgomp.sha256sum] = "4306289cec4f199f64daa8b108a1d4e38bfb9508ab4c84fad6102647a46fc864"

URI_aarch64_libhwasan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libhwasan-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libhwasan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libhwasan}"
SRC_URI[aarch64_libhwasan.sha256sum] = "0520bd02b66c24141fc2eda28bde002ed889a0fdbcad37992f26f92211a31d15"

URI_aarch64_libitm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libitm-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libitm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libitm}"
SRC_URI[aarch64_libitm.sha256sum] = "e88e555306f3d7d8c09ce700f0d45611a125b63595fef698bcd7d4ebe1d600ec"

URI_aarch64_libitm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libitm-devel-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libitm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libitm-devel}"
SRC_URI[aarch64_libitm-devel.sha256sum] = "40cc88d4bc1ef52a4f97d21aedc01631a6d4b8638e67f924dab49a2575051ca1"

URI_aarch64_liblsan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liblsan-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_liblsan;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblsan}"
SRC_URI[aarch64_liblsan.sha256sum] = "056ee54b8751494b6d1b5d81a3f43ab9239132e632afd20fc41c0ce2c9c9141a"

URI_aarch64_libstdc++ = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libstdc++-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libstdc++;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++}"
SRC_URI[aarch64_libstdc++.sha256sum] = "94cce465fcacc19f8da8948ffd0cff255bef7adf812f6984c3137215f9ed476c"

URI_aarch64_libstdc++-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstdc++-devel-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++-devel}"
SRC_URI[aarch64_libstdc++-devel.sha256sum] = "48f0fa9d999c606851fa3569635b1f9b4129e39505815c8528b02657ea24adea"

URI_aarch64_libstdc++-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstdc++-docs-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libstdc++-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++-docs}"
SRC_URI[aarch64_libstdc++-docs.sha256sum] = "4471458c5151268ffa2a58f36312daeb02978d9a4e8bfaa1e549cb2f9c0f9928"

URI_aarch64_libstdc++-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libstdc++-static-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libstdc++-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++-static}"
SRC_URI[aarch64_libstdc++-static.sha256sum] = "ddb454bead179347546dd671e261bc6d3edb543c4256e51323fc2d3cd561e18a"

URI_aarch64_libtsan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtsan-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libtsan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtsan}"
SRC_URI[aarch64_libtsan.sha256sum] = "a4efe7120e1358bbd6f9e08d1af84ffc190d095d89e0aa4f94d8a3dfab99f06e"

URI_aarch64_libubsan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libubsan-14.2.1-7.el10.alma.1.aarch64.rpm;name=aarch64_libubsan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libubsan}"
SRC_URI[aarch64_libubsan.sha256sum] = "9a144018d76d80ed321509f8750e653667192b320ffe8ce05abd81079dd69dd6"

RDEPENDS:cpp = " \
 filesystem \
 glibc \
 gmp \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc:x86_64_v2 = " \
 bash \
 binutils \
 cpp \
 glibc \
 glibc-devel \
 gmp \
 libgcc \
 libgomp \
 libmpc \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc:aarch64 = " \
 bash \
 binutils \
 cpp \
 glibc \
 glibc-devel \
 gmp \
 libasan \
 libatomic \
 libgcc \
 libgomp \
 libmpc \
 libubsan \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-c++ = " \
 gcc \
 glibc \
 gmp \
 libmpc \
 libstdc++ \
 libstdc++-devel \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-gfortran:x86_64_v2 = " \
 gcc \
 glibc \
 gmp \
 libgfortran \
 libmpc \
 libquadmath \
 libquadmath-devel \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-gfortran:aarch64 = " \
 gcc \
 glibc \
 gmp \
 libgfortran \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-offload-amdgcn = " \
 gcc \
 glibc \
 gmp \
 libgcc \
 libgomp-offload-amdgcn \
 libmpc \
 libstdc++ \
 libzstd \
 lld \
 llvm \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-offload-nvptx = " \
 gcc \
 glibc \
 gmp \
 libgcc \
 libgomp-offload-nvptx \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-plugin-annobin = " \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gcc-plugin-devel = " \
 gcc \
 glibc \
 gmp-devel \
 libmpc-devel \
 mpfr-devel \
 "
RDEPENDS:libasan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libatomic = " \
 glibc \
 "
RDEPENDS:libgcc = " \
 "
RDEPENDS:libgccjit = " \
 gcc \
 glibc \
 gmp \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:libgccjit-devel = " \
 libgccjit \
 "
RDEPENDS:libgfortran = " \
 glibc \
 libgcc \
 "
RDEPENDS:libgfortran-static:x86_64_v2 = " \
 gcc \
 libgfortran \
 libquadmath-static \
"
RDEPENDS:libgfortran-static:aarch64 = " \
 gcc \
 libgfortran \
"
RDEPENDS:libgomp = " \
 glibc \
 "
RDEPENDS:libgomp-offload-amdgcn = " \
 glibc \
 libgomp \
 "
RDEPENDS:libgomp-offload-nvptx = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:libhwasan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libitm = " \
 glibc \
 "
RDEPENDS:libitm-devel = " \
 gcc \
 libitm \
 "
RDEPENDS:liblsan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libquadmath = " \
 glibc \
 libgcc \
 "
RDEPENDS:libquadmath-devel = " \
 gcc \
 libquadmath \
 "
RDEPENDS:libquadmath-static = " \
 libquadmath-devel \
 "
RDEPENDS:libstdc++ = " \
 glibc \
 libgcc \
 "
RDEPENDS:libstdc++-devel = " \
 libstdc++ \
 "
RDEPENDS:libstdc++-docs = " \
 "
RDEPENDS:libstdc++-static = " \
 libstdc++-devel \
 "
RDEPENDS:libtsan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libubsan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
