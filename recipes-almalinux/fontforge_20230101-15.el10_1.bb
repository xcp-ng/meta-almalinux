# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fontforge"
PV = "20230101"
PR = "15.el10_1"
PACKAGES = " \
 fontforge \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/fontforge-20230101-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4475f89586804cb03a9e94f39621df2d932b39ef930064ad40cf5166a7caa6f5"

URI_x86_64_v2_fontforge = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fontforge-20230101-15.el10_1.x86_64_v2.rpm;name=x86_64_v2_fontforge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fontforge}"
SRC_URI[x86_64_v2_fontforge.sha256sum] = "5531073439f90c7dc801f044fe8255b6d3362d609d82508051f0381b7fc8ed70"

URI_aarch64_fontforge = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fontforge-20230101-15.el10_1.aarch64.rpm;name=aarch64_fontforge;unpack=0"
SRC_URI:append = " ${URI_aarch64_fontforge}"
SRC_URI[aarch64_fontforge.sha256sum] = "4aef0cb35e3c952471e12f21f44cfd2d7feba62079c661d5487aecdf078e91c1"

RDEPENDS:fontforge = " \
 cairo \
 freetype \
 giflib \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libgcc \
 libjpeg-turbo \
 libpng \
 libspiro \
 libstdc++ \
 libtiff \
 libxml2 \
 pango \
 potrace \
 python3 \
 python3-libs \
 readline \
 woff2 \
 xdg-utils \
 zlib-ng-compat \
 "
