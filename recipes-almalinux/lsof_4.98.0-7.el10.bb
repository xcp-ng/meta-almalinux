# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lsof"
PV = "4.98.0"
PR = "7.el10"
PACKAGES = " \
 lsof \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lsof-4.98.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "023dbe535c276b494f96a39f5fa3aee27475f356f7c458492ceebe97c1c877c5"

URI_x86_64_v2_lsof = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lsof-4.98.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_lsof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lsof}"
SRC_URI[x86_64_v2_lsof.sha256sum] = "a0594904788bd22158d574017e6c6fa0d5790ffcb0a54d0b224f9422a1795f7c"

URI_aarch64_lsof = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lsof-4.98.0-7.el10.aarch64.rpm;name=aarch64_lsof;unpack=0"
SRC_URI:append = " ${URI_aarch64_lsof}"
SRC_URI[aarch64_lsof.sha256sum] = "9d11380e2c04e605f4502d93c587243364a72a908a645787193d40c89336e6a2"

RDEPENDS:lsof = " \
 glibc \
 libselinux \
 libtirpc \
 "
