# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "delve"
PV = "1.26.1"
PR = "2.el10"
PACKAGES = " \
 delve \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/delve-1.26.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d6009e72953b116a7fa245f5ce4e2ffcd23bfcdbe03f25fbb6d23982aa6d74f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/delve-1.26.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_delve;unpack=0"
SRC_URI[x86_64_v2_delve.sha256sum] = "24c65e19b2b196a513503660722d8f5f86ad16d8c37467f7d8addaff0722f523"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/delve-1.26.1-2.el10.aarch64.rpm;name=aarch64_delve;unpack=0"
SRC_URI[aarch64_delve.sha256sum] = "edb40fb36c9cd7b5495569cd8aae9a54a038725ae8411166139280a81598a95a"

RDEPENDS:delve = " \
 glibc \
 "
