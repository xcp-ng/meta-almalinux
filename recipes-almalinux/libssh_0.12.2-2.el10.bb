# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libssh"
PV = "0.12.2"
PR = "2.el10"
PACKAGES = " \
 libssh \
 libssh-config \
 libssh-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libssh-0.12.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "373a09e648a312d7253cf2355794200b6487d0701c21435d639844138968c6cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libssh-0.12.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_libssh;unpack=0"
SRC_URI[x86_64_v2_libssh.sha256sum] = "037ad207226245f61ebc8e345fedfcca39c9afe6eb91716903fe584229de263c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libssh-config-0.12.2-2.el10.noarch.rpm;name=x86_64_v2_libssh-config;unpack=0"
SRC_URI[x86_64_v2_libssh-config.sha256sum] = "92bde602b43a1bb4cb48c0f6cf2b9791712f30a15281e9006e875139575cacb4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libssh-devel-0.12.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_libssh-devel;unpack=0"
SRC_URI[x86_64_v2_libssh-devel.sha256sum] = "1aa70c977d60918ed2015d728fdf188c12f68865d44d6b6afa64cd097deb92fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libssh-0.12.2-2.el10.aarch64.rpm;name=aarch64_libssh;unpack=0"
SRC_URI[aarch64_libssh.sha256sum] = "4b80dbda4b2b8ab478c08619e4586ddd3d20f4829cc0b247a53173721ae44676"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libssh-config-0.12.2-2.el10.noarch.rpm;name=aarch64_libssh-config;unpack=0"
SRC_URI[aarch64_libssh-config.sha256sum] = "92bde602b43a1bb4cb48c0f6cf2b9791712f30a15281e9006e875139575cacb4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libssh-devel-0.12.2-2.el10.aarch64.rpm;name=aarch64_libssh-devel;unpack=0"
SRC_URI[aarch64_libssh-devel.sha256sum] = "4f04b7a17486f7382a6a25b4ccf776e393832413431d7f57ae2bad375c709efe"

RDEPENDS:libssh = " \
 crypto-policies \
 glibc \
 krb5-libs \
 libfido2 \
 libssh-config \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libssh-config = " \
 "
RDEPENDS:libssh-devel = " \
 cmake-filesystem \
 krb5-devel \
 libssh \
 pkgconf-pkg-config \
 "
