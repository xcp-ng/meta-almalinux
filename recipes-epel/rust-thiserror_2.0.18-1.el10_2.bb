# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thiserror"
PV = "2.0.18"
PR = "1.el10_2"
PACKAGES = " \
 rust-thiserror+default-devel \
 rust-thiserror+std-devel \
 rust-thiserror-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thiserror-2.0.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be22d8b34b1d5ac891bdb9c113d493c537f5698fe7067a1bf75b9eff032a918a"

URI_x86_64_v2_rust-thiserror+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror+default-devel-2.0.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror+default-devel}"
SRC_URI[x86_64_v2_rust-thiserror+default-devel.sha256sum] = "af44bcbeeabeb67c32b994539c125e3a89522826852b9a91042aaad7c402109b"
RPROVIDES:rust-thiserror+default-devel:x86_64_v2 = "virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~"

URI_x86_64_v2_rust-thiserror+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror+std-devel-2.0.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror+std-devel}"
SRC_URI[x86_64_v2_rust-thiserror+std-devel.sha256sum] = "8988000a56833ec06424fed89a923a68c08aef7e7473d959ea72ad38a9308eff"

URI_x86_64_v2_rust-thiserror-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror-devel-2.0.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror-devel}"
SRC_URI[x86_64_v2_rust-thiserror-devel.sha256sum] = "6b3bd79a72da4e5916ce7da25576f77efc7a3b4a22a28c14aab4720e8c46b5c0"

URI_aarch64_rust-thiserror+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror+default-devel-2.0.18-1.el10_2.noarch.rpm;name=aarch64_rust-thiserror+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror+default-devel}"
SRC_URI[aarch64_rust-thiserror+default-devel.sha256sum] = "fa4e2ab9790b0d72208d040e2e07c9f47c66c59ba6a9180c751bcbcfe27e4fca"
RPROVIDES:rust-thiserror+default-devel:aarch64 = "virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~"

URI_aarch64_rust-thiserror+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror+std-devel-2.0.18-1.el10_2.noarch.rpm;name=aarch64_rust-thiserror+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror+std-devel}"
SRC_URI[aarch64_rust-thiserror+std-devel.sha256sum] = "af5137ec1de64e46f4769236b4faf11c965bddd809b02081aee037250e121c64"

URI_aarch64_rust-thiserror-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror-devel-2.0.18-1.el10_2.noarch.rpm;name=aarch64_rust-thiserror-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror-devel}"
SRC_URI[aarch64_rust-thiserror-devel.sha256sum] = "79d067b2676c86446c05c9f3e3539ef6ed90038d3d6fb9b9f28dd39a6a1803fe"

RDEPENDS:rust-thiserror+default-devel = " \
 cargo \
 rust-thiserror+std-devel \
 rust-thiserror-devel \
 "
RDEPENDS:rust-thiserror+std-devel = " \
 cargo \
 rust-thiserror-devel \
 "
RDEPENDS:rust-thiserror-devel = " \
 cargo \
 rust \
 rust-thiserror-impl+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~"
