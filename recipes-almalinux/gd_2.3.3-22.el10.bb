# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gd"
PV = "2.3.3"
PR = "22.el10"
PACKAGES = " \
 gd \
 gd-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gd-2.3.3-22.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0ba20e8c7b2a33b9d4ef0b766ff00494952effb8d8c91e7c05f45a65837a8ac5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gd-2.3.3-22.el10.x86_64_v2.rpm;name=x86_64_v2_gd;unpack=0"
SRC_URI[x86_64_v2_gd.sha256sum] = "3c726ffc7d182026c6d2692d0dcb23909559c8bccfc25e623ee16a236ae69367"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gd-devel-2.3.3-22.el10.x86_64_v2.rpm;name=x86_64_v2_gd-devel;unpack=0"
SRC_URI[x86_64_v2_gd-devel.sha256sum] = "5f1b7e5e0b6eb24300e7d3430c5446ab4fb7e1d1d0e0ab78f51e06e602912d4f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gd-2.3.3-22.el10.aarch64.rpm;name=aarch64_gd;unpack=0"
SRC_URI[aarch64_gd.sha256sum] = "4b93f61e2f9dc53d9e6432193cc244c11ee1e161f79f0e0418d57b311ec0459a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gd-devel-2.3.3-22.el10.aarch64.rpm;name=aarch64_gd-devel;unpack=0"
SRC_URI[aarch64_gd-devel.sha256sum] = "2e73b08b3355d6422e80b2b479afb14d08c3372d4b058cb4a6cbec94b7692143"

RDEPENDS:gd = " \
 fontconfig \
 freetype \
 glibc \
 libX11 \
 libXpm \
 libjpeg-turbo \
 libpng \
 libtiff \
 libwebp \
 zlib-ng-compat \
 "
RDEPENDS:gd-devel = " \
 fontconfig-devel \
 freetype-devel \
 gd \
 libX11-devel \
 libXpm-devel \
 libjpeg-turbo-devel \
 libpng-devel \
 libtiff-devel \
 libwebp-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
