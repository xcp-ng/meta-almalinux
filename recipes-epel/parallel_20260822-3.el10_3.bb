# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "parallel"
PV = "20260822"
PR = "3.el10_3"
PACKAGES = " \
 parallel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/parallel-20260822-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aa66d062dd25b6c1576e672cb47334e99d3aa8af69d56276318c170626cb1077"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parallel-20260822-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_parallel;unpack=0"
SRC_URI[x86_64_v2_parallel.sha256sum] = "a708cf985ae590d834243e707a7a5ef26483e58d94be35b54bafdeb4727a4b3a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/parallel-20260822-3.el10_3.noarch.rpm;name=aarch64_parallel;unpack=0"
SRC_URI[aarch64_parallel.sha256sum] = "29a99b2f005950f29f2c30104c55dc85684db82ac92703c5adcc9a93513c5f13"

RDEPENDS:parallel = " \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Path \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-Symbol \
 perl-Thread-Queue \
 perl-interpreter \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 "
