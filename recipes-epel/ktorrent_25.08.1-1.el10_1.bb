# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktorrent"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 ktorrent \
 ktorrent-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktorrent-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4eb70f9bd17532f6d02b88c24006c71df9575d50534f87866adef0ebbded6b9c"

URI_x86_64_v2_ktorrent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktorrent-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktorrent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktorrent}"
SRC_URI[x86_64_v2_ktorrent.sha256sum] = "86e1ef7d544c922baf3da9c88391e967cfaa6aa14a45c64b382580313ab47ded"

URI_x86_64_v2_ktorrent-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktorrent-libs-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktorrent-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktorrent-libs}"
SRC_URI[x86_64_v2_ktorrent-libs.sha256sum] = "a7c96e8f1b3eab9378236a6eb7dfc2f7bb14fe63ea8c98d3a8ee2f8f94584489"

URI_aarch64_ktorrent = "${EPEL_MIRROR}/aarch64/Packages/k/ktorrent-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_ktorrent;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktorrent}"
SRC_URI[aarch64_ktorrent.sha256sum] = "c6b87545631f766b216724a49651a12671daad89d3b6fd746a3441abf0a2c924"

URI_aarch64_ktorrent-libs = "${EPEL_MIRROR}/aarch64/Packages/k/ktorrent-libs-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_ktorrent-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktorrent-libs}"
SRC_URI[aarch64_ktorrent-libs.sha256sum] = "2c8e6669b573453df8fe3b3bf721dcda6cf9a93fa545b6fa7301f0e44629a777"

RDEPENDS:ktorrent = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kplotting \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-syndication \
 ktorrent-libs \
 libgcc \
 libktorrent \
 libmaxminddb \
 libstdc++ \
 phonon-qt6 \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 taglib \
 "
RDEPENDS:ktorrent-libs = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 ktorrent \
 libgcc \
 libktorrent \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
