# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksystemlog"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 ksystemlog \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksystemlog-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c639521e4ad6d765f401f4ff850d926d809f72584da8289918bfba00d8321a83"

URI_x86_64_v2_ksystemlog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksystemlog-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksystemlog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksystemlog}"
SRC_URI[x86_64_v2_ksystemlog.sha256sum] = "35ad1aa00c9d28e264fcfd01611a108c9f3baff060e80054d2583227bb8cebd7"

URI_aarch64_ksystemlog = "${EPEL_MIRROR}/aarch64/Packages/k/ksystemlog-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_ksystemlog;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksystemlog}"
SRC_URI[aarch64_ksystemlog.sha256sum] = "4762d7afa2bc68252a807f2fe83af9793aeac7fe406bbfaab0cf4b6b738a696d"

RDEPENDS:ksystemlog = " \
 audit-libs \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 systemd-libs \
 "
