# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "thermald"
PV = "2.5.13"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 thermald \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/thermald-2.5.13-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f2e65087962e85bb47a1e5fb9fa69c2147800d85c000913325107c0599fd7798"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/thermald-2.5.13-1.el10.x86_64_v2.rpm;name=x86_64_v2_thermald;unpack=0"
SRC_URI[x86_64_v2_thermald.sha256sum] = "f0ce1eb521eb31197b5049fac6d3d454cd29b2101d31793b51c59bbd2a4e01b8"

RDEPENDS:thermald = " \
 bash \
 dbus \
 glib2 \
 glibc \
 glibc-common \
 libevdev \
 libgcc \
 libstdc++ \
 libxml2 \
 shadow-utils \
 systemd \
 upower-libs \
 "
