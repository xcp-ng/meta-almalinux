# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opendbx"
PV = "1.4.6"
PR = "40.el10_0"
PACKAGES = " \
 opendbx \
 opendbx-devel \
 opendbx-mssql \
 opendbx-mysql \
 opendbx-postgresql \
 opendbx-sqlite \
 opendbx-sybase \
 opendbx-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opendbx-1.4.6-40.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d8cf2ee60a7091761710117641e9b1633efd1bff85e5da06b66bbcb91e88646"

URI_x86_64_v2_opendbx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-1.4.6-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx}"
SRC_URI[x86_64_v2_opendbx.sha256sum] = "5a328535d501ce0f00f8f92af8451d8cf07d4306b411543934aa0c4cbf56b0b3"

URI_x86_64_v2_opendbx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-devel-1.4.6-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx-devel}"
SRC_URI[x86_64_v2_opendbx-devel.sha256sum] = "aaa52a0ecf8efb3e919817fd241c7dc900aa527ab16093a0011d4de729dfcff2"

URI_x86_64_v2_opendbx-mssql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-mssql-1.4.6-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx-mssql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx-mssql}"
SRC_URI[x86_64_v2_opendbx-mssql.sha256sum] = "a102561a11bf28eb3bd79219d907641ded03ae573192510002ecf3b4e9dd6444"

URI_x86_64_v2_opendbx-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-mysql-1.4.6-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx-mysql}"
SRC_URI[x86_64_v2_opendbx-mysql.sha256sum] = "d76dd22681941c22aa99898c7e4b936d6b304ca7bda5bc47acd1557d0292de58"

URI_x86_64_v2_opendbx-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-postgresql-1.4.6-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx-postgresql}"
SRC_URI[x86_64_v2_opendbx-postgresql.sha256sum] = "8b96a9963c52f061eb0ee3a94f99ca466afb0b79362cf4e0ad8d33f2a123b00f"

URI_x86_64_v2_opendbx-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-sqlite-1.4.6-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx-sqlite}"
SRC_URI[x86_64_v2_opendbx-sqlite.sha256sum] = "f74e5cec05809b3e5d0c36ae3a6197e515a2d7b58b2ebbb023d68aa17151c8d1"

URI_x86_64_v2_opendbx-sybase = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-sybase-1.4.6-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx-sybase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx-sybase}"
SRC_URI[x86_64_v2_opendbx-sybase.sha256sum] = "29a4b69b4bddb27d918106cc087e562d68698895c5094d8f8ee4562774a8b2c6"

URI_x86_64_v2_opendbx-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-utils-1.4.6-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx-utils}"
SRC_URI[x86_64_v2_opendbx-utils.sha256sum] = "b1aeef864212a7526041183ecab6b3d9798a583daf9c7ae9ab6b9da002c75251"

URI_aarch64_opendbx = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-1.4.6-40.el10_0.aarch64.rpm;name=aarch64_opendbx;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx}"
SRC_URI[aarch64_opendbx.sha256sum] = "733f6459772414c4d72a420cc0b383a59c285f9cd3ed230d14dd64a7e8f58ac5"

URI_aarch64_opendbx-devel = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-devel-1.4.6-40.el10_0.aarch64.rpm;name=aarch64_opendbx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx-devel}"
SRC_URI[aarch64_opendbx-devel.sha256sum] = "b0f32344650ddd907473a40aa8f7b6399918f9078679e41f4360ad6d6e7a7821"

URI_aarch64_opendbx-mssql = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-mssql-1.4.6-40.el10_0.aarch64.rpm;name=aarch64_opendbx-mssql;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx-mssql}"
SRC_URI[aarch64_opendbx-mssql.sha256sum] = "0c1af6cccc2bc4968b7825429c395eb9db09a3b284f8b05f89be5e5f2aea6b3e"

URI_aarch64_opendbx-mysql = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-mysql-1.4.6-40.el10_0.aarch64.rpm;name=aarch64_opendbx-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx-mysql}"
SRC_URI[aarch64_opendbx-mysql.sha256sum] = "57142e76e8b49d756c6b97cdade6497ee42680b2b437a1f67c15ab91c7a7fb3e"

URI_aarch64_opendbx-postgresql = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-postgresql-1.4.6-40.el10_0.aarch64.rpm;name=aarch64_opendbx-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx-postgresql}"
SRC_URI[aarch64_opendbx-postgresql.sha256sum] = "406f9120700ff3cf3fa534665ddc1c120c0c0aa2b16dccf51d1dc1f114a38232"

URI_aarch64_opendbx-sqlite = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-sqlite-1.4.6-40.el10_0.aarch64.rpm;name=aarch64_opendbx-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx-sqlite}"
SRC_URI[aarch64_opendbx-sqlite.sha256sum] = "a2900ed1f85a05ac91e7ca410c4a1fd0ff31633f119dcfb5a913ad0877f553dd"

URI_aarch64_opendbx-sybase = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-sybase-1.4.6-40.el10_0.aarch64.rpm;name=aarch64_opendbx-sybase;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx-sybase}"
SRC_URI[aarch64_opendbx-sybase.sha256sum] = "5e38b888b321e1a52485132a35bccb50b11aef91412d08a775e749ba1917d150"

URI_aarch64_opendbx-utils = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-utils-1.4.6-40.el10_0.aarch64.rpm;name=aarch64_opendbx-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx-utils}"
SRC_URI[aarch64_opendbx-utils.sha256sum] = "9ab30eba1bac54aa87a96290c2c876c237042b06d6e63cd334f5ab828b450b4e"

RDEPENDS:opendbx = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:opendbx-devel = " \
 opendbx \
 pkgconf-pkg-config \
 "
RDEPENDS:opendbx-mssql = " \
 opendbx \
 "
RDEPENDS:opendbx-mysql = " \
 opendbx \
 "
RDEPENDS:opendbx-postgresql = " \
 opendbx \
 "
RDEPENDS:opendbx-sqlite = " \
 opendbx \
 "
RDEPENDS:opendbx-sybase = " \
 opendbx \
 "
RDEPENDS:opendbx-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-libs \
 opendbx \
 readline \
 "
