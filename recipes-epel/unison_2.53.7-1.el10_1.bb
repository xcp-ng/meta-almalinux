# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unison"
PV = "2.53.7"
PR = "1.el10_1"
PACKAGES = " \
 unison \
 unison-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/u/unison-2.53.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "07ac31e39a90e71733cda9715193e5802ab3dc135f7394eb1cc4ace4f2920e56"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unison-2.53.7-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unison;unpack=0"
SRC_URI[x86_64_v2_unison.sha256sum] = "cba7c8b9accf2989730a5209333ec6f7e1fa6a2418fddc6f9bc19d44baf6506c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unison-doc-2.53.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_unison-doc;unpack=0"
SRC_URI[x86_64_v2_unison-doc.sha256sum] = "e03e9042ad3a7c0674623cff5f1ef6663969a05da3f0df2d340ef2a09fc21d11"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/unison-2.53.7-1.el10_1.aarch64.rpm;name=aarch64_unison;unpack=0"
SRC_URI[aarch64_unison.sha256sum] = "1e859fc26e60e64949d133421b7835373d0769fdc348c59e38fe596fbc43c76e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/unison-doc-2.53.7-1.el10_1.noarch.rpm;name=aarch64_unison-doc;unpack=0"
SRC_URI[aarch64_unison-doc.sha256sum] = "e948706c9230acf473ed750613b3040a8bd7b978b9f39e18b8f8e598657a771f"

RDEPENDS:unison = " \
 glibc \
 "
RDEPENDS:unison-doc = " \
 "
