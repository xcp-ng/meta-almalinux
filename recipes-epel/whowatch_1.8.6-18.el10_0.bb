# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "whowatch"
PV = "1.8.6"
PR = "18.el10_0"
PACKAGES = " \
 whowatch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/whowatch-1.8.6-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eef6d1ec6b69b343c7ca22e0520a7b44ded6f15664f7e34d5794372ff5eeb3da"

URI_x86_64_v2_whowatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/whowatch-1.8.6-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_whowatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_whowatch}"
SRC_URI[x86_64_v2_whowatch.sha256sum] = "caa75dc5cc8e9f5e2862851adece9740c95456e861dc88aa5969c51ecd4eae3c"

URI_aarch64_whowatch = "${EPEL_MIRROR}/aarch64/Packages/w/whowatch-1.8.6-18.el10_0.aarch64.rpm;name=aarch64_whowatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_whowatch}"
SRC_URI[aarch64_whowatch.sha256sum] = "fd2a867c4b5c32696dcb0965de186ca4332cf390d992131a57f7f6630fe598ac"

RDEPENDS:whowatch = " \
 glibc \
 ncurses-libs \
 "
