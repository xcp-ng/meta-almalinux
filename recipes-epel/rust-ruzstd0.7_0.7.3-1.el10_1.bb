# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ruzstd0.7"
PV = "0.7.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-ruzstd0.7+default-devel \
 rust-ruzstd0.7+hash-devel \
 rust-ruzstd0.7+std-devel \
 rust-ruzstd0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ruzstd0.7-0.7.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc205bf65ec09f8608e8057bbb3373e9d811c894d63a55ccc10e6945d587933b"

URI_x86_64_v2_rust-ruzstd0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd0.7+default-devel-0.7.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd0.7+default-devel}"
SRC_URI[x86_64_v2_rust-ruzstd0.7+default-devel.sha256sum] = "bcae33581fe18fb432b846ab6e1335dd2fd49ebf284f7d1c0bd1e786296159df"

URI_x86_64_v2_rust-ruzstd0.7+hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd0.7+hash-devel-0.7.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd0.7+hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd0.7+hash-devel}"
SRC_URI[x86_64_v2_rust-ruzstd0.7+hash-devel.sha256sum] = "afff83b01634ddd2869e7c6b931bd245bb6a29cea7057e30d94a20f99eaa9e4b"

URI_x86_64_v2_rust-ruzstd0.7+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd0.7+std-devel-0.7.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd0.7+std-devel}"
SRC_URI[x86_64_v2_rust-ruzstd0.7+std-devel.sha256sum] = "0f6a4e86315cb9afdc7e98e4765068b29f82d0b62b4d812d8695307dad0e814d"

URI_x86_64_v2_rust-ruzstd0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd0.7-devel-0.7.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd0.7-devel}"
SRC_URI[x86_64_v2_rust-ruzstd0.7-devel.sha256sum] = "7e860e81b4f4f6fe23c1390a9e261c2f301baac08253879a4d50f4e91c9615cb"

URI_aarch64_rust-ruzstd0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd0.7+default-devel-0.7.3-1.el10_1.noarch.rpm;name=aarch64_rust-ruzstd0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd0.7+default-devel}"
SRC_URI[aarch64_rust-ruzstd0.7+default-devel.sha256sum] = "e08cdbb5ff7c7ac44cb448187daf75b26a406bdd394d5d1213a07034cd450f9d"

URI_aarch64_rust-ruzstd0.7+hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd0.7+hash-devel-0.7.3-1.el10_1.noarch.rpm;name=aarch64_rust-ruzstd0.7+hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd0.7+hash-devel}"
SRC_URI[aarch64_rust-ruzstd0.7+hash-devel.sha256sum] = "7f647a5231aa465cc0fe04083a35c62f9c4feb76e03356248cd9d071605df197"

URI_aarch64_rust-ruzstd0.7+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd0.7+std-devel-0.7.3-1.el10_1.noarch.rpm;name=aarch64_rust-ruzstd0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd0.7+std-devel}"
SRC_URI[aarch64_rust-ruzstd0.7+std-devel.sha256sum] = "46fa98cd3c045b4fe43db37c9a6a037cd15663c8d639a2209b0bbd0abdf6b32d"

URI_aarch64_rust-ruzstd0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd0.7-devel-0.7.3-1.el10_1.noarch.rpm;name=aarch64_rust-ruzstd0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd0.7-devel}"
SRC_URI[aarch64_rust-ruzstd0.7-devel.sha256sum] = "0209f826a9bde04a6c0eae654771fb1e3bd96926e728c2041c6d9d0a3897a6ef"

RDEPENDS:rust-ruzstd0.7+default-devel = " \
 cargo \
 rust-ruzstd0.7+hash-devel \
 rust-ruzstd0.7+std-devel \
 rust-ruzstd0.7-devel \
 "
RDEPENDS:rust-ruzstd0.7+hash-devel = " \
 cargo \
 rust-ruzstd0.7-devel \
 rust-twox-hash1-devel \
 "
RDEPENDS:rust-ruzstd0.7+std-devel = " \
 cargo \
 rust-ruzstd0.7-devel \
 "
RDEPENDS:rust-ruzstd0.7-devel = " \
 cargo \
 "
