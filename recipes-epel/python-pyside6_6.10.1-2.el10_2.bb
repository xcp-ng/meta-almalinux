# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyside6"
PV = "6.10.1"
PR = "2.el10_2"
PACKAGES = " \
 pyside6-tools \
 python3-pyside6 \
 python3-pyside6-devel \
 python3-shiboken6 \
 python3-shiboken6-devel \
 shiboken6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyside6-6.10.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "661faf06363ecb8e4658d400267694b1f99c2438838df3e8a9869c2f0bd62715"

URI_x86_64_v2_pyside6-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pyside6-tools-6.10.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pyside6-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pyside6-tools}"
SRC_URI[x86_64_v2_pyside6-tools.sha256sum] = "8890630b225372abb8067d43f467160f96455bc09ef95eadda8118fa9beb635e"

URI_x86_64_v2_python3-pyside6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyside6-6.10.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyside6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyside6}"
SRC_URI[x86_64_v2_python3-pyside6.sha256sum] = "176394d043f5a5c7bdde53d79eb43d031d76660fa31af3f925073e66a66ac2f2"

URI_x86_64_v2_python3-pyside6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyside6-devel-6.10.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyside6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyside6-devel}"
SRC_URI[x86_64_v2_python3-pyside6-devel.sha256sum] = "7aca6a95ba240584d70a67a832d681d49081efae6119f46dac4a41ce1402a74e"

URI_x86_64_v2_python3-shiboken6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-shiboken6-6.10.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-shiboken6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-shiboken6}"
SRC_URI[x86_64_v2_python3-shiboken6.sha256sum] = "1607475dac19ab1afb3bd77a1f3185b228ba4233490616ea711866e67cc6f904"

URI_x86_64_v2_python3-shiboken6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-shiboken6-devel-6.10.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-shiboken6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-shiboken6-devel}"
SRC_URI[x86_64_v2_python3-shiboken6-devel.sha256sum] = "802e1b51892d3bb0a3d2adfbf8c1eb6520dbb62b504146b390bc7497ae4a7acf"

URI_x86_64_v2_shiboken6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/shiboken6-6.10.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_shiboken6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shiboken6}"
SRC_URI[x86_64_v2_shiboken6.sha256sum] = "f53c1404b824918a176fb6993b05673d08ee1ffc22e8f1055b41116d8e7672c4"

URI_aarch64_pyside6-tools = "${EPEL_MIRROR}/aarch64/Packages/p/pyside6-tools-6.10.1-2.el10_2.aarch64.rpm;name=aarch64_pyside6-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pyside6-tools}"
SRC_URI[aarch64_pyside6-tools.sha256sum] = "5b60ab7d1d3f1803cb74e45b172d354caff24543bceb8e7c9d7f212dbd3a62c6"

URI_aarch64_python3-pyside6 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyside6-6.10.1-2.el10_2.aarch64.rpm;name=aarch64_python3-pyside6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyside6}"
SRC_URI[aarch64_python3-pyside6.sha256sum] = "f4b437fb08672b245ea49140407ca80e84f1e08b9d62ae3598e4cdd423e9265e"

URI_aarch64_python3-pyside6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyside6-devel-6.10.1-2.el10_2.aarch64.rpm;name=aarch64_python3-pyside6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyside6-devel}"
SRC_URI[aarch64_python3-pyside6-devel.sha256sum] = "fd9728383e73b2bb24b044dbee03e469bec9f53a31bd03b6ce5c86d027360535"

URI_aarch64_python3-shiboken6 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-shiboken6-6.10.1-2.el10_2.aarch64.rpm;name=aarch64_python3-shiboken6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-shiboken6}"
SRC_URI[aarch64_python3-shiboken6.sha256sum] = "74e03184f20957f13aac9d7c1f00c3ed0f02f01a78c0fb862cabc132d59456c6"

URI_aarch64_python3-shiboken6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-shiboken6-devel-6.10.1-2.el10_2.aarch64.rpm;name=aarch64_python3-shiboken6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-shiboken6-devel}"
SRC_URI[aarch64_python3-shiboken6-devel.sha256sum] = "ef5ba3ba71e7ac704ac383e949d3b3cdd6607718c7df8f10123fec477aa3acd6"

URI_aarch64_shiboken6 = "${EPEL_MIRROR}/aarch64/Packages/s/shiboken6-6.10.1-2.el10_2.aarch64.rpm;name=aarch64_shiboken6;unpack=0"
SRC_URI:append = " ${URI_aarch64_shiboken6}"
SRC_URI[aarch64_shiboken6.sha256sum] = "a9add2666e62416e0b9cfbf64f2e1c016ac5f66847254cd7017188fdfb7441b6"

RDEPENDS:pyside6-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 qt6-assistant \
 qt6-designer \
 qt6-linguist \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:python3-pyside6 = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 python3-shiboken6 \
 qt6-qt3d \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtconnectivity \
 qt6-qtdatavis3d \
 qt6-qtdeclarative \
 qt6-qtgraphs \
 qt6-qthttpserver \
 qt6-qtlocation \
 qt6-qtmultimedia \
 qt6-qtnetworkauth \
 qt6-qtpdf \
 qt6-qtpositioning \
 qt6-qtquick3d \
 qt6-qtremoteobjects \
 qt6-qtscxml \
 qt6-qtsensors \
 qt6-qtserialbus \
 qt6-qtserialport \
 qt6-qtspeech \
 qt6-qtsvg \
 qt6-qttools \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-help \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 qt6-qtwebsockets \
 qt6-qtwebview \
 "
RDEPENDS:python3-pyside6-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 pyside6-tools \
 python3-pyside6 \
 python3-shiboken6-devel \
 shiboken6 \
 "
RDEPENDS:python3-shiboken6 = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 "
RDEPENDS:python3-shiboken6-devel = " \
 clang20-libs \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 libxslt \
 pkgconf-pkg-config \
 python3 \
 python3-shiboken6 \
 qt6-qtbase \
 shiboken6 \
 "
RDEPENDS:shiboken6 = " \
 cmake-filesystem \
 "
