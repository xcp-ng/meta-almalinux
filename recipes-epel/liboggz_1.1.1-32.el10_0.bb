# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liboggz"
PV = "1.1.1"
PR = "32.el10_0"
PACKAGES = " \
 liboggz \
 liboggz-devel \
 liboggz-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/liboggz-1.1.1-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1eb35fa9c33eda542a6f713494f5660f04ee0884429aea63baf52a70645cb250"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liboggz-1.1.1-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liboggz;unpack=0"
SRC_URI[x86_64_v2_liboggz.sha256sum] = "b145300a4217e53160a69c365bc4cf1852f9089ca994d22627186adb24db87aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liboggz-devel-1.1.1-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liboggz-devel;unpack=0"
SRC_URI[x86_64_v2_liboggz-devel.sha256sum] = "0412eb7cca8350525d9988b1ff6fd16d7f083b9ad8b72dc555c6fc7c9e2d3e72"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liboggz-doc-1.1.1-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liboggz-doc;unpack=0"
SRC_URI[x86_64_v2_liboggz-doc.sha256sum] = "4ebb78de857d51fa8cfe626878adc51d903cd286613b53cedeca2120f7e26dd5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/liboggz-1.1.1-32.el10_0.aarch64.rpm;name=aarch64_liboggz;unpack=0"
SRC_URI[aarch64_liboggz.sha256sum] = "ee2434b949f1be7425b8543fad74fc2302aac7a0775f24617b12065d0d4090f7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/liboggz-devel-1.1.1-32.el10_0.aarch64.rpm;name=aarch64_liboggz-devel;unpack=0"
SRC_URI[aarch64_liboggz-devel.sha256sum] = "808d745968b639267b5c86f785d5c242c467c1e805c1683e388559fe68505992"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/liboggz-doc-1.1.1-32.el10_0.aarch64.rpm;name=aarch64_liboggz-doc;unpack=0"
SRC_URI[aarch64_liboggz-doc.sha256sum] = "59d891a46992bf870a5844f1432fc1439d90aa4fb4f96043628bad524c0d9876"

RDEPENDS:liboggz = " \
 bash \
 glibc \
 libogg \
 "
RDEPENDS:liboggz-devel = " \
 libogg-devel \
 liboggz \
 pkgconf-pkg-config \
 "
RDEPENDS:liboggz-doc = " \
 liboggz \
 "
