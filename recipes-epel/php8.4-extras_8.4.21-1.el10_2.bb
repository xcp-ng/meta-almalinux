# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php8.4-extras"
PV = "8.4.21"
PR = "1.el10_2"
PACKAGES = " \
 php8.4-pdo-dblib \
 php8.4-pdo-firebird \
 php8.4-sodium \
 php8.4-sodium-devel \
 php8.4-tidy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php8.4-extras-8.4.21-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b10bc80816885df1d020934065e472e5101509fd56ab1f71e58525df0ecda6d"

URI_x86_64_v2_php8.4-pdo-dblib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php8.4-pdo-dblib-8.4.21-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php8.4-pdo-dblib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-pdo-dblib}"
SRC_URI[x86_64_v2_php8.4-pdo-dblib.sha256sum] = "58a2b0e593c57b76a3f3fc3e563b1f645516183a1115325f4e0622a43a5716c6"

URI_x86_64_v2_php8.4-pdo-firebird = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php8.4-pdo-firebird-8.4.21-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php8.4-pdo-firebird;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-pdo-firebird}"
SRC_URI[x86_64_v2_php8.4-pdo-firebird.sha256sum] = "9f7816059ba60c4c0748b0f2900ac4e5b7d6d53c388716fcddf09307124cc3c5"

URI_x86_64_v2_php8.4-sodium = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php8.4-sodium-8.4.21-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php8.4-sodium;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-sodium}"
SRC_URI[x86_64_v2_php8.4-sodium.sha256sum] = "2696b56384bd2a34c692416c398511f21b3919c7bf191d6a24afef9bfb9df22d"
RPROVIDES:php8.4-sodium:x86_64_v2 = "virtual/php-sodium"

URI_x86_64_v2_php8.4-sodium-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php8.4-sodium-devel-8.4.21-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php8.4-sodium-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-sodium-devel}"
SRC_URI[x86_64_v2_php8.4-sodium-devel.sha256sum] = "fd32b9822f1906fb4f1706157744e08955f6fbac749e7616e2618a2247ff9834"

URI_x86_64_v2_php8.4-tidy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php8.4-tidy-8.4.21-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php8.4-tidy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-tidy}"
SRC_URI[x86_64_v2_php8.4-tidy.sha256sum] = "016b9303a0eeb90d48cab4502b3d0821197518a2517e71728d9c49d0ded94eb3"

URI_aarch64_php8.4-pdo-dblib = "${EPEL_MIRROR}/aarch64/Packages/p/php8.4-pdo-dblib-8.4.21-1.el10_2.aarch64.rpm;name=aarch64_php8.4-pdo-dblib;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-pdo-dblib}"
SRC_URI[aarch64_php8.4-pdo-dblib.sha256sum] = "880449ff9e93fd49c7e1141c6e46122f78361758100e65b98c2f6afdecafa9c5"

URI_aarch64_php8.4-pdo-firebird = "${EPEL_MIRROR}/aarch64/Packages/p/php8.4-pdo-firebird-8.4.21-1.el10_2.aarch64.rpm;name=aarch64_php8.4-pdo-firebird;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-pdo-firebird}"
SRC_URI[aarch64_php8.4-pdo-firebird.sha256sum] = "c3c9669226f60808abc8972e7331531dca36c35edb3c89893025b3062be4601a"

URI_aarch64_php8.4-sodium = "${EPEL_MIRROR}/aarch64/Packages/p/php8.4-sodium-8.4.21-1.el10_2.aarch64.rpm;name=aarch64_php8.4-sodium;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-sodium}"
SRC_URI[aarch64_php8.4-sodium.sha256sum] = "ab6bfe57c520ddaae0700aeb942a057ba52c08893c1d3cb569088720b45d3086"
RPROVIDES:php8.4-sodium:aarch64 = "virtual/php-sodium"

URI_aarch64_php8.4-sodium-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php8.4-sodium-devel-8.4.21-1.el10_2.aarch64.rpm;name=aarch64_php8.4-sodium-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-sodium-devel}"
SRC_URI[aarch64_php8.4-sodium-devel.sha256sum] = "0fe94e8799fe2bf5594e216032b99f2590fd7a19616803a90981a10e0fb59553"

URI_aarch64_php8.4-tidy = "${EPEL_MIRROR}/aarch64/Packages/p/php8.4-tidy-8.4.21-1.el10_2.aarch64.rpm;name=aarch64_php8.4-tidy;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-tidy}"
SRC_URI[aarch64_php8.4-tidy.sha256sum] = "e1068fd2304975dbe25630e66a265929ff3d87660730862823c337980b8a0912"

RDEPENDS:php8.4-pdo-dblib = " \
 freetds-libs \
 glibc \
 php8.4-common \
 php8.4-pdo \
 "
RDEPENDS:php8.4-pdo-firebird = " \
 glibc \
 libfbclient2 \
 libgcc \
 libstdc++ \
 php8.4-common \
 php8.4-pdo \
 "
RDEPENDS:php8.4-sodium = " \
 glibc \
 libsodium \
 php8.4-common \
 "
RDEPENDS:php8.4-sodium-devel = " \
 php8.4-common \
 php8.4-devel \
 php8.4-sodium \
 "
RDEPENDS:php8.4-tidy = " \
 glibc \
 libtidy \
 php8.4-common \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/php-sodium"

PROVIDES:append:aarch64 = " rpm/virtual/php-sodium"
