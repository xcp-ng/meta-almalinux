# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ctr"
PV = "0.9.2"
PR = "5.el10_0"
PACKAGES = " \
 rust-ctr+alloc-devel \
 rust-ctr+block-padding-devel \
 rust-ctr+default-devel \
 rust-ctr+std-devel \
 rust-ctr+zeroize-devel \
 rust-ctr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ctr-0.9.2-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6de79ef9d74577b16d7f4d77564e37ed93a2ec7f8c7a624b9f02ee07215c3cc"

URI_x86_64_v2_rust-ctr+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctr+alloc-devel-0.9.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctr+alloc-devel}"
SRC_URI[x86_64_v2_rust-ctr+alloc-devel.sha256sum] = "f28ccb586eb78dff319875c50cd581e01dbe615793814c7307886d6503f22b7d"

URI_x86_64_v2_rust-ctr+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctr+block-padding-devel-0.9.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctr+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctr+block-padding-devel}"
SRC_URI[x86_64_v2_rust-ctr+block-padding-devel.sha256sum] = "161effe101679edf2aa5b0bd2380eafce4817da310a9708bea6fb670e3838388"

URI_x86_64_v2_rust-ctr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctr+default-devel-0.9.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctr+default-devel}"
SRC_URI[x86_64_v2_rust-ctr+default-devel.sha256sum] = "eece42d6256721411a6f56f24f58872f1099a6afa2cb5dcb6951ced1e02c35ec"

URI_x86_64_v2_rust-ctr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctr+std-devel-0.9.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctr+std-devel}"
SRC_URI[x86_64_v2_rust-ctr+std-devel.sha256sum] = "181726ccf3057692d5ee1cf46f871997ae4084f2dd08c56828a6c1c95a6b0f4d"

URI_x86_64_v2_rust-ctr+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctr+zeroize-devel-0.9.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctr+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctr+zeroize-devel}"
SRC_URI[x86_64_v2_rust-ctr+zeroize-devel.sha256sum] = "bd9eb82b2561e47f0e9f8467f0261a6874146378becf74a8eb6ae4d867678fb8"

URI_x86_64_v2_rust-ctr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctr-devel-0.9.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctr-devel}"
SRC_URI[x86_64_v2_rust-ctr-devel.sha256sum] = "1e23c8cc995e5ab56182f452426f7c668cc42322f0b02629b44c654a16940023"

URI_aarch64_rust-ctr+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctr+alloc-devel-0.9.2-5.el10_0.noarch.rpm;name=aarch64_rust-ctr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctr+alloc-devel}"
SRC_URI[aarch64_rust-ctr+alloc-devel.sha256sum] = "e0efdfa36c24771e37ef66c14f28f57d498ec025e731996ca6a5b5a9478558a0"

URI_aarch64_rust-ctr+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctr+block-padding-devel-0.9.2-5.el10_0.noarch.rpm;name=aarch64_rust-ctr+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctr+block-padding-devel}"
SRC_URI[aarch64_rust-ctr+block-padding-devel.sha256sum] = "d09330b6ebc56b349cb460b02fd493706d330ce4c62e75c041aa278eca95d541"

URI_aarch64_rust-ctr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctr+default-devel-0.9.2-5.el10_0.noarch.rpm;name=aarch64_rust-ctr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctr+default-devel}"
SRC_URI[aarch64_rust-ctr+default-devel.sha256sum] = "db4369c422c5467b8d6a1b27b1b39e5af75e8116c7060994c3d8b4ce3b5bb73f"

URI_aarch64_rust-ctr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctr+std-devel-0.9.2-5.el10_0.noarch.rpm;name=aarch64_rust-ctr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctr+std-devel}"
SRC_URI[aarch64_rust-ctr+std-devel.sha256sum] = "6cd3babe375cb6cd5cbe281884427a70d715584e0889eec43e22b1d39c018e8f"

URI_aarch64_rust-ctr+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctr+zeroize-devel-0.9.2-5.el10_0.noarch.rpm;name=aarch64_rust-ctr+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctr+zeroize-devel}"
SRC_URI[aarch64_rust-ctr+zeroize-devel.sha256sum] = "f4afe30ddc90d419f6eee72e418bb9dc153cf2cae0c2680ab41e63cf0516e6c6"

URI_aarch64_rust-ctr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctr-devel-0.9.2-5.el10_0.noarch.rpm;name=aarch64_rust-ctr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctr-devel}"
SRC_URI[aarch64_rust-ctr-devel.sha256sum] = "a8cb0ea7ce6e198d807caca4163c70e5ee52edf001c8711355e1fd71d01284cc"

RDEPENDS:rust-ctr+alloc-devel = " \
 cargo \
 rust-cipher0.4+alloc-devel \
 rust-ctr-devel \
 "
RDEPENDS:rust-ctr+block-padding-devel = " \
 cargo \
 rust-cipher0.4+block-padding-devel \
 rust-ctr-devel \
 "
RDEPENDS:rust-ctr+default-devel = " \
 cargo \
 rust-ctr-devel \
 "
RDEPENDS:rust-ctr+std-devel = " \
 cargo \
 rust-cipher0.4+std-devel \
 rust-ctr+alloc-devel \
 rust-ctr-devel \
 "
RDEPENDS:rust-ctr+zeroize-devel = " \
 cargo \
 rust-cipher0.4+zeroize-devel \
 rust-ctr-devel \
 "
RDEPENDS:rust-ctr-devel = " \
 cargo \
 rust \
 rust-cipher0.4+default-devel \
 "
