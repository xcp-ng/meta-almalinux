# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jiff-core"
PV = "0.1.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-jiff-core+alloc-devel \
 rust-jiff-core+default-devel \
 rust-jiff-core+logging-devel \
 rust-jiff-core+std-devel \
 rust-jiff-core+tz-fat-devel \
 rust-jiff-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jiff-core-0.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c0c8b2149d1e6954a9209dd3c1b765588262662db1c245da07e277e04056cba"

URI_x86_64_v2_rust-jiff-core+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+alloc-devel-0.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-core+alloc-devel}"
SRC_URI[x86_64_v2_rust-jiff-core+alloc-devel.sha256sum] = "2cd880facfa3473b3300d0a3db23488ed31542695923760f302340fcc8cdddb0"

URI_x86_64_v2_rust-jiff-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+default-devel-0.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-core+default-devel}"
SRC_URI[x86_64_v2_rust-jiff-core+default-devel.sha256sum] = "2b68947851dffd160c5064cc8f9b5ab5663601cc2ab3f13cf0fdba4d707dccca"

URI_x86_64_v2_rust-jiff-core+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+logging-devel-0.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-core+logging-devel}"
SRC_URI[x86_64_v2_rust-jiff-core+logging-devel.sha256sum] = "ea1cef439615b45da612c8133ea9576e33c5005c42023554054e8f027ca1affe"

URI_x86_64_v2_rust-jiff-core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+std-devel-0.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-core+std-devel}"
SRC_URI[x86_64_v2_rust-jiff-core+std-devel.sha256sum] = "85c1c2e1c895b44299b9a11002eca698e63089b9c34acdd8b6340fa8b604f809"

URI_x86_64_v2_rust-jiff-core+tz-fat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+tz-fat-devel-0.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+tz-fat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-core+tz-fat-devel}"
SRC_URI[x86_64_v2_rust-jiff-core+tz-fat-devel.sha256sum] = "0db2c2bc12a39e7fea3d9e83b7b29a8581d67d7d36d3a877d7195d92657f9d88"

URI_x86_64_v2_rust-jiff-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core-devel-0.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-core-devel}"
SRC_URI[x86_64_v2_rust-jiff-core-devel.sha256sum] = "aa93158a28dc6a64479f87fd337b4421fb4e2c1e284b625e935575c503b3c495"

URI_aarch64_rust-jiff-core+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+alloc-devel-0.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-core+alloc-devel}"
SRC_URI[aarch64_rust-jiff-core+alloc-devel.sha256sum] = "1fa1ab12ac725fe307ed0a4de5e512e44eef44a33f3a1ae3fa6e614d93816195"

URI_aarch64_rust-jiff-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+default-devel-0.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-core+default-devel}"
SRC_URI[aarch64_rust-jiff-core+default-devel.sha256sum] = "e856a4d1283d796d8c441e425f9eb167c36cb94e0ab60eef47170d04b2cd001d"

URI_aarch64_rust-jiff-core+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+logging-devel-0.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-core+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-core+logging-devel}"
SRC_URI[aarch64_rust-jiff-core+logging-devel.sha256sum] = "99d4e391abacb05959b84fa3d549097ceae7e65107c5d1454ad89fd23274dfb7"

URI_aarch64_rust-jiff-core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+std-devel-0.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-core+std-devel}"
SRC_URI[aarch64_rust-jiff-core+std-devel.sha256sum] = "610b49a849533bffe4be1badbbc1b4086f125c312efdb52a8f140e29ea18cdb5"

URI_aarch64_rust-jiff-core+tz-fat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+tz-fat-devel-0.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-core+tz-fat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-core+tz-fat-devel}"
SRC_URI[aarch64_rust-jiff-core+tz-fat-devel.sha256sum] = "34e2c256f0660318a6b6e8d325751dd24c4e6e0b0106a1cc2ed970015952c702"

URI_aarch64_rust-jiff-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core-devel-0.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-core-devel}"
SRC_URI[aarch64_rust-jiff-core-devel.sha256sum] = "0b296026f330b4078ef7dbc44fb0462b7fce999b6a482edf7e3f73843ecdc724"

RDEPENDS:rust-jiff-core+alloc-devel = " \
 cargo \
 rust-jiff-core-devel \
 "
RDEPENDS:rust-jiff-core+default-devel = " \
 cargo \
 rust-jiff-core+std-devel \
 rust-jiff-core+tz-fat-devel \
 rust-jiff-core-devel \
 "
RDEPENDS:rust-jiff-core+logging-devel = " \
 cargo \
 rust-jiff-core-devel \
 rust-log-devel \
 "
RDEPENDS:rust-jiff-core+std-devel = " \
 cargo \
 rust-jiff-core+alloc-devel \
 rust-jiff-core-devel \
 "
RDEPENDS:rust-jiff-core+tz-fat-devel = " \
 cargo \
 rust-jiff-core-devel \
 "
RDEPENDS:rust-jiff-core-devel = " \
 cargo \
 rust \
 "
