# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-google-btree"
PV = "1.0.1"
PR = "11.el10_0"
PACKAGES = " \
 golang-github-google-btree-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-google-btree-1.0.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "da077e6fa407cacb265b66a9fb20e8c5ea826df25403c3d51935dc67a2eff49d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-google-btree-devel-1.0.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-google-btree-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-google-btree-devel.sha256sum] = "12b35e798853a2d411e6271d622dcd6faa3d22d674fb9115dec33a10e2f36c31"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-google-btree-devel-1.0.1-11.el10_0.noarch.rpm;name=aarch64_golang-github-google-btree-devel;unpack=0"
SRC_URI[aarch64_golang-github-google-btree-devel.sha256sum] = "326da94505d0b133d12fd8b563729713ceeaa0097e471d2acc3c99e50d9da1d6"

RDEPENDS:golang-github-google-btree-devel = " \
 go-filesystem \
 "
