# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "painless-password-rotation"
PV = "0.3"
PR = "5.el10_0"
PACKAGES = " \
 painless-password-rotation \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/painless-password-rotation-0.3-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f697cb1751b43ae47240d4ca85015a464358fc8051ac43415cc1876b69f18900"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/painless-password-rotation-0.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_painless-password-rotation;unpack=0"
SRC_URI[x86_64_v2_painless-password-rotation.sha256sum] = "f4ff9f354f634491fbd8970585631a7a474307bc0e02eef5ba82e0bdabc87733"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/painless-password-rotation-0.3-5.el10_0.noarch.rpm;name=aarch64_painless-password-rotation;unpack=0"
SRC_URI[aarch64_painless-password-rotation.sha256sum] = "9ac4acdd5e3d7436bbf15fd629661c3478b90381ba273da518313dfb2aa24eb3"

RDEPENDS:painless-password-rotation = " \
 bash \
 "
