# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "initial-setup"
PV = "0.3.101"
PR = "1.1.el10_0"
PACKAGES = " \
 initial-setup \
 initial-setup-gui \
 initial-setup-gui-wayland-generic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/initial-setup-0.3.101-1.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78cb680e17edb3c344ef48fce0b5fc6a24d81d86592c6bc8a96537d949fceb19"

URI_x86_64_v2_initial-setup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/initial-setup-0.3.101-1.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_initial-setup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_initial-setup}"
SRC_URI[x86_64_v2_initial-setup.sha256sum] = "6937db5885fa108444b3d59e84f09c7a0ed745116c7be2108d72e4842036b591"

URI_x86_64_v2_initial-setup-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/initial-setup-gui-0.3.101-1.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_initial-setup-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_initial-setup-gui}"
SRC_URI[x86_64_v2_initial-setup-gui.sha256sum] = "f6423b4d9d2d008adc0d9ca61d729229fa109bb9f4cc2bf9e6902998795b9253"

URI_x86_64_v2_initial-setup-gui-wayland-generic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/initial-setup-gui-wayland-generic-0.3.101-1.1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_initial-setup-gui-wayland-generic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_initial-setup-gui-wayland-generic}"
SRC_URI[x86_64_v2_initial-setup-gui-wayland-generic.sha256sum] = "c46c8ed1965fe1726c3af0ccef49f9efb1d1a885bf0eb3fac14eb0126d5bce62"
RPROVIDES:initial-setup-gui-wayland-generic:x86_64_v2 = "virtual/firstboot_gui-backend_"

URI_aarch64_initial-setup = "${EPEL_MIRROR}/aarch64/Packages/i/initial-setup-0.3.101-1.1.el10_0.aarch64.rpm;name=aarch64_initial-setup;unpack=0"
SRC_URI:append = " ${URI_aarch64_initial-setup}"
SRC_URI[aarch64_initial-setup.sha256sum] = "28da9d662668a847cea357c0c1a9739547454b4d24637c20733098394da0acf7"

URI_aarch64_initial-setup-gui = "${EPEL_MIRROR}/aarch64/Packages/i/initial-setup-gui-0.3.101-1.1.el10_0.aarch64.rpm;name=aarch64_initial-setup-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_initial-setup-gui}"
SRC_URI[aarch64_initial-setup-gui.sha256sum] = "343096810139b20bc218d21589f5999329d4c43eb7046ec6e0cdfcf5d05276a4"

URI_aarch64_initial-setup-gui-wayland-generic = "${EPEL_MIRROR}/aarch64/Packages/i/initial-setup-gui-wayland-generic-0.3.101-1.1.el10_0.aarch64.rpm;name=aarch64_initial-setup-gui-wayland-generic;unpack=0"
SRC_URI:append = " ${URI_aarch64_initial-setup-gui-wayland-generic}"
SRC_URI[aarch64_initial-setup-gui-wayland-generic.sha256sum] = "7f224c7cc10b5303f58f73dcb41d5e6533c2907db4fc630b1a72d84242445362"
RPROVIDES:initial-setup-gui-wayland-generic:aarch64 = "virtual/firstboot_gui-backend_"

RDEPENDS:initial-setup = " \
 anaconda-tui \
 bash \
 libxkbcommon \
 python3 \
 python3-simpleline \
 systemd \
 util-linux \
 "
RDEPENDS:initial-setup-gui = " \
 anaconda-gui \
 gtk3 \
 initial-setup \
 python3 \
 virtual/firstboot_gui-backend_ \
 "
RDEPENDS:initial-setup-gui-wayland-generic = " \
 bash \
 initial-setup-gui \
 weston \
 xorg-x11-server-Xwayland \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/firstboot_gui-backend_"

PROVIDES:append:aarch64 = " rpm/virtual/firstboot_gui-backend_"
