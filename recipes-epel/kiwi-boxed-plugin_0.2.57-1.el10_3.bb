# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi-boxed-plugin"
PV = "0.2.57"
PR = "1.el10_3"
PACKAGES = " \
 kiwi-boxed-plugin \
 python3-kiwi-boxed-plugin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kiwi-boxed-plugin-0.2.57-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7b8edc4738b80a951619a3474c0d798e9156f76b365e9a052778fd314f91165"

URI_x86_64_v2_kiwi-boxed-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-boxed-plugin-0.2.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-boxed-plugin}"
SRC_URI[x86_64_v2_kiwi-boxed-plugin.sha256sum] = "acdf933d71438184cc1c2b0d3dc3397e0f0b67da55da050c58465add3e38d7cc"

URI_x86_64_v2_python3-kiwi-boxed-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-boxed-plugin-0.2.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kiwi-boxed-plugin}"
SRC_URI[x86_64_v2_python3-kiwi-boxed-plugin.sha256sum] = "e41fd62dcd508e693f123f2c0d6989950be974b8d96341b1f40e3ceeac0a350f"

URI_aarch64_kiwi-boxed-plugin = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-boxed-plugin-0.2.57-1.el10_3.noarch.rpm;name=aarch64_kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-boxed-plugin}"
SRC_URI[aarch64_kiwi-boxed-plugin.sha256sum] = "b877b0a7ebc9c6da1699f70399b2862160ef8d909b8235beb3199a6cb20cb0bb"

URI_aarch64_python3-kiwi-boxed-plugin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-boxed-plugin-0.2.57-1.el10_3.noarch.rpm;name=aarch64_python3-kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kiwi-boxed-plugin}"
SRC_URI[aarch64_python3-kiwi-boxed-plugin.sha256sum] = "08c75dfad05d693833fa93b0bb2003bbe1d964cdda0bb6189259415e9764b6d5"

RDEPENDS:kiwi-boxed-plugin = " \
 python3-kiwi-boxed-plugin \
 "
RDEPENDS:python3-kiwi-boxed-plugin = " \
 python3 \
 python3-cerberus \
 python3-docopt-ng \
 python3-kiwi \
 python3-progressbar2 \
 python3-pyyaml \
 python3-requests \
 qemu-kvm \
 "
