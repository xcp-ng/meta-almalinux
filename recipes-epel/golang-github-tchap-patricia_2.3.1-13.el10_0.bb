# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-tchap-patricia"
PV = "2.3.1"
PR = "13.el10_0"
PACKAGES = " \
 compat-golang-github-tchap-patricia-2-devel \
 golang-github-tchap-patricia-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-tchap-patricia-2.3.1-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10ff80551422e676f57357ab784374db3c842d0600adba424285affb3bb352bd"

URI_x86_64_v2_compat-golang-github-tchap-patricia-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-tchap-patricia-2-devel-2.3.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-tchap-patricia-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-tchap-patricia-2-devel}"
SRC_URI[x86_64_v2_compat-golang-github-tchap-patricia-2-devel.sha256sum] = "2813965324a826b566647b82772da004da06fcadacd70b73986384a7597ef79e"

URI_x86_64_v2_golang-github-tchap-patricia-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-tchap-patricia-devel-2.3.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-tchap-patricia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-tchap-patricia-devel}"
SRC_URI[x86_64_v2_golang-github-tchap-patricia-devel.sha256sum] = "591565b16c391b7679f3b6ef091301a3943926e66b28c76fa28f87b0edd063d6"

URI_aarch64_compat-golang-github-tchap-patricia-2-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-tchap-patricia-2-devel-2.3.1-13.el10_0.noarch.rpm;name=aarch64_compat-golang-github-tchap-patricia-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-tchap-patricia-2-devel}"
SRC_URI[aarch64_compat-golang-github-tchap-patricia-2-devel.sha256sum] = "7e9aaf8d4cc8b80ba202d2c9d11b1b260bc5730be292535c13fccb67bd7dd654"

URI_aarch64_golang-github-tchap-patricia-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-tchap-patricia-devel-2.3.1-13.el10_0.noarch.rpm;name=aarch64_golang-github-tchap-patricia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-tchap-patricia-devel}"
SRC_URI[aarch64_golang-github-tchap-patricia-devel.sha256sum] = "2f2c72185bb3f35c67be2d6c4564a50f299fd33a6348a365a46786a641a0a602"

RDEPENDS:compat-golang-github-tchap-patricia-2-devel = " \
 go-filesystem \
 golang-github-tchap-patricia-devel \
 "
RDEPENDS:golang-github-tchap-patricia-devel = " \
 go-filesystem \
 "
