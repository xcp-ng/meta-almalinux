# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-nds"
PV = "0.1"
PR = "32.el10"
PACKAGES = " \
 hunspell-nds \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-nds-0.1-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "059d7174820c4340fed7f40c29cbebedf17a33a73bcd7deaf2a7c8b7df4fd3c9"

URI_x86_64_v2_hunspell-nds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-nds-0.1-32.el10.noarch.rpm;name=x86_64_v2_hunspell-nds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-nds}"
SRC_URI[x86_64_v2_hunspell-nds.sha256sum] = "495990a3ed7ef2340000b2df1148d222fde8eb196b0c8d0390152e14d635c3ca"

URI_aarch64_hunspell-nds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-nds-0.1-32.el10.noarch.rpm;name=aarch64_hunspell-nds;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-nds}"
SRC_URI[aarch64_hunspell-nds.sha256sum] = "495990a3ed7ef2340000b2df1148d222fde8eb196b0c8d0390152e14d635c3ca"

RDEPENDS:hunspell-nds = " \
 hunspell-filesystem \
 "
