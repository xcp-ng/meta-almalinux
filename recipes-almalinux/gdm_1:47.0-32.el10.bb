# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdm"
PE = "1"
PV = "47.0"
PR = "32.el10"
PACKAGES = " \
 gdm \
 gdm-devel \
 gdm-pam-extensions-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdm-47.0-32.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f73ffc67219f43268ca581a1638b88a8364c84052283e1d36e359ae39438e371"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdm-47.0-32.el10.x86_64_v2.rpm;name=x86_64_v2_gdm;unpack=0"
SRC_URI[x86_64_v2_gdm.sha256sum] = "419078d5a01d544b779e1b8875b6fda803ee94eef8c4199c93804f4724520cd5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdm-devel-47.0-32.el10.x86_64_v2.rpm;name=x86_64_v2_gdm-devel;unpack=0"
SRC_URI[x86_64_v2_gdm-devel.sha256sum] = "4171bff51f8beb8db110771187cc61821817dfe7074b5e98ea316fb02b270bf6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdm-pam-extensions-devel-47.0-32.el10.x86_64_v2.rpm;name=x86_64_v2_gdm-pam-extensions-devel;unpack=0"
SRC_URI[x86_64_v2_gdm-pam-extensions-devel.sha256sum] = "cbe75f2340f26656137cf01b1f22daf2c697c11cfa8cab69dfde35efdc4ada85"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdm-47.0-32.el10.aarch64.rpm;name=aarch64_gdm;unpack=0"
SRC_URI[aarch64_gdm.sha256sum] = "1d5e0552739a39c9e719776e0bf437c7eda53549662249533463eb9a5602ecc3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdm-devel-47.0-32.el10.aarch64.rpm;name=aarch64_gdm-devel;unpack=0"
SRC_URI[aarch64_gdm-devel.sha256sum] = "af19573df43a867e20219c5b5b72dde5c5fb8e62376cdc2027d8e292668ea926"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdm-pam-extensions-devel-47.0-32.el10.aarch64.rpm;name=aarch64_gdm-pam-extensions-devel;unpack=0"
SRC_URI[aarch64_gdm-pam-extensions-devel.sha256sum] = "c0e641cfbbd97d98fb3170fe718c18f6716ad27df0262a7fe11bcb0e4fc0aa6d"

RDEPENDS:gdm = " \
 accountsservice \
 accountsservice-libs \
 almalinux-logos \
 audit-libs \
 bash \
 dbus-daemon \
 dconf \
 glib2 \
 glibc \
 gnome-keyring-pam \
 gnome-session \
 gnome-session-wayland-session \
 gnome-settings-daemon \
 gnome-shell \
 iso-codes \
 json-glib \
 keyutils-libs \
 libXau \
 libgcc \
 libgudev \
 libselinux \
 pam \
 pam-libs \
 polkit-libs \
 python3-pam \
 shadow-utils \
 systemd \
 systemd-libs \
 util-linux \
 "
RDEPENDS:gdm-devel = " \
 gdm \
 gdm-pam-extensions-devel \
 glib2-devel \
 libselinux-devel \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:gdm-pam-extensions-devel = " \
 pam-devel \
 pkgconf-pkg-config \
 "
