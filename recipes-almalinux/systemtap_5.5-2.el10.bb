# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "systemtap"
PV = "5.5"
PR = "2.el10"
PACKAGES = " \
 systemtap \
 systemtap-client \
 systemtap-devel \
 systemtap-exporter \
 systemtap-initscript \
 systemtap-runtime \
 systemtap-runtime-java \
 systemtap-runtime-python3 \
 systemtap-runtime-virtguest \
 systemtap-runtime-virthost \
 systemtap-sdt-devel \
 systemtap-sdt-dtrace \
 systemtap-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/systemtap-5.5-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f2d45a856d53824a20a0fad0f7916033ed5951576882fe2e64d5fc1f6b9a3b4"

URI_x86_64_v2_systemtap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-5.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap}"
SRC_URI[x86_64_v2_systemtap.sha256sum] = "1d5dd04fee8b9bd97fc674650d380eac069899960a71d700a001a88b5f5e4836"

URI_x86_64_v2_systemtap-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-client-5.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-client}"
SRC_URI[x86_64_v2_systemtap-client.sha256sum] = "182aa9e7406a4fcf1521f79a0404acd96b61c70529212c31b2ecd6e8f2cc85c4"

URI_x86_64_v2_systemtap-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-devel-5.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-devel}"
SRC_URI[x86_64_v2_systemtap-devel.sha256sum] = "e0de70d5e034066098e564612e0d23b51792c849e8885dd8495374f65303f7eb"

URI_x86_64_v2_systemtap-exporter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-exporter-5.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-exporter}"
SRC_URI[x86_64_v2_systemtap-exporter.sha256sum] = "4801b3649cd008a3ff6a94f21042dafe3217aacfdd1dd1dc6eb0481d9eeab461"

URI_x86_64_v2_systemtap-initscript = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-initscript-5.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-initscript;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-initscript}"
SRC_URI[x86_64_v2_systemtap-initscript.sha256sum] = "2d8e241f5f148e9476ba2943a65994b9fd2e8aaa3b92606b7a7612db1d18ab2c"

URI_x86_64_v2_systemtap-runtime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-5.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime}"
SRC_URI[x86_64_v2_systemtap-runtime.sha256sum] = "f50f0af0a77520c5508730bbe24ad551f0f2164d63b329ad6ef0276741cb7b8c"

URI_x86_64_v2_systemtap-runtime-java = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-java-5.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-java}"
SRC_URI[x86_64_v2_systemtap-runtime-java.sha256sum] = "f344ff1b999a90c54134539fd21c6336722a56d5b0ce8a3114cba6ef0ef8800b"

URI_x86_64_v2_systemtap-runtime-python3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-python3-5.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-python3}"
SRC_URI[x86_64_v2_systemtap-runtime-python3.sha256sum] = "56da58e447228cb74daafb4701cb0e21e4c3ecad4ebd1ab21e0e32242a5bd204"

URI_x86_64_v2_systemtap-runtime-virtguest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-virtguest-5.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-virtguest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-virtguest}"
SRC_URI[x86_64_v2_systemtap-runtime-virtguest.sha256sum] = "e582646b7b9a094653f72e19df88709b5c9ff009abff9f278b66ef8dd5aa86f9"

URI_x86_64_v2_systemtap-runtime-virthost = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-virthost-5.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-virthost;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-virthost}"
SRC_URI[x86_64_v2_systemtap-runtime-virthost.sha256sum] = "489a1c684f4213afdb539822f8c3ece9a268ab91ae6bf893c56c4e32765fd147"

URI_x86_64_v2_systemtap-sdt-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-sdt-devel-5.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-sdt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-sdt-devel}"
SRC_URI[x86_64_v2_systemtap-sdt-devel.sha256sum] = "30dd4d4153988140d27d1fa8d381dcbfe67d29101c6ba6833b40f5e6230c104a"

URI_x86_64_v2_systemtap-sdt-dtrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-sdt-dtrace-5.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-sdt-dtrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-sdt-dtrace}"
SRC_URI[x86_64_v2_systemtap-sdt-dtrace.sha256sum] = "e62ff808790846d4ce10caace7f7d9f46e33aca232e20c7e868da90d1a012dcd"

URI_x86_64_v2_systemtap-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-server-5.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-server}"
SRC_URI[x86_64_v2_systemtap-server.sha256sum] = "894a4fd6a88f81cf68d19d6dde5d971f00967319a917dd66381711f00ec07274"

URI_aarch64_systemtap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-5.5-2.el10.aarch64.rpm;name=aarch64_systemtap;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap}"
SRC_URI[aarch64_systemtap.sha256sum] = "aa46993f934674d52dbe56c7ae6995b82522a2d505aabb7d0d1762fc943e14ae"

URI_aarch64_systemtap-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-client-5.5-2.el10.aarch64.rpm;name=aarch64_systemtap-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-client}"
SRC_URI[aarch64_systemtap-client.sha256sum] = "6d185497900ac6968bda1a3e30576ba2458b46c49fa5ecfd4b6aa30e24e7071c"

URI_aarch64_systemtap-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-devel-5.5-2.el10.aarch64.rpm;name=aarch64_systemtap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-devel}"
SRC_URI[aarch64_systemtap-devel.sha256sum] = "4a27db4ab381fa7a890fcafc9f0ff442e3a1841a5a938c162ec88e977397cad4"

URI_aarch64_systemtap-exporter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-exporter-5.5-2.el10.aarch64.rpm;name=aarch64_systemtap-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-exporter}"
SRC_URI[aarch64_systemtap-exporter.sha256sum] = "2cb0a23d17861bec8e107334c9128a0fda86dc1e7ad065432e2aff7de3aca28b"

URI_aarch64_systemtap-initscript = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-initscript-5.5-2.el10.aarch64.rpm;name=aarch64_systemtap-initscript;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-initscript}"
SRC_URI[aarch64_systemtap-initscript.sha256sum] = "d24968426f97b0867b1e6f2820f298bba27fd73f5275035f3077c74929be4137"

URI_aarch64_systemtap-runtime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-5.5-2.el10.aarch64.rpm;name=aarch64_systemtap-runtime;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime}"
SRC_URI[aarch64_systemtap-runtime.sha256sum] = "b01d2b13edd59ffe8fa704300fee996b43a645dd8880120e3b9c4cc59c2e8007"

URI_aarch64_systemtap-runtime-java = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-java-5.5-2.el10.aarch64.rpm;name=aarch64_systemtap-runtime-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-java}"
SRC_URI[aarch64_systemtap-runtime-java.sha256sum] = "64cb932cbaf25bff6f7ab96232f9ee2c0c4fb76904fa910b103d2f217fc1c09a"

URI_aarch64_systemtap-runtime-python3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-python3-5.5-2.el10.aarch64.rpm;name=aarch64_systemtap-runtime-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-python3}"
SRC_URI[aarch64_systemtap-runtime-python3.sha256sum] = "6e3fe4c0aa27f8676cd934ddb326fa4759f91da13c02797cdb42e23e85cc0828"

URI_aarch64_systemtap-runtime-virtguest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-virtguest-5.5-2.el10.aarch64.rpm;name=aarch64_systemtap-runtime-virtguest;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-virtguest}"
SRC_URI[aarch64_systemtap-runtime-virtguest.sha256sum] = "ad7b46a0ab1743ffc28e1ea2c1a0b4da5a545595a353dade34495bf47a623ac6"

URI_aarch64_systemtap-runtime-virthost = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-virthost-5.5-2.el10.aarch64.rpm;name=aarch64_systemtap-runtime-virthost;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-virthost}"
SRC_URI[aarch64_systemtap-runtime-virthost.sha256sum] = "3d5d78cfeaeb58754c287821b8e04633791177180ac139b71e252be57a5e6f32"

URI_aarch64_systemtap-sdt-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-sdt-devel-5.5-2.el10.aarch64.rpm;name=aarch64_systemtap-sdt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-sdt-devel}"
SRC_URI[aarch64_systemtap-sdt-devel.sha256sum] = "faa02a1c7d331440ab05368220a6d337cd9645a3266416768915546bb02307b0"

URI_aarch64_systemtap-sdt-dtrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-sdt-dtrace-5.5-2.el10.aarch64.rpm;name=aarch64_systemtap-sdt-dtrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-sdt-dtrace}"
SRC_URI[aarch64_systemtap-sdt-dtrace.sha256sum] = "bea7a8bb0ffc11ccbd246918d296c7212ae9645df4a236edd7979f0f404f9fa7"

URI_aarch64_systemtap-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-server-5.5-2.el10.aarch64.rpm;name=aarch64_systemtap-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-server}"
SRC_URI[aarch64_systemtap-server.sha256sum] = "e440f9291c9a0f08f1855a76bfa83e802d49eb3e4665f8f987495de8506a4eeb"

RDEPENDS:systemtap = " \
 bash \
 systemtap-client \
 systemtap-devel \
 "
RDEPENDS:systemtap-client:x86_64_v2 = " \
 avahi-libs \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 grep \
 json-c \
 libgcc \
 libstdc++ \
 mokutil \
 nspr \
 nss \
 openssh-clients \
 perl-interpreter \
 readline \
 rpm-libs \
 sed \
 sqlite-libs \
 systemtap-runtime \
 unzip \
 virtual/coreutils \
 zip \
"
RDEPENDS:systemtap-client:aarch64 = " \
 avahi-libs \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 grep \
 json-c \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 openssh-clients \
 perl-interpreter \
 readline \
 rpm-libs \
 sed \
 sqlite-libs \
 systemtap-runtime \
 unzip \
 virtual/coreutils \
 zip \
"
RDEPENDS:systemtap-devel = " \
 avahi-libs \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-devel \
 elfutils-libelf \
 elfutils-libs \
 gcc \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 make \
 nspr \
 nss \
 python3 \
 readline \
 rpm-libs \
 sqlite-libs \
 "
RDEPENDS:systemtap-exporter = " \
 bash \
 python3 \
 systemtap-runtime \
 "
RDEPENDS:systemtap-initscript = " \
 bash \
 systemd \
 systemtap \
 "
RDEPENDS:systemtap-runtime = " \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-libelf \
 glibc \
 json-c \
 libgcc \
 libselinux \
 libstdc++ \
 ncurses-libs \
 nspr \
 nss \
 shadow-utils \
 "
RDEPENDS:systemtap-runtime-java = " \
 bash \
 byteman \
 glibc \
 iproute \
 java-21-openjdk-devel \
 systemtap-runtime \
 "
RDEPENDS:systemtap-runtime-python3 = " \
 glibc \
 python3 \
 systemtap-runtime \
 "
RDEPENDS:systemtap-runtime-virtguest = " \
 bash \
 findutils \
 grep \
 systemtap-runtime \
 virtual/coreutils \
 "
RDEPENDS:systemtap-runtime-virthost = " \
 glibc \
 libvirt-libs \
 libxml2 \
 "
RDEPENDS:systemtap-sdt-devel = " \
 systemtap-sdt-dtrace \
 "
RDEPENDS:systemtap-sdt-dtrace = " \
 python3 \
 python3-pyparsing \
 "
RDEPENDS:systemtap-server:x86_64_v2 = " \
 avahi-libs \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 openssl \
 shadow-utils \
 systemd \
 systemtap-devel \
 unzip \
 virtual/coreutils \
 zip \
"
RDEPENDS:systemtap-server:aarch64 = " \
 avahi-libs \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 shadow-utils \
 systemd \
 systemtap-devel \
 unzip \
 virtual/coreutils \
 zip \
"
