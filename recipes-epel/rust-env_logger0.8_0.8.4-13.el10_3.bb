# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_logger0.8"
PV = "0.8.4"
PR = "13.el10_3"
PACKAGES = " \
 rust-env_logger0.8+atty-devel \
 rust-env_logger0.8+default-devel \
 rust-env_logger0.8+humantime-devel \
 rust-env_logger0.8+regex-devel \
 rust-env_logger0.8+termcolor-devel \
 rust-env_logger0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_logger0.8-0.8.4-13.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a8b2ff19700704f7d4c62bf9a6f4618008348d86b9ee84c0f8df724ceaff1bd"

URI_x86_64_v2_rust-env_logger0.8+atty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+atty-devel-0.8.4-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+atty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+atty-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+atty-devel.sha256sum] = "7a7b26eabcf32aadd9ef8f628d851894d0a4c73dc2a6648eab577d09b1556490"

URI_x86_64_v2_rust-env_logger0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+default-devel-0.8.4-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+default-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+default-devel.sha256sum] = "3e1b6069a647bec9f1a75fae3e993371f6edae1d24da3bc484b53368e7084602"

URI_x86_64_v2_rust-env_logger0.8+humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+humantime-devel-0.8.4-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+humantime-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+humantime-devel.sha256sum] = "27316acc382634a12770abee2931e54ad9fb2d670ee8ba9670a0639a5e2676e5"

URI_x86_64_v2_rust-env_logger0.8+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+regex-devel-0.8.4-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+regex-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+regex-devel.sha256sum] = "363c1c9d0adeb2f4a51450bcddf83ec7f14039c6abbeeee932a048d2067c1719"

URI_x86_64_v2_rust-env_logger0.8+termcolor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+termcolor-devel-0.8.4-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+termcolor-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+termcolor-devel.sha256sum] = "8a8672e97de775e9483bf22fde1bd9d2af2b6cecf4a0bde0a6bdf1e34558d4b0"

URI_x86_64_v2_rust-env_logger0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8-devel-0.8.4-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8-devel.sha256sum] = "e6fd5f725e24359b769e3e7380a473482ce440af8fe6fe3eefca6cb200ebbf7a"
RPROVIDES:rust-env_logger0.8-devel:x86_64_v2 = "virtual/crate_env_logger__ge_0.6.1"

URI_aarch64_rust-env_logger0.8+atty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+atty-devel-0.8.4-13.el10_3.noarch.rpm;name=aarch64_rust-env_logger0.8+atty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+atty-devel}"
SRC_URI[aarch64_rust-env_logger0.8+atty-devel.sha256sum] = "c8d08c2f4d0a87847abac74ada6952a3f13c4493894cb3ea2d826fb196126f66"

URI_aarch64_rust-env_logger0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+default-devel-0.8.4-13.el10_3.noarch.rpm;name=aarch64_rust-env_logger0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+default-devel}"
SRC_URI[aarch64_rust-env_logger0.8+default-devel.sha256sum] = "5d2bc74d80fd8ca2bac95a10a870d6c1c006acf49730b72c815e707bae0082dc"

URI_aarch64_rust-env_logger0.8+humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+humantime-devel-0.8.4-13.el10_3.noarch.rpm;name=aarch64_rust-env_logger0.8+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+humantime-devel}"
SRC_URI[aarch64_rust-env_logger0.8+humantime-devel.sha256sum] = "589cc46fe6aae7323b094fe03f7bf4c7c70b6deb403dbadd4c5e596c3b7071ea"

URI_aarch64_rust-env_logger0.8+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+regex-devel-0.8.4-13.el10_3.noarch.rpm;name=aarch64_rust-env_logger0.8+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+regex-devel}"
SRC_URI[aarch64_rust-env_logger0.8+regex-devel.sha256sum] = "20f33117ffab676c0d9b623ab6dd85ec455558777fb40b46fe26a7aef53dd0ec"

URI_aarch64_rust-env_logger0.8+termcolor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+termcolor-devel-0.8.4-13.el10_3.noarch.rpm;name=aarch64_rust-env_logger0.8+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+termcolor-devel}"
SRC_URI[aarch64_rust-env_logger0.8+termcolor-devel.sha256sum] = "84b1c1a413d3b56121edb913f6c590f8872f2ed731c7fc6849926f39f27adc02"

URI_aarch64_rust-env_logger0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8-devel-0.8.4-13.el10_3.noarch.rpm;name=aarch64_rust-env_logger0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8-devel}"
SRC_URI[aarch64_rust-env_logger0.8-devel.sha256sum] = "500780feea1947360467bb69fbba011c562ea53525caf7c91399b2be50041370"
RPROVIDES:rust-env_logger0.8-devel:aarch64 = "virtual/crate_env_logger__ge_0.6.1"

RDEPENDS:rust-env_logger0.8+atty-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 "
RDEPENDS:rust-env_logger0.8+default-devel = " \
 cargo \
 rust-env_logger0.8+atty-devel \
 rust-env_logger0.8+humantime-devel \
 rust-env_logger0.8+regex-devel \
 rust-env_logger0.8+termcolor-devel \
 rust-env_logger0.8-devel \
 "
RDEPENDS:rust-env_logger0.8+humantime-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 rust-humantime+default-devel \
 "
RDEPENDS:rust-env_logger0.8+regex-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-env_logger0.8+termcolor-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 rust-termcolor+default-devel \
 "
RDEPENDS:rust-env_logger0.8-devel = " \
 cargo \
 rust-log+default-devel \
 rust-log+std-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_env_logger__ge_0.6.1"

PROVIDES:append:aarch64 = " rpm/virtual/crate_env_logger__ge_0.6.1"
