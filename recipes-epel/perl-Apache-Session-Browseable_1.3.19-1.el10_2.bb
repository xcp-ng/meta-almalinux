# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Apache-Session-Browseable"
PV = "1.3.19"
PR = "1.el10_2"
PACKAGES = " \
 perl-Apache-Session-Browseable \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Apache-Session-Browseable-1.3.19-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d22802310ee880d2bc0ade395301e60a30df6a932a2b99df6c0e3900f1a73c5"

URI_x86_64_v2_perl-Apache-Session-Browseable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Apache-Session-Browseable-1.3.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Apache-Session-Browseable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Apache-Session-Browseable}"
SRC_URI[x86_64_v2_perl-Apache-Session-Browseable.sha256sum] = "adae8de99ffea2ee97fea5a26b03feea559cff0d3d7d5abe522eaeb868c8504a"

URI_aarch64_perl-Apache-Session-Browseable = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Apache-Session-Browseable-1.3.19-1.el10_2.noarch.rpm;name=aarch64_perl-Apache-Session-Browseable;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Apache-Session-Browseable}"
SRC_URI[aarch64_perl-Apache-Session-Browseable.sha256sum] = "f473fd8d70666cc74bf44583ebd99669cbab407c73c7b4160a89896092f24c33"

RDEPENDS:perl-Apache-Session-Browseable = " \
 perl-Apache-Session \
 perl-Apache-Session-Browseable \
 perl-AutoLoader \
 perl-Crypt-URandom \
 perl-DBI \
 perl-Digest-SHA \
 perl-JSON \
 perl-LDAP \
 perl-MIME-Base64 \
 perl-Redis \
 perl-Storable \
 perl-constant \
 perl-libs \
 perl-vars \
 "
