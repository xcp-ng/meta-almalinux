# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lato-fonts"
PV = "2.015"
PR = "23.el10"
PACKAGES = " \
 lato-fonts \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lato-fonts-2.015-23.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a038034af5a38d3636756f4813ed172d5119605a991467c3f0d849ce1cf6a535"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lato-fonts-2.015-23.el10.noarch.rpm;name=x86_64_v2_lato-fonts;unpack=0"
SRC_URI[x86_64_v2_lato-fonts.sha256sum] = "72e8638dd02fef6a97de1746729a28cb23c868d4b13d293e318f69e5bc2c63bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lato-fonts-2.015-23.el10.noarch.rpm;name=aarch64_lato-fonts;unpack=0"
SRC_URI[aarch64_lato-fonts.sha256sum] = "72e8638dd02fef6a97de1746729a28cb23c868d4b13d293e318f69e5bc2c63bd"

RDEPENDS:lato-fonts = " \
 fonts-filesystem \
 "
