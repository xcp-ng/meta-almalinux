# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtsvg"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtsvg \
 qt5-qtsvg-devel \
 qt5-qtsvg-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtsvg-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fde07ef67f4094aa2fe9a3a30c6b4d02f72a1ef432d1039160de7e7f1762ce9"

URI_x86_64_v2_qt5-qtsvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsvg-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsvg}"
SRC_URI[x86_64_v2_qt5-qtsvg.sha256sum] = "e09643a857002cca1391d6f026c29cbcb73836704f1202d6759685fd56ade870"

URI_x86_64_v2_qt5-qtsvg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsvg-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsvg-devel}"
SRC_URI[x86_64_v2_qt5-qtsvg-devel.sha256sum] = "cfd5fd0ce204b89b4b7ef052b7db13299c5afc786534540e732d6b09c1529563"

URI_x86_64_v2_qt5-qtsvg-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsvg-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsvg-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsvg-examples}"
SRC_URI[x86_64_v2_qt5-qtsvg-examples.sha256sum] = "399a4239512d871749ea6b3359be132337547437ad24afb4281b5226631cc3b4"

URI_aarch64_qt5-qtsvg = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsvg-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtsvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsvg}"
SRC_URI[aarch64_qt5-qtsvg.sha256sum] = "952c28f97b578c95cfa3ca75ca2e478c39d76909bdd17260b831552e451e9302"

URI_aarch64_qt5-qtsvg-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsvg-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtsvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsvg-devel}"
SRC_URI[aarch64_qt5-qtsvg-devel.sha256sum] = "151e6299bbb7653ca789022f576a7eb19d3aeb800a2fce78f164b619835bfdb1"

URI_aarch64_qt5-qtsvg-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsvg-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtsvg-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsvg-examples}"
SRC_URI[aarch64_qt5-qtsvg-examples.sha256sum] = "68d751de3cd4764c8e972f0f6b6ac6fce6c278c56fad31a179270dbb8c471774"

RDEPENDS:qt5-qtsvg = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qtsvg-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtsvg \
 "
RDEPENDS:qt5-qtsvg-examples = " \
 glibc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtsvg \
 "
