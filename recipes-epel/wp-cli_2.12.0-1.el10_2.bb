# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wp-cli"
PV = "2.12.0"
PR = "1.el10_2"
PACKAGES = " \
 wp-cli \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/wp-cli-2.12.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "765fd97c905e745381a8f9b7afb872039b8de02eec5d05e71a242093a73a0ff2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wp-cli-2.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_wp-cli;unpack=0"
SRC_URI[x86_64_v2_wp-cli.sha256sum] = "3caf09c93944191e7c6a9cc5c2c80952652acb445ba4640c2146147a1d7ee7e0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wp-cli-2.12.0-1.el10_2.noarch.rpm;name=aarch64_wp-cli;unpack=0"
SRC_URI[aarch64_wp-cli.sha256sum] = "aff48457c1b8f26c3e5d30669b4a438c65a922fa145b43e7fd8d2ad31d6517ea"

RDEPENDS:wp-cli = " \
 "
