# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-zc-lockfile"
PV = "3.0.post1"
PR = "11.el10_0"
PACKAGES = " \
 python3-zc-lockfile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-zc-lockfile-3.0.post1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93a4fb8ac9eae55f68cbcb6cfdf285784b13e1c4c6d775e8e37828e4e01a9c3c"

URI_x86_64_v2_python3-zc-lockfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zc-lockfile-3.0.post1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-zc-lockfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zc-lockfile}"
SRC_URI[x86_64_v2_python3-zc-lockfile.sha256sum] = "8ab3f0db25b5f521e7055e0e47b4e365bab97cf4ab665ec5232a1ae5d551ddfd"

URI_aarch64_python3-zc-lockfile = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zc-lockfile-3.0.post1-11.el10_0.noarch.rpm;name=aarch64_python3-zc-lockfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zc-lockfile}"
SRC_URI[aarch64_python3-zc-lockfile.sha256sum] = "dbe17c6781783b14d84a82d6a4fbf0e83274d7b61e35eda6b79849a3a38af54b"

RDEPENDS:python3-zc-lockfile = " \
 python3 \
 python3-setuptools \
 "
