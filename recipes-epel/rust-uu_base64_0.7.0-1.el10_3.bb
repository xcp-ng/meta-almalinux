# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_base64"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_base64+default-devel \
 rust-uu_base64-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_base64-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69c16b752a0e3ad129bc1960df802f951f3acef615bfefe3e553ab57b965311d"

URI_x86_64_v2_rust-uu_base64+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_base64+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_base64+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_base64+default-devel}"
SRC_URI[x86_64_v2_rust-uu_base64+default-devel.sha256sum] = "a8ae009f46ef9dd4c7ff0d73a47d6850392371e1a1b1bf1cd426444ab9961807"

URI_x86_64_v2_rust-uu_base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_base64-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_base64-devel}"
SRC_URI[x86_64_v2_rust-uu_base64-devel.sha256sum] = "d6208796dfb6fcf0efac551dff4715708d1abd1c80fc11e8330846fcb19ce5e8"

URI_aarch64_rust-uu_base64+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_base64+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_base64+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_base64+default-devel}"
SRC_URI[aarch64_rust-uu_base64+default-devel.sha256sum] = "5dc1f7931a510551d177fb0ec1bf9bd65d23f869e1724a3db3b4b8cf38276b90"

URI_aarch64_rust-uu_base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_base64-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_base64-devel}"
SRC_URI[aarch64_rust-uu_base64-devel.sha256sum] = "78ccc6eb0555216a2d5f8bcc65ad2fb3af375847cef0bb04f7af27d49a12cf57"

RDEPENDS:rust-uu_base64+default-devel = " \
 cargo \
 rust-uu_base64-devel \
 "
RDEPENDS:rust-uu_base64-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uu_base32+default-devel \
 rust-uucore+default-devel \
 rust-uucore+encoding-devel \
 "
