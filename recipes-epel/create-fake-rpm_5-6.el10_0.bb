# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "create-fake-rpm"
PV = "5"
PR = "6.el10_0"
PACKAGES = " \
 create-fake-rpm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/create-fake-rpm-5-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09e108fb75d2ef2c8adf11f7a525f41244dbf676b58d25baab90f63a6408c462"

URI_x86_64_v2_create-fake-rpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/create-fake-rpm-5-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_create-fake-rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_create-fake-rpm}"
SRC_URI[x86_64_v2_create-fake-rpm.sha256sum] = "228e20e514bf1f334addf34d65678f20927380ec8d55245dbb63de3cfdaab8cf"

URI_aarch64_create-fake-rpm = "${EPEL_MIRROR}/aarch64/Packages/c/create-fake-rpm-5-6.el10_0.noarch.rpm;name=aarch64_create-fake-rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_create-fake-rpm}"
SRC_URI[aarch64_create-fake-rpm.sha256sum] = "cd1cd638150f79dcbb5b959b017a516bd3cae7f193141d019e94a40b3978e6e6"

RDEPENDS:create-fake-rpm = " \
 bash \
 rpm-build \
 "
