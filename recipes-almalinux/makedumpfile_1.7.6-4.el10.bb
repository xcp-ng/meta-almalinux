# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "makedumpfile"
PV = "1.7.6"
PR = "4.el10"
PACKAGES = " \
 makedumpfile \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/makedumpfile-1.7.6-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1f9b6185ca9d3e374076bf7eaeffcd401d9783fb4fc508aecf300b524c4e4ebb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/makedumpfile-1.7.6-4.el10.x86_64_v2.rpm;name=x86_64_v2_makedumpfile;unpack=0"
SRC_URI[x86_64_v2_makedumpfile.sha256sum] = "5ac3d2a9cd82eddd77ff03874338b59c713f611366820c43ab1a671bdca2e728"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/makedumpfile-1.7.6-4.el10.aarch64.rpm;name=aarch64_makedumpfile;unpack=0"
SRC_URI[aarch64_makedumpfile.sha256sum] = "fa2f22108dcdceaa83fb842cbfd976fbebe58399403351db248efdcf7f50bd23"

RDEPENDS:makedumpfile = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libgcc \
 libzstd \
 lzo \
 ncurses-libs \
 snappy \
 zlib-ng-compat \
 "
