# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-credential-libsecret"
PV = "0.4.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-cargo-credential-libsecret+default-devel \
 rust-cargo-credential-libsecret-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-credential-libsecret-0.4.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "962acd93080e04941d257c40048aa5344d607147116336dd794713d7a970b8a3"

URI_x86_64_v2_rust-cargo-credential-libsecret+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-credential-libsecret+default-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-credential-libsecret+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-credential-libsecret+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-credential-libsecret+default-devel.sha256sum] = "1a59c052a92fed986a01f306689abbd980436c4d4572186005ca30b3691c81b8"

URI_x86_64_v2_rust-cargo-credential-libsecret-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-credential-libsecret-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-credential-libsecret-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-credential-libsecret-devel}"
SRC_URI[x86_64_v2_rust-cargo-credential-libsecret-devel.sha256sum] = "62b6000e782b006db7d4a1a9fec996ca918fb86c91a81ee9c7e08782569225e5"

URI_aarch64_rust-cargo-credential-libsecret+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-credential-libsecret+default-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-cargo-credential-libsecret+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-credential-libsecret+default-devel}"
SRC_URI[aarch64_rust-cargo-credential-libsecret+default-devel.sha256sum] = "d54b550d593c24f28a33db2f0de5b08a29e1c50f0ebed14268f71fdefa623772"

URI_aarch64_rust-cargo-credential-libsecret-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-credential-libsecret-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-cargo-credential-libsecret-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-credential-libsecret-devel}"
SRC_URI[aarch64_rust-cargo-credential-libsecret-devel.sha256sum] = "b8221b4120d2fdd4bfeacdd163d76c31a0ce1eb68d5278a820378de96f721c5f"

RDEPENDS:rust-cargo-credential-libsecret+default-devel = " \
 cargo \
 rust-cargo-credential-libsecret-devel \
 "
RDEPENDS:rust-cargo-credential-libsecret-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-cargo-credential+default-devel \
 rust-libloading+default-devel \
 "
