# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipa-healthcheck"
PV = "0.16"
PR = "7.el10"
PACKAGES = " \
 ipa-healthcheck \
 ipa-healthcheck-core \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ipa-healthcheck-0.16-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb3011b7ea3e44ce48f4ed8b6fd7702d186e13604c547549fdc54607ae1911ce"

URI_x86_64_v2_ipa-healthcheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-healthcheck-0.16-7.el10.noarch.rpm;name=x86_64_v2_ipa-healthcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-healthcheck}"
SRC_URI[x86_64_v2_ipa-healthcheck.sha256sum] = "d2cb9e82a416142c777deb0e8910d3c67a0b354575ab688ef8ac6cf6ef319355"

URI_x86_64_v2_ipa-healthcheck-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-healthcheck-core-0.16-7.el10.noarch.rpm;name=x86_64_v2_ipa-healthcheck-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-healthcheck-core}"
SRC_URI[x86_64_v2_ipa-healthcheck-core.sha256sum] = "2e122978491bcbf27ff7fe58df2e51b43b133cbe138690fd7dd3a1dcb9029698"

URI_aarch64_ipa-healthcheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-healthcheck-0.16-7.el10.noarch.rpm;name=aarch64_ipa-healthcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-healthcheck}"
SRC_URI[aarch64_ipa-healthcheck.sha256sum] = "d2cb9e82a416142c777deb0e8910d3c67a0b354575ab688ef8ac6cf6ef319355"

URI_aarch64_ipa-healthcheck-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-healthcheck-core-0.16-7.el10.noarch.rpm;name=aarch64_ipa-healthcheck-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-healthcheck-core}"
SRC_URI[aarch64_ipa-healthcheck-core.sha256sum] = "2e122978491bcbf27ff7fe58df2e51b43b133cbe138690fd7dd3a1dcb9029698"

RDEPENDS:ipa-healthcheck = " \
 bash \
 cronie-anacron \
 ipa-healthcheck-core \
 ipa-server \
 logrotate \
 python3 \
 python3-ipalib \
 python3-ipaserver \
 python3-lib389 \
 systemd \
 "
RDEPENDS:ipa-healthcheck-core = " \
 python3 \
 "
