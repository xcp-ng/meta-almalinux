# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pandas"
PV = "2.2.1"
PR = "7.el10_0"
PACKAGES = " \
 python3-pandas \
 python3-pandas+test \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pandas-2.2.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "416d5d84abf1db79d63bef27b30bfa496e41a305a86b40debaa65c625226e1fc"

URI_x86_64_v2_python3-pandas = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pandas-2.2.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pandas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pandas}"
SRC_URI[x86_64_v2_python3-pandas.sha256sum] = "d699c1e2ef103524ce9ed04c382d9351dd0c14e68d52051aee278036e6e342d3"

URI_x86_64_v2_python3-pandas+test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pandas+test-2.2.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pandas+test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pandas+test}"
SRC_URI[x86_64_v2_python3-pandas+test.sha256sum] = "5a1c44fae1c1c4e9cbad070ea6af3c258e4f11a5752efa0b44fd9e7d924e9780"

URI_aarch64_python3-pandas = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pandas-2.2.1-7.el10_0.aarch64.rpm;name=aarch64_python3-pandas;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pandas}"
SRC_URI[aarch64_python3-pandas.sha256sum] = "9165aeb7cf64875aa718ced634d3156a7518b7c22fce87c04ae1975d8590d689"

URI_aarch64_python3-pandas+test = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pandas+test-2.2.1-7.el10_0.aarch64.rpm;name=aarch64_python3-pandas+test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pandas+test}"
SRC_URI[aarch64_python3-pandas+test.sha256sum] = "8c196b2eecbac100c521db0ebed3076f5351d008901f0374e6086a86ccb6aa51"

RDEPENDS:python3-pandas = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-dateutil \
 python3-numpy \
 python3-pytz \
 "
RDEPENDS:python3-pandas+test = " \
 python3 \
 python3-hypothesis \
 python3-pandas \
 python3-pytest \
 python3-pytest-xdist \
 "
