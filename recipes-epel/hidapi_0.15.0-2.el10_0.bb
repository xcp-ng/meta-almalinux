# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hidapi"
PV = "0.15.0"
PR = "2.el10_0"
PACKAGES = " \
 hidapi \
 hidapi-devel \
 mingw32-hidapi \
 mingw64-hidapi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hidapi-0.15.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9974f8aabba298f8af32549b597efc4068afff23d96cb42b1d96d61b9ae98657"

URI_x86_64_v2_hidapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hidapi-0.15.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hidapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hidapi}"
SRC_URI[x86_64_v2_hidapi.sha256sum] = "73c281b8c0956a0e665380e0a324fb5ca81b264fdfcf099882c1869af1ae1e83"

URI_x86_64_v2_hidapi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hidapi-devel-0.15.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hidapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hidapi-devel}"
SRC_URI[x86_64_v2_hidapi-devel.sha256sum] = "708dbcd77a5812346b0b99c8c54b945955597a014035a9fabaff0fe8450797d0"

URI_x86_64_v2_mingw32-hidapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-hidapi-0.15.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mingw32-hidapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-hidapi}"
SRC_URI[x86_64_v2_mingw32-hidapi.sha256sum] = "ae871c5c918f9d2bfcf3ec492a37092e109813ed20cf9938a01b19d86a39253f"

URI_x86_64_v2_mingw64-hidapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-hidapi-0.15.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mingw64-hidapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-hidapi}"
SRC_URI[x86_64_v2_mingw64-hidapi.sha256sum] = "2ee217c19bfd943c636e50cd9d3e6eb021eb461b4bb3d052791be51d8d548201"

URI_aarch64_hidapi = "${EPEL_MIRROR}/aarch64/Packages/h/hidapi-0.15.0-2.el10_0.aarch64.rpm;name=aarch64_hidapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_hidapi}"
SRC_URI[aarch64_hidapi.sha256sum] = "69b3b4b4b04f192f0136947d695dc610e156771dff654b2fa43f9fa6f27a0f5e"

URI_aarch64_hidapi-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hidapi-devel-0.15.0-2.el10_0.aarch64.rpm;name=aarch64_hidapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hidapi-devel}"
SRC_URI[aarch64_hidapi-devel.sha256sum] = "788865bcaa923e5d7cf6f91465b1006bb5e137f2cd0b926c9cc40bfba1389d60"

URI_aarch64_mingw32-hidapi = "${EPEL_MIRROR}/aarch64/Packages/m/mingw32-hidapi-0.15.0-2.el10_0.aarch64.rpm;name=aarch64_mingw32-hidapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-hidapi}"
SRC_URI[aarch64_mingw32-hidapi.sha256sum] = "df4e41288873127ae23eaca7dc6a37f375cac725ac959253ef3114bae26b06a1"

URI_aarch64_mingw64-hidapi = "${EPEL_MIRROR}/aarch64/Packages/m/mingw64-hidapi-0.15.0-2.el10_0.aarch64.rpm;name=aarch64_mingw64-hidapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-hidapi}"
SRC_URI[aarch64_mingw64-hidapi.sha256sum] = "f842d4c61349502175c011bda8b6c39dbb707c4832986b387171594a0de3e64e"

RDEPENDS:hidapi = " \
 glibc \
 libgcc \
 libusb1 \
 systemd-libs \
 "
RDEPENDS:hidapi-devel = " \
 cmake-filesystem \
 hidapi \
 pkgconf-pkg-config \
 "
RDEPENDS:mingw32-hidapi = " \
 mingw32-crt \
 mingw32-filesystem \
 "
RDEPENDS:mingw64-hidapi = " \
 mingw64-crt \
 mingw64-filesystem \
 "
