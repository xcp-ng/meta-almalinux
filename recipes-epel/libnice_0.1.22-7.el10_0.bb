# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnice"
PV = "0.1.22"
PR = "7.el10_0"
PACKAGES = " \
 libnice \
 libnice-devel \
 libnice-gstreamer1 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libnice-0.1.22-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96d10da26630b190ca69bb0131b593834223d6c9242cfd796d26f14d6abc174b"

URI_x86_64_v2_libnice = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnice-0.1.22-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnice;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnice}"
SRC_URI[x86_64_v2_libnice.sha256sum] = "11525c294fe903ac4bf6c06f09e5a5087f0ce1aea5a9dc065379848b167ccde4"

URI_x86_64_v2_libnice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnice-devel-0.1.22-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnice-devel}"
SRC_URI[x86_64_v2_libnice-devel.sha256sum] = "4df377db19c6853a7e0182ec8de9ba5955182018e015eef7b6f9884960103e17"

URI_x86_64_v2_libnice-gstreamer1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnice-gstreamer1-0.1.22-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnice-gstreamer1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnice-gstreamer1}"
SRC_URI[x86_64_v2_libnice-gstreamer1.sha256sum] = "92ac17c99bacdc78b937b2c10cb147cc80419f2209374eb6144a2045520c7e92"

URI_aarch64_libnice = "${EPEL_MIRROR}/aarch64/Packages/l/libnice-0.1.22-7.el10_0.aarch64.rpm;name=aarch64_libnice;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnice}"
SRC_URI[aarch64_libnice.sha256sum] = "9d3aadc98fc055272579bd84eaa9c335ff4d816fcf74ca9b27c52ef076e706c9"

URI_aarch64_libnice-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libnice-devel-0.1.22-7.el10_0.aarch64.rpm;name=aarch64_libnice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnice-devel}"
SRC_URI[aarch64_libnice-devel.sha256sum] = "35eff826949fcde6bbba7308c65ea0cfa41fa8da400f068a7ae56488c36d1fcd"

URI_aarch64_libnice-gstreamer1 = "${EPEL_MIRROR}/aarch64/Packages/l/libnice-gstreamer1-0.1.22-7.el10_0.aarch64.rpm;name=aarch64_libnice-gstreamer1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnice-gstreamer1}"
SRC_URI[aarch64_libnice-gstreamer1.sha256sum] = "49f17b232face09b0513f24da9d7e43c2264b6ce26d38775196e08801d7f052d"

RDEPENDS:libnice = " \
 glib2 \
 glibc \
 gnutls \
 gupnp-igd \
 "
RDEPENDS:libnice-devel = " \
 glib2-devel \
 gnutls-devel \
 gupnp-igd-devel \
 libnice \
 pkgconf-pkg-config \
 "
RDEPENDS:libnice-gstreamer1 = " \
 glib2 \
 glibc \
 gstreamer1 \
 libnice \
 "
