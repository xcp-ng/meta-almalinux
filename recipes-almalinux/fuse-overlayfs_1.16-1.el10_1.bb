# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fuse-overlayfs"
PV = "1.16"
PR = "1.el10_1"
PACKAGES = " \
 fuse-overlayfs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fuse-overlayfs-1.16-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e51698ea699612abb0b02e75667315fdcd3fc7498e9a213695f4b623b7ca610"

URI_x86_64_v2_fuse-overlayfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fuse-overlayfs-1.16-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_fuse-overlayfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fuse-overlayfs}"
SRC_URI[x86_64_v2_fuse-overlayfs.sha256sum] = "2e27bbf6d2e5d0d3e84d217f03a9918caf552f4bcc4779fcf26ad0cf162a4ee0"

URI_aarch64_fuse-overlayfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fuse-overlayfs-1.16-1.el10_1.aarch64.rpm;name=aarch64_fuse-overlayfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fuse-overlayfs}"
SRC_URI[aarch64_fuse-overlayfs.sha256sum] = "6b997265756854d52e697f853f7452761cc8ff3386a0583417645607e3f90232"

RDEPENDS:fuse-overlayfs = " \
 bash \
 fuse3 \
 fuse3-libs \
 glibc \
 kmod \
 libgcc \
 "
