# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xmlto"
PV = "0.0.28"
PR = "25.el10"
PACKAGES = " \
 xmlto \
 xmlto-tex \
 xmlto-xhtml \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xmlto-0.0.28-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc273dd6719bdb4ce5f0e3bec9c55fead4af504130802404dd4f0ec743da1fb1"

URI_x86_64_v2_xmlto = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xmlto-0.0.28-25.el10.x86_64_v2.rpm;name=x86_64_v2_xmlto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlto}"
SRC_URI[x86_64_v2_xmlto.sha256sum] = "8a9c29dc38826021eeff059e7fc537047053e7e71358d80f00a5295085a0eff0"

URI_x86_64_v2_xmlto-tex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xmlto-tex-0.0.28-25.el10.noarch.rpm;name=x86_64_v2_xmlto-tex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlto-tex}"
SRC_URI[x86_64_v2_xmlto-tex.sha256sum] = "8785f0c1d6ceba3806b3bb5875c4d1b0d5594d0e114797b0e109048a576c7511"

URI_x86_64_v2_xmlto-xhtml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xmlto-xhtml-0.0.28-25.el10.noarch.rpm;name=x86_64_v2_xmlto-xhtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlto-xhtml}"
SRC_URI[x86_64_v2_xmlto-xhtml.sha256sum] = "b496ee0e6f2db0bb8d4ac74b258f953b727352049b4447ac8e1cbc7091520272"

URI_aarch64_xmlto = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xmlto-0.0.28-25.el10.aarch64.rpm;name=aarch64_xmlto;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlto}"
SRC_URI[aarch64_xmlto.sha256sum] = "8b8bc9723f4ed3fe2c1065d723e3050516f649541e5e30f0d41d272818b32fda"

URI_aarch64_xmlto-tex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xmlto-tex-0.0.28-25.el10.noarch.rpm;name=aarch64_xmlto-tex;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlto-tex}"
SRC_URI[aarch64_xmlto-tex.sha256sum] = "8785f0c1d6ceba3806b3bb5875c4d1b0d5594d0e114797b0e109048a576c7511"

URI_aarch64_xmlto-xhtml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xmlto-xhtml-0.0.28-25.el10.noarch.rpm;name=aarch64_xmlto-xhtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlto-xhtml}"
SRC_URI[aarch64_xmlto-xhtml.sha256sum] = "b496ee0e6f2db0bb8d4ac74b258f953b727352049b4447ac8e1cbc7091520272"

RDEPENDS:xmlto = " \
 bash \
 docbook-dtds \
 docbook-style-xsl \
 flex \
 glibc \
 libxslt \
 util-linux \
 "
RDEPENDS:xmlto-tex = " \
 texlive-passivetex \
 xmlto \
 "
RDEPENDS:xmlto-xhtml = " \
 xhtml2fo-style-xsl \
 xmlto \
 "
