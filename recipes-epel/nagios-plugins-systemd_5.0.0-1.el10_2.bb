# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nagios-plugins-systemd"
PV = "5.0.0"
PR = "1.el10_2"
PACKAGES = " \
 nagios-plugins-systemd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nagios-plugins-systemd-5.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcb87a4c3ab7381f7a5c99298f46c4e4d896076dad2a990685f6e5f316159334"

URI_x86_64_v2_nagios-plugins-systemd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-systemd-5.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-systemd}"
SRC_URI[x86_64_v2_nagios-plugins-systemd.sha256sum] = "76f73771922fa330db7b575467958346e47154aa63d6d541c42784f149386aac"

URI_aarch64_nagios-plugins-systemd = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-systemd-5.0.0-1.el10_2.aarch64.rpm;name=aarch64_nagios-plugins-systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-systemd}"
SRC_URI[aarch64_nagios-plugins-systemd.sha256sum] = "4c5c4c6505e6e4d8a22101659c2699f0372b448c35d905db1271d25b870cdc31"

RDEPENDS:nagios-plugins-systemd = " \
 nagios-common \
 python3 \
 python3-nagiosplugin \
 "
