# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-autovivification"
PV = "0.18"
PR = "18.el10_1"
PACKAGES = " \
 perl-autovivification \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-autovivification-0.18-18.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15af989cfde2b8bb2d0d7d64341c112fff7e7e459c3b4e22b10a22b4be0bad24"

URI_x86_64_v2_perl-autovivification = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-autovivification-0.18-18.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-autovivification;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-autovivification}"
SRC_URI[x86_64_v2_perl-autovivification.sha256sum] = "b051f4fa61a08143c5c6b7c8ecff997d3d0729680d4bc5606794f11a367c24d4"

URI_aarch64_perl-autovivification = "${EPEL_MIRROR}/aarch64/Packages/p/perl-autovivification-0.18-18.el10_1.aarch64.rpm;name=aarch64_perl-autovivification;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-autovivification}"
SRC_URI[aarch64_perl-autovivification.sha256sum] = "433355a98ff95d30c31a0c2577457fc6f1327671aad7d8ac7f408469a7fbf3de"

RDEPENDS:perl-autovivification = " \
 glibc \
 perl-libs \
 "
