# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-hashtable"
PV = "0.9.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-hashtable+default-devel \
 rust-gix-hashtable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-hashtable-0.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "654946ab25490837b2a76f3d079ff5be444b001fc6591a10c922ca885cbe9daf"

URI_x86_64_v2_rust-gix-hashtable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hashtable+default-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hashtable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hashtable+default-devel}"
SRC_URI[x86_64_v2_rust-gix-hashtable+default-devel.sha256sum] = "1fe36f713077172a7d4e168fb0ac9a5c50bb9395e93ab05ac0e35fc05937350d"

URI_x86_64_v2_rust-gix-hashtable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hashtable-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hashtable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hashtable-devel}"
SRC_URI[x86_64_v2_rust-gix-hashtable-devel.sha256sum] = "80a222d50840b5e4f772a211f6b50de0a0656889f2db202f4711bd30d1cae831"

URI_aarch64_rust-gix-hashtable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hashtable+default-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-hashtable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hashtable+default-devel}"
SRC_URI[aarch64_rust-gix-hashtable+default-devel.sha256sum] = "7d9a832fdf31c14ce54acba3112872974e06e880f035b373826736817753e048"

URI_aarch64_rust-gix-hashtable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hashtable-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-hashtable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hashtable-devel}"
SRC_URI[aarch64_rust-gix-hashtable-devel.sha256sum] = "5bc58054ac56ce36b7f536bc7d08392646a280380c69ea53bdf3d69641d1c5f4"

RDEPENDS:rust-gix-hashtable+default-devel = " \
 cargo \
 rust-gix-hashtable-devel \
 "
RDEPENDS:rust-gix-hashtable-devel = " \
 cargo \
 rust \
 rust-gix-hash+default-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown-devel \
 rust-parking_lot+default-devel \
 "
