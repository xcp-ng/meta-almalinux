# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "btop"
PV = "1.4.7"
PR = "1.el10_3"
PACKAGES = " \
 btop \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/btop-1.4.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "888d81da759a1b4939edf213fd5d26cde6124713938a7e564ca02766980d3ac2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/btop-1.4.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_btop;unpack=0"
SRC_URI[x86_64_v2_btop.sha256sum] = "e890fe2dad369d1f52210ffade2051c1dae49b003f60056de76b4b5a02c9dcf5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/btop-1.4.7-1.el10_3.aarch64.rpm;name=aarch64_btop;unpack=0"
SRC_URI[aarch64_btop.sha256sum] = "72cb30f0c097db4791b7db06dbc1f3bf33240bb91bc1f270713df3191df794ee"

RDEPENDS:btop = " \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 "
