# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmail"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kmail \
 kmail-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmail-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba25b3aeefd49aec31a5e87b389c928a48f24c15522ff3c16519f816e2b7c4c1"

URI_x86_64_v2_kmail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmail-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmail}"
SRC_URI[x86_64_v2_kmail.sha256sum] = "94893c3ce6f5ec255828eb27874c6bd3213f9ad7de4bb06672968a6e5050350c"

URI_x86_64_v2_kmail-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmail-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmail-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmail-libs}"
SRC_URI[x86_64_v2_kmail-libs.sha256sum] = "194bdbc83fdf30b7111721d0266d077eb12d8d9f5cdaf6e4084dc551e3363869"

URI_aarch64_kmail = "${EPEL_MIRROR}/aarch64/Packages/k/kmail-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmail;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmail}"
SRC_URI[aarch64_kmail.sha256sum] = "0db08d01d34a0579a566abeef6fcbaf32e5e62da63900240be1bb33cdfaa601b"

URI_aarch64_kmail-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kmail-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmail-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmail-libs}"
SRC_URI[aarch64_kmail-libs.sha256sum] = "dea9cab2aa1cc277ee6bf509f52ae8999cd87570cc1da5ec90e00d807e43af72"

RDEPENDS:kmail = " \
 akonadi-import-wizard \
 akonadi-mime \
 akonadi-server \
 glibc \
 grantlee-editor \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kservice \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kidentitymanagement \
 kmail-account-wizard \
 kmail-libs \
 kmailtransport \
 kmime \
 kontactinterface \
 ktnef \
 libgcc \
 libstdc++ \
 mailcommon \
 messagelib \
 pim-data-exporter \
 pim-sieve-editor \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:kmail-libs = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-search \
 akonadi-server \
 glibc \
 gpgme2pp \
 kcalutils \
 kf6-kbookmarks \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 kidentitymanagement \
 kldap \
 kmail \
 kmailtransport \
 kmime \
 kontactinterface \
 kpimtextedit \
 ktextaddons-qt6 \
 libgcc \
 libgpg-error \
 libgravatar \
 libkdepim \
 libkleo \
 libksieve \
 libstdc++ \
 mailcommon \
 messagelib \
 pimcommon \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
