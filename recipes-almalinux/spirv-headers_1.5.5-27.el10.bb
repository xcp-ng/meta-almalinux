# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spirv-headers"
PV = "1.5.5"
PR = "27.el10"
PACKAGES = " \
 spirv-headers-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/spirv-headers-1.5.5-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca695ce081d1b8fc4eff3f029e8290098a0e85659198665775f42358809cfdc0"

URI_x86_64_v2_spirv-headers-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/spirv-headers-devel-1.5.5-27.el10.noarch.rpm;name=x86_64_v2_spirv-headers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spirv-headers-devel}"
SRC_URI[x86_64_v2_spirv-headers-devel.sha256sum] = "46e6aba399ecf33ce3db6b4b1d0f69e06a9c0f73c621f52e25a18d0c98f05729"

URI_aarch64_spirv-headers-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/spirv-headers-devel-1.5.5-27.el10.noarch.rpm;name=aarch64_spirv-headers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_spirv-headers-devel}"
SRC_URI[aarch64_spirv-headers-devel.sha256sum] = "46e6aba399ecf33ce3db6b4b1d0f69e06a9c0f73c621f52e25a18d0c98f05729"

RDEPENDS:spirv-headers-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
