# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-TimeZone-SystemV"
PV = "0.010"
PR = "18.el10_0"
PACKAGES = " \
 perl-DateTime-TimeZone-SystemV \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-TimeZone-SystemV-0.010-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "140633c89faebe390efb05d30ca88f71353571dd8083706160f09f93b2b8d9aa"

URI_x86_64_v2_perl-DateTime-TimeZone-SystemV = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-TimeZone-SystemV-0.010-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-TimeZone-SystemV;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-TimeZone-SystemV}"
SRC_URI[x86_64_v2_perl-DateTime-TimeZone-SystemV.sha256sum] = "71472bb8b265f68cdb29b829bfc7610021cc09e2057d508854e04658149cb403"

URI_aarch64_perl-DateTime-TimeZone-SystemV = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-TimeZone-SystemV-0.010-18.el10_0.noarch.rpm;name=aarch64_perl-DateTime-TimeZone-SystemV;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-TimeZone-SystemV}"
SRC_URI[aarch64_perl-DateTime-TimeZone-SystemV.sha256sum] = "f7612f650e883494ecfb959b4bdc68fcc06f5ccd676df4c5f730453c5276c824"

RDEPENDS:perl-DateTime-TimeZone-SystemV = " \
 perl-Carp \
 perl-Date-ISO8601 \
 perl-Params-Classify \
 perl-libs \
 "
