# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fpc-srpm-macros"
PV = "1.3"
PR = "7.el10_0"
PACKAGES = " \
 fpc-srpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fpc-srpm-macros-1.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "798b552ed300f2c7a9d869be296154a6642c661a3818fd59eab5c2325993eefa"

URI_x86_64_v2_fpc-srpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fpc-srpm-macros-1.3-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fpc-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fpc-srpm-macros}"
SRC_URI[x86_64_v2_fpc-srpm-macros.sha256sum] = "e5d7ca064263c4c26086302ecf270f6b2a6f5c12324888eb8a8de66d8c46123f"

URI_aarch64_fpc-srpm-macros = "${EPEL_MIRROR}/aarch64/Packages/f/fpc-srpm-macros-1.3-7.el10_0.noarch.rpm;name=aarch64_fpc-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_fpc-srpm-macros}"
SRC_URI[aarch64_fpc-srpm-macros.sha256sum] = "5f3bfb71a3414639eb7de5994ffa4585a4b9a0e59db9ec45ec4423d5f0c3b330"

RDEPENDS:fpc-srpm-macros = " \
 "
