# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Config-Tiny"
PV = "2.30"
PR = "1.el10_0"
PACKAGES = " \
 perl-Config-Tiny \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Config-Tiny-2.30-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7011accd5ec4bbb59e8c1121208690e3ff56c31658da0f3d008a66083ee98c3f"

URI_x86_64_v2_perl-Config-Tiny = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Config-Tiny-2.30-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Config-Tiny;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Config-Tiny}"
SRC_URI[x86_64_v2_perl-Config-Tiny.sha256sum] = "8f5aacd9eb4012aa875ff0ae6f7ac699e17e20b6b2c559891e063d424287eec9"

URI_aarch64_perl-Config-Tiny = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Config-Tiny-2.30-1.el10_0.noarch.rpm;name=aarch64_perl-Config-Tiny;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Config-Tiny}"
SRC_URI[aarch64_perl-Config-Tiny.sha256sum] = "906b5388e856d87f68a1a2577d4d91b1948326c2b906627eba28c0b3d5a6b5d7"

RDEPENDS:perl-Config-Tiny = " \
 perl-libs \
 "
