# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-gssapi"
PV = "1.7.3"
PR = "10.el10"
PACKAGES = " \
 python3-gssapi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-gssapi-1.7.3-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f9460912d3c863f89c8949652b0ce69f7f9e8c00f46ef40aab57d2dd62e3225"

URI_x86_64_v2_python3-gssapi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-gssapi-1.7.3-10.el10.x86_64_v2.rpm;name=x86_64_v2_python3-gssapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gssapi}"
SRC_URI[x86_64_v2_python3-gssapi.sha256sum] = "2b2e767d631122200883005a379c042773a98cfa66e4626bb6f16a5f4ecfff74"

URI_aarch64_python3-gssapi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-gssapi-1.7.3-10.el10.aarch64.rpm;name=aarch64_python3-gssapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gssapi}"
SRC_URI[aarch64_python3-gssapi.sha256sum] = "d7005caaa87ac974dbedbadf62c4c7eff9fbab7ba6d03b7047a4552116abfa1c"

RDEPENDS:python3-gssapi = " \
 glibc \
 krb5-libs \
 python3 \
 python3-decorator \
 "
