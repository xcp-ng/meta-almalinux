# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktextaddons"
PV = "2.1.0"
PR = "2.el10_3"
PACKAGES = " \
 ktextaddons-common \
 ktextaddons-qt6 \
 ktextaddons-qt6-devel \
 ktextaddons-qt6-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktextaddons-2.1.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdc3763f3a067bed33e285267b8fa8a40de7f8879eeefbd209adda8ba5c0fd01"

URI_x86_64_v2_ktextaddons-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-common-2.1.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ktextaddons-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-common}"
SRC_URI[x86_64_v2_ktextaddons-common.sha256sum] = "c8e08223be3d0598824f5a1b23abdf276b9d4187cc69f7772e2b954d2a35fab3"

URI_x86_64_v2_ktextaddons-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-qt6-2.1.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktextaddons-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-qt6}"
SRC_URI[x86_64_v2_ktextaddons-qt6.sha256sum] = "f9598660193ffd92b1996624dff23ef3efd41569046697e41ccb06218dc4b838"

URI_x86_64_v2_ktextaddons-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-qt6-devel-2.1.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktextaddons-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-qt6-devel}"
SRC_URI[x86_64_v2_ktextaddons-qt6-devel.sha256sum] = "6a0755ea3b301ea1a5f3864adbee3991f6bcc500ade6d62f355881e462995c4b"

URI_x86_64_v2_ktextaddons-qt6-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-qt6-doc-2.1.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ktextaddons-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-qt6-doc}"
SRC_URI[x86_64_v2_ktextaddons-qt6-doc.sha256sum] = "bfcddd482f7766eb7c7e2870e81c7e66edfcef058e805abc46eb1e5cf1ac2ef9"

URI_aarch64_ktextaddons-common = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-common-2.1.0-2.el10_3.noarch.rpm;name=aarch64_ktextaddons-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-common}"
SRC_URI[aarch64_ktextaddons-common.sha256sum] = "ac497a8a156da0a99dbd0fcc09da8e185f7ff05cb7ecbeb91bd866b47c930dcc"

URI_aarch64_ktextaddons-qt6 = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-qt6-2.1.0-2.el10_3.aarch64.rpm;name=aarch64_ktextaddons-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-qt6}"
SRC_URI[aarch64_ktextaddons-qt6.sha256sum] = "6e8ef9b009512697392aa7d7bce5c0a831f623ad2297f5126dfd71be027b99dc"

URI_aarch64_ktextaddons-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-qt6-devel-2.1.0-2.el10_3.aarch64.rpm;name=aarch64_ktextaddons-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-qt6-devel}"
SRC_URI[aarch64_ktextaddons-qt6-devel.sha256sum] = "a9df801829790d2881fbe50c09b19c59d530c0d89b73b246e1b90bfadce90d12"

URI_aarch64_ktextaddons-qt6-doc = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-qt6-doc-2.1.0-2.el10_3.noarch.rpm;name=aarch64_ktextaddons-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-qt6-doc}"
SRC_URI[aarch64_ktextaddons-qt6-doc.sha256sum] = "6b06e6951a40c32f31a328b8cde6958a1a7150155ba64891ba9da4508725319e"

RDEPENDS:ktextaddons-common = " \
 "
RDEPENDS:ktextaddons-qt6 = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-sonnet \
 kf6-syntax-highlighting \
 ktextaddons-common \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 qtkeychain-qt6 \
 "
RDEPENDS:ktextaddons-qt6-devel = " \
 cmake-filesystem \
 glibc \
 kf6-ki18n \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:ktextaddons-qt6-doc = " \
 "
