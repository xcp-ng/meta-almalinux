# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyasyncore"
PV = "1.0.4"
PR = "1.el10_1"
PACKAGES = " \
 python3-pyasyncore \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyasyncore-1.0.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a42959ca8bafa0123f11a3f45df6c1792f7511ae5d82e7bc5d209e24659fbba0"

URI_x86_64_v2_python3-pyasyncore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyasyncore-1.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyasyncore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyasyncore}"
SRC_URI[x86_64_v2_python3-pyasyncore.sha256sum] = "7e2b25ed1adc779b7df222244bf52e1e4ccee1b108fe071c4c16fa093d6d6cb8"

URI_aarch64_python3-pyasyncore = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyasyncore-1.0.4-1.el10_1.noarch.rpm;name=aarch64_python3-pyasyncore;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyasyncore}"
SRC_URI[aarch64_python3-pyasyncore.sha256sum] = "d170ace8281ce17ec7ef3180a08e7da0b5e326083d9101f4d07528529f46799a"

RDEPENDS:python3-pyasyncore = " \
 python3 \
 "
