# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "blake3"
PV = "1.5.5"
PR = "1.el10_0"
PACKAGES = " \
 blake3 \
 blake3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/blake3-1.5.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "216e2a4b9a5d8ed966f97f3e3ad38ad9b34c3b70c88b70a9eaee2b6f1b02b33e"

URI_x86_64_v2_blake3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blake3-1.5.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blake3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blake3}"
SRC_URI[x86_64_v2_blake3.sha256sum] = "70c2f5cf5da1285601709c3318eaf873aac8eb4e57c08d9531ba05dfd0f998b5"

URI_x86_64_v2_blake3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blake3-devel-1.5.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blake3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blake3-devel}"
SRC_URI[x86_64_v2_blake3-devel.sha256sum] = "0156161649567dcc602184e90995d8d3185d1dfd8a3b1edcff7a191b7f6ef8f1"

URI_aarch64_blake3 = "${EPEL_MIRROR}/aarch64/Packages/b/blake3-1.5.5-1.el10_0.aarch64.rpm;name=aarch64_blake3;unpack=0"
SRC_URI:append = " ${URI_aarch64_blake3}"
SRC_URI[aarch64_blake3.sha256sum] = "cbd73898eafbe941c3180f96e92771b069fa1d6d765a08fedff4332d0c6e4abf"

URI_aarch64_blake3-devel = "${EPEL_MIRROR}/aarch64/Packages/b/blake3-devel-1.5.5-1.el10_0.aarch64.rpm;name=aarch64_blake3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_blake3-devel}"
SRC_URI[aarch64_blake3-devel.sha256sum] = "1388c1901c76e1e63afb00c6f22086a5704b80db915074a0c59f356f329021a5"

RDEPENDS:blake3 = " \
 glibc \
 "
RDEPENDS:blake3-devel = " \
 blake3 \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
