# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zeal"
PV = "0.7.2"
PR = "3.el10_1"
PACKAGES = " \
 zeal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zeal-0.7.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99b4d3f9b7d252212c3d2cf0d3a4913413dd20553947cc8c29b182d0375fe61a"

URI_x86_64_v2_zeal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zeal-0.7.2-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zeal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zeal}"
SRC_URI[x86_64_v2_zeal.sha256sum] = "da87dbb019e7299148e0fef68f6304d860ab42f08a8bc5e8e62b31a8a396cdb1"

URI_aarch64_zeal = "${EPEL_MIRROR}/aarch64/Packages/z/zeal-0.7.2-3.el10_1.aarch64.rpm;name=aarch64_zeal;unpack=0"
SRC_URI:append = " ${URI_aarch64_zeal}"
SRC_URI[aarch64_zeal.sha256sum] = "3c41b2312c0b02765554098f83bf651280509936b4341cf98666850986cd434b"

RDEPENDS:zeal = " \
 glibc \
 hicolor-icon-theme \
 libX11 \
 libarchive \
 libgcc \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 sqlite-libs \
 xcb-util-keysyms \
 "
