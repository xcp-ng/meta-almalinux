# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-vcstool"
PV = "0.3.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-vcstool \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-vcstool-0.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87e7d423730028831a9c43923959f6fe1bd15eb8264e29f4d60fa32a56e5daac"

URI_x86_64_v2_python3-vcstool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-vcstool-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-vcstool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-vcstool}"
SRC_URI[x86_64_v2_python3-vcstool.sha256sum] = "416843f800853652db0cbdc7c9fb2f0bab7180e9e00caef61128c27a9a0323fb"

URI_aarch64_python3-vcstool = "${EPEL_MIRROR}/aarch64/Packages/p/python3-vcstool-0.3.0-1.el10_0.noarch.rpm;name=aarch64_python3-vcstool;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-vcstool}"
SRC_URI[aarch64_python3-vcstool.sha256sum] = "a43a8fb075791c88b31a09ffb966c9e6cc7452a98d6c858a9ab4b5bb2481482b"

RDEPENDS:python3-vcstool = " \
 python3 \
 python3-pyyaml \
 python3-setuptools \
 "
