# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bacula"
PV = "15.0.3"
PR = "2.el10_1"
PACKAGES = " \
 bacula-client \
 bacula-common \
 bacula-console \
 bacula-console-bat \
 bacula-devel \
 bacula-director \
 bacula-libs \
 bacula-libs-sql \
 bacula-logwatch \
 bacula-storage \
 bacula-traymonitor \
 nagios-plugins-bacula \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bacula-15.0.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49a7ec62c2be7c7bfede5ba3871cb89ea74b83a95d194c3584b8c2672d544388"

URI_x86_64_v2_bacula-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-client-15.0.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-client}"
SRC_URI[x86_64_v2_bacula-client.sha256sum] = "39e939b507682ae334c0f37ceb4b5a1b0e4234277ce56de560b5c9c23d994271"

URI_x86_64_v2_bacula-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-common-15.0.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-common}"
SRC_URI[x86_64_v2_bacula-common.sha256sum] = "0968379c0ce44595f0ba8adb00e151d99f7428179d6620e1b21b2881ac8d6c30"

URI_x86_64_v2_bacula-console = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-console-15.0.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-console;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-console}"
SRC_URI[x86_64_v2_bacula-console.sha256sum] = "ac8836e17710d1bdeca78c05447415c86a3a3a10ed6e718bbad36403db3a39fe"

URI_x86_64_v2_bacula-console-bat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-console-bat-15.0.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-console-bat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-console-bat}"
SRC_URI[x86_64_v2_bacula-console-bat.sha256sum] = "d104d7691417fc8e127aa18db02052031b494278148a7b973a97c6b881563a4c"

URI_x86_64_v2_bacula-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-devel-15.0.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-devel}"
SRC_URI[x86_64_v2_bacula-devel.sha256sum] = "5a6c4dc214f76a7c7df918dc8deb0afa0806fe28304b368ca4cc9f5f799a043f"

URI_x86_64_v2_bacula-director = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-director-15.0.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-director;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-director}"
SRC_URI[x86_64_v2_bacula-director.sha256sum] = "3d561735fe8adc7a5170cca91a8d0e7f288fc96c6bb557a7285e237bb9506499"

URI_x86_64_v2_bacula-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-libs-15.0.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-libs}"
SRC_URI[x86_64_v2_bacula-libs.sha256sum] = "b1348cd6e8221bfc25c30b81dde4e1a04fde1fb0d638305c6f88121bba191615"

URI_x86_64_v2_bacula-libs-sql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-libs-sql-15.0.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-libs-sql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-libs-sql}"
SRC_URI[x86_64_v2_bacula-libs-sql.sha256sum] = "ba5bf51f5f4dd7cd74f8651bfc6fee24345927cb7fa2f0b58d0a123f252c6986"

URI_x86_64_v2_bacula-logwatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-logwatch-15.0.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_bacula-logwatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-logwatch}"
SRC_URI[x86_64_v2_bacula-logwatch.sha256sum] = "d16ea047388f65856f70cf305ad52f0404e9e2d93e85d5538e7e67108758d8b6"

URI_x86_64_v2_bacula-storage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-storage-15.0.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-storage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-storage}"
SRC_URI[x86_64_v2_bacula-storage.sha256sum] = "afb86f2ec5c50bb6670c6f6d50e18bab71ba217bad791467db5de5235ee36556"

URI_x86_64_v2_bacula-traymonitor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bacula-traymonitor-15.0.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bacula-traymonitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bacula-traymonitor}"
SRC_URI[x86_64_v2_bacula-traymonitor.sha256sum] = "71ed2305bceee88cdbea3eee2ab7db68ba949acb6b16c4c16435c34c6b4c37f9"

URI_x86_64_v2_nagios-plugins-bacula = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-bacula-15.0.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-bacula;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-bacula}"
SRC_URI[x86_64_v2_nagios-plugins-bacula.sha256sum] = "602f39f973f8734aad09d3b57b97dc9021afb35cf562cea96de80ea81235602b"

URI_aarch64_bacula-client = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-client-15.0.3-2.el10_1.aarch64.rpm;name=aarch64_bacula-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-client}"
SRC_URI[aarch64_bacula-client.sha256sum] = "39ec71ceb8aa31805b6f7b0171a7d3a916d7ab5d84cca23519461d98c070d9b2"

URI_aarch64_bacula-common = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-common-15.0.3-2.el10_1.aarch64.rpm;name=aarch64_bacula-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-common}"
SRC_URI[aarch64_bacula-common.sha256sum] = "9cc7f1e529217642a05e4d293492aa8c42fc1c3a92c6972cc26a2cb025539085"

URI_aarch64_bacula-console = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-console-15.0.3-2.el10_1.aarch64.rpm;name=aarch64_bacula-console;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-console}"
SRC_URI[aarch64_bacula-console.sha256sum] = "313302ea8650da1389592848555e6bd89fecc3de25e1d2f7ed2e59978c9dc417"

URI_aarch64_bacula-console-bat = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-console-bat-15.0.3-2.el10_1.aarch64.rpm;name=aarch64_bacula-console-bat;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-console-bat}"
SRC_URI[aarch64_bacula-console-bat.sha256sum] = "79301ece9b94eb3cec3e5324eaf2ccb58ff4bb89cc4908b2b18c05e6cdf65e5d"

URI_aarch64_bacula-devel = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-devel-15.0.3-2.el10_1.aarch64.rpm;name=aarch64_bacula-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-devel}"
SRC_URI[aarch64_bacula-devel.sha256sum] = "7bb87867c86de87421bb4f7a0ff8a52adaa850c70bdae4d78e1766844e5874e2"

URI_aarch64_bacula-director = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-director-15.0.3-2.el10_1.aarch64.rpm;name=aarch64_bacula-director;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-director}"
SRC_URI[aarch64_bacula-director.sha256sum] = "bf5848cfbdb78447ea9235d49514e75ff15f7a3a2aa03fdd42188801b179ff83"

URI_aarch64_bacula-libs = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-libs-15.0.3-2.el10_1.aarch64.rpm;name=aarch64_bacula-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-libs}"
SRC_URI[aarch64_bacula-libs.sha256sum] = "ba98aa46dc23a47e2b92aea7262cc5372c83e0fbaa139393003b26d1f34be923"

URI_aarch64_bacula-libs-sql = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-libs-sql-15.0.3-2.el10_1.aarch64.rpm;name=aarch64_bacula-libs-sql;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-libs-sql}"
SRC_URI[aarch64_bacula-libs-sql.sha256sum] = "32f8034cbbf64005b8611c0670814b3243a71de38b0a80be1eeccb19532ed68a"

URI_aarch64_bacula-logwatch = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-logwatch-15.0.3-2.el10_1.noarch.rpm;name=aarch64_bacula-logwatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-logwatch}"
SRC_URI[aarch64_bacula-logwatch.sha256sum] = "d441f61c59b1b4160eec4358e3f6be489dec84986f8dbf4fa53671cefb2b5bc8"

URI_aarch64_bacula-storage = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-storage-15.0.3-2.el10_1.aarch64.rpm;name=aarch64_bacula-storage;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-storage}"
SRC_URI[aarch64_bacula-storage.sha256sum] = "ba230a1c2011d81c01ac87eb20e7e8e4abb2e14b0be289f888dae3d1a8b65d85"

URI_aarch64_bacula-traymonitor = "${EPEL_MIRROR}/aarch64/Packages/b/bacula-traymonitor-15.0.3-2.el10_1.aarch64.rpm;name=aarch64_bacula-traymonitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_bacula-traymonitor}"
SRC_URI[aarch64_bacula-traymonitor.sha256sum] = "6abb2b7819ca69cbc62c5f0019328d34cef797ddc0457af528cf17d9eae246a4"

URI_aarch64_nagios-plugins-bacula = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-bacula-15.0.3-2.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-bacula;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-bacula}"
SRC_URI[aarch64_nagios-plugins-bacula.sha256sum] = "d99990757dd3e7d663e634ac7aefeb4952a5388b23fdfb2044f910b377c863fc"

RDEPENDS:bacula-client = " \
 bacula-common \
 bacula-libs \
 bash \
 glibc \
 libacl \
 libgcc \
 libstdc++ \
 libzstd \
 lzo \
 systemd \
 zlib-ng-compat \
 "
RDEPENDS:bacula-common = " \
 bacula-libs \
 bash \
 shadow-utils \
 "
RDEPENDS:bacula-console = " \
 bacula-libs \
 glibc \
 libgcc \
 libstdc++ \
 readline \
 "
RDEPENDS:bacula-console-bat = " \
 bacula-libs \
 dejavu-lgc-sans-fonts \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:bacula-devel = " \
 bacula-libs \
 bacula-libs-sql \
 "
RDEPENDS:bacula-director = " \
 bacula-common \
 bacula-libs \
 bacula-libs-sql \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 openldap \
 openssl-libs \
 perl-Fcntl \
 perl-File-Basename \
 perl-interpreter \
 perl-libs \
 python3 \
 systemd \
 "
RDEPENDS:bacula-libs = " \
 glibc \
 libcap \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:bacula-libs-sql = " \
 bash \
 glibc \
 libgcc \
 libpq \
 libstdc++ \
 libxcrypt \
 mariadb-connector-c \
 sqlite-libs \
 "
RDEPENDS:bacula-logwatch = " \
 bacula-director \
 logwatch \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:bacula-storage = " \
 bacula-common \
 bacula-libs \
 bacula-libs-sql \
 bash \
 glibc \
 libcap \
 libgcc \
 libstdc++ \
 libzstd \
 lzo \
 mt-st \
 mtx \
 sdparm \
 systemd \
 zlib-ng-compat \
 "
RDEPENDS:bacula-traymonitor = " \
 bacula-libs \
 dejavu-lgc-sans-fonts \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:nagios-plugins-bacula = " \
 bacula-libs \
 glibc \
 nagios-common \
 "
