# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ftp"
PV = "0.17"
PR = "97.el10"
PACKAGES = " \
 ftp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ftp-0.17-97.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cf0349eda19907bf817d528f50acefe66fa6d9fbb29ecb8f792b51e693fba3f"

URI_x86_64_v2_ftp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ftp-0.17-97.el10.x86_64_v2.rpm;name=x86_64_v2_ftp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ftp}"
SRC_URI[x86_64_v2_ftp.sha256sum] = "63cf13f13a286a0b52d9ebd5e736574d99ab3c08bce0da22d02b8732b582f32e"

URI_aarch64_ftp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ftp-0.17-97.el10.aarch64.rpm;name=aarch64_ftp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ftp}"
SRC_URI[aarch64_ftp.sha256sum] = "871025246171d360b532062c737090b0514505a2095e0a28338e0ad40b03fa61"

RDEPENDS:ftp = " \
 glibc \
 readline \
 "
