# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-desktop"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 plasma-desktop \
 plasma-desktop-doc \
 sddm-breeze \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-desktop-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8afa9144370a919894405cbb035b683234e7c3a6febb7a74a8fce15d115093a9"

URI_x86_64_v2_plasma-desktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-desktop-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-desktop}"
SRC_URI[x86_64_v2_plasma-desktop.sha256sum] = "d0d17d1f9635b019ba7b200ff8a7d5ee132a3f2e4d5ee1584948ee7c01786df3"

URI_x86_64_v2_plasma-desktop-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-desktop-doc-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-desktop-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-desktop-doc}"
SRC_URI[x86_64_v2_plasma-desktop-doc.sha256sum] = "7fdf9bc49b322c2f3dbd08aa31f29eafba7d85c395ae8fd4eb02b6a6fdbe54b0"

URI_x86_64_v2_sddm-breeze = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-breeze-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_sddm-breeze;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sddm-breeze}"
SRC_URI[x86_64_v2_sddm-breeze.sha256sum] = "1bd68f18120d7b697a0ae96e2603dd09990c1f0be02d7ad9389c83d348df4f9a"

URI_aarch64_plasma-desktop = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-desktop-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-desktop}"
SRC_URI[aarch64_plasma-desktop.sha256sum] = "34a19f5aa78f448adf7934653ec091305105211b9073cd029256e27af2bd7695"

URI_aarch64_plasma-desktop-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-desktop-doc-6.4.5-1.el10_1.noarch.rpm;name=aarch64_plasma-desktop-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-desktop-doc}"
SRC_URI[aarch64_plasma-desktop-doc.sha256sum] = "ab28b3750505d98d154af1b796c846f470806136a94af9402028fc3d90dee7fa"

URI_aarch64_sddm-breeze = "${EPEL_MIRROR}/aarch64/Packages/s/sddm-breeze-6.4.5-1.el10_1.noarch.rpm;name=aarch64_sddm-breeze;unpack=0"
SRC_URI:append = " ${URI_aarch64_sddm-breeze}"
SRC_URI[aarch64_sddm-breeze.sha256sum] = "2901ae4ebd7c51443b263a4e447ec3aef8dc30b9799fc9bdfe9e2da88d64c1c0"

RDEPENDS:plasma-desktop = " \
 PackageKit-Qt6 \
 accountsservice \
 glib2 \
 glibc \
 ibus-libs \
 kaccounts-integration-qt6 \
 kde-cli-tools \
 kf6-attica \
 kf6-baloo-libs \
 kf6-kauth \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kpackage \
 kf6-krunner \
 kf6-kservice \
 kf6-ksvg \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-qqc2-desktop-style \
 kf6-solid \
 kf6-sonnet \
 kio-extras \
 kmenuedit \
 kpipewire \
 kwin \
 kwrited \
 libX11 \
 libXi \
 libaccounts-qt6 \
 libcanberra \
 libksysguard \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwacom \
 libwayland-client \
 libxcb \
 libxkbcommon \
 libxkbfile \
 plasma-activities \
 plasma-activities-stats \
 plasma-integration \
 plasma-systemsettings \
 plasma-workspace \
 plasma-workspace-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtwayland \
 signon-plugin-oauth2 \
 virtual/libSDL2-2.0.so.0___64bit_ \
 xcb-util-keysyms \
 xdg-utils \
 "
RDEPENDS:plasma-desktop-doc = " \
 "
RDEPENDS:sddm-breeze = " \
 desktop-backgrounds-compat \
 kde-settings-sddm \
 kf6-kimageformats \
 libplasma \
 plasma-workspace \
 qt6-qtvirtualkeyboard \
 "
