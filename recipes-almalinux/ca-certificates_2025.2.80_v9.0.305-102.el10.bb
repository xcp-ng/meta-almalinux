# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ca-certificates"
PV = "2025.2.80_v9.0.305"
PR = "102.el10"
PACKAGES = " \
 ca-certificates \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ca-certificates-2025.2.80_v9.0.305-102.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c57decc669aee9974abded8870eaba6789bd9bd23c1f0e6a7f200c1cc3e3e9db"

URI_x86_64_v2_ca-certificates = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ca-certificates-2025.2.80_v9.0.305-102.el10.noarch.rpm;name=x86_64_v2_ca-certificates;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ca-certificates}"
SRC_URI[x86_64_v2_ca-certificates.sha256sum] = "43c2d277d0196a49c6d45bcae1a7be4337196938bb963a4cfdea0ec54c05fa2b"

URI_aarch64_ca-certificates = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ca-certificates-2025.2.80_v9.0.305-102.el10.noarch.rpm;name=aarch64_ca-certificates;unpack=0"
SRC_URI:append = " ${URI_aarch64_ca-certificates}"
SRC_URI[aarch64_ca-certificates.sha256sum] = "43c2d277d0196a49c6d45bcae1a7be4337196938bb963a4cfdea0ec54c05fa2b"

RDEPENDS:ca-certificates = " \
 bash \
 findutils \
 grep \
 libffi \
 p11-kit-trust \
 sed \
 virtual/coreutils \
 "
