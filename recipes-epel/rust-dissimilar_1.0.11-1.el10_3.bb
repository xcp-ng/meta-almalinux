# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dissimilar"
PV = "1.0.11"
PR = "1.el10_3"
PACKAGES = " \
 rust-dissimilar+default-devel \
 rust-dissimilar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dissimilar-1.0.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3a23b0ab8137cc85c9e1ed549d3f9ef640412f53718becf297440ba5de10116"

URI_x86_64_v2_rust-dissimilar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dissimilar+default-devel-1.0.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dissimilar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dissimilar+default-devel}"
SRC_URI[x86_64_v2_rust-dissimilar+default-devel.sha256sum] = "92c2f5d915a6a5fa7b58b7136ec86e769d3fa33ff02f24ed9036a69eb123e1c5"

URI_x86_64_v2_rust-dissimilar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dissimilar-devel-1.0.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dissimilar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dissimilar-devel}"
SRC_URI[x86_64_v2_rust-dissimilar-devel.sha256sum] = "eb2f1055a74b92249aaca482c522b18ec96306f60bffbf0583b8d7c4f568283f"

URI_aarch64_rust-dissimilar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dissimilar+default-devel-1.0.11-1.el10_3.noarch.rpm;name=aarch64_rust-dissimilar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dissimilar+default-devel}"
SRC_URI[aarch64_rust-dissimilar+default-devel.sha256sum] = "5cfda04cb090a6360a5d44fd3327a0f61ec3776552cf6ef8a021cf57c8a556b9"

URI_aarch64_rust-dissimilar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dissimilar-devel-1.0.11-1.el10_3.noarch.rpm;name=aarch64_rust-dissimilar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dissimilar-devel}"
SRC_URI[aarch64_rust-dissimilar-devel.sha256sum] = "b4299da7fa35df3d000db808985cd9426b7b07b062876ec64172b9fdb245a7fe"

RDEPENDS:rust-dissimilar+default-devel = " \
 cargo \
 rust-dissimilar-devel \
 "
RDEPENDS:rust-dissimilar-devel = " \
 cargo \
 rust \
 "
