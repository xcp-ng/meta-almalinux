# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-desktop-portal-kde"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 xdg-desktop-portal-kde \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/x/xdg-desktop-portal-kde-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bfe60f199263cc31253ff760012c4386942787b467a48fdb79795aecbe9ec6e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xdg-desktop-portal-kde-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xdg-desktop-portal-kde;unpack=0"
SRC_URI[x86_64_v2_xdg-desktop-portal-kde.sha256sum] = "bc429e8afa61432d780be353d7b52ff9557070cae6db8489a2987de68ace94c2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xdg-desktop-portal-kde-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_xdg-desktop-portal-kde;unpack=0"
SRC_URI[aarch64_xdg-desktop-portal-kde.sha256sum] = "4c2a3dc02b788e6063bf1674720b98e583f9355281e151c8d4f7a24efa58f32e"

RDEPENDS:xdg-desktop-portal-kde = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifications \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kwayland \
 libstdc++ \
 libwayland-client \
 libxkbcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xdg-desktop-portal \
 xdg-desktop-portal-gtk \
 "
