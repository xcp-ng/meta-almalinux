# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-databake"
PV = "0.2.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-databake+default-devel \
 rust-databake+derive-devel \
 rust-databake-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-databake-0.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73526ac2c799d36eeed62c73940f4e8e6283a77f41acba372b7987bc9d081ad0"

URI_x86_64_v2_rust-databake+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake+default-devel-0.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake+default-devel}"
SRC_URI[x86_64_v2_rust-databake+default-devel.sha256sum] = "cfe124336cc54c67ded70fc175a252a09780a3f5b3623321f66dbf2b38a51a02"

URI_x86_64_v2_rust-databake+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake+derive-devel-0.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake+derive-devel}"
SRC_URI[x86_64_v2_rust-databake+derive-devel.sha256sum] = "ec3d522cda4965ddbe9775a6f2a83689ad6b337a5d46386a6feb6c202023c057"

URI_x86_64_v2_rust-databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake-devel-0.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake-devel}"
SRC_URI[x86_64_v2_rust-databake-devel.sha256sum] = "a82a42577f97ec700d3bb51bcedbcb4537986c7586f492dc621ff664f538d897"

URI_aarch64_rust-databake+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake+default-devel-0.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-databake+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake+default-devel}"
SRC_URI[aarch64_rust-databake+default-devel.sha256sum] = "f81e8373a995045dd661cf15d1458dd1ee6f52c208caebada63cb5b1d4c87492"

URI_aarch64_rust-databake+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake+derive-devel-0.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-databake+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake+derive-devel}"
SRC_URI[aarch64_rust-databake+derive-devel.sha256sum] = "0d6588adc1b25d159b5531706db7141085bcc67f8013afd29289617202291397"

URI_aarch64_rust-databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake-devel-0.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake-devel}"
SRC_URI[aarch64_rust-databake-devel.sha256sum] = "1cd3209b0b46e6bdc377250c2ddbcc16019a0342eafb67e0554d834a8ee33f82"

RDEPENDS:rust-databake+default-devel = " \
 cargo \
 rust-databake-devel \
 "
RDEPENDS:rust-databake+derive-devel = " \
 cargo \
 rust-databake-derive-devel \
 rust-databake-devel \
 "
RDEPENDS:rust-databake-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
