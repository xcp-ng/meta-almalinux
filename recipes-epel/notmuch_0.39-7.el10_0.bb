# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "notmuch"
PV = "0.39"
PR = "7.el10_0"
PACKAGES = " \
 emacs-notmuch \
 notmuch \
 notmuch-devel \
 notmuch-git \
 python3-notmuch2 \
 ruby-notmuch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/notmuch-0.39-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3444434171192c5ba74e3e610778bbd9c773632c8ec75b75dca66dae095af859"

URI_x86_64_v2_emacs-notmuch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/emacs-notmuch-0.39-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_emacs-notmuch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_emacs-notmuch}"
SRC_URI[x86_64_v2_emacs-notmuch.sha256sum] = "eca4ba036d21beb964e3d1b58732e3dcc37ff73ea91c7a09bdbd32a04eaf0fdc"

URI_x86_64_v2_notmuch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/notmuch-0.39-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_notmuch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_notmuch}"
SRC_URI[x86_64_v2_notmuch.sha256sum] = "5bbb2a71e73a78f6a847d4f353beaf003afd2eafcf9099fe4ec781e774d62767"

URI_x86_64_v2_notmuch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/notmuch-devel-0.39-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_notmuch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_notmuch-devel}"
SRC_URI[x86_64_v2_notmuch-devel.sha256sum] = "34709b9aca115c6ee46d1c24db59380868102860e8f026b8dde7e7a9fa0a3bb9"

URI_x86_64_v2_notmuch-git = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/notmuch-git-0.39-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_notmuch-git;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_notmuch-git}"
SRC_URI[x86_64_v2_notmuch-git.sha256sum] = "e8afc891236d2df7083167d2cda2ecddea1a7135a05a1591273c0f5102e13d32"

URI_x86_64_v2_python3-notmuch2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-notmuch2-0.39-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-notmuch2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-notmuch2}"
SRC_URI[x86_64_v2_python3-notmuch2.sha256sum] = "08f67f4d2511a06c393b4aec7e596ec28d66e943820f277210bf0ebc0403fa2f"

URI_x86_64_v2_ruby-notmuch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-notmuch-0.39-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ruby-notmuch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-notmuch}"
SRC_URI[x86_64_v2_ruby-notmuch.sha256sum] = "29aeff45511caa2498ecaed54ab2db6a4fea03402a406c71277f49a353d1e875"

URI_aarch64_emacs-notmuch = "${EPEL_MIRROR}/aarch64/Packages/e/emacs-notmuch-0.39-7.el10_0.noarch.rpm;name=aarch64_emacs-notmuch;unpack=0"
SRC_URI:append = " ${URI_aarch64_emacs-notmuch}"
SRC_URI[aarch64_emacs-notmuch.sha256sum] = "fc8832fa649e614bdbcf55d5d09f60bd2493bd5cf71e6a8b6559d9dee2ccf325"

URI_aarch64_notmuch = "${EPEL_MIRROR}/aarch64/Packages/n/notmuch-0.39-7.el10_0.aarch64.rpm;name=aarch64_notmuch;unpack=0"
SRC_URI:append = " ${URI_aarch64_notmuch}"
SRC_URI[aarch64_notmuch.sha256sum] = "76b039e78b5a4890a459b5e046c41101a3b876f1c5dc1662b1ac65f8101d2ffa"

URI_aarch64_notmuch-devel = "${EPEL_MIRROR}/aarch64/Packages/n/notmuch-devel-0.39-7.el10_0.aarch64.rpm;name=aarch64_notmuch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_notmuch-devel}"
SRC_URI[aarch64_notmuch-devel.sha256sum] = "0bfe94ee9e21aeebfeecf34f9cac1940ddd78676599e7a6899a8f1dee0a71754"

URI_aarch64_notmuch-git = "${EPEL_MIRROR}/aarch64/Packages/n/notmuch-git-0.39-7.el10_0.aarch64.rpm;name=aarch64_notmuch-git;unpack=0"
SRC_URI:append = " ${URI_aarch64_notmuch-git}"
SRC_URI[aarch64_notmuch-git.sha256sum] = "802d270a3531629b5fd3dbec0863ee757b3c03dcfb79a25ff4af0bb3c3098e4a"

URI_aarch64_python3-notmuch2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-notmuch2-0.39-7.el10_0.aarch64.rpm;name=aarch64_python3-notmuch2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-notmuch2}"
SRC_URI[aarch64_python3-notmuch2.sha256sum] = "33c66b19ce955d17b7a61226e88dbf9e073fdcb4df8d2907be38532206126e06"

URI_aarch64_ruby-notmuch = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-notmuch-0.39-7.el10_0.aarch64.rpm;name=aarch64_ruby-notmuch;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-notmuch}"
SRC_URI[aarch64_ruby-notmuch.sha256sum] = "62036574e0ca0e0f3240e03df211523845e01eebea6e85954cb167bbcf3f9787"

RDEPENDS:emacs-notmuch = " \
 bash \
 notmuch \
 virtual/emacs_bin__ge_29.4 \
 "
RDEPENDS:notmuch = " \
 glib2 \
 glibc \
 gmime30 \
 info \
 libgcc \
 libstdc++ \
 libtalloc \
 sfsexp \
 xapian-core-libs \
 zlib-ng-compat \
 "
RDEPENDS:notmuch-devel = " \
 notmuch \
 "
RDEPENDS:notmuch-git = " \
 git-core \
 notmuch \
 python3 \
 "
RDEPENDS:python3-notmuch2 = " \
 glibc \
 notmuch \
 python3 \
 python3-cffi \
 "
RDEPENDS:ruby-notmuch = " \
 glibc \
 libtalloc \
 notmuch \
 ruby-libs \
 "
