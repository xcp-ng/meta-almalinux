# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-opaque-debug"
PV = "0.3.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-opaque-debug+default-devel \
 rust-opaque-debug-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-opaque-debug-0.3.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9614652813e92efb9c38fb92c8dc48e6dd8a7a75d05b46d776bcdbf7490e8df5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-opaque-debug+default-devel-0.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-opaque-debug+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-opaque-debug+default-devel.sha256sum] = "7d4a19b1d79a05f3a9893f70c207ebc99037a6b879beffe2652a86322ae093a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-opaque-debug-devel-0.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-opaque-debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-opaque-debug-devel.sha256sum] = "d704916e5d9d2b5ba16e04e34f9696a523dd5e15028f628bd3c9cc9d22caf5e7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-opaque-debug+default-devel-0.3.1-2.el10_0.noarch.rpm;name=aarch64_rust-opaque-debug+default-devel;unpack=0"
SRC_URI[aarch64_rust-opaque-debug+default-devel.sha256sum] = "62a01b62e4e8130af19af60d5f2c8cd57a64b86dd70686a7f634db1fd5f9bca4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-opaque-debug-devel-0.3.1-2.el10_0.noarch.rpm;name=aarch64_rust-opaque-debug-devel;unpack=0"
SRC_URI[aarch64_rust-opaque-debug-devel.sha256sum] = "af04123a6010456bd765f547e9a82cfba2772545176d25344347af78c73f35a7"

RDEPENDS:rust-opaque-debug+default-devel = " \
 cargo \
 rust-opaque-debug-devel \
 "
RDEPENDS:rust-opaque-debug-devel = " \
 cargo \
 "
