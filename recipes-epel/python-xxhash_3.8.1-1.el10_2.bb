# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-xxhash"
PV = "3.8.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-xxhash \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-xxhash-3.8.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "984fd16c317f5b1f84c146b446b53c7cb169264c1d16e7f4fc42883ac5641c55"

URI_x86_64_v2_python3-xxhash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-xxhash-3.8.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-xxhash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-xxhash}"
SRC_URI[x86_64_v2_python3-xxhash.sha256sum] = "3b1bb9d6c1a731d5c703b1c62c1f12d66789b146cd17c6f7185fa8f41773af57"

URI_aarch64_python3-xxhash = "${EPEL_MIRROR}/aarch64/Packages/p/python3-xxhash-3.8.1-1.el10_2.aarch64.rpm;name=aarch64_python3-xxhash;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-xxhash}"
SRC_URI[aarch64_python3-xxhash.sha256sum] = "62fcaf1c8101c6b89c2b6a8977bf3fda31c467f133eb7d6c30c7d2d78bc6c1bd"

RDEPENDS:python3-xxhash = " \
 glibc \
 python3 \
 xxhash-libs \
 "
