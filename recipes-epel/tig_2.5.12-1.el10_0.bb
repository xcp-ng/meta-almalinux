# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tig"
PV = "2.5.12"
PR = "1.el10_0"
PACKAGES = " \
 tig \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tig-2.5.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99c0ee5a518bb0ddd1af1870bad9a8ee9fc5bff67f6ef8fb9eb28e6e63818f4d"

URI_x86_64_v2_tig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tig-2.5.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tig}"
SRC_URI[x86_64_v2_tig.sha256sum] = "250afc3e65de0c48dd150206e1b2d70bf77913fce88d55f245a5270a3165ff47"

URI_aarch64_tig = "${EPEL_MIRROR}/aarch64/Packages/t/tig-2.5.12-1.el10_0.aarch64.rpm;name=aarch64_tig;unpack=0"
SRC_URI:append = " ${URI_aarch64_tig}"
SRC_URI[aarch64_tig.sha256sum] = "cfcdffaf583858390171b76f09135cac08a868a051431f1d3878f27b7b4e1c52"

RDEPENDS:tig = " \
 git-core \
 glibc \
 ncurses-libs \
 readline \
 "
