# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "egl-wayland2"
PV = "1.0.1~20251021gite16cb0f"
PR = "1.el10_0"
PACKAGES = " \
 egl-wayland2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/egl-wayland2-1.0.1~20251021gite16cb0f-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ffe85c3cf80a4b5eb546c100d0226573ad1cd40fa2d624f5ed3fb20d0cc43dc"

URI_x86_64_v2_egl-wayland2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-wayland2-1.0.1~20251021gite16cb0f-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-wayland2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_egl-wayland2}"
SRC_URI[x86_64_v2_egl-wayland2.sha256sum] = "1b8670c9f57081546be232541790bd93567ef37fd66c0f4c535fe26567e8f570"

URI_aarch64_egl-wayland2 = "${EPEL_MIRROR}/aarch64/Packages/e/egl-wayland2-1.0.1~20251021gite16cb0f-1.el10_0.aarch64.rpm;name=aarch64_egl-wayland2;unpack=0"
SRC_URI:append = " ${URI_aarch64_egl-wayland2}"
SRC_URI[aarch64_egl-wayland2.sha256sum] = "31921cb08951d017532722c1ff04aa65bd88366bd5f92fd44d5eca3b23b8a0df"

RDEPENDS:egl-wayland2 = " \
 glibc \
 libdrm \
 libglvnd-egl \
 libwayland-client \
 mesa-libgbm \
 "
