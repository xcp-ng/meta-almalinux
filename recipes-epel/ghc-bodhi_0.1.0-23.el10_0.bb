# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-bodhi"
PV = "0.1.0"
PR = "23.el10_0"
PACKAGES = " \
 ghc-bodhi \
 ghc-bodhi-devel \
 ghc-bodhi-doc \
 ghc-bodhi-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-bodhi-0.1.0-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2216de5618cbbb1471fb33c9103c1d771c15050689b56d154fe8d277068e1a2e"

URI_x86_64_v2_ghc-bodhi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bodhi-0.1.0-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bodhi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bodhi}"
SRC_URI[x86_64_v2_ghc-bodhi.sha256sum] = "92a42717ed062557d08dc2e4c5feb1db81813bfbf44bec276aa4b56d44fcd10c"

URI_x86_64_v2_ghc-bodhi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bodhi-devel-0.1.0-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bodhi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bodhi-devel}"
SRC_URI[x86_64_v2_ghc-bodhi-devel.sha256sum] = "aa26ac0e8963f2c8942f083f8602bb0f4dcf945894aa1a798d0597e285601e46"

URI_x86_64_v2_ghc-bodhi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bodhi-doc-0.1.0-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-bodhi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bodhi-doc}"
SRC_URI[x86_64_v2_ghc-bodhi-doc.sha256sum] = "7a738984d4e7812c497b85bfb767d610a25bef1b4d5bc25b1dabbc22fb7e234a"

URI_x86_64_v2_ghc-bodhi-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bodhi-prof-0.1.0-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bodhi-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bodhi-prof}"
SRC_URI[x86_64_v2_ghc-bodhi-prof.sha256sum] = "27ca00056afb852ec0077d26dee8e84e1db2f23106b5ce9fa02eac93778ee2e4"

URI_aarch64_ghc-bodhi = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bodhi-0.1.0-23.el10_0.aarch64.rpm;name=aarch64_ghc-bodhi;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bodhi}"
SRC_URI[aarch64_ghc-bodhi.sha256sum] = "5a0db3692aefe54c5e7fdcfb78ab06dde02b5adf0cef58eb55d911ba0d01bfa9"

URI_aarch64_ghc-bodhi-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bodhi-devel-0.1.0-23.el10_0.aarch64.rpm;name=aarch64_ghc-bodhi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bodhi-devel}"
SRC_URI[aarch64_ghc-bodhi-devel.sha256sum] = "0fc1e3d7f1be6ca668577e8f718acecdeb11ae34db624757e8eb922d9c542dd9"

URI_aarch64_ghc-bodhi-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bodhi-doc-0.1.0-23.el10_0.noarch.rpm;name=aarch64_ghc-bodhi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bodhi-doc}"
SRC_URI[aarch64_ghc-bodhi-doc.sha256sum] = "b3f1cc73003af1ce3be08c03f797c006d1aa480ec9f1bb9c2686c984f56e9872"

URI_aarch64_ghc-bodhi-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bodhi-prof-0.1.0-23.el10_0.aarch64.rpm;name=aarch64_ghc-bodhi-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bodhi-prof}"
SRC_URI[aarch64_ghc-bodhi-prof.sha256sum] = "1f2b83f9f1817e7d02fa447b66cf8c70f95d20ffae74ece5c99d6fac83ba5011"

RDEPENDS:ghc-bodhi = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-conduit \
 ghc-http-query \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-bodhi-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-bodhi \
 ghc-compiler \
 ghc-http-query-devel \
 ghc-text-devel \
 ghc-time-devel \
 "
RDEPENDS:ghc-bodhi-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-bodhi-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-bodhi-devel \
 ghc-http-query-prof \
 ghc-text-prof \
 ghc-time-prof \
 "
