# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-license-data"
PV = "1.74"
PR = "1.el10_3"
PACKAGES = " \
 fedora-license-data \
 rpmlint-fedora-license-data \
 rpmlint-fedora-license-data-legacy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-license-data-1.74-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03cc53cf4e358258eb70cb9096369889cc4e061f9db01fe4ed693c4ef58bb116"

URI_x86_64_v2_fedora-license-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-license-data-1.74-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-license-data}"
SRC_URI[x86_64_v2_fedora-license-data.sha256sum] = "a893567970570ad5bed0201e148ef8efd26f72dee265b16ddbcf661bd861cd50"

URI_x86_64_v2_rpmlint-fedora-license-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmlint-fedora-license-data-1.74-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rpmlint-fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmlint-fedora-license-data}"
SRC_URI[x86_64_v2_rpmlint-fedora-license-data.sha256sum] = "c039acc2f0a2b4e3b99df2c896ed6b99f5d5ec25841c72d87f035925c76306dd"

URI_x86_64_v2_rpmlint-fedora-license-data-legacy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmlint-fedora-license-data-legacy-1.74-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rpmlint-fedora-license-data-legacy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmlint-fedora-license-data-legacy}"
SRC_URI[x86_64_v2_rpmlint-fedora-license-data-legacy.sha256sum] = "db8a0c054b07a93f499dd518739d6bb175762db250ec622eb06443736819ed15"

URI_aarch64_fedora-license-data = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-license-data-1.74-1.el10_3.noarch.rpm;name=aarch64_fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-license-data}"
SRC_URI[aarch64_fedora-license-data.sha256sum] = "83ee1cef92ae4b7afb79373fc8aa2c1db762200f46c339199347e6259fdacedc"

URI_aarch64_rpmlint-fedora-license-data = "${EPEL_MIRROR}/aarch64/Packages/r/rpmlint-fedora-license-data-1.74-1.el10_3.noarch.rpm;name=aarch64_rpmlint-fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmlint-fedora-license-data}"
SRC_URI[aarch64_rpmlint-fedora-license-data.sha256sum] = "27b3e4cac57deb9c69dd33301f022638148bd4280c554e5efab3cdd9d589780f"

URI_aarch64_rpmlint-fedora-license-data-legacy = "${EPEL_MIRROR}/aarch64/Packages/r/rpmlint-fedora-license-data-legacy-1.74-1.el10_3.noarch.rpm;name=aarch64_rpmlint-fedora-license-data-legacy;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmlint-fedora-license-data-legacy}"
SRC_URI[aarch64_rpmlint-fedora-license-data-legacy.sha256sum] = "842596e65bfbf6e6e6b07ca3124302b9f04c91ebc2d91964fb7ff74e3ab5b8bb"

RDEPENDS:fedora-license-data = " \
 "
RDEPENDS:rpmlint-fedora-license-data = " \
 rpmlint \
 "
RDEPENDS:rpmlint-fedora-license-data-legacy = " \
 rpmlint \
 "
