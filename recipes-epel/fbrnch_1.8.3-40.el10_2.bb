# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fbrnch"
PV = "1.8.3"
PR = "40.el10_2"
PACKAGES:x86_64_v2 = " \
 fbrnch \
 ghc-copr-api \
 ghc-copr-api-devel \
 ghc-copr-api-doc \
 ghc-fedora-krb \
 ghc-fedora-krb-devel \
 ghc-fedora-krb-doc \
 ghc-say \
 ghc-say-devel \
 ghc-say-doc \
"
PACKAGES:aarch64 = " \
 fbrnch \
 ghc-copr-api \
 ghc-copr-api-devel \
 ghc-copr-api-doc \
 ghc-copr-api-prof \
 ghc-fedora-krb \
 ghc-fedora-krb-devel \
 ghc-fedora-krb-doc \
 ghc-fedora-krb-prof \
 ghc-say \
 ghc-say-devel \
 ghc-say-doc \
 ghc-say-prof \
"

URI_src = "${EPELSRC_MIRROR}/Packages/f/fbrnch-1.8.3-40.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24060c47aa9697c6047c2be513282fa8879517e93a6050bc37fcd59bff561ea8"

URI_x86_64_v2_fbrnch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fbrnch-1.8.3-40.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fbrnch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fbrnch}"
SRC_URI[x86_64_v2_fbrnch.sha256sum] = "8dfb20f768c1ad309b5478951ba541c088c095e75cbcaaa9e39490a7e37f790e"

URI_x86_64_v2_ghc-copr-api = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copr-api-0.2.0-40.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copr-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copr-api}"
SRC_URI[x86_64_v2_ghc-copr-api.sha256sum] = "1587c7a6b87697f1755ea9962da364f3e8ea44eb3e9b59e04720dd0dfb2229a2"

URI_x86_64_v2_ghc-copr-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copr-api-devel-0.2.0-40.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copr-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copr-api-devel}"
SRC_URI[x86_64_v2_ghc-copr-api-devel.sha256sum] = "2357320e1f91b9be5992aba78b4cc68bd6bde80da4ca7727df7029cfb2ad4d63"

URI_x86_64_v2_ghc-copr-api-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copr-api-doc-0.2.0-40.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-copr-api-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copr-api-doc}"
SRC_URI[x86_64_v2_ghc-copr-api-doc.sha256sum] = "c3752afbf4ccf48b2078046e0ff8f0077e5e70b3580ef10984860a898ab8ceb6"

URI_x86_64_v2_ghc-fedora-krb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fedora-krb-0.1.0-40.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fedora-krb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fedora-krb}"
SRC_URI[x86_64_v2_ghc-fedora-krb.sha256sum] = "bb8ae91849a5669ecd8b68b8c809728a2ad7b9da6f1e26cb6451b0082efecd45"

URI_x86_64_v2_ghc-fedora-krb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fedora-krb-devel-0.1.0-40.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fedora-krb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fedora-krb-devel}"
SRC_URI[x86_64_v2_ghc-fedora-krb-devel.sha256sum] = "6c8652e9dd7cd888c0178aa5065a7ca9f977c23531de43111606ac94b406bfec"

URI_x86_64_v2_ghc-fedora-krb-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fedora-krb-doc-0.1.0-40.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-fedora-krb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fedora-krb-doc}"
SRC_URI[x86_64_v2_ghc-fedora-krb-doc.sha256sum] = "6dd0e6f7293c86131245b8be2f1a0d1cdaea603d88f6fd7948b57bce42872028"

URI_x86_64_v2_ghc-say = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-say-0.1.0.1-40.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-say;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-say}"
SRC_URI[x86_64_v2_ghc-say.sha256sum] = "e6e59677a285ccc83f607a967d08bfc4231fb843ac0c95082983a04ec00f5531"

URI_x86_64_v2_ghc-say-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-say-devel-0.1.0.1-40.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-say-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-say-devel}"
SRC_URI[x86_64_v2_ghc-say-devel.sha256sum] = "cefba75be79e752511d796ededbfcbdcf5de1daf64080d4c7ed39509509fc61e"

URI_x86_64_v2_ghc-say-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-say-doc-0.1.0.1-40.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-say-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-say-doc}"
SRC_URI[x86_64_v2_ghc-say-doc.sha256sum] = "c7279f9578d337dae49cc09bbe1725c1351b11779f894838def78014cfe3d866"

URI_aarch64_fbrnch = "${EPEL_MIRROR}/aarch64/Packages/f/fbrnch-1.8.3-40.el10_2.aarch64.rpm;name=aarch64_fbrnch;unpack=0"
SRC_URI:append = " ${URI_aarch64_fbrnch}"
SRC_URI[aarch64_fbrnch.sha256sum] = "afa82b5eba33922bd93d0340f9cdfa2f5ac325847e24ffa951160a6eeb52b993"

URI_aarch64_ghc-copr-api = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copr-api-0.2.0-40.el10_2.aarch64.rpm;name=aarch64_ghc-copr-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copr-api}"
SRC_URI[aarch64_ghc-copr-api.sha256sum] = "01efc3f18b948b0bb35d5730b59f633c4f053d74011fb639e62bcad6649940f1"

URI_aarch64_ghc-copr-api-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copr-api-devel-0.2.0-40.el10_2.aarch64.rpm;name=aarch64_ghc-copr-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copr-api-devel}"
SRC_URI[aarch64_ghc-copr-api-devel.sha256sum] = "b6b7d2b600a4af40d10f7dd8eb83e2451a4fb9faa7b7fa15c3de41ed6c419eb6"

URI_aarch64_ghc-copr-api-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copr-api-doc-0.2.0-40.el10_2.noarch.rpm;name=aarch64_ghc-copr-api-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copr-api-doc}"
SRC_URI[aarch64_ghc-copr-api-doc.sha256sum] = "e16739f9ab795306deeea09077ef3bd4b225e9e9accbe3f279447b207ba96b21"

URI_aarch64_ghc-copr-api-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copr-api-prof-0.2.0-40.el10_2.aarch64.rpm;name=aarch64_ghc-copr-api-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copr-api-prof}"
SRC_URI[aarch64_ghc-copr-api-prof.sha256sum] = "d0da16424c7fa3209ae415e37d39f4d351820d95c3047541a77f5c617c4d75d6"

URI_aarch64_ghc-fedora-krb = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fedora-krb-0.1.0-40.el10_2.aarch64.rpm;name=aarch64_ghc-fedora-krb;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fedora-krb}"
SRC_URI[aarch64_ghc-fedora-krb.sha256sum] = "d499b4ff9d7360d47ab269007eb31c1c2ace8d63a97c37d8fe2d8800d0ce1f29"

URI_aarch64_ghc-fedora-krb-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fedora-krb-devel-0.1.0-40.el10_2.aarch64.rpm;name=aarch64_ghc-fedora-krb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fedora-krb-devel}"
SRC_URI[aarch64_ghc-fedora-krb-devel.sha256sum] = "3e3b3b12da663d3f7bfbae754b37e9c878f6be47d6fb3622464edd0195596861"

URI_aarch64_ghc-fedora-krb-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fedora-krb-doc-0.1.0-40.el10_2.noarch.rpm;name=aarch64_ghc-fedora-krb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fedora-krb-doc}"
SRC_URI[aarch64_ghc-fedora-krb-doc.sha256sum] = "7c461f6df5bf7b2914d94b4ec3a8dee7d9509c921dc49e08c59b5e5bc29e15d0"

URI_aarch64_ghc-fedora-krb-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fedora-krb-prof-0.1.0-40.el10_2.aarch64.rpm;name=aarch64_ghc-fedora-krb-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fedora-krb-prof}"
SRC_URI[aarch64_ghc-fedora-krb-prof.sha256sum] = "b952469710164ec1e2125b309ae797fb2fd44adac5a7306364bb5aa35a2a4281"

URI_aarch64_ghc-say = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-say-0.1.0.1-40.el10_2.aarch64.rpm;name=aarch64_ghc-say;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-say}"
SRC_URI[aarch64_ghc-say.sha256sum] = "779aa38082a0f75c6cc1a9d4bee4f265347e99dd227ce738683529930fa32caf"

URI_aarch64_ghc-say-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-say-devel-0.1.0.1-40.el10_2.aarch64.rpm;name=aarch64_ghc-say-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-say-devel}"
SRC_URI[aarch64_ghc-say-devel.sha256sum] = "4ce9fc50b8cf46672e61ee72a4582211eac486e300a1f49815bc53a38d10a40c"

URI_aarch64_ghc-say-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-say-doc-0.1.0.1-40.el10_2.noarch.rpm;name=aarch64_ghc-say-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-say-doc}"
SRC_URI[aarch64_ghc-say-doc.sha256sum] = "44a930a9bd92274bc07a41a12cc6173122eb3c05e77fe3637762b96e0d25e750"

URI_aarch64_ghc-say-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-say-prof-0.1.0.1-40.el10_2.aarch64.rpm;name=aarch64_ghc-say-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-say-prof}"
SRC_URI[aarch64_ghc-say-prof.sha256sum] = "9200c2e0a40b1d9040d32df34502cfeeb6e354a3bbd0f98c581a368d622d7695"

RDEPENDS:fbrnch = " \
 bodhi-client \
 curl \
 fedpkg \
 git-core \
 glibc \
 gmp \
 koji \
 libffi \
 ncurses-libs \
 openssh-clients \
 openssl-libs \
 rpm-build \
 rpmautospec \
 rpmdevtools \
 util-linux \
 zlib-ng-compat \
 "
RDEPENDS:ghc-copr-api = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-conduit \
 ghc-http-query \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-copr-api-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-copr-api \
 ghc-http-query-devel \
 ghc-text-devel \
 ghc-unordered-containers-devel \
 "
RDEPENDS:ghc-copr-api-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-fedora-krb = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-clock \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-extra \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-simple-cmd \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-fedora-krb-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-fedora-krb \
 ghc-simple-cmd-devel \
 "
RDEPENDS:ghc-fedora-krb-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-say = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-say-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-say \
 ghc-text-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-say-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-copr-api-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-copr-api-devel \
 ghc-http-query-prof \
 ghc-text-prof \
 ghc-unordered-containers-prof \
 "
RDEPENDS:ghc-fedora-krb-prof = " \
 ghc-base-prof \
 ghc-fedora-krb-devel \
 ghc-simple-cmd-prof \
 "
RDEPENDS:ghc-say-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-say-devel \
 ghc-text-prof \
 ghc-transformers-prof \
 "
