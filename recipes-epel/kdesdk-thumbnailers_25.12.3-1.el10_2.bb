# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdesdk-thumbnailers"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kdesdk-thumbnailers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdesdk-thumbnailers-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "489b10046d909c3572e6c292153f5bae87668b470a90bc9a956a5a7fce91ac43"

URI_x86_64_v2_kdesdk-thumbnailers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdesdk-thumbnailers-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdesdk-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdesdk-thumbnailers}"
SRC_URI[x86_64_v2_kdesdk-thumbnailers.sha256sum] = "03502c62e4b7efd50bf6fec096cdc0e60c5efe0a685025d574fd367e64a4f4a0"

URI_aarch64_kdesdk-thumbnailers = "${EPEL_MIRROR}/aarch64/Packages/k/kdesdk-thumbnailers-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdesdk-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdesdk-thumbnailers}"
SRC_URI[aarch64_kdesdk-thumbnailers.sha256sum] = "ff86a1338fcbbe121a6880dc9bb385f3700f4ebbee644fc5199921bdb417e0cd"

RDEPENDS:kdesdk-thumbnailers = " \
 gettext-libs \
 glibc \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
