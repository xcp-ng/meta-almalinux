# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmahjongg"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kmahjongg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmahjongg-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c7c14a697a4dbd74384bc099b517eda7b33078c805c5c9622ae5f92267f1b44"

URI_x86_64_v2_kmahjongg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmahjongg-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmahjongg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmahjongg}"
SRC_URI[x86_64_v2_kmahjongg.sha256sum] = "00e16de5523183c4f31a465d5313b347c9f01f367e65a4291b92ff5133df7ef5"

URI_aarch64_kmahjongg = "${EPEL_MIRROR}/aarch64/Packages/k/kmahjongg-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmahjongg;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmahjongg}"
SRC_URI[aarch64_kmahjongg.sha256sum] = "3c2ae5509933a4f0edc395c81548a1e5783195444a9c50df48a5a3c546c066fe"

RDEPENDS:kmahjongg = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libkmahjongg \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
