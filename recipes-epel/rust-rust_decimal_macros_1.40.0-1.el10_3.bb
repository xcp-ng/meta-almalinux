# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust_decimal_macros"
PV = "1.40.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-rust_decimal_macros+default-devel \
 rust-rust_decimal_macros+reexportable-devel \
 rust-rust_decimal_macros-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rust_decimal_macros-1.40.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "701ac83a8224805316bf4112510f6428534b87e320e05a440f2925509601e4bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal_macros+default-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal_macros+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rust_decimal_macros+default-devel.sha256sum] = "6cf4a2ca0b1e734aa32de425a81e7b370126d386d6df0a280c235a4914bcf01e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal_macros+reexportable-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal_macros+reexportable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rust_decimal_macros+reexportable-devel.sha256sum] = "17fb7db051bb3dbfa9ce9bf9a0445089328dc12eb5118a8f6e439c414576b729"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal_macros-devel-1.40.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal_macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rust_decimal_macros-devel.sha256sum] = "1e84d7f3a66ee79115d159971719ce5462b444f680ff5b144d7f2607e85b4780"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal_macros+default-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal_macros+default-devel;unpack=0"
SRC_URI[aarch64_rust-rust_decimal_macros+default-devel.sha256sum] = "ba75cf484f1ccaa38db859e9a6fc2f6b09b2cc0b815c9c68ccc1a1c93c56f106"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal_macros+reexportable-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal_macros+reexportable-devel;unpack=0"
SRC_URI[aarch64_rust-rust_decimal_macros+reexportable-devel.sha256sum] = "445c4f2f87b6aa7c3ece0299bb40ba5ca55e7781b00350211de6966bd3bb2796"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal_macros-devel-1.40.0-1.el10_3.noarch.rpm;name=aarch64_rust-rust_decimal_macros-devel;unpack=0"
SRC_URI[aarch64_rust-rust_decimal_macros-devel.sha256sum] = "dd893acbd1089e922abaccc7a36da22913c6cd4ed247f76562005e98ee5063e0"

RDEPENDS:rust-rust_decimal_macros+default-devel = " \
 cargo \
 rust-rust_decimal_macros-devel \
 "
RDEPENDS:rust-rust_decimal_macros+reexportable-devel = " \
 cargo \
 rust-rust_decimal_macros-devel \
 "
RDEPENDS:rust-rust_decimal_macros-devel = " \
 cargo \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 "
