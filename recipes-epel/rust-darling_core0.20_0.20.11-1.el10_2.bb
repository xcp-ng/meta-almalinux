# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-darling_core0.20"
PV = "0.20.11"
PR = "1.el10_2"
PACKAGES = " \
 rust-darling_core0.20+default-devel \
 rust-darling_core0.20+diagnostics-devel \
 rust-darling_core0.20+strsim-devel \
 rust-darling_core0.20+suggestions-devel \
 rust-darling_core0.20-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-darling_core0.20-0.20.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d3f3a3f919aa37bcda75e3fbc3be520b77a45972c7b7a77b5ef3b9e2aed3d6c"

URI_x86_64_v2_rust-darling_core0.20+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core0.20+default-devel-0.20.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core0.20+default-devel}"
SRC_URI[x86_64_v2_rust-darling_core0.20+default-devel.sha256sum] = "ee287668b838061a36dcd793ec8292751ab5bd32353e526161f72d5ab6165fdb"

URI_x86_64_v2_rust-darling_core0.20+diagnostics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core0.20+diagnostics-devel-0.20.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core0.20+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core0.20+diagnostics-devel}"
SRC_URI[x86_64_v2_rust-darling_core0.20+diagnostics-devel.sha256sum] = "517230a9ef8dbe3209dc822793ae23676a0e0527d82e210af2238f003ed701d1"

URI_x86_64_v2_rust-darling_core0.20+strsim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core0.20+strsim-devel-0.20.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core0.20+strsim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core0.20+strsim-devel}"
SRC_URI[x86_64_v2_rust-darling_core0.20+strsim-devel.sha256sum] = "0508c2200788ffa867b8e741cd1637b354544fbe9f285f51c351c47fa54e4a15"

URI_x86_64_v2_rust-darling_core0.20+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core0.20+suggestions-devel-0.20.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core0.20+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core0.20+suggestions-devel}"
SRC_URI[x86_64_v2_rust-darling_core0.20+suggestions-devel.sha256sum] = "95a21eedc4eb7d6cd45da3eed175b6bf891824ae757a0006db9061ae520ac0cd"

URI_x86_64_v2_rust-darling_core0.20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core0.20-devel-0.20.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core0.20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core0.20-devel}"
SRC_URI[x86_64_v2_rust-darling_core0.20-devel.sha256sum] = "7c8426b5e54b39f58e656f0a4147217ec6bb12f0c715a79dbdd19eb4d82e4bea"

URI_aarch64_rust-darling_core0.20+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core0.20+default-devel-0.20.11-1.el10_2.noarch.rpm;name=aarch64_rust-darling_core0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core0.20+default-devel}"
SRC_URI[aarch64_rust-darling_core0.20+default-devel.sha256sum] = "36dad995db9a2dcfe6c08049a758f8983af873a981dfe526d02829e6dd687272"

URI_aarch64_rust-darling_core0.20+diagnostics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core0.20+diagnostics-devel-0.20.11-1.el10_2.noarch.rpm;name=aarch64_rust-darling_core0.20+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core0.20+diagnostics-devel}"
SRC_URI[aarch64_rust-darling_core0.20+diagnostics-devel.sha256sum] = "5ccc71d691eea8517ff514aeb007a386b1d0692cb01bc83606b7d9c5723b5fb6"

URI_aarch64_rust-darling_core0.20+strsim-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core0.20+strsim-devel-0.20.11-1.el10_2.noarch.rpm;name=aarch64_rust-darling_core0.20+strsim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core0.20+strsim-devel}"
SRC_URI[aarch64_rust-darling_core0.20+strsim-devel.sha256sum] = "07abe40ca7c2738fe68afe7a87ca0c14e97312c3c4a5ccbbf15b5daf0efc9382"

URI_aarch64_rust-darling_core0.20+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core0.20+suggestions-devel-0.20.11-1.el10_2.noarch.rpm;name=aarch64_rust-darling_core0.20+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core0.20+suggestions-devel}"
SRC_URI[aarch64_rust-darling_core0.20+suggestions-devel.sha256sum] = "95586bf60e36b0814c9bc445c3bcecd09d8493553dff3d4461f63f036d81dd3d"

URI_aarch64_rust-darling_core0.20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core0.20-devel-0.20.11-1.el10_2.noarch.rpm;name=aarch64_rust-darling_core0.20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core0.20-devel}"
SRC_URI[aarch64_rust-darling_core0.20-devel.sha256sum] = "d533ffa5f88d1ae736136811d0451013fa77d2d173274b864824ff4ced09e58a"

RDEPENDS:rust-darling_core0.20+default-devel = " \
 cargo \
 rust-darling_core0.20-devel \
 "
RDEPENDS:rust-darling_core0.20+diagnostics-devel = " \
 cargo \
 rust-darling_core0.20-devel \
 "
RDEPENDS:rust-darling_core0.20+strsim-devel = " \
 cargo \
 rust-darling_core0.20-devel \
 rust-strsim+default-devel \
 "
RDEPENDS:rust-darling_core0.20+suggestions-devel = " \
 cargo \
 rust-darling_core0.20+strsim-devel \
 rust-darling_core0.20-devel \
 "
RDEPENDS:rust-darling_core0.20-devel = " \
 cargo \
 rust \
 rust-fnv+default-devel \
 rust-ident_case+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 "
