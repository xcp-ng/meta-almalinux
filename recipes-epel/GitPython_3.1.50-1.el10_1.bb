# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "GitPython"
PV = "3.1.50"
PR = "1.el10_1"
PACKAGES = " \
 python3-GitPython \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/GitPython-3.1.50-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a32674747bbcc8e47608e46c938bd75198c37383f31be4d02d3a3dc8083b4a6f"

URI_x86_64_v2_python3-GitPython = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-GitPython-3.1.50-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-GitPython;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-GitPython}"
SRC_URI[x86_64_v2_python3-GitPython.sha256sum] = "293685cb78e65737c5579ddd5b5b2171ae0c4d5de423c267395d303897f3a5e7"

URI_aarch64_python3-GitPython = "${EPEL_MIRROR}/aarch64/Packages/p/python3-GitPython-3.1.50-1.el10_1.noarch.rpm;name=aarch64_python3-GitPython;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-GitPython}"
SRC_URI[aarch64_python3-GitPython.sha256sum] = "c7fb0cee5444273fac979f4a8d3a6ea973bf0ec831606a65b0743d3b890bfc21"

RDEPENDS:python3-GitPython = " \
 git-core \
 python3 \
 python3-gitdb \
 "
