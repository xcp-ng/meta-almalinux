# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-Rcpp"
PV = "1.1.2"
PR = "1.el10_3"
PACKAGES = " \
 R-Rcpp \
 R-Rcpp-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-Rcpp-1.1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2257fcc06a9f96f4afee1e3f0bd585403529c0d847c2d084d6d68470be2d71ce"

URI_x86_64_v2_R-Rcpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-Rcpp-1.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-Rcpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-Rcpp}"
SRC_URI[x86_64_v2_R-Rcpp.sha256sum] = "b8ed422d32853bb20976bdf181815cfef6c553a8eb9500656e95e544fa31e105"

URI_x86_64_v2_R-Rcpp-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-Rcpp-examples-1.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-Rcpp-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-Rcpp-examples}"
SRC_URI[x86_64_v2_R-Rcpp-examples.sha256sum] = "26646ecc00bba8c755ec3ff6921d6b5a18e797e2526b710ce23762e61dc33c2b"

URI_aarch64_R-Rcpp = "${EPEL_MIRROR}/aarch64/Packages/r/R-Rcpp-1.1.2-1.el10_3.aarch64.rpm;name=aarch64_R-Rcpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-Rcpp}"
SRC_URI[aarch64_R-Rcpp.sha256sum] = "934262a5675a47c62287a5ae2de746db64443ad623528824de5b25bf0af300a4"

URI_aarch64_R-Rcpp-examples = "${EPEL_MIRROR}/aarch64/Packages/r/R-Rcpp-examples-1.1.2-1.el10_3.aarch64.rpm;name=aarch64_R-Rcpp-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-Rcpp-examples}"
SRC_URI[aarch64_R-Rcpp-examples.sha256sum] = "2151b05e51a222e53667c7b43d540d1546b7b19454de46b66a830611ca97fac2"

RDEPENDS:R-Rcpp = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:R-Rcpp-examples = " \
 R-Rcpp \
 R-littler \
 bash \
 "
