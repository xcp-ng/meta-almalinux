# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ncompress"
PV = "5.0"
PR = "7.el10_0"
PACKAGES = " \
 ncompress \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/ncompress-5.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "eb345f07577094885e4e99ae1164de3a377b1747bd10c7bbedd92d3a75ad4790"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ncompress-5.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ncompress;unpack=0"
SRC_URI[x86_64_v2_ncompress.sha256sum] = "a33392055352e9c38dd70114b7047396c038340227976f5a1fed61d7f4e53470"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/ncompress-5.0-7.el10_0.aarch64.rpm;name=aarch64_ncompress;unpack=0"
SRC_URI[aarch64_ncompress.sha256sum] = "dbfc0309bbefd787c09eb8ef7714728809fbba438e40c8705d5e0e86fa4aa36a"

RDEPENDS:ncompress = " \
 glibc \
 "
