# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-python-multipart"
PV = "0.0.32"
PR = "1.el10_3"
PACKAGES = " \
 python3-python-multipart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-python-multipart-0.0.32-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c470427cc183d47d9de7b73267f2f80a97666d0f3b6f6a802c54d57531d4d5c0"

URI_x86_64_v2_python3-python-multipart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-python-multipart-0.0.32-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-python-multipart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-python-multipart}"
SRC_URI[x86_64_v2_python3-python-multipart.sha256sum] = "14ab4a00acffc4ce57cf41910e61524591e72697e5de86bae913b460a20e1dc5"

URI_aarch64_python3-python-multipart = "${EPEL_MIRROR}/aarch64/Packages/p/python3-python-multipart-0.0.32-1.el10_3.noarch.rpm;name=aarch64_python3-python-multipart;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-python-multipart}"
SRC_URI[aarch64_python3-python-multipart.sha256sum] = "51471f69248880207ef1ec7d33947fde47c567227043a3af0d61a91402754d8c"

RDEPENDS:python3-python-multipart = " \
 python3 \
 "
