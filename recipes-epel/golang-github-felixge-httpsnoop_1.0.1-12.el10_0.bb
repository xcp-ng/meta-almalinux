# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-felixge-httpsnoop"
PV = "1.0.1"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-felixge-httpsnoop-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-felixge-httpsnoop-1.0.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ddd8074c4dcf0489b0361e20d2b5df7c6d7ab9f18dc2139113746d1e377135a"

URI_x86_64_v2_golang-github-felixge-httpsnoop-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-felixge-httpsnoop-devel-1.0.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-felixge-httpsnoop-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-felixge-httpsnoop-devel}"
SRC_URI[x86_64_v2_golang-github-felixge-httpsnoop-devel.sha256sum] = "215c5e5a2c32b81dbd98595509ede68a549c932876a259743d0160678ad9184d"

URI_aarch64_golang-github-felixge-httpsnoop-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-felixge-httpsnoop-devel-1.0.1-12.el10_0.noarch.rpm;name=aarch64_golang-github-felixge-httpsnoop-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-felixge-httpsnoop-devel}"
SRC_URI[aarch64_golang-github-felixge-httpsnoop-devel.sha256sum] = "ed63bc76bfd4dd1a10bbf141c196aaccaef3906bae72eb3aa1f596642aea8f79"

RDEPENDS:golang-github-felixge-httpsnoop-devel = " \
 go-filesystem \
 "
