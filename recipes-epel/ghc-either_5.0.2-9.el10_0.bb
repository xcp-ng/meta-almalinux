# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-either"
PV = "5.0.2"
PR = "9.el10_0"
PACKAGES = " \
 ghc-either \
 ghc-either-devel \
 ghc-either-doc \
 ghc-either-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-either-5.0.2-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27012353676a8266b84677cdcf3200959f8cc1079bc0541f5066c90f9f11166b"

URI_x86_64_v2_ghc-either = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-either-5.0.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-either;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-either}"
SRC_URI[x86_64_v2_ghc-either.sha256sum] = "da9de97bf5ec0713c0ac9e2876db479c17263ef2ba4ddc959902c9c61a3a5b90"

URI_x86_64_v2_ghc-either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-either-devel-5.0.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-either-devel}"
SRC_URI[x86_64_v2_ghc-either-devel.sha256sum] = "ab342a531077ab71499c06ec4e32f7e0ed7fc16ead55792d1032a1d07721ee49"

URI_x86_64_v2_ghc-either-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-either-doc-5.0.2-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-either-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-either-doc}"
SRC_URI[x86_64_v2_ghc-either-doc.sha256sum] = "78e4881b517f8d2c37ccf1850814a6dbcc8d1d63da394724dc655ebbd98ac07c"

URI_x86_64_v2_ghc-either-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-either-prof-5.0.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-either-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-either-prof}"
SRC_URI[x86_64_v2_ghc-either-prof.sha256sum] = "18c0241a6da23352410bcfb0549b3e97277387e3f7d065ca11f5a8695e19d935"

URI_aarch64_ghc-either = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-either-5.0.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-either;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-either}"
SRC_URI[aarch64_ghc-either.sha256sum] = "7662606aa454c8a6c2c690a3c9426274731e77f4410cb641f293f9d817cdf25d"

URI_aarch64_ghc-either-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-either-devel-5.0.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-either-devel}"
SRC_URI[aarch64_ghc-either-devel.sha256sum] = "c3c6b73881086bddd48e5f9ff3c13a20bbac2b1a989fd84ce9da6b5dddbdde8d"

URI_aarch64_ghc-either-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-either-doc-5.0.2-9.el10_0.noarch.rpm;name=aarch64_ghc-either-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-either-doc}"
SRC_URI[aarch64_ghc-either-doc.sha256sum] = "fcbd8b6bdee2ae20c609d03935bae499981c352e2637f65d7946929f36b34b48"

URI_aarch64_ghc-either-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-either-prof-5.0.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-either-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-either-prof}"
SRC_URI[aarch64_ghc-either-prof.sha256sum] = "eb1798ce7f007dc85a3ecb93bde5cff1de4e9c70a432ed6f6a232ff0a78dffe5"

RDEPENDS:ghc-either = " \
 ghc-StateVar \
 ghc-array \
 ghc-assoc \
 ghc-base \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-deepseq \
 ghc-distributive \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-profunctors \
 ghc-semigroupoids \
 ghc-stm \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-th-abstraction \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unordered-containers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-either-devel = " \
 ghc-base-devel \
 ghc-bifunctors-devel \
 ghc-compiler \
 ghc-either \
 ghc-mtl-devel \
 ghc-profunctors-devel \
 ghc-semigroupoids-devel \
 "
RDEPENDS:ghc-either-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-either-prof = " \
 ghc-base-prof \
 ghc-bifunctors-prof \
 ghc-either-devel \
 ghc-mtl-prof \
 ghc-profunctors-prof \
 ghc-semigroupoids-prof \
 "
