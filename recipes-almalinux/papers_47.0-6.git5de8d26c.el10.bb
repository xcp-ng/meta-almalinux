# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "papers"
PV = "47.0"
PR = "6.git5de8d26c.el10"
PACKAGES = " \
 papers \
 papers-devel \
 papers-libs \
 papers-nautilus \
 papers-previewer \
 papers-thumbnailer \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/papers-47.0-6.git5de8d26c.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fd7e3014d423417a8a22e1b818f4cba01e70a3e83938aa13e63842c10ae1440"

URI_x86_64_v2_papers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papers-47.0-6.git5de8d26c.el10.x86_64_v2.rpm;name=x86_64_v2_papers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers}"
SRC_URI[x86_64_v2_papers.sha256sum] = "35891b2c5d0826592670330bd0f461ea57ecac67c7525a86192931b83d8a5080"

URI_x86_64_v2_papers-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/papers-devel-47.0-6.git5de8d26c.el10.x86_64_v2.rpm;name=x86_64_v2_papers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers-devel}"
SRC_URI[x86_64_v2_papers-devel.sha256sum] = "eb20616fc47e74b8fd47cb6676414b8ea5cd6b71a796f944922d3867d4047813"

URI_x86_64_v2_papers-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papers-libs-47.0-6.git5de8d26c.el10.x86_64_v2.rpm;name=x86_64_v2_papers-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers-libs}"
SRC_URI[x86_64_v2_papers-libs.sha256sum] = "a961fb70f18a766dffaa56652d9dacc6dd7e6bd9262120460668927b1a652c0e"

URI_x86_64_v2_papers-nautilus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papers-nautilus-47.0-6.git5de8d26c.el10.x86_64_v2.rpm;name=x86_64_v2_papers-nautilus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers-nautilus}"
SRC_URI[x86_64_v2_papers-nautilus.sha256sum] = "c214633b222abf400ee8ad14bb44c05c0b17144f12d0be4c08b6afb1098cd5de"

URI_x86_64_v2_papers-previewer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papers-previewer-47.0-6.git5de8d26c.el10.x86_64_v2.rpm;name=x86_64_v2_papers-previewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers-previewer}"
SRC_URI[x86_64_v2_papers-previewer.sha256sum] = "8768fcdd6246f2c8d14ed82af14d11ff2109c6a4119b861137f0e87582ddcbe3"

URI_x86_64_v2_papers-thumbnailer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papers-thumbnailer-47.0-6.git5de8d26c.el10.x86_64_v2.rpm;name=x86_64_v2_papers-thumbnailer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papers-thumbnailer}"
SRC_URI[x86_64_v2_papers-thumbnailer.sha256sum] = "4b6280623e04a3e9ffe81237831f9a88fb792df978264530b10f1715b3d10df7"

URI_aarch64_papers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papers-47.0-6.git5de8d26c.el10.aarch64.rpm;name=aarch64_papers;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers}"
SRC_URI[aarch64_papers.sha256sum] = "607f2848e4abee0850f2f70868e33454cef97937b08d2b3ebe0c385279442237"

URI_aarch64_papers-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/papers-devel-47.0-6.git5de8d26c.el10.aarch64.rpm;name=aarch64_papers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers-devel}"
SRC_URI[aarch64_papers-devel.sha256sum] = "1aeb4aa3b703f1c4224bc0896743396e2902c7b2cf9a97f6f703124e24c56e81"

URI_aarch64_papers-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papers-libs-47.0-6.git5de8d26c.el10.aarch64.rpm;name=aarch64_papers-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers-libs}"
SRC_URI[aarch64_papers-libs.sha256sum] = "a37cc55ee02128346006f1f2528af56516c08f2fcf20fc359941b273e49c7863"

URI_aarch64_papers-nautilus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papers-nautilus-47.0-6.git5de8d26c.el10.aarch64.rpm;name=aarch64_papers-nautilus;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers-nautilus}"
SRC_URI[aarch64_papers-nautilus.sha256sum] = "037677f9d5eb0f363b959e3800dfc3746d27bba63083152733f7016ad9eb4876"

URI_aarch64_papers-previewer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papers-previewer-47.0-6.git5de8d26c.el10.aarch64.rpm;name=aarch64_papers-previewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers-previewer}"
SRC_URI[aarch64_papers-previewer.sha256sum] = "c6b1c1306e120c5e2679e8481dd2d75a13c46453ff3aa0d909ccef8c6bd5ed73"

URI_aarch64_papers-thumbnailer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papers-thumbnailer-47.0-6.git5de8d26c.el10.aarch64.rpm;name=aarch64_papers-thumbnailer;unpack=0"
SRC_URI:append = " ${URI_aarch64_papers-thumbnailer}"
SRC_URI[aarch64_papers-thumbnailer.sha256sum] = "5aa7c132a5bd0abcca6262556931a93986f8ef0ac59807d28d09935c084fd1e9"

RDEPENDS:papers = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 hicolor-icon-theme \
 libadwaita \
 libgcc \
 pango \
 papers-libs \
 papers-previewer \
 papers-thumbnailer \
 "
RDEPENDS:papers-devel = " \
 glib2-devel \
 gtk4-devel \
 libadwaita-devel \
 papers-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:papers-libs = " \
 cairo \
 exempi \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 gtksourceview5 \
 libadwaita \
 libarchive \
 libgcc \
 libspelling \
 libtiff \
 pango \
 poppler-glib \
 "
RDEPENDS:papers-nautilus = " \
 glib2 \
 glibc \
 libgcc \
 nautilus \
 nautilus-extensions \
 papers-libs \
 "
RDEPENDS:papers-previewer = " \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
 libgcc \
 papers-libs \
 "
RDEPENDS:papers-thumbnailer = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libgcc \
 papers-libs \
 "
