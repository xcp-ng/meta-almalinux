# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustc-hash"
PV = "2.1.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-rustc-hash+default-devel \
 rust-rustc-hash+rand-devel \
 rust-rustc-hash+std-devel \
 rust-rustc-hash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustc-hash-2.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "015a2bae5634de1ee27ed0bca6a11c97c7d318281907498ff5985ea2a5faf45b"

URI_x86_64_v2_rust-rustc-hash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-hash+default-devel-2.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-hash+default-devel}"
SRC_URI[x86_64_v2_rust-rustc-hash+default-devel.sha256sum] = "888c7d07b31b7d52c5f765f109117633c79f43400adc85fa6daea1df169c1b17"

URI_x86_64_v2_rust-rustc-hash+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-hash+rand-devel-2.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-hash+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-hash+rand-devel}"
SRC_URI[x86_64_v2_rust-rustc-hash+rand-devel.sha256sum] = "8609ee6941e316910296b8cdd762ab0e1d9616a36ed3a2f90ab4ef8579d8dd14"

URI_x86_64_v2_rust-rustc-hash+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-hash+std-devel-2.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-hash+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-hash+std-devel}"
SRC_URI[x86_64_v2_rust-rustc-hash+std-devel.sha256sum] = "98726da3d61ea2eb481756fbf747ca92b61e7ff4c6d705d181e3aa4fe0a890d3"

URI_x86_64_v2_rust-rustc-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-hash-devel-2.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-hash-devel}"
SRC_URI[x86_64_v2_rust-rustc-hash-devel.sha256sum] = "6b60571704ead8fce3548cf4b32734db8c8dbcd0179792753cbb60064d61e0da"

URI_aarch64_rust-rustc-hash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-hash+default-devel-2.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-rustc-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-hash+default-devel}"
SRC_URI[aarch64_rust-rustc-hash+default-devel.sha256sum] = "7831527859459ef4ad2b95f387d908d668102134e237da09d5dc85d13edc5040"

URI_aarch64_rust-rustc-hash+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-hash+rand-devel-2.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-rustc-hash+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-hash+rand-devel}"
SRC_URI[aarch64_rust-rustc-hash+rand-devel.sha256sum] = "06cc4dbfdc3edb42f3a7505bd91f3eed3ce7003a891e08832b4b6f3b594d9289"

URI_aarch64_rust-rustc-hash+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-hash+std-devel-2.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-rustc-hash+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-hash+std-devel}"
SRC_URI[aarch64_rust-rustc-hash+std-devel.sha256sum] = "f11cdad13f3d9551c68ea30270f30a5cd3b0faf969a8cb935be96e7aef68a385"

URI_aarch64_rust-rustc-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-hash-devel-2.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-rustc-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-hash-devel}"
SRC_URI[aarch64_rust-rustc-hash-devel.sha256sum] = "6ed7cf4f29d42cbae8c9e0d001daf8d8437ca810dd00388f1496bba64d751d81"

RDEPENDS:rust-rustc-hash+default-devel = " \
 cargo \
 rust-rustc-hash+std-devel \
 rust-rustc-hash-devel \
 "
RDEPENDS:rust-rustc-hash+rand-devel = " \
 cargo \
 rust-rand0.8+default-devel \
 rust-rustc-hash+std-devel \
 rust-rustc-hash-devel \
 "
RDEPENDS:rust-rustc-hash+std-devel = " \
 cargo \
 rust-rustc-hash-devel \
 "
RDEPENDS:rust-rustc-hash-devel = " \
 cargo \
 "
