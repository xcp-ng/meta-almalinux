# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libftdi"
PV = "1.5"
PR = "15.el10_0"
PACKAGES = " \
 libftdi \
 libftdi-c++ \
 libftdi-c++-devel \
 libftdi-devel \
 python3-libftdi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libftdi-1.5-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1297774916b09e822a122c44451c4e2a4bec3cbc25f789ff29fee69ceae0db9d"

URI_x86_64_v2_libftdi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libftdi-1.5-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libftdi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libftdi}"
SRC_URI[x86_64_v2_libftdi.sha256sum] = "7d6bf1d4beb3576bba13b0183046eb60da9477750349d596df35040d8f47762c"

URI_x86_64_v2_libftdi-c++ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libftdi-c++-1.5-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libftdi-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libftdi-c++}"
SRC_URI[x86_64_v2_libftdi-c++.sha256sum] = "739b0f5f1b43a7cbfaf4b9eeb9da54249fcf38721fe3b2c708e3b7a9c90a9c6b"

URI_x86_64_v2_libftdi-c++-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libftdi-c++-devel-1.5-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libftdi-c++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libftdi-c++-devel}"
SRC_URI[x86_64_v2_libftdi-c++-devel.sha256sum] = "f74a76514f204f556ea1c8ea58c5130361f78003a392746b871d118601b511da"

URI_x86_64_v2_libftdi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libftdi-devel-1.5-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libftdi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libftdi-devel}"
SRC_URI[x86_64_v2_libftdi-devel.sha256sum] = "d475add9ae88dcfaf560ecfc36382b36d16accae76b6c2d37c8521104cea1ebb"

URI_x86_64_v2_python3-libftdi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libftdi-1.5-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-libftdi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libftdi}"
SRC_URI[x86_64_v2_python3-libftdi.sha256sum] = "f9e74d143079e0aee681052923caedbc80b538a7cebcfc96903a046de95cd2ed"

URI_aarch64_libftdi = "${EPEL_MIRROR}/aarch64/Packages/l/libftdi-1.5-15.el10_0.aarch64.rpm;name=aarch64_libftdi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libftdi}"
SRC_URI[aarch64_libftdi.sha256sum] = "e578b08f8d816f20b2857435221fd896af63dd84a5bbadb082451ecd358abb7a"

URI_aarch64_libftdi-c++ = "${EPEL_MIRROR}/aarch64/Packages/l/libftdi-c++-1.5-15.el10_0.aarch64.rpm;name=aarch64_libftdi-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_libftdi-c++}"
SRC_URI[aarch64_libftdi-c++.sha256sum] = "f5f7ef08c7d8acc4edcf3bbfd5446ac5945f3e84fc2098e5050c480488652467"

URI_aarch64_libftdi-c++-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libftdi-c++-devel-1.5-15.el10_0.aarch64.rpm;name=aarch64_libftdi-c++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libftdi-c++-devel}"
SRC_URI[aarch64_libftdi-c++-devel.sha256sum] = "4fa664a090fe4d220fbaa5b79af7efb546601822f7e6ed6365a9eef9078c2f8c"

URI_aarch64_libftdi-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libftdi-devel-1.5-15.el10_0.aarch64.rpm;name=aarch64_libftdi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libftdi-devel}"
SRC_URI[aarch64_libftdi-devel.sha256sum] = "da81de6eae195a3a147263373d2e7843d1644e24d539aaacbee79a611c1cd9ba"

URI_aarch64_python3-libftdi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libftdi-1.5-15.el10_0.aarch64.rpm;name=aarch64_python3-libftdi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libftdi}"
SRC_URI[aarch64_python3-libftdi.sha256sum] = "44f6233a6c6975267515522f547dab3d343c70d38d66d6ccac5f398289a573bd"

RDEPENDS:libftdi = " \
 glibc \
 libusb1 \
 systemd \
 "
RDEPENDS:libftdi-c++ = " \
 glibc \
 libftdi \
 libgcc \
 libstdc++ \
 libusb1 \
 "
RDEPENDS:libftdi-c++-devel = " \
 libftdi-c++ \
 libftdi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libftdi-devel = " \
 bash \
 cmake-filesystem \
 glibc \
 libconfuse \
 libftdi \
 libusb1 \
 libusb1-devel \
 pkgconf-pkg-config \
 python3-libftdi \
 "
RDEPENDS:python3-libftdi = " \
 glibc \
 libftdi \
 python3 \
 "
