# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hash-slinger"
PV = "3.5"
PR = "1.el10_1"
PACKAGES = " \
 hash-slinger \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hash-slinger-3.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a83ab034464dfc650c54fe6d6222b21b0b5ff208cdafb593e6120d6bd9217fdb"

URI_x86_64_v2_hash-slinger = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hash-slinger-3.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_hash-slinger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hash-slinger}"
SRC_URI[x86_64_v2_hash-slinger.sha256sum] = "2e1ace230bed83a0648db9df07cf48d1e2a64d240b05165916f230054156c143"

URI_aarch64_hash-slinger = "${EPEL_MIRROR}/aarch64/Packages/h/hash-slinger-3.5-1.el10_1.noarch.rpm;name=aarch64_hash-slinger;unpack=0"
SRC_URI:append = " ${URI_aarch64_hash-slinger}"
SRC_URI[aarch64_hash-slinger.sha256sum] = "ebf4706a8d8fa4d17451257f4ab7d80962fbcf134f9c13ac0343e6e41cd73083"

RDEPENDS:hash-slinger = " \
 openssh-clients \
 python3 \
 python3-cryptography \
 python3-dns \
 python3-gnupg \
 python3-unbound \
 "
