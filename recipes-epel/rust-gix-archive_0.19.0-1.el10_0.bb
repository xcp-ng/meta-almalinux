# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-archive"
PV = "0.19.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-archive+default-devel \
 rust-gix-archive+document-features-devel \
 rust-gix-archive+tar-devel \
 rust-gix-archive+tar_gz-devel \
 rust-gix-archive+zip-devel \
 rust-gix-archive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-archive-0.19.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f893e7dac73d9aeb0f264eb375488f4e31f68e8a282c02629297edb8ca412a2"

URI_x86_64_v2_rust-gix-archive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+default-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+default-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+default-devel.sha256sum] = "a1dfc9ab4ac6da31f14498542d8cfc0e9b1e120051d1c0d2685f2f7eea804e5b"

URI_x86_64_v2_rust-gix-archive+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+document-features-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+document-features-devel.sha256sum] = "c535d64ddfb06b834ddd674379e30542cef950a7ef746bbb66bc176ca4de166c"

URI_x86_64_v2_rust-gix-archive+tar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+tar-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+tar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+tar-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+tar-devel.sha256sum] = "5dab4d2a64b5647f176b224cc2bc0848af6b3b6f0dfd5254b6dceb8cf275dbc0"

URI_x86_64_v2_rust-gix-archive+tar_gz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+tar_gz-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+tar_gz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+tar_gz-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+tar_gz-devel.sha256sum] = "bd0c39a9d7718c352bde857b36646842865ecf0e6358dd0589da4d7528f0acc9"

URI_x86_64_v2_rust-gix-archive+zip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+zip-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+zip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+zip-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+zip-devel.sha256sum] = "3d710fee265f103b650e785a6fe3a6ac3f7c0188e91a7c6492fa1dfc837fb67a"

URI_x86_64_v2_rust-gix-archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive-devel}"
SRC_URI[x86_64_v2_rust-gix-archive-devel.sha256sum] = "2bded3e6781f062f67aa8bd648020e4231f55f62d1f6bfc9e6e6ff02225e842a"

URI_aarch64_rust-gix-archive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+default-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-archive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+default-devel}"
SRC_URI[aarch64_rust-gix-archive+default-devel.sha256sum] = "bcbbef234cf1c5e1b1c6e17765fca2456ca8285d4c51ac2c52424b7abdfdea01"

URI_aarch64_rust-gix-archive+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+document-features-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-archive+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+document-features-devel}"
SRC_URI[aarch64_rust-gix-archive+document-features-devel.sha256sum] = "6278ffdaf4d23a583da478edff0b737b33ff065bcb5bb226794ca6919f42871d"

URI_aarch64_rust-gix-archive+tar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+tar-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-archive+tar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+tar-devel}"
SRC_URI[aarch64_rust-gix-archive+tar-devel.sha256sum] = "90ba8810b6cb51dba64e2fb579265c88628b2476458212cfeb833709879193a0"

URI_aarch64_rust-gix-archive+tar_gz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+tar_gz-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-archive+tar_gz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+tar_gz-devel}"
SRC_URI[aarch64_rust-gix-archive+tar_gz-devel.sha256sum] = "d45499379f51ab59abbf4716e3e18dfaa51f5d48b14bc8874f969faee76e758d"

URI_aarch64_rust-gix-archive+zip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+zip-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-archive+zip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+zip-devel}"
SRC_URI[aarch64_rust-gix-archive+zip-devel.sha256sum] = "0b5c72567f804c89b6295f3083dc7a895918972899e3b520fea942b23f8ff0f7"

URI_aarch64_rust-gix-archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive-devel}"
SRC_URI[aarch64_rust-gix-archive-devel.sha256sum] = "5dc334d7f474656bbe7428c073660b97133598f40bc229a5feecde0f127b1502"

RDEPENDS:rust-gix-archive+default-devel = " \
 cargo \
 rust-gix-archive+tar-devel \
 rust-gix-archive+tar_gz-devel \
 rust-gix-archive+zip-devel \
 rust-gix-archive-devel \
 "
RDEPENDS:rust-gix-archive+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-archive-devel \
 "
RDEPENDS:rust-gix-archive+tar-devel = " \
 cargo \
 rust-gix-archive-devel \
 rust-gix-path+default-devel \
 rust-tar+default-devel \
 "
RDEPENDS:rust-gix-archive+tar_gz-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-gix-archive+tar-devel \
 rust-gix-archive-devel \
 "
RDEPENDS:rust-gix-archive+zip-devel = " \
 cargo \
 rust-gix-archive-devel \
 rust-zip0.6+deflate-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-gix-archive-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-date+default-devel \
 rust-gix-object+default-devel \
 rust-gix-worktree-stream+default-devel \
 rust-jiff0.1+std-devel \
 rust-jiff0.1-devel \
 rust-thiserror+default-devel \
 "
