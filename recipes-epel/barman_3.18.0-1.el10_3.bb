# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "barman"
PV = "3.18.0"
PR = "1.el10_3"
PACKAGES = " \
 barman \
 barman-cli \
 python3-barman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/barman-3.18.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0528093c8ce28fa62a4b2b1c4cfc1db090abd15a32e0e26866d724ff7c398168"

URI_x86_64_v2_barman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/barman-3.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_barman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_barman}"
SRC_URI[x86_64_v2_barman.sha256sum] = "ecf765530ab56fd90a42568a1b4aa0783c785cc5b838e4fb8bf64c3f8e417816"

URI_x86_64_v2_barman-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/barman-cli-3.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_barman-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_barman-cli}"
SRC_URI[x86_64_v2_barman-cli.sha256sum] = "252cfad4a0301bdbd48ff2ff460810709d969cdf071f461c61191c32d05246f9"

URI_x86_64_v2_python3-barman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-barman-3.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-barman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-barman}"
SRC_URI[x86_64_v2_python3-barman.sha256sum] = "a815fcdb4c54bfcc7e2a43a6de3909dc343022e9c0a81c24dfea42f30305287f"

URI_aarch64_barman = "${EPEL_MIRROR}/aarch64/Packages/b/barman-3.18.0-1.el10_3.noarch.rpm;name=aarch64_barman;unpack=0"
SRC_URI:append = " ${URI_aarch64_barman}"
SRC_URI[aarch64_barman.sha256sum] = "3669e3e4855a042f1e9630e494de7e3d72659211fbb1ffb7152c045d1ac629f4"

URI_aarch64_barman-cli = "${EPEL_MIRROR}/aarch64/Packages/b/barman-cli-3.18.0-1.el10_3.noarch.rpm;name=aarch64_barman-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_barman-cli}"
SRC_URI[aarch64_barman-cli.sha256sum] = "38860c8be0ee302ee303bd3e0326a5ac7ebf632c14d89f913327997c5016532b"

URI_aarch64_python3-barman = "${EPEL_MIRROR}/aarch64/Packages/p/python3-barman-3.18.0-1.el10_3.noarch.rpm;name=aarch64_python3-barman;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-barman}"
SRC_URI[aarch64_python3-barman.sha256sum] = "5acf86a2824c8d4d7e96f837db6e74b23783eb2fd108416a33d40151677d6d30"

RDEPENDS:barman = " \
 bash \
 cronie \
 logrotate \
 python3 \
 python3-argcomplete \
 python3-barman \
 rsync \
 shadow-utils \
 "
RDEPENDS:barman-cli = " \
 python3 \
 python3-barman \
 "
RDEPENDS:python3-barman = " \
 python3 \
 python3-dateutil \
 python3-psycopg2 \
 python3-setuptools \
 "
