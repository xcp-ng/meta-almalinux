# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "log4cpp"
PV = "1.1.3"
PR = "20.el10_0"
PACKAGES = " \
 log4cpp \
 log4cpp-devel \
 log4cpp-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/log4cpp-1.1.3-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37e126d80e4818ffdb8b6ba489a27b41e4b44f3fc9400bdb35fa4c14f86e806e"

URI_x86_64_v2_log4cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cpp-1.1.3-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cpp}"
SRC_URI[x86_64_v2_log4cpp.sha256sum] = "e9d8cff1cacaecd4e4847f1c188f4557daa01d007de658c5736308113579d1e0"

URI_x86_64_v2_log4cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cpp-devel-1.1.3-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cpp-devel}"
SRC_URI[x86_64_v2_log4cpp-devel.sha256sum] = "444fa4afbf8fc00bac002c42b2cbd563d57560469b936703cae96ca91717d560"

URI_x86_64_v2_log4cpp-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cpp-doc-1.1.3-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cpp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cpp-doc}"
SRC_URI[x86_64_v2_log4cpp-doc.sha256sum] = "4eaf68b65eec4b21baa22cd2560d566da85e676b5a3fc7e0aaa21d908ab03e32"

URI_aarch64_log4cpp = "${EPEL_MIRROR}/aarch64/Packages/l/log4cpp-1.1.3-20.el10_0.aarch64.rpm;name=aarch64_log4cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cpp}"
SRC_URI[aarch64_log4cpp.sha256sum] = "7058158f54f88989dd3ace77660fd1e47a407df0b86547b080b0bc004dc8ed21"

URI_aarch64_log4cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/log4cpp-devel-1.1.3-20.el10_0.aarch64.rpm;name=aarch64_log4cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cpp-devel}"
SRC_URI[aarch64_log4cpp-devel.sha256sum] = "ed8639f7cdf266008bfee1b7fba18050bd16bae3164dd11548c2d13118bf1f2a"

URI_aarch64_log4cpp-doc = "${EPEL_MIRROR}/aarch64/Packages/l/log4cpp-doc-1.1.3-20.el10_0.aarch64.rpm;name=aarch64_log4cpp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cpp-doc}"
SRC_URI[aarch64_log4cpp-doc.sha256sum] = "cf7d21ec8023eafd701f8e0c6c0ae9ab4a49aee334f0acb1dcecc34b2b980568"

RDEPENDS:log4cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:log4cpp-devel = " \
 bash \
 log4cpp \
 pkgconf-pkg-config \
 "
RDEPENDS:log4cpp-doc = " \
 log4cpp \
 "
