# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpq"
PV = "16.14"
PR = "1.el10_2"
PACKAGES = " \
 libpq \
 libpq-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libpq-16.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2c0d75f28af817dd2215c82d9370efeb4344d33f7de6ffe9e45e89e3e708449"

URI_x86_64_v2_libpq = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpq-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libpq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpq}"
SRC_URI[x86_64_v2_libpq.sha256sum] = "8031adecf5080665323ae2234741f1d2f0a50ec8e77b0b76c84a30d06de601e5"

URI_x86_64_v2_libpq-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpq-devel-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libpq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpq-devel}"
SRC_URI[x86_64_v2_libpq-devel.sha256sum] = "901c69911b0dfb4873f632e2d5f09b42782d867c3836e749e5d676c631b3d232"

URI_aarch64_libpq = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpq-16.14-1.el10_2.aarch64.rpm;name=aarch64_libpq;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpq}"
SRC_URI[aarch64_libpq.sha256sum] = "f7eecf7f0af3be86aeae6e1f8c02d6d6138f9a2f18a356c562b34d270f84363d"

URI_aarch64_libpq-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpq-devel-16.14-1.el10_2.aarch64.rpm;name=aarch64_libpq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpq-devel}"
SRC_URI[aarch64_libpq-devel.sha256sum] = "ecad497e38c0b1f880e7a9bd3f3b2f4c8a32e5010b1aeea51b6e61eb6d7f19a8"

RDEPENDS:libpq = " \
 glibc \
 krb5-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:libpq-devel = " \
 glibc \
 libpq \
 openssl-devel \
 pkgconf-pkg-config \
 "
