# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sec"
PV = "2.9.4"
PR = "1.el10_2"
PACKAGES = " \
 sec \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sec-2.9.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee028d9e79726aa95e8664acc222cd769fdc4fb5ac3ea5d99c3c4a1990677642"

URI_x86_64_v2_sec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sec-2.9.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_sec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sec}"
SRC_URI[x86_64_v2_sec.sha256sum] = "4be93326adbad71891d774ca79fd5b0a578e3760a5349908d9ca5290bdb3b3ba"

URI_aarch64_sec = "${EPEL_MIRROR}/aarch64/Packages/s/sec-2.9.4-1.el10_2.noarch.rpm;name=aarch64_sec;unpack=0"
SRC_URI:append = " ${URI_aarch64_sec}"
SRC_URI[aarch64_sec.sha256sum] = "3940000440500d30c9edde1d946bdca13f2c22cf9825e8b6412d9238e24b5ab8"

RDEPENDS:sec = " \
 bash \
 logrotate \
 perl-Fcntl \
 perl-Getopt-Long \
 perl-IO \
 perl-POSIX \
 perl-Socket \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 systemd \
 "
