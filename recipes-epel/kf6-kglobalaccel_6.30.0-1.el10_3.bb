# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kglobalaccel"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kglobalaccel \
 kf6-kglobalaccel-devel \
 kf6-kglobalaccel-doc \
 kf6-kglobalaccel-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kglobalaccel-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a4399ea64e9a45fb1134122f82ca326fddeacd6520f7ee55a4c892220aca69da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kglobalaccel;unpack=0"
SRC_URI[x86_64_v2_kf6-kglobalaccel.sha256sum] = "06d38b2e756311304f1b796d4e06be22b6f66aff9e251f2c5e4a2c398b1cfd98"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kglobalaccel-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kglobalaccel-devel.sha256sum] = "1292b386a1cbbbb0d1dd04fd043530cac647c9a16eee5404d1983d789eaddc86"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kglobalaccel-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kglobalaccel-doc.sha256sum] = "5727703a32fa3f4909d56fe84d518b480c25fe6d93b120e4d9965ac85c6366ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kglobalaccel-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kglobalaccel-html.sha256sum] = "0298fe1543049592648da34def8180efa53799aab4e1280a02dd347f36fc4f3d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kglobalaccel;unpack=0"
SRC_URI[aarch64_kf6-kglobalaccel.sha256sum] = "cb7036d3fbb1d9aa0c2fa3885702b5e6069d4f595dc7868e4793fc40dedd7086"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kglobalaccel-devel;unpack=0"
SRC_URI[aarch64_kf6-kglobalaccel-devel.sha256sum] = "74051d045fd40e5f5fc54895f9832ba260f04d62cebfad05b553c62324923533"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kglobalaccel-doc;unpack=0"
SRC_URI[aarch64_kf6-kglobalaccel-doc.sha256sum] = "4a84cf9afca35a70c1035d6e4407665dc6bf0f7eed22d64da3b583edc5e0900d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kglobalaccel-html;unpack=0"
SRC_URI[aarch64_kf6-kglobalaccel-html.sha256sum] = "927a6e3d23da148d5f89e9c182db8debc0642ff6baf01993cadbf3c6a8fda958"

RDEPENDS:kf6-kglobalaccel = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kglobalaccel-devel = " \
 cmake-filesystem \
 kf6-kglobalaccel \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kglobalaccel-doc = " \
 "
RDEPENDS:kf6-kglobalaccel-html = " \
 "
