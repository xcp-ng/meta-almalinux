# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex-lite"
PV = "0.1.8"
PR = "1.el10_0"
PACKAGES = " \
 rust-regex-lite+default-devel \
 rust-regex-lite+std-devel \
 rust-regex-lite+string-devel \
 rust-regex-lite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-lite-0.1.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9dacb1536bf51d7ad02e6b4b3dbce7476127a41f8b7c624ac80283d710215c27"

URI_x86_64_v2_rust-regex-lite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-lite+default-devel-0.1.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-lite+default-devel}"
SRC_URI[x86_64_v2_rust-regex-lite+default-devel.sha256sum] = "74c526e45289a45c8cb52dd3b2bedfa8bbd91297cfed5752ee7550c13e1848e7"

URI_x86_64_v2_rust-regex-lite+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-lite+std-devel-0.1.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-lite+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-lite+std-devel}"
SRC_URI[x86_64_v2_rust-regex-lite+std-devel.sha256sum] = "86749baad2102006450ec8c3c48d1019b531e00fa43fe147d71894a36865d575"

URI_x86_64_v2_rust-regex-lite+string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-lite+string-devel-0.1.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-lite+string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-lite+string-devel}"
SRC_URI[x86_64_v2_rust-regex-lite+string-devel.sha256sum] = "87933913998e9e8fc6ffcf9e5110e5eef4bbe6ab906e9b258dd7c6ec9aaa0145"

URI_x86_64_v2_rust-regex-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-lite-devel-0.1.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-lite-devel}"
SRC_URI[x86_64_v2_rust-regex-lite-devel.sha256sum] = "5a04351763cf6c53172069378600b4e89f6db0e96952a0954b2d0d2ef4102d0c"

URI_aarch64_rust-regex-lite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-lite+default-devel-0.1.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-lite+default-devel}"
SRC_URI[aarch64_rust-regex-lite+default-devel.sha256sum] = "36b1febd903607592a18ced7e005ba5fce7a6b5eb1f7320d59b0a43da9487335"

URI_aarch64_rust-regex-lite+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-lite+std-devel-0.1.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-lite+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-lite+std-devel}"
SRC_URI[aarch64_rust-regex-lite+std-devel.sha256sum] = "57df4c59eb59df480161dc674c72a18cd11abeaf0ef98644bd6187a5ff9a3187"

URI_aarch64_rust-regex-lite+string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-lite+string-devel-0.1.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-lite+string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-lite+string-devel}"
SRC_URI[aarch64_rust-regex-lite+string-devel.sha256sum] = "86b8db5d6b8fa1719b3cdb44d244ea7ff2046cd328d4fc81250f995d15142bfa"

URI_aarch64_rust-regex-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-lite-devel-0.1.8-1.el10_0.noarch.rpm;name=aarch64_rust-regex-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-lite-devel}"
SRC_URI[aarch64_rust-regex-lite-devel.sha256sum] = "b93f8de09bb16c6bd2835b5a316103350191b120ba6f14d4fad5b74745b40553"

RDEPENDS:rust-regex-lite+default-devel = " \
 cargo \
 rust-regex-lite+std-devel \
 rust-regex-lite+string-devel \
 rust-regex-lite-devel \
 "
RDEPENDS:rust-regex-lite+std-devel = " \
 cargo \
 rust-regex-lite-devel \
 "
RDEPENDS:rust-regex-lite+string-devel = " \
 cargo \
 rust-regex-lite-devel \
 "
RDEPENDS:rust-regex-lite-devel = " \
 cargo \
 rust \
 "
