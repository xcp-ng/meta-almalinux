# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "steam-devices"
PV = "1.0.0.101^git20260625.22ec85e"
PR = "1.el10_2"
PACKAGES = " \
 steam-devices \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/steam-devices-1.0.0.101^git20260625.22ec85e-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6eb818ddfd4f9af04e51b568e5486721fcc6f7d9788cbbad423a18161a44592c"

URI_x86_64_v2_steam-devices = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/steam-devices-1.0.0.101^git20260625.22ec85e-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_steam-devices;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_steam-devices}"
SRC_URI[x86_64_v2_steam-devices.sha256sum] = "0bb5ce3b0a3da9f8b8931841b64d1ca7711bfd3afea16d1d5e730ecf934fc89e"

URI_aarch64_steam-devices = "${EPEL_MIRROR}/aarch64/Packages/s/steam-devices-1.0.0.101^git20260625.22ec85e-1.el10_2.noarch.rpm;name=aarch64_steam-devices;unpack=0"
SRC_URI:append = " ${URI_aarch64_steam-devices}"
SRC_URI[aarch64_steam-devices.sha256sum] = "4b82fe08adb3be941a6b8d90b9a9e8187d13bfbcb0ad02b3e620d1c2fdbabe4e"

RDEPENDS:steam-devices = " \
 "
