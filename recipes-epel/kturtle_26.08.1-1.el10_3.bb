# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kturtle"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kturtle \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kturtle-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cfa1a0b5b15f01588eec995258d54acd1f37db9648948caf31847c30592bff83"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kturtle-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kturtle;unpack=0"
SRC_URI[x86_64_v2_kturtle.sha256sum] = "ec49cb1213c5a68347530d0334c2c0d6637f08d0930074b0b67eb0371a597590"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kturtle-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kturtle;unpack=0"
SRC_URI[aarch64_kturtle.sha256sum] = "c2c25679ef3107a39300423bd75d552444a3ea13f70d8549f196906ca2af0e93"

RDEPENDS:kturtle = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-knewstuff \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
