# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "helm3"
PV = "3.19.3"
PR = "1.el10_1"
PACKAGES = " \
 helm3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/helm3-3.19.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edbdf6a133ed2294c7ecb1f606d4b793069074cadfb38bbf49192c18c90be178"

URI_x86_64_v2_helm3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/helm3-3.19.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_helm3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_helm3}"
SRC_URI[x86_64_v2_helm3.sha256sum] = "465725c85293239ea94f07ffc8b3392881ab45e88ce24b657965eb93daedb349"

URI_aarch64_helm3 = "${EPEL_MIRROR}/aarch64/Packages/h/helm3-3.19.3-1.el10_1.aarch64.rpm;name=aarch64_helm3;unpack=0"
SRC_URI:append = " ${URI_aarch64_helm3}"
SRC_URI[aarch64_helm3.sha256sum] = "6510a55ad7a9cc0ccdea083b4e26967d8606c7697c4f53e74b2528f657e98809"

RDEPENDS:helm3 = " \
 glibc \
 "
