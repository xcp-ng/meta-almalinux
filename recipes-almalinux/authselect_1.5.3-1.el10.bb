# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "authselect"
PV = "1.5.3"
PR = "1.el10"
PACKAGES = " \
 authselect \
 authselect-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/authselect-1.5.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "74a2a4a7e303b3eab8991d0aded4c65d21b638f015a4d059de82d884bf23deaa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/authselect-1.5.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_authselect;unpack=0"
SRC_URI[x86_64_v2_authselect.sha256sum] = "cecd776d5648d1188b4ca088e5ec0fccb172cf885eb35443a78b18b91596e3b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/authselect-libs-1.5.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_authselect-libs;unpack=0"
SRC_URI[x86_64_v2_authselect-libs.sha256sum] = "fae42724644df9c2680e0cc7692f0dba3645bc0da463a25ada5227aa525c48bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/authselect-1.5.3-1.el10.aarch64.rpm;name=aarch64_authselect;unpack=0"
SRC_URI[aarch64_authselect.sha256sum] = "f028b62d70cc0abaec72e14528e4fec73e867468242e3f0bd547aa48f9cae7b6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/authselect-libs-1.5.3-1.el10.aarch64.rpm;name=aarch64_authselect-libs;unpack=0"
SRC_URI[aarch64_authselect-libs.sha256sum] = "1587e1df84a3473a82d966a3af073ffa6369df051a94ed6a3d9df718d05e3bdc"

RDEPENDS:authselect = " \
 authselect-libs \
 bash \
 glibc \
 popt \
 "
RDEPENDS:authselect-libs = " \
 bash \
 glibc \
 libselinux \
 sed \
 virtual/coreutils \
 "
