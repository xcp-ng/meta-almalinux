# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-starlette"
PV = "0.47.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-starlette \
 python3-starlette+full \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-starlette-0.47.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48123fad927bcca4c996e1d9142ccda1e883851ddc25c0cbe92c36620a1ad952"

URI_x86_64_v2_python3-starlette = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-starlette-0.47.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-starlette;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-starlette}"
SRC_URI[x86_64_v2_python3-starlette.sha256sum] = "9e00a9aa40063c94a1773ca5cecb9b7f56e60b38cea3390c1a606227c4a9c241"

URI_x86_64_v2_python3-starlette+full = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-starlette+full-0.47.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-starlette+full;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-starlette+full}"
SRC_URI[x86_64_v2_python3-starlette+full.sha256sum] = "5078822676dc4e5a4f21994c80c5d3fdbd226da22b86e2a363be7fbce36aeb2c"

URI_aarch64_python3-starlette = "${EPEL_MIRROR}/aarch64/Packages/p/python3-starlette-0.47.0-2.el10_1.noarch.rpm;name=aarch64_python3-starlette;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-starlette}"
SRC_URI[aarch64_python3-starlette.sha256sum] = "609eae5295b55eeda9f38058613f020cc6a164450158ea8a4b6fa0b1c594b783"

URI_aarch64_python3-starlette+full = "${EPEL_MIRROR}/aarch64/Packages/p/python3-starlette+full-0.47.0-2.el10_1.noarch.rpm;name=aarch64_python3-starlette+full;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-starlette+full}"
SRC_URI[aarch64_python3-starlette+full.sha256sum] = "91ccf2fda28ee546c87b2a0105444c29a9f7d3d2c2ab05b4d9b0299ad1343238"

RDEPENDS:python3-starlette = " \
 python3 \
 python3-anyio \
 "
RDEPENDS:python3-starlette+full = " \
 python3 \
 python3-httpx \
 python3-itsdangerous \
 python3-jinja2 \
 python3-python-multipart \
 python3-pyyaml \
 python3-starlette \
 "
