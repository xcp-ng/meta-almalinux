# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tinyxml"
PV = "2.6.2"
PR = "30.el10_0"
PACKAGES = " \
 tinyxml \
 tinyxml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tinyxml-2.6.2-30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe7bc56b6f8931c8daa316f2318585e6f01cd64796e751b8cafb78271bef655c"

URI_x86_64_v2_tinyxml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tinyxml-2.6.2-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tinyxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tinyxml}"
SRC_URI[x86_64_v2_tinyxml.sha256sum] = "fffafe3340ea54a0032f9e5029a159108dee43c2977999416c993ac2fbea3f0e"

URI_x86_64_v2_tinyxml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tinyxml-devel-2.6.2-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tinyxml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tinyxml-devel}"
SRC_URI[x86_64_v2_tinyxml-devel.sha256sum] = "d7f737a859a320b937887dd8d4ac3d3b23486a38253ed42ef2ebc37649c6b888"

URI_aarch64_tinyxml = "${EPEL_MIRROR}/aarch64/Packages/t/tinyxml-2.6.2-30.el10_0.aarch64.rpm;name=aarch64_tinyxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_tinyxml}"
SRC_URI[aarch64_tinyxml.sha256sum] = "31b3d5827475a536221d021cadb005728daf7ae846be7d1ff44ae6f1c740ac46"

URI_aarch64_tinyxml-devel = "${EPEL_MIRROR}/aarch64/Packages/t/tinyxml-devel-2.6.2-30.el10_0.aarch64.rpm;name=aarch64_tinyxml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tinyxml-devel}"
SRC_URI[aarch64_tinyxml-devel.sha256sum] = "b7f3cec4c5f98d3710d67a69e9b670c806e7b8438037f4d3d088de4c6ee25681"

RDEPENDS:tinyxml = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:tinyxml-devel = " \
 pkgconf-pkg-config \
 tinyxml \
 "
