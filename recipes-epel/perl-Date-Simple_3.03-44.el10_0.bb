# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Date-Simple"
PV = "3.03"
PR = "44.el10_0"
PACKAGES = " \
 perl-Date-Simple \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Date-Simple-3.03-44.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acb242b6519d3a98c12a7a01ae099b0f1f3d385c7c6b35bab9f6d88346949c21"

URI_x86_64_v2_perl-Date-Simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Date-Simple-3.03-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Date-Simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Date-Simple}"
SRC_URI[x86_64_v2_perl-Date-Simple.sha256sum] = "da1694f38419b843cf8f6d0e6ca02680f74026cd49f3bbd1d13e742d10c0c8c7"

URI_aarch64_perl-Date-Simple = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Date-Simple-3.03-44.el10_0.aarch64.rpm;name=aarch64_perl-Date-Simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Date-Simple}"
SRC_URI[aarch64_perl-Date-Simple.sha256sum] = "476cd27eeb0320ad47c89baa037f764bdecf6e2ecdbb88e9738f76a609072939"

RDEPENDS:perl-Date-Simple = " \
 glibc \
 perl-Carp \
 perl-Date-Simple \
 perl-DynaLoader \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-base \
 perl-libs \
 perl-overload \
 "
