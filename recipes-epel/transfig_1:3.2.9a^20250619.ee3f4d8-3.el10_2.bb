# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "transfig"
PE = "1"
PV = "3.2.9a^20250619.ee3f4d8"
PR = "3.el10_2"
PACKAGES = " \
 transfig \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/transfig-3.2.9a^20250619.ee3f4d8-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0721ba7b0ae7e8510d81ecb067f24c5aa0a11b82faf3ef30c04cf02e29aae66a"

URI_x86_64_v2_transfig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/transfig-3.2.9a^20250619.ee3f4d8-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_transfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_transfig}"
SRC_URI[x86_64_v2_transfig.sha256sum] = "361c11ee09647138c1de061c8d24b9f8e5e9f73f71e4e1ff0f9a7610aede5881"

URI_aarch64_transfig = "${EPEL_MIRROR}/aarch64/Packages/t/transfig-3.2.9a^20250619.ee3f4d8-3.el10_2.aarch64.rpm;name=aarch64_transfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_transfig}"
SRC_URI[aarch64_transfig.sha256sum] = "ebf58e4c1f76c6f0e89c5d4689a01a2004b32361c0e138275c3d441f793c0310"

RDEPENDS:transfig = " \
 bash \
 bc \
 ghostscript \
 glibc \
 libpng \
 netpbm-progs \
 zlib-ng-compat \
 "
