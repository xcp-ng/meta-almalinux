# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "memcached"
PV = "1.6.23"
PR = "8.el10"
PACKAGES = " \
 memcached \
 memcached-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/memcached-1.6.23-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e530142bda0a4d7354de911b4df1b6898d10e6c3bbe7e1a0de7babe5a3c6ecde"

URI_x86_64_v2_memcached = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/memcached-1.6.23-8.el10.x86_64_v2.rpm;name=x86_64_v2_memcached;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_memcached}"
SRC_URI[x86_64_v2_memcached.sha256sum] = "93353a5344429f9ccd1c59d8e9eb501f85f00ee9ced3980964b6e14abf81d26a"

URI_x86_64_v2_memcached-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/memcached-selinux-1.6.23-8.el10.x86_64_v2.rpm;name=x86_64_v2_memcached-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_memcached-selinux}"
SRC_URI[x86_64_v2_memcached-selinux.sha256sum] = "11c2b0d15eeb6bfb3492e9e54e66655798ddc5b51262c2b52d874d36fe47bc88"

URI_aarch64_memcached = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/memcached-1.6.23-8.el10.aarch64.rpm;name=aarch64_memcached;unpack=0"
SRC_URI:append = " ${URI_aarch64_memcached}"
SRC_URI[aarch64_memcached.sha256sum] = "88559721ba7887b28f874666e4bca29ed9a63ed660777704bac9bc0a597cdeef"

URI_aarch64_memcached-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/memcached-selinux-1.6.23-8.el10.aarch64.rpm;name=aarch64_memcached-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_memcached-selinux}"
SRC_URI[aarch64_memcached-selinux.sha256sum] = "1b40a7bd1255d598022317c1a3f11c3fe9c263219eb89985c6538f6c2d14319b"

RDEPENDS:memcached = " \
 bash \
 cyrus-sasl-lib \
 glibc \
 libevent \
 memcached-selinux \
 openssl-libs \
 perl-IO \
 perl-interpreter \
 perl-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:memcached-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
