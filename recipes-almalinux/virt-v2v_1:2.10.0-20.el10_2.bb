# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virt-v2v"
PE = "1"
PV = "2.10.0"
PR = "20.el10_2"
PACKAGES:x86_64_v2 = " \
 virt-v2v \
 virt-v2v-bash-completion \
 virt-v2v-man-pages-ja \
 virt-v2v-man-pages-uk \
"
PACKAGES:aarch64 = " \
 virt-v2v-bash-completion \
 virt-v2v-man-pages-ja \
 virt-v2v-man-pages-uk \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/virt-v2v-2.10.0-20.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0255ccc353fcf775075b5b9d774e57d3dd4081f62d7b4484d8401aecb02357d"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - virt-v2v-bash-completion: virt-v2v = 1:2.10.0-20.el10_2
# - virt-v2v-man-pages-ja: virt-v2v = 1:2.10.0-20.el10_2
# - virt-v2v-man-pages-uk: virt-v2v = 1:2.10.0-20.el10_2

URI_x86_64_v2_virt-v2v = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-v2v-2.10.0-20.el10_2.x86_64_v2.rpm;name=x86_64_v2_virt-v2v;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-v2v}"
SRC_URI[x86_64_v2_virt-v2v.sha256sum] = "e6598af07101fc23ac5e1f0c94277b04073ac49112e7c43727abb8e9490c2303"

URI_x86_64_v2_virt-v2v-bash-completion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-v2v-bash-completion-2.10.0-20.el10_2.noarch.rpm;name=x86_64_v2_virt-v2v-bash-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-v2v-bash-completion}"
SRC_URI[x86_64_v2_virt-v2v-bash-completion.sha256sum] = "f631f1aa9a411f104ae4a77c50e712a91dd394cff875e343992b70631efcea48"

URI_x86_64_v2_virt-v2v-man-pages-ja = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/virt-v2v-man-pages-ja-2.10.0-20.el10_2.noarch.rpm;name=x86_64_v2_virt-v2v-man-pages-ja;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-v2v-man-pages-ja}"
SRC_URI[x86_64_v2_virt-v2v-man-pages-ja.sha256sum] = "f9aa3b4c6bf11a8eed57d9409eb828b0ee8ae6c6b5556e3bbd4b804a9e4c1f46"

URI_x86_64_v2_virt-v2v-man-pages-uk = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/virt-v2v-man-pages-uk-2.10.0-20.el10_2.noarch.rpm;name=x86_64_v2_virt-v2v-man-pages-uk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-v2v-man-pages-uk}"
SRC_URI[x86_64_v2_virt-v2v-man-pages-uk.sha256sum] = "0f420e9c432f6f69fb4707e24bc9ddc481f999836439e2d596605740fabf5e59"

URI_aarch64_virt-v2v-bash-completion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-v2v-bash-completion-2.10.0-20.el10_2.noarch.rpm;name=aarch64_virt-v2v-bash-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-v2v-bash-completion}"
SRC_URI[aarch64_virt-v2v-bash-completion.sha256sum] = "f631f1aa9a411f104ae4a77c50e712a91dd394cff875e343992b70631efcea48"

URI_aarch64_virt-v2v-man-pages-ja = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/virt-v2v-man-pages-ja-2.10.0-20.el10_2.noarch.rpm;name=aarch64_virt-v2v-man-pages-ja;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-v2v-man-pages-ja}"
SRC_URI[aarch64_virt-v2v-man-pages-ja.sha256sum] = "f9aa3b4c6bf11a8eed57d9409eb828b0ee8ae6c6b5556e3bbd4b804a9e4c1f46"

URI_aarch64_virt-v2v-man-pages-uk = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/virt-v2v-man-pages-uk-2.10.0-20.el10_2.noarch.rpm;name=aarch64_virt-v2v-man-pages-uk;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-v2v-man-pages-uk}"
SRC_URI[aarch64_virt-v2v-man-pages-uk.sha256sum] = "0f420e9c432f6f69fb4707e24bc9ddc481f999836439e2d596605740fabf5e59"

RDEPENDS:virt-v2v = " \
 curl \
 edk2-ovmf \
 gawk \
 glib2 \
 glibc \
 guestfs-tools \
 gzip \
 json-c \
 libgcc \
 libguestfs \
 libguestfs-winsupport \
 libguestfs-xfs \
 libnbd \
 libosinfo \
 libvirt-client \
 libvirt-libs \
 libxcrypt \
 libxml2 \
 mingw-srvany-redistributable \
 nbdkit-basic-filters \
 nbdkit-basic-plugins \
 nbdkit-curl-plugin \
 nbdkit-nbd-plugin \
 nbdkit-python-plugin \
 nbdkit-server \
 nbdkit-ssh-plugin \
 nbdkit-vddk-plugin \
 openssh-clients \
 openssl \
 pcre2 \
 python3 \
 qemu-img \
 unzip \
 "
RDEPENDS:virt-v2v-bash-completion:x86_64_v2 = " \
 bash-completion \
 virt-v2v \
"
RDEPENDS:virt-v2v-bash-completion:aarch64 = " \
 bash-completion \
"
RDEPENDS:virt-v2v-man-pages-ja:x86_64_v2 = " \
 virt-v2v \
"
RDEPENDS:virt-v2v-man-pages-ja:aarch64 = " \
  \
"
RDEPENDS:virt-v2v-man-pages-uk:x86_64_v2 = " \
 virt-v2v \
"
RDEPENDS:virt-v2v-man-pages-uk:aarch64 = " \
  \
"
