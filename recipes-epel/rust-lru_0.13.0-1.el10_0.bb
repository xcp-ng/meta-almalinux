# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lru"
PV = "0.13.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-lru+default-devel \
 rust-lru+hashbrown-devel \
 rust-lru-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lru-0.13.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e302ce75556c249f6351fe1bbe30c8d2aa753a2364911f0ea5d95c050efc4ea6"

URI_x86_64_v2_rust-lru+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru+default-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru+default-devel}"
SRC_URI[x86_64_v2_rust-lru+default-devel.sha256sum] = "6474442c4f8dc8e8794b9248f0abb95547c2d63e21947fb66142d4c3d054b5d5"

URI_x86_64_v2_rust-lru+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru+hashbrown-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-lru+hashbrown-devel.sha256sum] = "1e172b2287c0c7c277f8014683a0e59faa72e3eeddb479efb34957aac0fa05e0"

URI_x86_64_v2_rust-lru-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru-devel}"
SRC_URI[x86_64_v2_rust-lru-devel.sha256sum] = "1feccd2b265a5706b2aac9f79cf62f697154760a6e28ababdab625bb45dae49b"

URI_aarch64_rust-lru+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru+default-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-lru+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru+default-devel}"
SRC_URI[aarch64_rust-lru+default-devel.sha256sum] = "82c97dc3add504c97f76defaed8c1a0cc781b5659535ae8742fc08892623d88c"

URI_aarch64_rust-lru+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru+hashbrown-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-lru+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru+hashbrown-devel}"
SRC_URI[aarch64_rust-lru+hashbrown-devel.sha256sum] = "744beb244ba8459b791466c44e08bb7012bd312f27f31558e372d4398b9a96e6"

URI_aarch64_rust-lru-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-lru-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru-devel}"
SRC_URI[aarch64_rust-lru-devel.sha256sum] = "1a4524f2a118fea8d756d4b44332c9c2c371b9e4a454c2bd746eb033a02d5190"

RDEPENDS:rust-lru+default-devel = " \
 cargo \
 rust-lru+hashbrown-devel \
 rust-lru-devel \
 "
RDEPENDS:rust-lru+hashbrown-devel = " \
 cargo \
 rust-hashbrown+default-devel \
 rust-lru-devel \
 "
RDEPENDS:rust-lru-devel = " \
 cargo \
 "
