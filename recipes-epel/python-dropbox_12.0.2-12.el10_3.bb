# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dropbox"
PV = "12.0.2"
PR = "12.el10_3"
PACKAGES = " \
 python3-dropbox \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-dropbox-12.0.2-12.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c05d300acbb2efb22f7a049e965f29d9d96641f710cdd245d3d0b7a44aeb7cd"

URI_x86_64_v2_python3-dropbox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dropbox-12.0.2-12.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dropbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dropbox}"
SRC_URI[x86_64_v2_python3-dropbox.sha256sum] = "64fb2742b5b6e72fc024a49035a03bb7af1597ee35a33d0052eff709d5504eeb"

URI_aarch64_python3-dropbox = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dropbox-12.0.2-12.el10_3.noarch.rpm;name=aarch64_python3-dropbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dropbox}"
SRC_URI[aarch64_python3-dropbox.sha256sum] = "061372558633d1c007f62d7c099a92911419c43c1bb82b886056f1b97e30bb10"

RDEPENDS:python3-dropbox = " \
 python3 \
 python3-requests \
 python3-six \
 python3-stone \
 python3-urllib3 \
 "
