# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpm-ostree"
PV = "2025.11"
PR = "2.el10_1"
PACKAGES = " \
 rpm-ostree \
 rpm-ostree-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rpm-ostree-2025.11-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86ac39f09053c56385fd35a19fb8bb81e57d4a66bcb21be160c139113f819460"

URI_x86_64_v2_rpm-ostree = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-ostree-2025.11-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_rpm-ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-ostree}"
SRC_URI[x86_64_v2_rpm-ostree.sha256sum] = "12a21e19d57fa035fea50a4187fb9796402ce84f3e69c544174f3e5290729887"

URI_x86_64_v2_rpm-ostree-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-ostree-libs-2025.11-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_rpm-ostree-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-ostree-libs}"
SRC_URI[x86_64_v2_rpm-ostree-libs.sha256sum] = "d7272b2529315feee02d19deb4711fc8fa6a8376b351342f221173e1ac9f4f0a"

URI_aarch64_rpm-ostree = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-ostree-2025.11-2.el10_1.aarch64.rpm;name=aarch64_rpm-ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-ostree}"
SRC_URI[aarch64_rpm-ostree.sha256sum] = "614dbf87bc75d441e931170bdcb6b88afeea3382c5155bd3387cae693a3c6d31"

URI_aarch64_rpm-ostree-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-ostree-libs-2025.11-2.el10_1.aarch64.rpm;name=aarch64_rpm-ostree-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-ostree-libs}"
SRC_URI[aarch64_rpm-ostree-libs.sha256sum] = "6343ef30c905ae132caed44798ea74953f08bcc0860848b90d557eb9dc4bd19b"

RDEPENDS:rpm-ostree = " \
 bash \
 bootc \
 bubblewrap \
 fuse3 \
 glib2 \
 glibc \
 json-c \
 json-glib \
 libarchive \
 libcap \
 libgcc \
 libmodulemd \
 librepo \
 libsolv \
 libstdc++ \
 libzstd \
 openssl-libs \
 ostree \
 ostree-libs \
 polkit-libs \
 rpm-libs \
 rpm-ostree-libs \
 skopeo \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:rpm-ostree-libs = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 ostree-libs \
 popt \
 rpm-libs \
 "
