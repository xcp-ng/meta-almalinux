# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "eccodes"
PV = "2.44.0"
PR = "1.el10_2"
PACKAGES = " \
 eccodes \
 eccodes-data \
 eccodes-devel \
 eccodes-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/eccodes-2.44.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "52dac7b408db20b38933548b9f2e4c83982f2b8563abc67ddb8a58deac253b91"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eccodes-2.44.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eccodes;unpack=0"
SRC_URI[x86_64_v2_eccodes.sha256sum] = "7ca227111ea4ba7516ffc15148546c1df36783f2ce0b97c2e4db12ca7c1be52c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eccodes-data-2.44.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_eccodes-data;unpack=0"
SRC_URI[x86_64_v2_eccodes-data.sha256sum] = "5476125ca5f4a04e333333316a58cf14344b8a875db90e7d65be10cff1d1e871"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eccodes-devel-2.44.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eccodes-devel;unpack=0"
SRC_URI[x86_64_v2_eccodes-devel.sha256sum] = "c766d72769316ae06e2db79a53ea121dee590eb355cce97dc2324259a97bf64a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eccodes-doc-2.44.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_eccodes-doc;unpack=0"
SRC_URI[x86_64_v2_eccodes-doc.sha256sum] = "f576b5d62307f0e02b462cb5962bad6a4600a907d6bfb262359530cd1c2c0ee3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/eccodes-2.44.0-1.el10_2.aarch64.rpm;name=aarch64_eccodes;unpack=0"
SRC_URI[aarch64_eccodes.sha256sum] = "1bd3101a1ebd01fd109b6a41239eef54627a7a1dc31d6fd065f7204bd8d9fd11"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/eccodes-data-2.44.0-1.el10_2.noarch.rpm;name=aarch64_eccodes-data;unpack=0"
SRC_URI[aarch64_eccodes-data.sha256sum] = "55980f3d7d88497d9ffc38befba01ac2081d06716c72b0d40c2717f7db3d4fcd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/eccodes-devel-2.44.0-1.el10_2.aarch64.rpm;name=aarch64_eccodes-devel;unpack=0"
SRC_URI[aarch64_eccodes-devel.sha256sum] = "93e9e074ca01297dc2b72a10ad63afcfd00d1a9314490a950bc6ba0fd84891d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/eccodes-doc-2.44.0-1.el10_2.noarch.rpm;name=aarch64_eccodes-doc;unpack=0"
SRC_URI[aarch64_eccodes-doc.sha256sum] = "00c78ddca6a5aae9706ceb3f7400ed4ea5e793386023151e4432100bea75b926"

RDEPENDS:eccodes = " \
 bash \
 eccodes-data \
 glibc \
 jasper-libs \
 libaec \
 libgcc \
 libgfortran \
 libgomp \
 libpng \
 libstdc++ \
 netcdf \
 openjpeg2 \
 "
RDEPENDS:eccodes-data = " \
 "
RDEPENDS:eccodes-devel = " \
 cmake-filesystem \
 eccodes \
 gcc-gfortran \
 jasper-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:eccodes-doc = " \
 "
