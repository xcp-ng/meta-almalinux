# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyproject-metadata"
PV = "0.8.0"
PR = "3.el10_0"
PACKAGES = " \
 python3-pyproject-metadata \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyproject-metadata-0.8.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a30713704136802010db6fabbb0c6b3d6f353e6a574b01809d298c2765939d8"

URI_x86_64_v2_python3-pyproject-metadata = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyproject-metadata-0.8.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyproject-metadata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyproject-metadata}"
SRC_URI[x86_64_v2_python3-pyproject-metadata.sha256sum] = "b15082e2160d98c5bd630774ccf1750f38ff9449c3b2bbfe4bf4dd2323d98fd1"

URI_aarch64_python3-pyproject-metadata = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyproject-metadata-0.8.0-3.el10_0.noarch.rpm;name=aarch64_python3-pyproject-metadata;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyproject-metadata}"
SRC_URI[aarch64_python3-pyproject-metadata.sha256sum] = "708639bdbd6b61d54ae16e06773ca4d800327773691823930f91e2384ccec4b0"

RDEPENDS:python3-pyproject-metadata = " \
 python3 \
 python3-packaging \
 "
