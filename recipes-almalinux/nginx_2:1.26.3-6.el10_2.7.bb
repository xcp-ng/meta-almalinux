# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx"
PE = "2"
PV = "1.26.3"
PR = "6.el10_2.7"
PACKAGES = " \
 nginx \
 nginx-all-modules \
 nginx-core \
 nginx-filesystem \
 nginx-mod-devel \
 nginx-mod-http-image-filter \
 nginx-mod-http-perl \
 nginx-mod-http-xslt-filter \
 nginx-mod-mail \
 nginx-mod-stream \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nginx-1.26.3-6.el10_2.7.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "71ccf9df1cd795d7c2aa250425e018714f1470e479f4e1b4c66ec986320ea06f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-1.26.3-6.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_nginx;unpack=0"
SRC_URI[x86_64_v2_nginx.sha256sum] = "969e4c8564e0d4f758e2287bfb6f7f0964542da364c03051bdce24795a32565c"
RPROVIDES:nginx:append:x86_64_v2 = " virtual/httpd_or_nginx virtual/webserver"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-all-modules-1.26.3-6.el10_2.7.noarch.rpm;name=x86_64_v2_nginx-all-modules;unpack=0"
SRC_URI[x86_64_v2_nginx-all-modules.sha256sum] = "c401bf9f42c3bc11357a0635ba27b08076df988c187958490043e82bcf9ca248"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-core-1.26.3-6.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_nginx-core;unpack=0"
SRC_URI[x86_64_v2_nginx-core.sha256sum] = "35fcf1a16585e1f353c8ddb42230ad280696dccef4ed215149095f48cb09680c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-filesystem-1.26.3-6.el10_2.7.noarch.rpm;name=x86_64_v2_nginx-filesystem;unpack=0"
SRC_URI[x86_64_v2_nginx-filesystem.sha256sum] = "9e02356ee55819abf5dd9f44929c35a20fae932d02ce8934f7cf4b184f83edfa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nginx-mod-devel-1.26.3-6.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-devel;unpack=0"
SRC_URI[x86_64_v2_nginx-mod-devel.sha256sum] = "2fa1d330c61533000780a025cdfd7d5115874b5f913613d7c7f644f31b2856f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-image-filter-1.26.3-6.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-image-filter;unpack=0"
SRC_URI[x86_64_v2_nginx-mod-http-image-filter.sha256sum] = "22679833f5a10950071d8cbfe542d1eb789d5c41b4e79387e0bc1b3042e24e67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-perl-1.26.3-6.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-perl;unpack=0"
SRC_URI[x86_64_v2_nginx-mod-http-perl.sha256sum] = "63eb8a5f1e3aee90e3d352aaef3299529d179b457e764c44e0023804ba16ec95"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-xslt-filter-1.26.3-6.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-xslt-filter;unpack=0"
SRC_URI[x86_64_v2_nginx-mod-http-xslt-filter.sha256sum] = "6adbb842f26e21ecb64e9daab61ebd4d97cc49178902548b2e11685ed5ee8ee7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-mail-1.26.3-6.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-mail;unpack=0"
SRC_URI[x86_64_v2_nginx-mod-mail.sha256sum] = "d6aa26a4d3e82eefaccdfd74352bc0f5f8bc0a5d2ebbaa3158754be76684bb01"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-stream-1.26.3-6.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-stream;unpack=0"
SRC_URI[x86_64_v2_nginx-mod-stream.sha256sum] = "f42dca9db120632009413a96b090924b5ae96ebfd2125c3d3ac0f073be85faf8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-1.26.3-6.el10_2.7.aarch64.rpm;name=aarch64_nginx;unpack=0"
SRC_URI[aarch64_nginx.sha256sum] = "3a9bb802a6c465e8a48b4ed6f142a191d54828b324ec058b7001b61df54c417a"
RPROVIDES:nginx:append:aarch64 = " virtual/httpd_or_nginx virtual/webserver"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-all-modules-1.26.3-6.el10_2.7.noarch.rpm;name=aarch64_nginx-all-modules;unpack=0"
SRC_URI[aarch64_nginx-all-modules.sha256sum] = "c401bf9f42c3bc11357a0635ba27b08076df988c187958490043e82bcf9ca248"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-core-1.26.3-6.el10_2.7.aarch64.rpm;name=aarch64_nginx-core;unpack=0"
SRC_URI[aarch64_nginx-core.sha256sum] = "284f182bae6069fcf5ab979c31609656aeeac9c031d999d96391570ecc570564"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-filesystem-1.26.3-6.el10_2.7.noarch.rpm;name=aarch64_nginx-filesystem;unpack=0"
SRC_URI[aarch64_nginx-filesystem.sha256sum] = "9e02356ee55819abf5dd9f44929c35a20fae932d02ce8934f7cf4b184f83edfa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nginx-mod-devel-1.26.3-6.el10_2.7.aarch64.rpm;name=aarch64_nginx-mod-devel;unpack=0"
SRC_URI[aarch64_nginx-mod-devel.sha256sum] = "5ac654ccf27c05a286332c02b55e2ba75c6fc035e5a4160cb60785b76663a600"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-image-filter-1.26.3-6.el10_2.7.aarch64.rpm;name=aarch64_nginx-mod-http-image-filter;unpack=0"
SRC_URI[aarch64_nginx-mod-http-image-filter.sha256sum] = "87eb1dfd6a032560cdc24eec30888074ad3569784b838e8650add85641f51b55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-perl-1.26.3-6.el10_2.7.aarch64.rpm;name=aarch64_nginx-mod-http-perl;unpack=0"
SRC_URI[aarch64_nginx-mod-http-perl.sha256sum] = "333fa73b3b00c564f6101cf4dde357c038d01cbe7ed7f038a30d03f8c1483bb2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-xslt-filter-1.26.3-6.el10_2.7.aarch64.rpm;name=aarch64_nginx-mod-http-xslt-filter;unpack=0"
SRC_URI[aarch64_nginx-mod-http-xslt-filter.sha256sum] = "a223930faadb8c017a853b13694acdbf18ebf732818c3154382e9a3b55ea8335"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-mail-1.26.3-6.el10_2.7.aarch64.rpm;name=aarch64_nginx-mod-mail;unpack=0"
SRC_URI[aarch64_nginx-mod-mail.sha256sum] = "253d6492288bedbe0a00cdcd50929b1f620fc258957084cdc5fa874aba790316"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-stream-1.26.3-6.el10_2.7.aarch64.rpm;name=aarch64_nginx-mod-stream;unpack=0"
SRC_URI[aarch64_nginx-mod-stream.sha256sum] = "63113909f4443a60e45ee90966590686acb974628ab2bd4f1dc6584651d837d9"

RDEPENDS:nginx = " \
 almalinux-logos-httpd \
 bash \
 nginx-core \
 nginx-filesystem \
 systemd \
 "
RDEPENDS:nginx-all-modules = " \
 nginx-mod-http-image-filter \
 nginx-mod-http-perl \
 nginx-mod-http-xslt-filter \
 nginx-mod-mail \
 nginx-mod-stream \
 "
RDEPENDS:nginx-core = " \
 glibc \
 libxcrypt \
 nginx-filesystem \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:nginx-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:nginx-mod-devel = " \
 bash \
 gcc \
 gd-devel \
 libxslt-devel \
 make \
 nginx \
 openssl-devel \
 pcre2-devel \
 perl-Exporter \
 perl-ExtUtils-Embed \
 perl-constant \
 perl-devel \
 perl-interpreter \
 perl-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:nginx-mod-http-image-filter = " \
 bash \
 gd \
 glibc \
 nginx \
 "
RDEPENDS:nginx-mod-http-perl = " \
 bash \
 glibc \
 nginx \
 perl-Exporter \
 perl-constant \
 perl-libs \
 "
RDEPENDS:nginx-mod-http-xslt-filter = " \
 bash \
 glibc \
 libxml2 \
 libxslt \
 nginx \
 "
RDEPENDS:nginx-mod-mail = " \
 bash \
 glibc \
 nginx \
 "
RDEPENDS:nginx-mod-stream = " \
 bash \
 glibc \
 nginx \
 "
