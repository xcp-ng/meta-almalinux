# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-solid"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-solid \
 kf6-solid-devel \
 kf6-solid-doc \
 kf6-solid-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-solid-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa404ee1a859a7f4574e87e8eb130d3ff36ea2c99b4843d016dbf8721a3fe210"

URI_x86_64_v2_kf6-solid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-solid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-solid}"
SRC_URI[x86_64_v2_kf6-solid.sha256sum] = "7254dbc7f2ba8a5eb4320cb36ac66b94655971581ea903ea3d7eff8e9af26f16"

URI_x86_64_v2_kf6-solid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-solid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-solid-devel}"
SRC_URI[x86_64_v2_kf6-solid-devel.sha256sum] = "6acea8c42f774cfa774b2bf83e28cc4cf5ac931f8ea855f3351f543db8b5e7dc"

URI_x86_64_v2_kf6-solid-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-solid-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-solid-doc}"
SRC_URI[x86_64_v2_kf6-solid-doc.sha256sum] = "f23840f25910f760be9567cf730e9ee2dd9c80fd87d9286b041efda69c0bbc4b"

URI_x86_64_v2_kf6-solid-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-solid-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-solid-html}"
SRC_URI[x86_64_v2_kf6-solid-html.sha256sum] = "716e825cf09286a12da22cfeb65f982c4b9b5750f4bcf2cfa940bc2688f184de"

URI_aarch64_kf6-solid = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-solid;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-solid}"
SRC_URI[aarch64_kf6-solid.sha256sum] = "f18115aefde1a46cf5e16c588479a37ca9f626c179232628852759272bbcb82a"

URI_aarch64_kf6-solid-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-solid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-solid-devel}"
SRC_URI[aarch64_kf6-solid-devel.sha256sum] = "ab3cfcbbbd49d875c0894e298c68863a6a8b5b78a65ca4bfa1d8d4b2a786d870"

URI_aarch64_kf6-solid-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-solid-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-solid-doc}"
SRC_URI[aarch64_kf6-solid-doc.sha256sum] = "149939d7d0d882eec6c20a2620d74ec0a1984a641b000d186a52483859bbb153"

URI_aarch64_kf6-solid-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-solid-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-solid-html}"
SRC_URI[aarch64_kf6-solid-html.sha256sum] = "04efef12937285978e016a88760a36d3571d513dca0e55041059f7baf1a843fe"

RDEPENDS:kf6-solid = " \
 glibc \
 kf6-filesystem \
 libimobiledevice \
 libmount \
 libplist \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 systemd-libs \
 "
RDEPENDS:kf6-solid-devel = " \
 cmake-filesystem \
 kf6-solid \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-solid-doc = " \
 "
RDEPENDS:kf6-solid-html = " \
 "
