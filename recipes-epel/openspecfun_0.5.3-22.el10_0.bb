# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openspecfun"
PV = "0.5.3"
PR = "22.el10_0"
PACKAGES = " \
 openspecfun \
 openspecfun-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openspecfun-0.5.3-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f93f1cbff3312a5f21294f432b91f32d807714d828b63e273839d850432ccf2"

URI_x86_64_v2_openspecfun = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openspecfun-0.5.3-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openspecfun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openspecfun}"
SRC_URI[x86_64_v2_openspecfun.sha256sum] = "23ed46f0b99dd3c32932472b9924673b82ebb6512c1b703255d0ebb4a5fdf849"

URI_x86_64_v2_openspecfun-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openspecfun-devel-0.5.3-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openspecfun-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openspecfun-devel}"
SRC_URI[x86_64_v2_openspecfun-devel.sha256sum] = "6fe9a819ec971aae6e4b56e1dbd3b88ef02a0e2feb142f516af6e4ac7fc600cb"

URI_aarch64_openspecfun = "${EPEL_MIRROR}/aarch64/Packages/o/openspecfun-0.5.3-22.el10_0.aarch64.rpm;name=aarch64_openspecfun;unpack=0"
SRC_URI:append = " ${URI_aarch64_openspecfun}"
SRC_URI[aarch64_openspecfun.sha256sum] = "590f378c86090b90d5d020cecb6e3e26790f07b5ee8ac0d288d35c435f8a1fe2"

URI_aarch64_openspecfun-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openspecfun-devel-0.5.3-22.el10_0.aarch64.rpm;name=aarch64_openspecfun-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openspecfun-devel}"
SRC_URI[aarch64_openspecfun-devel.sha256sum] = "badf0ba20907887fe53caf9d076fc39dbd0ad4190d78ee31176878bfffba6791"

RDEPENDS:openspecfun = " \
 glibc \
 libgcc \
 libgfortran \
 "
RDEPENDS:openspecfun-devel = " \
 openspecfun \
 "
