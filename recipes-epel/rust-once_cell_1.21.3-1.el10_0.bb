# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-once_cell"
PV = "1.21.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-once_cell+alloc-devel \
 rust-once_cell+atomic-polyfill-devel \
 rust-once_cell+critical-section-devel \
 rust-once_cell+default-devel \
 rust-once_cell+parking_lot-devel \
 rust-once_cell+portable-atomic-devel \
 rust-once_cell+race-devel \
 rust-once_cell+std-devel \
 rust-once_cell+unstable-devel \
 rust-once_cell-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-once_cell-1.21.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de5542b8c7739c63525e6f09f93c6f52e87c50a7199e36649db24d1c3cb9e0f7"

URI_x86_64_v2_rust-once_cell+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+alloc-devel-1.21.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+alloc-devel}"
SRC_URI[x86_64_v2_rust-once_cell+alloc-devel.sha256sum] = "4b092dd092fbe6b7925f598c018838fae52f71f723e265c5e86a8f8ecd2d08f3"

URI_x86_64_v2_rust-once_cell+atomic-polyfill-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+atomic-polyfill-devel-1.21.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+atomic-polyfill-devel}"
SRC_URI[x86_64_v2_rust-once_cell+atomic-polyfill-devel.sha256sum] = "d8658ee0070cb192164d099fd51f394bd2da40eab46047630ac1687987b0cfb2"

URI_x86_64_v2_rust-once_cell+critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+critical-section-devel-1.21.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+critical-section-devel}"
SRC_URI[x86_64_v2_rust-once_cell+critical-section-devel.sha256sum] = "657fe7ac9463174cb6f0577b39b5114e88f5db8e62b982a8d73bc06e3b131f78"

URI_x86_64_v2_rust-once_cell+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+default-devel-1.21.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+default-devel}"
SRC_URI[x86_64_v2_rust-once_cell+default-devel.sha256sum] = "705380c4c88f3da6e5f8ac90cfcb224ffc9e2b307b4f70487248a9f495539a39"

URI_x86_64_v2_rust-once_cell+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+parking_lot-devel-1.21.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-once_cell+parking_lot-devel.sha256sum] = "f49f8f7083e072e432c018e5ea5c88c8daf9aee17f47be2b6c67599a25e5bf91"

URI_x86_64_v2_rust-once_cell+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+portable-atomic-devel-1.21.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-once_cell+portable-atomic-devel.sha256sum] = "45b1787b1bad5a3855ba2eaf289d06924f64d4403a691549bff98b8b96b84ea2"

URI_x86_64_v2_rust-once_cell+race-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+race-devel-1.21.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+race-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+race-devel}"
SRC_URI[x86_64_v2_rust-once_cell+race-devel.sha256sum] = "94fa1775994b8a6da4caed7f7848bebec05ca00568d2eb5f9fe3d39b431d2f25"

URI_x86_64_v2_rust-once_cell+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+std-devel-1.21.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+std-devel}"
SRC_URI[x86_64_v2_rust-once_cell+std-devel.sha256sum] = "0865e631a853a188d4e2567ca050f7bf34805e6298e9d17205834977ad0a32e2"

URI_x86_64_v2_rust-once_cell+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+unstable-devel-1.21.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+unstable-devel}"
SRC_URI[x86_64_v2_rust-once_cell+unstable-devel.sha256sum] = "793944a88af87637f6d375bd1bc2325956ad941e5529d459c28fb6b0cc6503cf"

URI_x86_64_v2_rust-once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell-devel-1.21.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell-devel}"
SRC_URI[x86_64_v2_rust-once_cell-devel.sha256sum] = "2fb97261dedc27b26e256d5ebba6ac92bc5071f309a688c40d883f8a164cbf37"

URI_aarch64_rust-once_cell+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+alloc-devel-1.21.3-1.el10_0.noarch.rpm;name=aarch64_rust-once_cell+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+alloc-devel}"
SRC_URI[aarch64_rust-once_cell+alloc-devel.sha256sum] = "4aa6a89d9845c5718b6f947ced2163b5a3510d60d16935b2974fdeac505d6924"

URI_aarch64_rust-once_cell+atomic-polyfill-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+atomic-polyfill-devel-1.21.3-1.el10_0.noarch.rpm;name=aarch64_rust-once_cell+atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+atomic-polyfill-devel}"
SRC_URI[aarch64_rust-once_cell+atomic-polyfill-devel.sha256sum] = "9e998eb61ce939704fc7e937aadc9c1f8528a086ad5bddf68a6d1766e4210c6d"

URI_aarch64_rust-once_cell+critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+critical-section-devel-1.21.3-1.el10_0.noarch.rpm;name=aarch64_rust-once_cell+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+critical-section-devel}"
SRC_URI[aarch64_rust-once_cell+critical-section-devel.sha256sum] = "d4af10f2ff53ce4b67b82384d71c70fe53500bcc4b0515682116ab28a40bf8e9"

URI_aarch64_rust-once_cell+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+default-devel-1.21.3-1.el10_0.noarch.rpm;name=aarch64_rust-once_cell+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+default-devel}"
SRC_URI[aarch64_rust-once_cell+default-devel.sha256sum] = "e336a1aa51931211faf2edbde9c62fbd5055e64dd57d5dc7ee26d30b6edf311b"

URI_aarch64_rust-once_cell+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+parking_lot-devel-1.21.3-1.el10_0.noarch.rpm;name=aarch64_rust-once_cell+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+parking_lot-devel}"
SRC_URI[aarch64_rust-once_cell+parking_lot-devel.sha256sum] = "984facc481c8081a9f5acc083cc03ef723c4934aa5a22025a07951c3ba65758e"

URI_aarch64_rust-once_cell+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+portable-atomic-devel-1.21.3-1.el10_0.noarch.rpm;name=aarch64_rust-once_cell+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+portable-atomic-devel}"
SRC_URI[aarch64_rust-once_cell+portable-atomic-devel.sha256sum] = "faaea012de65009acbe4694b295bba4c1df1267de2f7b7b066c7f72585c58040"

URI_aarch64_rust-once_cell+race-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+race-devel-1.21.3-1.el10_0.noarch.rpm;name=aarch64_rust-once_cell+race-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+race-devel}"
SRC_URI[aarch64_rust-once_cell+race-devel.sha256sum] = "2c18ccba9fb89906b92176a359fb6b8f77607575a2d290aec6b87a25a031d742"

URI_aarch64_rust-once_cell+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+std-devel-1.21.3-1.el10_0.noarch.rpm;name=aarch64_rust-once_cell+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+std-devel}"
SRC_URI[aarch64_rust-once_cell+std-devel.sha256sum] = "52e6a1df1320d760918a1c5553ea8cb4e996abc5dd89a937dcc45b39cc6c37df"

URI_aarch64_rust-once_cell+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+unstable-devel-1.21.3-1.el10_0.noarch.rpm;name=aarch64_rust-once_cell+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+unstable-devel}"
SRC_URI[aarch64_rust-once_cell+unstable-devel.sha256sum] = "c79b9173def4d2e723a46ae05be696f392aa9527a396806a5f5896e1b4888c1e"

URI_aarch64_rust-once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell-devel-1.21.3-1.el10_0.noarch.rpm;name=aarch64_rust-once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell-devel}"
SRC_URI[aarch64_rust-once_cell-devel.sha256sum] = "7f26edbf2aab1db73bf4055e44f37ded55ed203ea40f35be6c3ebc5f6a2ab2e1"

RDEPENDS:rust-once_cell+alloc-devel = " \
 cargo \
 rust-once_cell+race-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+atomic-polyfill-devel = " \
 cargo \
 rust-once_cell+critical-section-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+critical-section-devel = " \
 cargo \
 rust-critical-section+default-devel \
 rust-once_cell+portable-atomic-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+default-devel = " \
 cargo \
 rust-once_cell+std-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+parking_lot-devel = " \
 cargo \
 rust-once_cell-devel \
 rust-parking_lot_core-devel \
 "
RDEPENDS:rust-once_cell+portable-atomic-devel = " \
 cargo \
 rust-once_cell-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-once_cell+race-devel = " \
 cargo \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+std-devel = " \
 cargo \
 rust-once_cell+alloc-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+unstable-devel = " \
 cargo \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell-devel = " \
 cargo \
 rust \
 "
