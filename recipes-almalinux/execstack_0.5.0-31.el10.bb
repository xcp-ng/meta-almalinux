# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "execstack"
PV = "0.5.0"
PR = "31.el10"
PACKAGES = " \
 execstack \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/execstack-0.5.0-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10c9fdaab21769239aa1d8e9aeaaca729f295690b5a90bc1bc0b9a8bef73c5c0"

URI_x86_64_v2_execstack = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/execstack-0.5.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_execstack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_execstack}"
SRC_URI[x86_64_v2_execstack.sha256sum] = "03a7f057dbb23b66649797b60d88fd7ca1c7a084cd3c1fa41f24d87fe3c99a31"

URI_aarch64_execstack = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/execstack-0.5.0-31.el10.aarch64.rpm;name=aarch64_execstack;unpack=0"
SRC_URI:append = " ${URI_aarch64_execstack}"
SRC_URI[aarch64_execstack.sha256sum] = "4c2ec613c525ca5068f7b896ffc774792b4394e755289ef3e4bfb57840e039c9"

RDEPENDS:execstack = " \
 elfutils-libelf \
 findutils \
 gawk \
 glibc \
 grep \
 libselinux \
 util-linux \
 virtual/coreutils \
 "
