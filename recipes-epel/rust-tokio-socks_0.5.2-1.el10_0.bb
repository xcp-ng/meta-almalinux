# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-socks"
PV = "0.5.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-tokio-socks+default-devel \
 rust-tokio-socks+futures-io-devel \
 rust-tokio-socks+tokio-devel \
 rust-tokio-socks+tor-devel \
 rust-tokio-socks-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-socks-0.5.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b78ef8124f7f9d1132535eb3826c9f993c63c3c0d5d6103c1668f25b38740936"

URI_x86_64_v2_rust-tokio-socks+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-socks+default-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-socks+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-socks+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-socks+default-devel.sha256sum] = "40eac7bed196f565ed9842197bc9d25091dbc395d907c4356252fe22cbd1f232"

URI_x86_64_v2_rust-tokio-socks+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-socks+futures-io-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-socks+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-socks+futures-io-devel}"
SRC_URI[x86_64_v2_rust-tokio-socks+futures-io-devel.sha256sum] = "3b36bfb4361f7b311c1c2cd41bab866706321de7404df97ce8ad0f051678fb22"

URI_x86_64_v2_rust-tokio-socks+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-socks+tokio-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-socks+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-socks+tokio-devel}"
SRC_URI[x86_64_v2_rust-tokio-socks+tokio-devel.sha256sum] = "1972ed6708c41ccc75abb86442d53cbec976ae5659612499a5c65671ef506673"

URI_x86_64_v2_rust-tokio-socks+tor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-socks+tor-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-socks+tor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-socks+tor-devel}"
SRC_URI[x86_64_v2_rust-tokio-socks+tor-devel.sha256sum] = "9d307c248692514a7c17650e8a75add4691e96917cc4589977d4e313e8def644"

URI_x86_64_v2_rust-tokio-socks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-socks-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-socks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-socks-devel}"
SRC_URI[x86_64_v2_rust-tokio-socks-devel.sha256sum] = "0c391aeecf4786c62696e3601ecdea89d2882af0506f223424f3c63fffc761aa"

URI_aarch64_rust-tokio-socks+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-socks+default-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-socks+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-socks+default-devel}"
SRC_URI[aarch64_rust-tokio-socks+default-devel.sha256sum] = "d0c0d94e135f13cbf27bf5ee2d057faaf7ea5e3b6958a196f676b2c075785a48"

URI_aarch64_rust-tokio-socks+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-socks+futures-io-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-socks+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-socks+futures-io-devel}"
SRC_URI[aarch64_rust-tokio-socks+futures-io-devel.sha256sum] = "a7160a094e4b21e2786b57f527b07381a25142fd1862b1a4f13834148c0af07d"

URI_aarch64_rust-tokio-socks+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-socks+tokio-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-socks+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-socks+tokio-devel}"
SRC_URI[aarch64_rust-tokio-socks+tokio-devel.sha256sum] = "e1b535c3f70e6341db97efee8217d3f6171cbb07a27e09091faa175ca9181923"

URI_aarch64_rust-tokio-socks+tor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-socks+tor-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-socks+tor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-socks+tor-devel}"
SRC_URI[aarch64_rust-tokio-socks+tor-devel.sha256sum] = "c8142719bca385d3066447ddd6dab84bb18f979bcff4c1c9fe428539b379a43b"

URI_aarch64_rust-tokio-socks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-socks-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-socks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-socks-devel}"
SRC_URI[aarch64_rust-tokio-socks-devel.sha256sum] = "f0fc663cd279649bda4de699ebc682c6e3043679c94603721dfa10775e443baf"

RDEPENDS:rust-tokio-socks+default-devel = " \
 cargo \
 rust-tokio-socks+tokio-devel \
 rust-tokio-socks-devel \
 "
RDEPENDS:rust-tokio-socks+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-tokio-socks-devel \
 "
RDEPENDS:rust-tokio-socks+tokio-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio-socks-devel \
 "
RDEPENDS:rust-tokio-socks+tor-devel = " \
 cargo \
 rust-tokio-socks-devel \
 "
RDEPENDS:rust-tokio-socks-devel = " \
 bash \
 cargo \
 rust-either+default-devel \
 rust-futures-util-devel \
 rust-thiserror1+default-devel \
 "
