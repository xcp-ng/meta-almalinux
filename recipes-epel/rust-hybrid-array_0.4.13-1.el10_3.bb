# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hybrid-array"
PV = "0.4.13"
PR = "1.el10_3"
PACKAGES = " \
 rust-hybrid-array+alloc-devel \
 rust-hybrid-array+arbitrary-devel \
 rust-hybrid-array+bytemuck-devel \
 rust-hybrid-array+ctutils-devel \
 rust-hybrid-array+default-devel \
 rust-hybrid-array+extra-sizes-devel \
 rust-hybrid-array+serde-devel \
 rust-hybrid-array+subtle-devel \
 rust-hybrid-array+zerocopy-devel \
 rust-hybrid-array+zeroize-devel \
 rust-hybrid-array-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hybrid-array-0.4.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b00470c427ea70c6ca8496f1131fe8f708e67eec84b5129f8531d6044ef403c"

URI_x86_64_v2_rust-hybrid-array+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+alloc-devel-0.4.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+alloc-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+alloc-devel.sha256sum] = "38b9cad3b6a2ff33c46ae10057287e8cc2f5176aa4ad893ac804d950c28d3159"

URI_x86_64_v2_rust-hybrid-array+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+arbitrary-devel-0.4.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+arbitrary-devel.sha256sum] = "f77000eb075f111c35a368fa96c532d45475c439c8a86418ddc3db9f9b10bdbe"

URI_x86_64_v2_rust-hybrid-array+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+bytemuck-devel-0.4.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+bytemuck-devel.sha256sum] = "de9b0e7003aa5b048c6e07fcaefe579aae1d0449baa50750b0f0fcecce8fdadd"

URI_x86_64_v2_rust-hybrid-array+ctutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+ctutils-devel-0.4.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+ctutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+ctutils-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+ctutils-devel.sha256sum] = "457ed24e7da50a0d617b84a3cea4354e1065826f821fff2483894434dceed088"

URI_x86_64_v2_rust-hybrid-array+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+default-devel-0.4.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+default-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+default-devel.sha256sum] = "84ffc28c0467a26bba272269cea4b2d3f8f2ebaee0b310453472b6cf4857a5eb"

URI_x86_64_v2_rust-hybrid-array+extra-sizes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+extra-sizes-devel-0.4.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+extra-sizes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+extra-sizes-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+extra-sizes-devel.sha256sum] = "ba43f9e64f36e6f24817685ebbabcf18461c217431f61bcdc827291e7f70bcaa"

URI_x86_64_v2_rust-hybrid-array+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+serde-devel-0.4.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+serde-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+serde-devel.sha256sum] = "f9beac0ece401d92078fea7b2b2b0fd1e0777f1939b413f4a65b4b76eeb2bbce"

URI_x86_64_v2_rust-hybrid-array+subtle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+subtle-devel-0.4.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+subtle-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+subtle-devel.sha256sum] = "f9400389ce5f8c6d545d1c2e0e833361e55b328cd4ed9f27a5a2460e7c60e75f"

URI_x86_64_v2_rust-hybrid-array+zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+zerocopy-devel-0.4.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+zerocopy-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+zerocopy-devel.sha256sum] = "562cbad8109b5fc74befd08ed44e817e92d209d448746261464d9e1bcf51a475"

URI_x86_64_v2_rust-hybrid-array+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+zeroize-devel-0.4.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+zeroize-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+zeroize-devel.sha256sum] = "55547b0afdb4cc3057d93021b0a16ae6df64ca71fb72890405a140af38d88621"

URI_x86_64_v2_rust-hybrid-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array-devel-0.4.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array-devel.sha256sum] = "4410fcac293a7ff5c7c4bff71b20d72fd0868c217f3636c917fd4cb073a5e4c9"

URI_aarch64_rust-hybrid-array+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+alloc-devel-0.4.13-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+alloc-devel}"
SRC_URI[aarch64_rust-hybrid-array+alloc-devel.sha256sum] = "ccf97b1ba76b8429a0597b98a33120879c519fe4183e8aaffca954e5465e1311"

URI_aarch64_rust-hybrid-array+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+arbitrary-devel-0.4.13-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+arbitrary-devel}"
SRC_URI[aarch64_rust-hybrid-array+arbitrary-devel.sha256sum] = "3e6a05f426ddc251c800530330c9c85346e0e5f3cb2ef631b9cd0b5fe821fc35"

URI_aarch64_rust-hybrid-array+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+bytemuck-devel-0.4.13-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+bytemuck-devel}"
SRC_URI[aarch64_rust-hybrid-array+bytemuck-devel.sha256sum] = "31c488f49638b3354af02c3042b6cffb2b2996469e4f525cc065eee1e5efbbb1"

URI_aarch64_rust-hybrid-array+ctutils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+ctutils-devel-0.4.13-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+ctutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+ctutils-devel}"
SRC_URI[aarch64_rust-hybrid-array+ctutils-devel.sha256sum] = "4205f3e70b4cae4c9836dbc8ff68828562d1d5a37f904f06299d126270ede1fa"

URI_aarch64_rust-hybrid-array+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+default-devel-0.4.13-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+default-devel}"
SRC_URI[aarch64_rust-hybrid-array+default-devel.sha256sum] = "5dde25689a2c582d8a19845d8ab79948e1cc0c34725bc668dfdd2282431c2202"

URI_aarch64_rust-hybrid-array+extra-sizes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+extra-sizes-devel-0.4.13-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+extra-sizes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+extra-sizes-devel}"
SRC_URI[aarch64_rust-hybrid-array+extra-sizes-devel.sha256sum] = "425d03859f1362272cbe42ebf8715111b4bd728751818c4decb448b72985a5df"

URI_aarch64_rust-hybrid-array+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+serde-devel-0.4.13-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+serde-devel}"
SRC_URI[aarch64_rust-hybrid-array+serde-devel.sha256sum] = "9df6d3f46d00b9e05788cbc2854ce57ea52b23b3bf765ed458c7712ff3a42eb3"

URI_aarch64_rust-hybrid-array+subtle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+subtle-devel-0.4.13-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+subtle-devel}"
SRC_URI[aarch64_rust-hybrid-array+subtle-devel.sha256sum] = "d010350cd2f8d0d274268debe0e2d3c1559409836dcdbdff0bfdbe88ffd60178"

URI_aarch64_rust-hybrid-array+zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+zerocopy-devel-0.4.13-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+zerocopy-devel}"
SRC_URI[aarch64_rust-hybrid-array+zerocopy-devel.sha256sum] = "f62a4b57723cc81a85483d441d09f5f156383d344b643286da0e5da9a29aa385"

URI_aarch64_rust-hybrid-array+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+zeroize-devel-0.4.13-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+zeroize-devel}"
SRC_URI[aarch64_rust-hybrid-array+zeroize-devel.sha256sum] = "53a9c157c240e5d97b5be01f5cde6ece4dc773b9c6251469c6f59e63a2eb8e7f"

URI_aarch64_rust-hybrid-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array-devel-0.4.13-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array-devel}"
SRC_URI[aarch64_rust-hybrid-array-devel.sha256sum] = "ae948579b9936b65795fcbfbab99e4736cfa9f80a5e83389526e3c42af9dcba2"

RDEPENDS:rust-hybrid-array+alloc-devel = " \
 cargo \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+bytemuck-devel = " \
 cargo \
 rust-bytemuck-devel \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+ctutils-devel = " \
 cargo \
 rust-ctutils+default-devel \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+default-devel = " \
 cargo \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+extra-sizes-devel = " \
 cargo \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+serde-devel = " \
 cargo \
 rust-hybrid-array-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-hybrid-array+subtle-devel = " \
 cargo \
 rust-hybrid-array-devel \
 rust-subtle+const-generics-devel \
 rust-subtle-devel \
 "
RDEPENDS:rust-hybrid-array+zerocopy-devel = " \
 cargo \
 rust-hybrid-array-devel \
 rust-zerocopy+default-devel \
 rust-zerocopy+derive-devel \
 "
RDEPENDS:rust-hybrid-array+zeroize-devel = " \
 cargo \
 rust-hybrid-array-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-hybrid-array-devel = " \
 cargo \
 rust \
 rust-typenum+const-generics-devel \
 rust-typenum+default-devel \
 "
