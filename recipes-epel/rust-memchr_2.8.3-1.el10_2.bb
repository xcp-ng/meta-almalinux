# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memchr"
PV = "2.8.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-memchr+alloc-devel \
 rust-memchr+default-devel \
 rust-memchr+libc-devel \
 rust-memchr+logging-devel \
 rust-memchr+std-devel \
 rust-memchr+use_std-devel \
 rust-memchr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memchr-2.8.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "355e46634a05645c27cf6a16cefbb0dcd81848fc599acd5d4683ba3ffa78293d"

URI_x86_64_v2_rust-memchr+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+alloc-devel-2.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+alloc-devel}"
SRC_URI[x86_64_v2_rust-memchr+alloc-devel.sha256sum] = "0543172aaf8fe0d0d68e133486568f3777d0b679565333988b07f8d3ca2e5d38"

URI_x86_64_v2_rust-memchr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+default-devel-2.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+default-devel}"
SRC_URI[x86_64_v2_rust-memchr+default-devel.sha256sum] = "14daa6f9e859205f2dcd5d0143f7387fef8f729860b666936d6a3d1d1b5194f0"

URI_x86_64_v2_rust-memchr+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+libc-devel-2.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+libc-devel}"
SRC_URI[x86_64_v2_rust-memchr+libc-devel.sha256sum] = "a79ff19fb5612a536b2a9a920419c3fd4d5c9797a2fbc26019f16f8cb1dbd0da"

URI_x86_64_v2_rust-memchr+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+logging-devel-2.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+logging-devel}"
SRC_URI[x86_64_v2_rust-memchr+logging-devel.sha256sum] = "12dfaa14c583e164bc7e5afa49c3773d1a1c9fe7b44ad4883add80685f5ab114"

URI_x86_64_v2_rust-memchr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+std-devel-2.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+std-devel}"
SRC_URI[x86_64_v2_rust-memchr+std-devel.sha256sum] = "a1ad9bd16a0c789f420ceaf349d0d74a76ef64d318ddc1bd9cf10b6f01779085"

URI_x86_64_v2_rust-memchr+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+use_std-devel-2.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+use_std-devel}"
SRC_URI[x86_64_v2_rust-memchr+use_std-devel.sha256sum] = "0e3896c4fada8d7c5b24fa1539d7aa1104536ee29640c43e27e866ba82bb2687"

URI_x86_64_v2_rust-memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr-devel-2.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr-devel}"
SRC_URI[x86_64_v2_rust-memchr-devel.sha256sum] = "054f6da5fb761e3f6bdb27ca36612b7ee29131ceadb562a3bf6b8f6bb29744cb"

URI_aarch64_rust-memchr+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+alloc-devel-2.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-memchr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+alloc-devel}"
SRC_URI[aarch64_rust-memchr+alloc-devel.sha256sum] = "b4af6e241b4470149d3c3a18610d68b8cc642a95517d5abf47c3b926659a2466"

URI_aarch64_rust-memchr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+default-devel-2.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-memchr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+default-devel}"
SRC_URI[aarch64_rust-memchr+default-devel.sha256sum] = "5b81d56179b9c26fbf5775e99275f55f68d21c9ad115b439b0777e96f1e79b1c"

URI_aarch64_rust-memchr+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+libc-devel-2.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-memchr+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+libc-devel}"
SRC_URI[aarch64_rust-memchr+libc-devel.sha256sum] = "5dbd6d1f91e261e1b10aec7b3d37d12896b5fa2172e1796b1bf8e7bb3465e336"

URI_aarch64_rust-memchr+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+logging-devel-2.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-memchr+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+logging-devel}"
SRC_URI[aarch64_rust-memchr+logging-devel.sha256sum] = "0ac69807fb65fb054a12a66d5557b8dbfcb85a4c581dd8ad09977209b902eda7"

URI_aarch64_rust-memchr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+std-devel-2.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-memchr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+std-devel}"
SRC_URI[aarch64_rust-memchr+std-devel.sha256sum] = "605983f05d126676c0b7d93ab8278bc490b6b4e1c4dd3d6e8eed7fadca84c923"

URI_aarch64_rust-memchr+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+use_std-devel-2.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-memchr+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+use_std-devel}"
SRC_URI[aarch64_rust-memchr+use_std-devel.sha256sum] = "0daf390394fe7564dbf13cbcd64b8af57d7a96a03e4c7ac847990cab461f03e1"

URI_aarch64_rust-memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr-devel-2.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr-devel}"
SRC_URI[aarch64_rust-memchr-devel.sha256sum] = "a8ecaef98e678804ca099fbb18ab2809c40515bb4b08b283afb0927f7991754f"

RDEPENDS:rust-memchr+alloc-devel = " \
 cargo \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+default-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+libc-devel = " \
 cargo \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+logging-devel = " \
 cargo \
 rust-log+default-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+std-devel = " \
 cargo \
 rust-memchr+alloc-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+use_std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr-devel = " \
 cargo \
 rust \
 "
