# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mrtg"
PV = "2.17.10"
PR = "12.el10_2.1"
PACKAGES = " \
 mrtg \
 mrtg-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mrtg-2.17.10-12.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "296fb288a25badafe23571ec9ab2336e9ad2cbb20c1a08548b19bae540ac1fca"

URI_x86_64_v2_mrtg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mrtg-2.17.10-12.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_mrtg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mrtg}"
SRC_URI[x86_64_v2_mrtg.sha256sum] = "3f5ffa6545b0d7e24fc821f98a5996eef35394af6d8a3a48838a5c8503c2f04d"

URI_x86_64_v2_mrtg-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mrtg-selinux-2.17.10-12.el10_2.1.noarch.rpm;name=x86_64_v2_mrtg-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mrtg-selinux}"
SRC_URI[x86_64_v2_mrtg-selinux.sha256sum] = "d7555e699b1e01e77cb85e1fbe4038f3f7826311959865d40f4c38eed8aa6134"

URI_aarch64_mrtg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mrtg-2.17.10-12.el10_2.1.aarch64.rpm;name=aarch64_mrtg;unpack=0"
SRC_URI:append = " ${URI_aarch64_mrtg}"
SRC_URI[aarch64_mrtg.sha256sum] = "ec79bacc19870521cfc9bd0913b407a0527a0c8610c4e847d3916cede0ce8419"

URI_aarch64_mrtg-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mrtg-selinux-2.17.10-12.el10_2.1.noarch.rpm;name=aarch64_mrtg-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_mrtg-selinux}"
SRC_URI[aarch64_mrtg-selinux.sha256sum] = "d7555e699b1e01e77cb85e1fbe4038f3f7826311959865d40f4c38eed8aa6134"

RDEPENDS:mrtg = " \
 bash \
 gd \
 glibc \
 mrtg \
 mrtg-selinux \
 perl-CGI \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IO \
 perl-IO-Socket-INET6 \
 perl-Math-BigInt \
 perl-POSIX \
 perl-Pod-Usage \
 perl-SNMP_Session \
 perl-Socket \
 perl-Socket6 \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-locale \
 perl-vars \
 systemd \
 "
RDEPENDS:mrtg-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
