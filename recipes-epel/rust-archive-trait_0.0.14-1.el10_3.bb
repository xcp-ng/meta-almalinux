# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-archive-trait"
PV = "0.0.14"
PR = "1.el10_3"
PACKAGES = " \
 rust-archive-trait+default-devel \
 rust-archive-trait-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-archive-trait-0.0.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2bb77e70ce48f736fff33c4bd98f46c73db11399b0f2c4331a111f849463982c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-archive-trait+default-devel-0.0.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-archive-trait+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-archive-trait+default-devel.sha256sum] = "7d394d61ac49672ce84835434778f94488778146ec4cc848911b7d0668b3bb34"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-archive-trait-devel-0.0.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-archive-trait-devel;unpack=0"
SRC_URI[x86_64_v2_rust-archive-trait-devel.sha256sum] = "e0d685f163c3223672da9290da2f3f659b32656216c29d7959b60878450a67b9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-archive-trait+default-devel-0.0.14-1.el10_3.noarch.rpm;name=aarch64_rust-archive-trait+default-devel;unpack=0"
SRC_URI[aarch64_rust-archive-trait+default-devel.sha256sum] = "4cb512eef9c7787867b312e2966a6efe9704b7d2437c34b925dd92d9fc0e3141"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-archive-trait-devel-0.0.14-1.el10_3.noarch.rpm;name=aarch64_rust-archive-trait-devel;unpack=0"
SRC_URI[aarch64_rust-archive-trait-devel.sha256sum] = "becf911a67f6520e3e93fb98013c8389f0f2a7d150661e59b21882db0c98102b"

RDEPENDS:rust-archive-trait+default-devel = " \
 cargo \
 rust-archive-trait-devel \
 "
RDEPENDS:rust-archive-trait-devel = " \
 cargo \
 rust-cap-std+default-devel \
 rust-thiserror+default-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-walkdir+default-devel \
 "
