# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kruler"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kruler \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kruler-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "644da7a9dad31c714d1321ba835d4b5ca4288fde1d1156f99332cabbcf2b9e3b"

URI_x86_64_v2_kruler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kruler-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kruler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kruler}"
SRC_URI[x86_64_v2_kruler.sha256sum] = "9a9306f38141ad5f210211434affc843beb81dccd95daaaacece2a1d69789e16"

URI_aarch64_kruler = "${EPEL_MIRROR}/aarch64/Packages/k/kruler-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kruler;unpack=0"
SRC_URI:append = " ${URI_aarch64_kruler}"
SRC_URI[aarch64_kruler.sha256sum] = "41b1b744e327aa82efa661557f4bb5daf02507b4fb63882890df280bb1921f73"

RDEPENDS:kruler = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
