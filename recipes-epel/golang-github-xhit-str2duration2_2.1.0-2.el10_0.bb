# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-xhit-str2duration2"
PV = "2.1.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-xhit-str2duration2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-xhit-str2duration2-2.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa28cd56d888b86635e87743eb493f4e486083ed0b547dc95c6727f5839b8d45"

URI_x86_64_v2_golang-github-xhit-str2duration2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-xhit-str2duration2-devel-2.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-xhit-str2duration2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-xhit-str2duration2-devel}"
SRC_URI[x86_64_v2_golang-github-xhit-str2duration2-devel.sha256sum] = "cb5bcfc6d44aeacc1e0192affde2e61dd0951feadafd92771ab904d9b18a537f"

URI_aarch64_golang-github-xhit-str2duration2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-xhit-str2duration2-devel-2.1.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-xhit-str2duration2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-xhit-str2duration2-devel}"
SRC_URI[aarch64_golang-github-xhit-str2duration2-devel.sha256sum] = "7dbccd8877a8ea10ccc71c401f460b57419924a1d60901ceb272220513e70885"

RDEPENDS:golang-github-xhit-str2duration2-devel = " \
 go-filesystem \
 "
