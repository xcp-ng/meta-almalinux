# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colorful"
PV = "0.5.7"
PR = "1.el10_0"
PACKAGES = " \
 python3-colorful \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colorful-0.5.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb1bbe18d08a0dc27a9f83e326da7abe54984c3e10ee0793e23fed84bb264454"

URI_x86_64_v2_python3-colorful = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colorful-0.5.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colorful;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colorful}"
SRC_URI[x86_64_v2_python3-colorful.sha256sum] = "7ddd7fb31e9e8fed2cfcf322742fc983903e40ef9e18e49c6beaba47383f74c9"

URI_aarch64_python3-colorful = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colorful-0.5.7-1.el10_0.noarch.rpm;name=aarch64_python3-colorful;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colorful}"
SRC_URI[aarch64_python3-colorful.sha256sum] = "a685bcc0f8e638be2d39e706fbe10b0e4ae2f7dc5694ee54e9fd469197085206"

RDEPENDS:python3-colorful = " \
 python3 \
 "
