# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rspec"
PV = "1.0.0"
PR = "12.el10_0"
PACKAGES = " \
 rust-rspec+default-devel \
 rust-rspec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rspec-1.0.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0397ca026cbcb9809c32cc6040891054104c088506c359bd3626907a8758c6a1"

URI_x86_64_v2_rust-rspec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rspec+default-devel-1.0.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rspec+default-devel}"
SRC_URI[x86_64_v2_rust-rspec+default-devel.sha256sum] = "6ab4ab9bc90e8c1927b667d2dcca4ebe434b87d9bea8266a23732eedd8507ce6"

URI_x86_64_v2_rust-rspec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rspec-devel-1.0.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rspec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rspec-devel}"
SRC_URI[x86_64_v2_rust-rspec-devel.sha256sum] = "b0aaf8e4d39a0ca1d1ba488e4d2f3014acddd194ea1b630789a22301f512545d"

URI_aarch64_rust-rspec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rspec+default-devel-1.0.0-12.el10_0.noarch.rpm;name=aarch64_rust-rspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rspec+default-devel}"
SRC_URI[aarch64_rust-rspec+default-devel.sha256sum] = "2fa6bd76ae4024f950f5c4a08270a0439a22ad730d661195b3f56f916d51e85d"

URI_aarch64_rust-rspec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rspec-devel-1.0.0-12.el10_0.noarch.rpm;name=aarch64_rust-rspec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rspec-devel}"
SRC_URI[aarch64_rust-rspec-devel.sha256sum] = "9ee701690fd742eddb1745dbe454d50a84824859e27a452540cb7f29ac056975"

RDEPENDS:rust-rspec+default-devel = " \
 cargo \
 rust-rspec-devel \
 "
RDEPENDS:rust-rspec-devel = " \
 cargo \
 rust-colored2+default-devel \
 rust-derive-new+default-devel \
 rust-derive_builder+default-devel \
 rust-rayon+default-devel \
 rust-time+default-devel \
 "
