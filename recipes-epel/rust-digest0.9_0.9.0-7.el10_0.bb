# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-digest0.9"
PV = "0.9.0"
PR = "7.el10_0"
PACKAGES = " \
 rust-digest0.9+alloc-devel \
 rust-digest0.9+blobby-devel \
 rust-digest0.9+default-devel \
 rust-digest0.9+dev-devel \
 rust-digest0.9+std-devel \
 rust-digest0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-digest0.9-0.9.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bee7cef504750d028ff51e409939d318c810a3a2bb8198044b639f8b4f38edaf"

URI_x86_64_v2_rust-digest0.9+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.9+alloc-devel-0.9.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.9+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.9+alloc-devel}"
SRC_URI[x86_64_v2_rust-digest0.9+alloc-devel.sha256sum] = "013e392cc02cfaa6056279f589f74938f02fddd61f86c5b7cf486a033e889378"

URI_x86_64_v2_rust-digest0.9+blobby-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.9+blobby-devel-0.9.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.9+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.9+blobby-devel}"
SRC_URI[x86_64_v2_rust-digest0.9+blobby-devel.sha256sum] = "7791b968c23f55c1a51f10f4f7b70bc84975c73ff6395975c2bcd92347afdad8"

URI_x86_64_v2_rust-digest0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.9+default-devel-0.9.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.9+default-devel}"
SRC_URI[x86_64_v2_rust-digest0.9+default-devel.sha256sum] = "a28365847848ad9b7bb8d5844054701eef3409b140b77fc04cf39ca0d7e426fb"

URI_x86_64_v2_rust-digest0.9+dev-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.9+dev-devel-0.9.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.9+dev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.9+dev-devel}"
SRC_URI[x86_64_v2_rust-digest0.9+dev-devel.sha256sum] = "4c2b8fc6a217b952645fb9e821342c8b69ba93c5ac86eeade9ba32db8c51629f"

URI_x86_64_v2_rust-digest0.9+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.9+std-devel-0.9.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.9+std-devel}"
SRC_URI[x86_64_v2_rust-digest0.9+std-devel.sha256sum] = "12f244b91cb3521d7723f45b3b7f3c99f8b095730c672e78c8f6a30d92d9f59f"

URI_x86_64_v2_rust-digest0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.9-devel-0.9.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.9-devel}"
SRC_URI[x86_64_v2_rust-digest0.9-devel.sha256sum] = "259b6ed5a8a1f94fd0a5946407dfb3e314cb8aac43ada5aa38ef4808a9a26cf2"

URI_aarch64_rust-digest0.9+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.9+alloc-devel-0.9.0-7.el10_0.noarch.rpm;name=aarch64_rust-digest0.9+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.9+alloc-devel}"
SRC_URI[aarch64_rust-digest0.9+alloc-devel.sha256sum] = "d527cac634428ddf15c0c5eaaf813a9c6bc6f79083612ff29dfef28331653308"

URI_aarch64_rust-digest0.9+blobby-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.9+blobby-devel-0.9.0-7.el10_0.noarch.rpm;name=aarch64_rust-digest0.9+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.9+blobby-devel}"
SRC_URI[aarch64_rust-digest0.9+blobby-devel.sha256sum] = "2e07268faab387cf27b37a6ff29f93515a3f5f5a2d9ccfbf78495534e14ad434"

URI_aarch64_rust-digest0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.9+default-devel-0.9.0-7.el10_0.noarch.rpm;name=aarch64_rust-digest0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.9+default-devel}"
SRC_URI[aarch64_rust-digest0.9+default-devel.sha256sum] = "f63d7c8c8818b09e2939e2440ab84e7e4feef28381db3fb59cc4086c5de65fe3"

URI_aarch64_rust-digest0.9+dev-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.9+dev-devel-0.9.0-7.el10_0.noarch.rpm;name=aarch64_rust-digest0.9+dev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.9+dev-devel}"
SRC_URI[aarch64_rust-digest0.9+dev-devel.sha256sum] = "a2e23d8df19b9128e4a1a25e99882b05b7103d545b97aa9515b8b6a67b22a0e0"

URI_aarch64_rust-digest0.9+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.9+std-devel-0.9.0-7.el10_0.noarch.rpm;name=aarch64_rust-digest0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.9+std-devel}"
SRC_URI[aarch64_rust-digest0.9+std-devel.sha256sum] = "0c4844acebf957324b041b78d129bfb5685d9f558f81c5a4a902287f4138884c"

URI_aarch64_rust-digest0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.9-devel-0.9.0-7.el10_0.noarch.rpm;name=aarch64_rust-digest0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.9-devel}"
SRC_URI[aarch64_rust-digest0.9-devel.sha256sum] = "77b94a10fde2805ee342c5a865e4ae6ce3575c110a52ce81eba4cc11cb6d57da"

RDEPENDS:rust-digest0.9+alloc-devel = " \
 cargo \
 rust-digest0.9-devel \
 "
RDEPENDS:rust-digest0.9+blobby-devel = " \
 cargo \
 rust-blobby0.1+default-devel \
 rust-digest0.9-devel \
 "
RDEPENDS:rust-digest0.9+default-devel = " \
 cargo \
 rust-digest0.9-devel \
 "
RDEPENDS:rust-digest0.9+dev-devel = " \
 cargo \
 rust-digest0.9+blobby-devel \
 rust-digest0.9-devel \
 "
RDEPENDS:rust-digest0.9+std-devel = " \
 cargo \
 rust-digest0.9+alloc-devel \
 rust-digest0.9-devel \
 "
RDEPENDS:rust-digest0.9-devel = " \
 cargo \
 rust-generic-array+default-devel \
 "
