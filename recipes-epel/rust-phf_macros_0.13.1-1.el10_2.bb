# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf_macros"
PV = "0.13.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-phf_macros+default-devel \
 rust-phf_macros+uncased-devel \
 rust-phf_macros+uncased_-devel \
 rust-phf_macros+unicase-devel \
 rust-phf_macros+unicase_-devel \
 rust-phf_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf_macros-0.13.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bc2f3dcada27f15f911f6522eb22b95dec3a96781d793a884a98728680a892c"

URI_x86_64_v2_rust-phf_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros+default-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros+default-devel}"
SRC_URI[x86_64_v2_rust-phf_macros+default-devel.sha256sum] = "48db267459a237fffe4d26ada8b16b39b36d463aeaf8113ce6f06f9957c0b5af"

URI_x86_64_v2_rust-phf_macros+uncased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros+uncased-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros+uncased-devel}"
SRC_URI[x86_64_v2_rust-phf_macros+uncased-devel.sha256sum] = "5b9fd7503a319b1b6fe6fbcbe58ade7aa5d57b51d9f75813998b63aa0c3ef503"

URI_x86_64_v2_rust-phf_macros+uncased_-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros+uncased_-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros+uncased_-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros+uncased_-devel}"
SRC_URI[x86_64_v2_rust-phf_macros+uncased_-devel.sha256sum] = "955cf3acaa44cd9429805d612dfb634ab2c7a8655dfd9d91cf46d71d4acb2127"

URI_x86_64_v2_rust-phf_macros+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros+unicase-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros+unicase-devel}"
SRC_URI[x86_64_v2_rust-phf_macros+unicase-devel.sha256sum] = "5d07e8eab89f283d29d4e43c3eb6a28d185b08ddf64464af8debe8807ec5eb18"

URI_x86_64_v2_rust-phf_macros+unicase_-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros+unicase_-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros+unicase_-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros+unicase_-devel}"
SRC_URI[x86_64_v2_rust-phf_macros+unicase_-devel.sha256sum] = "3b8ef82234ae2f31955833a648dba5224912850d896defe4cdd1fde6b8a31a63"

URI_x86_64_v2_rust-phf_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros-devel}"
SRC_URI[x86_64_v2_rust-phf_macros-devel.sha256sum] = "77b48cbd7cbe1a05f05bce25f25d21baf2bfba766fbfa9327d48a28d5b8e665c"

URI_aarch64_rust-phf_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros+default-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros+default-devel}"
SRC_URI[aarch64_rust-phf_macros+default-devel.sha256sum] = "e71a58bb5da6aae218eb7e802f24649d5cd9220e820b316f8a9df51754c0261c"

URI_aarch64_rust-phf_macros+uncased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros+uncased-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf_macros+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros+uncased-devel}"
SRC_URI[aarch64_rust-phf_macros+uncased-devel.sha256sum] = "77414379ae752eb3f437c776fbbfd707e571d01ab3f86402d881c86bcc76cd62"

URI_aarch64_rust-phf_macros+uncased_-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros+uncased_-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf_macros+uncased_-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros+uncased_-devel}"
SRC_URI[aarch64_rust-phf_macros+uncased_-devel.sha256sum] = "51fce9408634ef7f7033e03c21f674f7c2824168548862606ec2b23ba948a9ac"

URI_aarch64_rust-phf_macros+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros+unicase-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf_macros+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros+unicase-devel}"
SRC_URI[aarch64_rust-phf_macros+unicase-devel.sha256sum] = "49efc0fd6bea3808c046999cabb06fa80ee6d125e1c4ba1909d7cd2e66b4aa42"

URI_aarch64_rust-phf_macros+unicase_-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros+unicase_-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf_macros+unicase_-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros+unicase_-devel}"
SRC_URI[aarch64_rust-phf_macros+unicase_-devel.sha256sum] = "5baf0f9127a78a88c80df923a7ad7c34ff22938db3bae8754dc3ea2d1e542d6e"

URI_aarch64_rust-phf_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros-devel}"
SRC_URI[aarch64_rust-phf_macros-devel.sha256sum] = "df5a6ccd6f691f0159b17c9ce9048015c5158f174473e4209b68081418e0a864"

RDEPENDS:rust-phf_macros+default-devel = " \
 cargo \
 rust-phf_macros-devel \
 "
RDEPENDS:rust-phf_macros+uncased-devel = " \
 cargo \
 rust-phf_macros+uncased_-devel \
 rust-phf_macros-devel \
 rust-phf_shared+uncased-devel \
 "
RDEPENDS:rust-phf_macros+uncased_-devel = " \
 cargo \
 rust-phf_macros-devel \
 rust-uncased+default-devel \
 "
RDEPENDS:rust-phf_macros+unicase-devel = " \
 cargo \
 rust-phf_macros+unicase_-devel \
 rust-phf_macros-devel \
 rust-phf_shared+unicase-devel \
 "
RDEPENDS:rust-phf_macros+unicase_-devel = " \
 cargo \
 rust-phf_macros-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-phf_macros-devel = " \
 cargo \
 rust \
 rust-phf_generator+default-devel \
 rust-phf_shared-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
