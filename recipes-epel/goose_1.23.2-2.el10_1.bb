# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "goose"
PV = "1.23.2"
PR = "2.el10_1"
PACKAGES = " \
 goose \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/goose-1.23.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8ca08ee2d9d3e4976260dab4dee03bdfb4508be7d5ba5fa0213444b39a1bc12"

URI_x86_64_v2_goose = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/goose-1.23.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_goose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_goose}"
SRC_URI[x86_64_v2_goose.sha256sum] = "bcfe29b93d5a9c68bf2bfd4e0eccf5b32b70c22f772e47481ea01671453e3a2c"

URI_aarch64_goose = "${EPEL_MIRROR}/aarch64/Packages/g/goose-1.23.2-2.el10_1.aarch64.rpm;name=aarch64_goose;unpack=0"
SRC_URI:append = " ${URI_aarch64_goose}"
SRC_URI[aarch64_goose.sha256sum] = "8b34e714eda4ab1341c0d5957ca31e0b2e36f9cecbc57e91b73709aabf99dd54"

RDEPENDS:goose = " \
 bzip2-libs \
 dbus-libs \
 glibc \
 libgcc \
 libxcb \
 libzstd \
 oniguruma \
 openssl-libs \
 sqlite-libs \
 zlib-ng-compat \
 "
