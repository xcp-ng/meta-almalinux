# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap-verbosity-flag"
PV = "3.0.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-clap-verbosity-flag+default-devel \
 rust-clap-verbosity-flag+log-devel \
 rust-clap-verbosity-flag+serde-devel \
 rust-clap-verbosity-flag+tracing-devel \
 rust-clap-verbosity-flag-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap-verbosity-flag-3.0.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a924db03597aa46615d14977043be8872af8e9d41ed58848ee7a0d1d56ac7ec2"

URI_x86_64_v2_rust-clap-verbosity-flag+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-verbosity-flag+default-devel-3.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-verbosity-flag+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-verbosity-flag+default-devel}"
SRC_URI[x86_64_v2_rust-clap-verbosity-flag+default-devel.sha256sum] = "da2cd4c5acaf05aa63d73bccbf04c5feda1d3934192eeee268510bd7f59d62c0"

URI_x86_64_v2_rust-clap-verbosity-flag+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-verbosity-flag+log-devel-3.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-verbosity-flag+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-verbosity-flag+log-devel}"
SRC_URI[x86_64_v2_rust-clap-verbosity-flag+log-devel.sha256sum] = "6a5ad3e9b56c2e246030aa22aa18a0b05b866fdfef534cc5940380bbcc80628b"

URI_x86_64_v2_rust-clap-verbosity-flag+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-verbosity-flag+serde-devel-3.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-verbosity-flag+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-verbosity-flag+serde-devel}"
SRC_URI[x86_64_v2_rust-clap-verbosity-flag+serde-devel.sha256sum] = "bf8dc35b6e7063212a1dac44bbcf0003159340b50a0c43a90e4e39c2620a54b1"

URI_x86_64_v2_rust-clap-verbosity-flag+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-verbosity-flag+tracing-devel-3.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-verbosity-flag+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-verbosity-flag+tracing-devel}"
SRC_URI[x86_64_v2_rust-clap-verbosity-flag+tracing-devel.sha256sum] = "c2ef11c18753e0a9740cdd017362125f7f3c690c78d8a50e383040e4337e2c1a"

URI_x86_64_v2_rust-clap-verbosity-flag-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-verbosity-flag-devel-3.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-verbosity-flag-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-verbosity-flag-devel}"
SRC_URI[x86_64_v2_rust-clap-verbosity-flag-devel.sha256sum] = "4b5461ea6554d1f688f821fbbdfae9cc89004555637989bec41432581e539dc1"

URI_aarch64_rust-clap-verbosity-flag+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-verbosity-flag+default-devel-3.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-clap-verbosity-flag+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-verbosity-flag+default-devel}"
SRC_URI[aarch64_rust-clap-verbosity-flag+default-devel.sha256sum] = "5c3657bb3db7a09892ed43496764f12abcf98d2bc0ae28693fbeefa5a9106a7c"

URI_aarch64_rust-clap-verbosity-flag+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-verbosity-flag+log-devel-3.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-clap-verbosity-flag+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-verbosity-flag+log-devel}"
SRC_URI[aarch64_rust-clap-verbosity-flag+log-devel.sha256sum] = "7cd9cb002b08d4808c81248442a93867268c35d3b75242bd8c176f2ee604d62d"

URI_aarch64_rust-clap-verbosity-flag+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-verbosity-flag+serde-devel-3.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-clap-verbosity-flag+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-verbosity-flag+serde-devel}"
SRC_URI[aarch64_rust-clap-verbosity-flag+serde-devel.sha256sum] = "84b4723b4cf1f74aba875f212feb0acebd4fabd82a24a0d59303d883bb143225"

URI_aarch64_rust-clap-verbosity-flag+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-verbosity-flag+tracing-devel-3.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-clap-verbosity-flag+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-verbosity-flag+tracing-devel}"
SRC_URI[aarch64_rust-clap-verbosity-flag+tracing-devel.sha256sum] = "27fc46a76851b7ab93f214bbf9d21daaa8d4f00b429836da6b314f963371ed05"

URI_aarch64_rust-clap-verbosity-flag-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-verbosity-flag-devel-3.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-clap-verbosity-flag-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-verbosity-flag-devel}"
SRC_URI[aarch64_rust-clap-verbosity-flag-devel.sha256sum] = "ddf9a50b62bb3a5e5bc8015c901226b63b7718e0e9bf517f269715f3e74cb878"

RDEPENDS:rust-clap-verbosity-flag+default-devel = " \
 cargo \
 rust-clap-verbosity-flag+log-devel \
 rust-clap-verbosity-flag-devel \
 "
RDEPENDS:rust-clap-verbosity-flag+log-devel = " \
 cargo \
 rust-clap-verbosity-flag-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-clap-verbosity-flag+serde-devel = " \
 cargo \
 rust-clap-verbosity-flag-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-clap-verbosity-flag+tracing-devel = " \
 cargo \
 rust-clap-verbosity-flag-devel \
 rust-tracing-core+default-devel \
 "
RDEPENDS:rust-clap-verbosity-flag-devel = " \
 cargo \
 rust \
 rust-clap+derive-devel \
 rust-clap+std-devel \
 rust-clap-devel \
 "
