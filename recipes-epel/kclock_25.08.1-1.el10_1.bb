# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kclock"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kclock \
 kclock-plasma-applet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kclock-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c168ccadcd17e2dc44eaa8f9ef478b545252b82528f7f14497bd2e40dc14486c"

URI_x86_64_v2_kclock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kclock-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kclock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kclock}"
SRC_URI[x86_64_v2_kclock.sha256sum] = "433a98fddff2b1c1f1fecc11a6dc0173b75cd70943f7f2ff2f2d2bd60791fbc2"

URI_x86_64_v2_kclock-plasma-applet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kclock-plasma-applet-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kclock-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kclock-plasma-applet}"
SRC_URI[x86_64_v2_kclock-plasma-applet.sha256sum] = "8e8b75882eafd420104f49e03d6ccba27e54caa15e7f51da9243dbbf88199f4e"

URI_aarch64_kclock = "${EPEL_MIRROR}/aarch64/Packages/k/kclock-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kclock;unpack=0"
SRC_URI:append = " ${URI_aarch64_kclock}"
SRC_URI[aarch64_kclock.sha256sum] = "48106a9b593cd1700445235f0e9ea5385a110adea139166e21c5fca03c33f8a2"

URI_aarch64_kclock-plasma-applet = "${EPEL_MIRROR}/aarch64/Packages/k/kclock-plasma-applet-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kclock-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kclock-plasma-applet}"
SRC_URI[aarch64_kclock-plasma-applet.sha256sum] = "9b5e6d6b4b5d3666312322e852de0bccf83e6121ba3e5cee33b6c9b45c0def25"

RDEPENDS:kclock = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-ksvg \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
RDEPENDS:kclock-plasma-applet = " \
 glibc \
 kclock \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-kservice \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 "
