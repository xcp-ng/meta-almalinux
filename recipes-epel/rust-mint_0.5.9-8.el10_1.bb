# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mint"
PV = "0.5.9"
PR = "8.el10_1"
PACKAGES = " \
 rust-mint+default-devel \
 rust-mint+serde-devel \
 rust-mint-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mint-0.5.9-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c1abb140a0ec43f2d46c22b5b6d10a26e81b37207ef6b446b91f457a9e41d68"

URI_x86_64_v2_rust-mint+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mint+default-devel-0.5.9-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mint+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mint+default-devel}"
SRC_URI[x86_64_v2_rust-mint+default-devel.sha256sum] = "2114e22f3bf7ea99cac640d797b429e586c6142166fc5b29588cbe6a3fc48f02"

URI_x86_64_v2_rust-mint+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mint+serde-devel-0.5.9-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mint+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mint+serde-devel}"
SRC_URI[x86_64_v2_rust-mint+serde-devel.sha256sum] = "f2ab84000efd9f234a612369aeb65589bca683e469c13a2e4e23a8058600cf1f"

URI_x86_64_v2_rust-mint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mint-devel-0.5.9-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mint-devel}"
SRC_URI[x86_64_v2_rust-mint-devel.sha256sum] = "a50a1df55684c2f75b1090241e9fa9b1cc776028dc63974c596053d1ef3a3177"

URI_aarch64_rust-mint+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mint+default-devel-0.5.9-8.el10_1.noarch.rpm;name=aarch64_rust-mint+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mint+default-devel}"
SRC_URI[aarch64_rust-mint+default-devel.sha256sum] = "61570385a111471c54085e3d212c0a30d64b1a1bd21a8a1a63a232746202edff"

URI_aarch64_rust-mint+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mint+serde-devel-0.5.9-8.el10_1.noarch.rpm;name=aarch64_rust-mint+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mint+serde-devel}"
SRC_URI[aarch64_rust-mint+serde-devel.sha256sum] = "72ca3b0a83f9cf472a796eba78446da6b77fa87a5375c8333b0636c3cd7b3ee1"

URI_aarch64_rust-mint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mint-devel-0.5.9-8.el10_1.noarch.rpm;name=aarch64_rust-mint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mint-devel}"
SRC_URI[aarch64_rust-mint-devel.sha256sum] = "a3ca36a0988fddd4b005e0b316ffeee6161f0453ec0ebebd4b7306a2be19b3f6"

RDEPENDS:rust-mint+default-devel = " \
 cargo \
 rust-mint-devel \
 "
RDEPENDS:rust-mint+serde-devel = " \
 cargo \
 rust-mint-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-mint-devel = " \
 cargo \
 "
