# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Image-PNG-Libpng"
PV = "0.60"
PR = "1.el10_3"
PACKAGES = " \
 perl-Image-PNG-Libpng \
 perl-Image-PNG-Libpng-tests \
 perl-Image-PNG-Libpng-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Image-PNG-Libpng-0.60-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c1100c26bf38764c4624dd20c46b256a5c249ef70524df323d9e3c19cd831f6"

URI_x86_64_v2_perl-Image-PNG-Libpng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-PNG-Libpng-0.60-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Image-PNG-Libpng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-PNG-Libpng}"
SRC_URI[x86_64_v2_perl-Image-PNG-Libpng.sha256sum] = "8c6f453ce0b217ee80d05013389f1ae35166cc0fb6c020f1eba7b45456d0a036"

URI_x86_64_v2_perl-Image-PNG-Libpng-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-PNG-Libpng-tests-0.60-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Image-PNG-Libpng-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-PNG-Libpng-tests}"
SRC_URI[x86_64_v2_perl-Image-PNG-Libpng-tests.sha256sum] = "d5aecd78ac2f480974ee5e1b68553c7836917151ece61c7f165ca3c48c2eb495"

URI_x86_64_v2_perl-Image-PNG-Libpng-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-PNG-Libpng-tools-0.60-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Image-PNG-Libpng-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-PNG-Libpng-tools}"
SRC_URI[x86_64_v2_perl-Image-PNG-Libpng-tools.sha256sum] = "c921d01ac4246c21a28798e880c04d14128a9d500c6df8f2c47f0f5c09542406"

URI_aarch64_perl-Image-PNG-Libpng = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-PNG-Libpng-0.60-1.el10_3.aarch64.rpm;name=aarch64_perl-Image-PNG-Libpng;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-PNG-Libpng}"
SRC_URI[aarch64_perl-Image-PNG-Libpng.sha256sum] = "f5ddf0dd3c6dcf084ffc4a9325ab2cb1dfea0c7c491325c5498b3807bd32a6b1"

URI_aarch64_perl-Image-PNG-Libpng-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-PNG-Libpng-tests-0.60-1.el10_3.noarch.rpm;name=aarch64_perl-Image-PNG-Libpng-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-PNG-Libpng-tests}"
SRC_URI[aarch64_perl-Image-PNG-Libpng-tests.sha256sum] = "b7a9ff39e3278a14685937b4ec069e66c31de545ebd9efcc226840ea43e9fafc"

URI_aarch64_perl-Image-PNG-Libpng-tools = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-PNG-Libpng-tools-0.60-1.el10_3.noarch.rpm;name=aarch64_perl-Image-PNG-Libpng-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-PNG-Libpng-tools}"
SRC_URI[aarch64_perl-Image-PNG-Libpng-tools.sha256sum] = "48c9ab407c9dd410469a2acff0a8caafa432ec092114bb6bb9a0da12778bf1cd"

RDEPENDS:perl-Image-PNG-Libpng = " \
 glibc \
 libpng \
 perl-Carp \
 perl-Exporter \
 perl-Image-PNG-Libpng \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Image-PNG-Libpng-tests = " \
 bash \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Compare \
 perl-FindBin \
 perl-Image-PNG-Libpng \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-lib \
 perl-libs \
 virtual/coreutils \
 "
RDEPENDS:perl-Image-PNG-Libpng-tools = " \
 perl-Data-Dumper \
 perl-Getopt-Long \
 perl-Image-PNG-Libpng \
 perl-interpreter \
 perl-libs \
 "
