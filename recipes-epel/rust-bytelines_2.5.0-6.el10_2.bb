# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytelines"
PV = "2.5.0"
PR = "6.el10_2"
PACKAGES = " \
 rust-bytelines+default-devel \
 rust-bytelines+futures-util-devel \
 rust-bytelines+tokio-devel \
 rust-bytelines-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytelines-2.5.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2902305ac8d241c44c0e24b7d9a81ed1c2c72ea191626ffddd5d67713d681c38"

URI_x86_64_v2_rust-bytelines+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytelines+default-devel-2.5.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytelines+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytelines+default-devel}"
SRC_URI[x86_64_v2_rust-bytelines+default-devel.sha256sum] = "90945bca56df0e093388a5437510e6ba81f408e536cc807be4176f8f1fcfa5a5"

URI_x86_64_v2_rust-bytelines+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytelines+futures-util-devel-2.5.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytelines+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytelines+futures-util-devel}"
SRC_URI[x86_64_v2_rust-bytelines+futures-util-devel.sha256sum] = "28975315e9a445133d10f5ce8fdf40cbe2d7bd7cf294d3da52d62d1dfe98ff0d"

URI_x86_64_v2_rust-bytelines+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytelines+tokio-devel-2.5.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytelines+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytelines+tokio-devel}"
SRC_URI[x86_64_v2_rust-bytelines+tokio-devel.sha256sum] = "e4ac1c9a7f806056dcddacd6a7fa812128da5fb767197c9af4b2550e85622ef1"

URI_x86_64_v2_rust-bytelines-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytelines-devel-2.5.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytelines-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytelines-devel}"
SRC_URI[x86_64_v2_rust-bytelines-devel.sha256sum] = "964c9d7439bb7cf19295098b981ebf101d11e146591de874cc8894430b8a5016"

URI_aarch64_rust-bytelines+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytelines+default-devel-2.5.0-6.el10_2.noarch.rpm;name=aarch64_rust-bytelines+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytelines+default-devel}"
SRC_URI[aarch64_rust-bytelines+default-devel.sha256sum] = "0e24d4360a6f980bbd7ee985e3ef801e2531b268c2a1cddcb8b601e2ae5096a8"

URI_aarch64_rust-bytelines+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytelines+futures-util-devel-2.5.0-6.el10_2.noarch.rpm;name=aarch64_rust-bytelines+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytelines+futures-util-devel}"
SRC_URI[aarch64_rust-bytelines+futures-util-devel.sha256sum] = "35b89c8cad8aca7a757a26b3eeb4b6e96de80cbd2ac7f8794fc0be588724ca0d"

URI_aarch64_rust-bytelines+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytelines+tokio-devel-2.5.0-6.el10_2.noarch.rpm;name=aarch64_rust-bytelines+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytelines+tokio-devel}"
SRC_URI[aarch64_rust-bytelines+tokio-devel.sha256sum] = "3e7b60d34a443f5f59f0258966287425d593d67a3d40685d231476cc31533559"

URI_aarch64_rust-bytelines-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytelines-devel-2.5.0-6.el10_2.noarch.rpm;name=aarch64_rust-bytelines-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytelines-devel}"
SRC_URI[aarch64_rust-bytelines-devel.sha256sum] = "6d0ce6272c8c577b99264b26a5704d6da450942d614d89dc1b511abfedd0a842"

RDEPENDS:rust-bytelines+default-devel = " \
 cargo \
 rust-bytelines+tokio-devel \
 rust-bytelines-devel \
 "
RDEPENDS:rust-bytelines+futures-util-devel = " \
 cargo \
 rust-bytelines-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-bytelines+tokio-devel = " \
 cargo \
 rust-bytelines+futures-util-devel \
 rust-bytelines-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 "
RDEPENDS:rust-bytelines-devel = " \
 cargo \
 "
