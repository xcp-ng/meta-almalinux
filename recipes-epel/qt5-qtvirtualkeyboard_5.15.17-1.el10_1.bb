# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtvirtualkeyboard"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtvirtualkeyboard \
 qt5-qtvirtualkeyboard-devel \
 qt5-qtvirtualkeyboard-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtvirtualkeyboard-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc100d7b5e00c7c71c755ea00574c9d7af22f709c439dc8c48c0a75e80a56d17"

URI_x86_64_v2_qt5-qtvirtualkeyboard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtvirtualkeyboard-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtvirtualkeyboard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtvirtualkeyboard}"
SRC_URI[x86_64_v2_qt5-qtvirtualkeyboard.sha256sum] = "9e6c5108887a3d906e7e570013e1b71704b042125b8e75d8d37c01d42b5330bb"

URI_x86_64_v2_qt5-qtvirtualkeyboard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtvirtualkeyboard-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtvirtualkeyboard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtvirtualkeyboard-devel}"
SRC_URI[x86_64_v2_qt5-qtvirtualkeyboard-devel.sha256sum] = "2d55afb6f812bfcded20400e367fb2799e121827d7cc86359c9f950f33dcd3f8"

URI_x86_64_v2_qt5-qtvirtualkeyboard-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtvirtualkeyboard-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtvirtualkeyboard-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtvirtualkeyboard-examples}"
SRC_URI[x86_64_v2_qt5-qtvirtualkeyboard-examples.sha256sum] = "c60c2be54d7316c6643c334eaa59f3451771f134cab252887e074c0b8c515115"

URI_aarch64_qt5-qtvirtualkeyboard = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtvirtualkeyboard-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtvirtualkeyboard;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtvirtualkeyboard}"
SRC_URI[aarch64_qt5-qtvirtualkeyboard.sha256sum] = "9f0d6c4e2c2e2c57c60d8998358462549eaadc52587b3ad2bfcb2d65afaea9ac"

URI_aarch64_qt5-qtvirtualkeyboard-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtvirtualkeyboard-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtvirtualkeyboard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtvirtualkeyboard-devel}"
SRC_URI[aarch64_qt5-qtvirtualkeyboard-devel.sha256sum] = "9c3665c7435568db365a2d849996d42bb4ed302ebf9e98df0cb22e7cea8d0ad8"

URI_aarch64_qt5-qtvirtualkeyboard-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtvirtualkeyboard-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtvirtualkeyboard-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtvirtualkeyboard-examples}"
SRC_URI[aarch64_qt5-qtvirtualkeyboard-examples.sha256sum] = "b56d661e8e99dd69fbe2e2463b7cde01362b76fcecdd942672bf1a97c354f769"

RDEPENDS:qt5-qtvirtualkeyboard = " \
 glibc \
 hunspell \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtsvg \
 "
RDEPENDS:qt5-qtvirtualkeyboard-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtvirtualkeyboard \
 "
RDEPENDS:qt5-qtvirtualkeyboard-examples = " \
 qt5-qtvirtualkeyboard \
 "
