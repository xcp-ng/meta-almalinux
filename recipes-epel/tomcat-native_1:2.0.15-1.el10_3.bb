# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomcat-native"
PE = "1"
PV = "2.0.15"
PR = "1.el10_3"
PACKAGES = " \
 tomcat-native \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tomcat-native-2.0.15-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fe733e1a8cd9e3e5802752c3fc07c6cf7fb9392b5ee5f0e1a8cbaa8c33a6a608"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tomcat-native-2.0.15-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tomcat-native;unpack=0"
SRC_URI[x86_64_v2_tomcat-native.sha256sum] = "89da91dbb1056b7e1b5652e9cf249c0f53ac78b2a64d83ac8922672e196e0d29"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tomcat-native-2.0.15-1.el10_3.aarch64.rpm;name=aarch64_tomcat-native;unpack=0"
SRC_URI[aarch64_tomcat-native.sha256sum] = "d84335f28ea747eeb04781ec81eb22747d4d447e9c0fb6ec9b25e8f26ae5de50"

RDEPENDS:tomcat-native = " \
 apr \
 glibc \
 openssl-libs \
 "
