# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mpdecimal"
PV = "2.5.1"
PR = "12.el10"
PACKAGES = " \
 mpdecimal \
 mpdecimal++ \
 mpdecimal-devel \
 mpdecimal-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mpdecimal-2.5.1-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1abd6c3e4105dff43e12d21f549ec4aff74088094370bb784dc926937b1e9da4"

URI_x86_64_v2_mpdecimal = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mpdecimal-2.5.1-12.el10.x86_64_v2.rpm;name=x86_64_v2_mpdecimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpdecimal}"
SRC_URI[x86_64_v2_mpdecimal.sha256sum] = "1e21e561aadc58c12e8382792f6273b8c86ebf43ccfca0216ef5866b6cf29398"

URI_x86_64_v2_mpdecimal++ = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mpdecimal++-2.5.1-12.el10.x86_64_v2.rpm;name=x86_64_v2_mpdecimal++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpdecimal++}"
SRC_URI[x86_64_v2_mpdecimal++.sha256sum] = "ae7ae17372877aed114cbdd2774d5c78374534f65e537834daee7e27bbab08e8"

URI_x86_64_v2_mpdecimal-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mpdecimal-devel-2.5.1-12.el10.x86_64_v2.rpm;name=x86_64_v2_mpdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpdecimal-devel}"
SRC_URI[x86_64_v2_mpdecimal-devel.sha256sum] = "28246d169c0b1846569fceb4c0da7b334b8632db359607f80d08bb0fdf1d2ba9"

URI_x86_64_v2_mpdecimal-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mpdecimal-doc-2.5.1-12.el10.noarch.rpm;name=x86_64_v2_mpdecimal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpdecimal-doc}"
SRC_URI[x86_64_v2_mpdecimal-doc.sha256sum] = "34f65f4c3c1c6a0c4c74ff72de5a0fc896d51fb628dca9a94664b569b1c53b1b"

URI_aarch64_mpdecimal = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mpdecimal-2.5.1-12.el10.aarch64.rpm;name=aarch64_mpdecimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpdecimal}"
SRC_URI[aarch64_mpdecimal.sha256sum] = "b9e107d2b85558e37a77e832200c3235c0c2e902c121f60450141fdaadd77d15"

URI_aarch64_mpdecimal++ = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mpdecimal++-2.5.1-12.el10.aarch64.rpm;name=aarch64_mpdecimal++;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpdecimal++}"
SRC_URI[aarch64_mpdecimal++.sha256sum] = "acc69969691920cd3df2a16185dc0e77e2291b0777bf51b0a30ede5f9dba7f45"

URI_aarch64_mpdecimal-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mpdecimal-devel-2.5.1-12.el10.aarch64.rpm;name=aarch64_mpdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpdecimal-devel}"
SRC_URI[aarch64_mpdecimal-devel.sha256sum] = "46892edad7cb3f7ba372198ebed658a56760742c0cbcff2cb40204aba7c2ffb7"

URI_aarch64_mpdecimal-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mpdecimal-doc-2.5.1-12.el10.noarch.rpm;name=aarch64_mpdecimal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpdecimal-doc}"
SRC_URI[aarch64_mpdecimal-doc.sha256sum] = "34f65f4c3c1c6a0c4c74ff72de5a0fc896d51fb628dca9a94664b569b1c53b1b"

RDEPENDS:mpdecimal = " \
 glibc \
 "
RDEPENDS:mpdecimal++ = " \
 glibc \
 libgcc \
 libstdc++ \
 mpdecimal \
 "
RDEPENDS:mpdecimal-devel = " \
 mpdecimal \
 mpdecimal++ \
 "
RDEPENDS:mpdecimal-doc = " \
 "
