# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-blivet"
PE = "1"
PV = "3.13.0"
PR = "5.el10.alma.1"
PACKAGES = " \
 blivet-data \
 python3-blivet \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-blivet-3.13.0-5.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a235ca2e25965d789900b01d322e77f366aa8c2cbe778a9da20ce323d76e62ae"

URI_x86_64_v2_blivet-data = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/blivet-data-3.13.0-5.el10.alma.1.noarch.rpm;name=x86_64_v2_blivet-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blivet-data}"
SRC_URI[x86_64_v2_blivet-data.sha256sum] = "4d6fde0a32e423dac20cb5a1e9d3edd445c441faa8e9299d25e067375c63504a"

URI_x86_64_v2_python3-blivet = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-blivet-3.13.0-5.el10.alma.1.noarch.rpm;name=x86_64_v2_python3-blivet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-blivet}"
SRC_URI[x86_64_v2_python3-blivet.sha256sum] = "0af90b3a040a63feaece69ecdc313bdc198d97a1e15f76e077b3431ec854d868"

URI_aarch64_blivet-data = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/blivet-data-3.13.0-5.el10.alma.1.noarch.rpm;name=aarch64_blivet-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_blivet-data}"
SRC_URI[aarch64_blivet-data.sha256sum] = "4d6fde0a32e423dac20cb5a1e9d3edd445c441faa8e9299d25e067375c63504a"

URI_aarch64_python3-blivet = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-blivet-3.13.0-5.el10.alma.1.noarch.rpm;name=aarch64_python3-blivet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-blivet}"
SRC_URI[aarch64_python3-blivet.sha256sum] = "0af90b3a040a63feaece69ecdc313bdc198d97a1e15f76e077b3431ec854d868"

RDEPENDS:blivet-data = " \
 python3 \
 "
RDEPENDS:python3-blivet = " \
 blivet-data \
 lsof \
 parted \
 python3 \
 python3-blockdev \
 python3-bytesize \
 python3-dasbus \
 python3-gobject-base \
 python3-libmount \
 python3-libselinux \
 python3-pyparted \
 python3-pyudev \
 systemd-udev \
 util-linux \
 "
