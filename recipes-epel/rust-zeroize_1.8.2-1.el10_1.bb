# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zeroize"
PV = "1.8.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-zeroize+aarch64-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize+default-devel \
 rust-zeroize+derive-devel \
 rust-zeroize+serde-devel \
 rust-zeroize+simd-devel \
 rust-zeroize+std-devel \
 rust-zeroize+zeroize_derive-devel \
 rust-zeroize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zeroize-1.8.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f8dd70f8cc7f1bb6569124031793c2e85bc0254ce84dc21b88640d04cf102a8"

URI_x86_64_v2_rust-zeroize+aarch64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+aarch64-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+aarch64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+aarch64-devel}"
SRC_URI[x86_64_v2_rust-zeroize+aarch64-devel.sha256sum] = "0cb9c3bef71803dcf90e9c6c8fe4e5b13e4d4a2a3ffd2c464d3d1d944ed41879"

URI_x86_64_v2_rust-zeroize+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+alloc-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+alloc-devel}"
SRC_URI[x86_64_v2_rust-zeroize+alloc-devel.sha256sum] = "be01bc7bf1f88afe3ac32958b3167e61fa881132d13bd0f6e7b017a24a222b27"

URI_x86_64_v2_rust-zeroize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+default-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+default-devel}"
SRC_URI[x86_64_v2_rust-zeroize+default-devel.sha256sum] = "658264b373576ba5747ea6cac560a7eedfd6482c9907446b8d120e5161d2be0a"

URI_x86_64_v2_rust-zeroize+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+derive-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+derive-devel}"
SRC_URI[x86_64_v2_rust-zeroize+derive-devel.sha256sum] = "a1fc5456d858c9853065742c1cb28599041cd1b2f09e79ea5f0260d46dc68151"

URI_x86_64_v2_rust-zeroize+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+serde-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+serde-devel}"
SRC_URI[x86_64_v2_rust-zeroize+serde-devel.sha256sum] = "1d8695402511c72ca436ee25d12d2dce15346131d3b8e4e61a13c0c895326e4f"

URI_x86_64_v2_rust-zeroize+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+simd-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+simd-devel}"
SRC_URI[x86_64_v2_rust-zeroize+simd-devel.sha256sum] = "0f266839f817767a1ec8b2d8ddf00d94731cc7e0b7ca055f81fe14701ed54b5f"

URI_x86_64_v2_rust-zeroize+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+std-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+std-devel}"
SRC_URI[x86_64_v2_rust-zeroize+std-devel.sha256sum] = "fef97a3411016b9c230fe994a3a96a816499a97ecae284f50663f6beaf04fbc3"

URI_x86_64_v2_rust-zeroize+zeroize_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+zeroize_derive-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+zeroize_derive-devel}"
SRC_URI[x86_64_v2_rust-zeroize+zeroize_derive-devel.sha256sum] = "2f1a7c3e463352350cda2c29b922dc5f9860a86a018095935314f92fc33f34c0"

URI_x86_64_v2_rust-zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize-devel}"
SRC_URI[x86_64_v2_rust-zeroize-devel.sha256sum] = "c343dd6e96f9ebcf6ea6a005b17213567ee91c2c12bdc07cad01209311b85de6"

URI_aarch64_rust-zeroize+aarch64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+aarch64-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-zeroize+aarch64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+aarch64-devel}"
SRC_URI[aarch64_rust-zeroize+aarch64-devel.sha256sum] = "7334e91ef99f68502a2e0ea3b922ee398e7b7817b80c2e6a983567a08a7a6410"

URI_aarch64_rust-zeroize+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+alloc-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-zeroize+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+alloc-devel}"
SRC_URI[aarch64_rust-zeroize+alloc-devel.sha256sum] = "028ed2d54a85afa291b226219fb230735639d76e76f6b4fcd5e6edfea6f0b9fe"

URI_aarch64_rust-zeroize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+default-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-zeroize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+default-devel}"
SRC_URI[aarch64_rust-zeroize+default-devel.sha256sum] = "41a5bf4711aa696a3c653d746674b06bd3a9f2be4a5ea64cf6263cf07eb8261d"

URI_aarch64_rust-zeroize+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+derive-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-zeroize+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+derive-devel}"
SRC_URI[aarch64_rust-zeroize+derive-devel.sha256sum] = "d4552088e5403679e73661ace342421a861152959e929d6d7f730644ec5f1451"

URI_aarch64_rust-zeroize+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+serde-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-zeroize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+serde-devel}"
SRC_URI[aarch64_rust-zeroize+serde-devel.sha256sum] = "6a6020d12a79f118fa5f8efe464fa32262348e74bb25cf6e0349c007ab12f34e"

URI_aarch64_rust-zeroize+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+simd-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-zeroize+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+simd-devel}"
SRC_URI[aarch64_rust-zeroize+simd-devel.sha256sum] = "53bafdb05de0b44599c1e249188d90ecc9600cfb470c8f07c5dab0613f1165dd"

URI_aarch64_rust-zeroize+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+std-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-zeroize+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+std-devel}"
SRC_URI[aarch64_rust-zeroize+std-devel.sha256sum] = "a2caf30336221979c9820f1c016cd640254adacfc0689353d704d09fa37ae512"

URI_aarch64_rust-zeroize+zeroize_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+zeroize_derive-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-zeroize+zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+zeroize_derive-devel}"
SRC_URI[aarch64_rust-zeroize+zeroize_derive-devel.sha256sum] = "04ae3afc2f5dcc6b8b66df1641c850a8999d59de18163b75f00e8f2363f1a17b"

URI_aarch64_rust-zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize-devel}"
SRC_URI[aarch64_rust-zeroize-devel.sha256sum] = "b3d324efe933f9d8eebf1b29e2fc4b1adbca4dff1d1ee3702a7e33a1b7a2732a"

RDEPENDS:rust-zeroize+aarch64-devel = " \
 cargo \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+alloc-devel = " \
 cargo \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+default-devel = " \
 cargo \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+derive-devel = " \
 cargo \
 rust-zeroize+zeroize_derive-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+simd-devel = " \
 cargo \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+std-devel = " \
 cargo \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+zeroize_derive-devel = " \
 cargo \
 rust-zeroize-devel \
 rust-zeroize_derive+default-devel \
 "
RDEPENDS:rust-zeroize-devel = " \
 cargo \
 rust \
 "
