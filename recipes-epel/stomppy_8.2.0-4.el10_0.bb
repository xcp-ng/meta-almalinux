# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stomppy"
PV = "8.2.0"
PR = "4.el10_0"
PACKAGES = " \
 python3-stomppy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stomppy-8.2.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbd9914e40a217ad0a15ebcb3471ca7a25790131a5b8412305386b4a42c73922"

URI_x86_64_v2_python3-stomppy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-stomppy-8.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-stomppy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-stomppy}"
SRC_URI[x86_64_v2_python3-stomppy.sha256sum] = "82c16d265c341d2773a4a53e88fb0fe0a30743b1200ac3efb29d4f6634a35dc6"

URI_aarch64_python3-stomppy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-stomppy-8.2.0-4.el10_0.noarch.rpm;name=aarch64_python3-stomppy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-stomppy}"
SRC_URI[aarch64_python3-stomppy.sha256sum] = "f21f7c60babf313a6dcc35c2219394441d91aa41e35b7a60d31789c29e61bcd3"

RDEPENDS:python3-stomppy = " \
 python3 \
 python3-docopt \
 python3-websocket-client \
 "
