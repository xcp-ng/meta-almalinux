# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-scikit-learn"
PV = "1.6.1"
PR = "3.el10_1"
PACKAGES = " \
 python3-scikit-learn \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-scikit-learn-1.6.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6aee6384901dd34d764b67cf0efebb4d6b0a6380409e5f3ce224f6d71b6f3bcb"

URI_x86_64_v2_python3-scikit-learn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-scikit-learn-1.6.1-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-scikit-learn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-scikit-learn}"
SRC_URI[x86_64_v2_python3-scikit-learn.sha256sum] = "e1a4576b6bc8cf3ebf1ccee8822d4f608e01aeaa65209e538b1ee747c4454b3a"

URI_aarch64_python3-scikit-learn = "${EPEL_MIRROR}/aarch64/Packages/p/python3-scikit-learn-1.6.1-3.el10_1.aarch64.rpm;name=aarch64_python3-scikit-learn;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-scikit-learn}"
SRC_URI[aarch64_python3-scikit-learn.sha256sum] = "916ad7682d88ea12dfa2dfe2561e64ec904c8d6a29d60dadbc89043fc6d0cc8a"

RDEPENDS:python3-scikit-learn = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 python3 \
 python3-joblib \
 python3-numpy \
 python3-scipy \
 python3-threadpoolctl \
 "
