# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netatalk"
PE = "5"
PV = "4.1.2"
PR = "2.el10_1"
PACKAGES = " \
 netatalk \
 netatalk-afptest \
 netatalk-devel \
 netatalk-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netatalk-4.1.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "368e8c81d9f8b41a6f4c3a1e389c13cf17fcd6a7fe83b6e76b4dfda45ff408ae"

URI_x86_64_v2_netatalk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-4.1.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netatalk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netatalk}"
SRC_URI[x86_64_v2_netatalk.sha256sum] = "2dcc2e9b981c2b66af3b5d2367a1a3744df34ea3ef325e2dbd1be316f84d1987"

URI_x86_64_v2_netatalk-afptest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-afptest-4.1.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netatalk-afptest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netatalk-afptest}"
SRC_URI[x86_64_v2_netatalk-afptest.sha256sum] = "14d0ff5ca5ad458ad0ed1617ecc16ce9e112af0efba5a83a026175ca27dd9b63"

URI_x86_64_v2_netatalk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-devel-4.1.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netatalk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netatalk-devel}"
SRC_URI[x86_64_v2_netatalk-devel.sha256sum] = "f696cca98384dc25280792cc11fdfa67948b38fe05e57140592fd096cf0f5db6"

URI_x86_64_v2_netatalk-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-doc-4.1.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_netatalk-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netatalk-doc}"
SRC_URI[x86_64_v2_netatalk-doc.sha256sum] = "49efca3d2ac572c4931eea14ff5723536babeb06ad10a2558a2107e5698d0342"

URI_aarch64_netatalk = "${EPEL_MIRROR}/aarch64/Packages/n/netatalk-4.1.2-2.el10_1.aarch64.rpm;name=aarch64_netatalk;unpack=0"
SRC_URI:append = " ${URI_aarch64_netatalk}"
SRC_URI[aarch64_netatalk.sha256sum] = "6040db50ca6c1f10e8fc12de58644fe7ddcb517a19724c45b4c70f254c53a33d"

URI_aarch64_netatalk-afptest = "${EPEL_MIRROR}/aarch64/Packages/n/netatalk-afptest-4.1.2-2.el10_1.aarch64.rpm;name=aarch64_netatalk-afptest;unpack=0"
SRC_URI:append = " ${URI_aarch64_netatalk-afptest}"
SRC_URI[aarch64_netatalk-afptest.sha256sum] = "03e17a7232d3e3c0f9828a13d212938d2e5a8056798247d0dd4120fe8ba48ba9"

URI_aarch64_netatalk-devel = "${EPEL_MIRROR}/aarch64/Packages/n/netatalk-devel-4.1.2-2.el10_1.aarch64.rpm;name=aarch64_netatalk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netatalk-devel}"
SRC_URI[aarch64_netatalk-devel.sha256sum] = "5008d66d0f203c6996a978b0a93ad1326c4d09da7d2b5ee554ce90b0ba45ee14"

URI_aarch64_netatalk-doc = "${EPEL_MIRROR}/aarch64/Packages/n/netatalk-doc-4.1.2-2.el10_1.noarch.rpm;name=aarch64_netatalk-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_netatalk-doc}"
SRC_URI[aarch64_netatalk-doc.sha256sum] = "f44a22bd3e8b8f52fcb26f732a2aa932d167c737b224c41b9c1a9506a4cb0661"

RDEPENDS:netatalk = " \
 avahi-libs \
 bash \
 cracklib \
 dconf \
 glib2 \
 glibc \
 krb5-libs \
 libacl \
 libdb \
 libevent \
 libgcrypt \
 libtalloc \
 libtirpc \
 libtracker-sparql \
 libxcrypt \
 mariadb-connector-c \
 openldap \
 pam-libs \
 perl-File-Basename \
 perl-File-Temp \
 perl-IO-Socket-IP \
 perl-IPC-Open3 \
 perl-Net-DBus \
 perl-PathTools \
 perl-Socket \
 perl-bignum \
 perl-interpreter \
 perl-libs \
 perl-vars \
 python3-dbus \
 systemd \
 "
RDEPENDS:netatalk-afptest = " \
 glibc \
 netatalk \
 "
RDEPENDS:netatalk-devel = " \
 netatalk \
 "
RDEPENDS:netatalk-doc = " \
 "
