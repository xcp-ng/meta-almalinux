# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-dev-scripts"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kde-dev-scripts \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kde-dev-scripts-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9e23d4a05a5fc47be77136db9cc1aea14347204d031b47e6eb32ebe6539fa4ec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-dev-scripts-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kde-dev-scripts;unpack=0"
SRC_URI[x86_64_v2_kde-dev-scripts.sha256sum] = "d6871efb93bcf4471894dc5848e39a791bfbd5bf4e71396fd12c328f52ee19d4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kde-dev-scripts-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kde-dev-scripts;unpack=0"
SRC_URI[aarch64_kde-dev-scripts.sha256sum] = "766e021fd18ce8c0433eb27f8c9f674757504a0915fda64e1ba5194c0cb84103"

RDEPENDS:kde-dev-scripts = " \
 advancecomp \
 bash \
 optipng \
 perl-Data-Dumper \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Term-ANSIColor \
 perl-Time-Local \
 perl-XML-DOM \
 perl-constant \
 perl-interpreter \
 perl-libs \
 python3 \
 "
