# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "toolbox"
PV = "0.3"
PR = "2.el10_2"
PACKAGES = " \
 toolbox \
 toolbox-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/toolbox-0.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2a4631eb1fd884074f2861b988a5f89224744d22e1745fb4adbef5951c8a14e"

URI_x86_64_v2_toolbox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/toolbox-0.3-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_toolbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_toolbox}"
SRC_URI[x86_64_v2_toolbox.sha256sum] = "462489bf9967d9ba342e65988d3297ca6242cac2028016bfb92b18b6da01416b"

URI_x86_64_v2_toolbox-tests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/toolbox-tests-0.3-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_toolbox-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_toolbox-tests}"
SRC_URI[x86_64_v2_toolbox-tests.sha256sum] = "2a0fecba2fa43a8c87e923e5f079c2abdebd582b587517f6e9e82f0238cafbc7"

URI_aarch64_toolbox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/toolbox-0.3-2.el10_2.aarch64.rpm;name=aarch64_toolbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_toolbox}"
SRC_URI[aarch64_toolbox.sha256sum] = "f6f8f04814274da878b2fd8c732aa143c6294e68db245b6c5b7b478ee9d96665"

URI_aarch64_toolbox-tests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/toolbox-tests-0.3-2.el10_2.aarch64.rpm;name=aarch64_toolbox-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_toolbox-tests}"
SRC_URI[aarch64_toolbox-tests.sha256sum] = "e95293977fe124ca64973c4bf4ffe681089db0e5ed1a5a7ea8aed46122110e36"

RDEPENDS:toolbox = " \
 containers-common \
 flatpak-session-helper \
 glibc \
 podman \
 shadow-utils-subid \
 "
RDEPENDS:toolbox-tests = " \
 diffutils \
 glib2 \
 grep \
 httpd-tools \
 openssl \
 python3 \
 skopeo \
 toolbox \
 virtual/coreutils \
 "
