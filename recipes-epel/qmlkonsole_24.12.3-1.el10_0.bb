# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qmlkonsole"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 qmlkonsole \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qmlkonsole-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "121116b3a6f0cd4ecaf7e8777e0c7582278505c74d223c4a2e5aade23ddd93e7"

URI_x86_64_v2_qmlkonsole = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qmlkonsole-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qmlkonsole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qmlkonsole}"
SRC_URI[x86_64_v2_qmlkonsole.sha256sum] = "c4f307eaeb17e6b5c3aa841c75dfb4c380b47489c5d595927e2051b61ddac723"

URI_aarch64_qmlkonsole = "${EPEL_MIRROR}/aarch64/Packages/q/qmlkonsole-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_qmlkonsole;unpack=0"
SRC_URI:append = " ${URI_aarch64_qmlkonsole}"
SRC_URI[aarch64_qmlkonsole.sha256sum] = "8b90a6ae293e3a7f99961eb6b91e7f20655fa9908651cffa23d066428df1bda2"

RDEPENDS:qmlkonsole = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kpty \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
