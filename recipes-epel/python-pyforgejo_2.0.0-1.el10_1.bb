# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyforgejo"
PV = "2.0.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-pyforgejo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyforgejo-2.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7709eb7c87065980087fd40aee6b41d31b6da0794ddae102961731dba107bfa"

URI_x86_64_v2_python3-pyforgejo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyforgejo-2.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyforgejo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyforgejo}"
SRC_URI[x86_64_v2_python3-pyforgejo.sha256sum] = "5e4d89f8f2a519e55d080dbe59e4095ddce902f0fe259c163e6dae3a8fe8a544"

URI_aarch64_python3-pyforgejo = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyforgejo-2.0.0-1.el10_1.noarch.rpm;name=aarch64_python3-pyforgejo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyforgejo}"
SRC_URI[aarch64_python3-pyforgejo.sha256sum] = "4618d48728366d51d85e1194e786db21637997dd1a4b3244846d5b0a5a93a75e"

RDEPENDS:python3-pyforgejo = " \
 python3 \
 python3-dotenv \
 python3-httpx \
 python3-pydantic \
 "
