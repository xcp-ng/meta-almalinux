# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php8.4-pecl-rpminfo"
PV = "1.2.1"
PR = "1.el10_2"
PACKAGES = " \
 php8.4-pecl-rpminfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php8.4-pecl-rpminfo-1.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7465bc998619a4b593b551ff253c8f2f9057e4d58c80afad723f5959ba7099a0"

URI_x86_64_v2_php8.4-pecl-rpminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php8.4-pecl-rpminfo-1.2.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php8.4-pecl-rpminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-pecl-rpminfo}"
SRC_URI[x86_64_v2_php8.4-pecl-rpminfo.sha256sum] = "79c4cf37337baa72285e2416e10f571f3735d6e79703ec60057a1f91b68d5176"

URI_aarch64_php8.4-pecl-rpminfo = "${EPEL_MIRROR}/aarch64/Packages/p/php8.4-pecl-rpminfo-1.2.1-1.el10_2.aarch64.rpm;name=aarch64_php8.4-pecl-rpminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-pecl-rpminfo}"
SRC_URI[aarch64_php8.4-pecl-rpminfo.sha256sum] = "4457ea2737da6b95f7cff72aa52e6ca4acbef59323f40f5e7833fb3576a671ad"

RDEPENDS:php8.4-pecl-rpminfo = " \
 glibc \
 php8.4-common \
 popt \
 rpm-libs \
 "
