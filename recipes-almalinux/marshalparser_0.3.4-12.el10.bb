# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "marshalparser"
PV = "0.3.4"
PR = "12.el10"
PACKAGES = " \
 marshalparser \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/marshalparser-0.3.4-12.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fac2a05f2c03ac74069cadc688f0b917f47d1e4c4ee71117e4e99253a6a6dfe2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/marshalparser-0.3.4-12.el10.noarch.rpm;name=x86_64_v2_marshalparser;unpack=0"
SRC_URI[x86_64_v2_marshalparser.sha256sum] = "184a2861dcdccc00fe3704d07c5f57752b3baad96e5ec8051b1ff56f536ba9a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/marshalparser-0.3.4-12.el10.noarch.rpm;name=aarch64_marshalparser;unpack=0"
SRC_URI[aarch64_marshalparser.sha256sum] = "184a2861dcdccc00fe3704d07c5f57752b3baad96e5ec8051b1ff56f536ba9a2"

RDEPENDS:marshalparser = " \
 python3 \
 "
