# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rusticata-macros"
PV = "4.1.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-rusticata-macros+default-devel \
 rust-rusticata-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rusticata-macros-4.1.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15482c0cb8cbc06904d6002a009455ba3f9bc7ff9df268eaea6051232c018f1d"

URI_x86_64_v2_rust-rusticata-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusticata-macros+default-devel-4.1.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusticata-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusticata-macros+default-devel}"
SRC_URI[x86_64_v2_rust-rusticata-macros+default-devel.sha256sum] = "99c82cf24bf82a6388b1fede9302a6e1f5d9de0b90743fafae7bb37973ef5751"

URI_x86_64_v2_rust-rusticata-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusticata-macros-devel-4.1.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusticata-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusticata-macros-devel}"
SRC_URI[x86_64_v2_rust-rusticata-macros-devel.sha256sum] = "43a5c1fb250b74d883aef32e0d125696a5a9284d83ad69bc0d001ec63f0b2b45"

URI_aarch64_rust-rusticata-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusticata-macros+default-devel-4.1.0-2.el10_1.noarch.rpm;name=aarch64_rust-rusticata-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusticata-macros+default-devel}"
SRC_URI[aarch64_rust-rusticata-macros+default-devel.sha256sum] = "5c002bef18aadc263c6ff7ec570e3a62a1127a2fa098163bbd833f444094a6c9"

URI_aarch64_rust-rusticata-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusticata-macros-devel-4.1.0-2.el10_1.noarch.rpm;name=aarch64_rust-rusticata-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusticata-macros-devel}"
SRC_URI[aarch64_rust-rusticata-macros-devel.sha256sum] = "e7beb07eae6125ae8ddb10fc03a67eaee827f24ed27886ac218ff286edb2cda4"

RDEPENDS:rust-rusticata-macros+default-devel = " \
 cargo \
 rust-rusticata-macros-devel \
 "
RDEPENDS:rust-rusticata-macros-devel = " \
 cargo \
 rust-nom7+std-devel \
 rust-nom7-devel \
 "
