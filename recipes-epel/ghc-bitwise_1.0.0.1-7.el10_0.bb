# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-bitwise"
PV = "1.0.0.1"
PR = "7.el10_0"
PACKAGES = " \
 ghc-bitwise \
 ghc-bitwise-devel \
 ghc-bitwise-doc \
 ghc-bitwise-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-bitwise-1.0.0.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c0a6d6075510539ccdbc374e6b5e884e28e02cb774bd072d23173342883905a"

URI_x86_64_v2_ghc-bitwise = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bitwise-1.0.0.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bitwise;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bitwise}"
SRC_URI[x86_64_v2_ghc-bitwise.sha256sum] = "c3e0600a19bce7f971fa698eae622ba0633e13b71b3438bfdbc81c92b1cd9c33"

URI_x86_64_v2_ghc-bitwise-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bitwise-devel-1.0.0.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bitwise-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bitwise-devel}"
SRC_URI[x86_64_v2_ghc-bitwise-devel.sha256sum] = "9292d7490af8bb26a4067b0bbba2aea88f94f3e8ad791bb39b40741fe645e787"

URI_x86_64_v2_ghc-bitwise-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bitwise-doc-1.0.0.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-bitwise-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bitwise-doc}"
SRC_URI[x86_64_v2_ghc-bitwise-doc.sha256sum] = "c6d0539f7218ced91409f82bcc6ec54d0f5fee2ae0871f175c7174adb5d44111"

URI_x86_64_v2_ghc-bitwise-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bitwise-prof-1.0.0.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bitwise-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bitwise-prof}"
SRC_URI[x86_64_v2_ghc-bitwise-prof.sha256sum] = "2833518ae0f77f18ea582be379575fdbf6110557f663aece87b11c4bcab57ed7"

URI_aarch64_ghc-bitwise = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bitwise-1.0.0.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-bitwise;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bitwise}"
SRC_URI[aarch64_ghc-bitwise.sha256sum] = "f59885f55dc67dc8bcaadae6a09ab60af93a92b43706aa7ce11002c14609d40d"

URI_aarch64_ghc-bitwise-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bitwise-devel-1.0.0.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-bitwise-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bitwise-devel}"
SRC_URI[aarch64_ghc-bitwise-devel.sha256sum] = "212cf7fde55926ca0da6f941fcee2c2dbb3389227d563022bfb841cbf3a9b4f3"

URI_aarch64_ghc-bitwise-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bitwise-doc-1.0.0.1-7.el10_0.noarch.rpm;name=aarch64_ghc-bitwise-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bitwise-doc}"
SRC_URI[aarch64_ghc-bitwise-doc.sha256sum] = "6eca7b4e80289c65ade9bf55b6b7d39b7c3108711c2648afb51f9801bd5021e0"

URI_aarch64_ghc-bitwise-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bitwise-prof-1.0.0.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-bitwise-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bitwise-prof}"
SRC_URI[aarch64_ghc-bitwise-prof.sha256sum] = "ec17f9096874e3936a81e8c45257a4be74338f765f1e901efa6f8e43d08fd941"

RDEPENDS:ghc-bitwise = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-bitwise-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bitwise \
 ghc-bytestring-devel \
 ghc-compiler \
 "
RDEPENDS:ghc-bitwise-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-bitwise-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bitwise-devel \
 ghc-bytestring-prof \
 "
