# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerofrom"
PV = "0.1.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-zerofrom+alloc-devel \
 rust-zerofrom+default-devel \
 rust-zerofrom+derive-devel \
 rust-zerofrom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerofrom-0.1.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75a90767cabd02f0dee5c485ace6a6bbe6dd299d723296005e33efed9fecefad"

URI_x86_64_v2_rust-zerofrom+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom+alloc-devel-0.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom+alloc-devel}"
SRC_URI[x86_64_v2_rust-zerofrom+alloc-devel.sha256sum] = "952c1029425edadd225f405b5dc9811a5819626c6154556748e926de6d936259"

URI_x86_64_v2_rust-zerofrom+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom+default-devel-0.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom+default-devel}"
SRC_URI[x86_64_v2_rust-zerofrom+default-devel.sha256sum] = "2ffaca51199a8b956f49a4c10eed56990a06ee559cb8473dde694eff9063166e"

URI_x86_64_v2_rust-zerofrom+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom+derive-devel-0.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom+derive-devel}"
SRC_URI[x86_64_v2_rust-zerofrom+derive-devel.sha256sum] = "9660f64a0dcb3fc51bb14116cefe07a3000cacb0ef98f84dbf6178c0d4d901a0"

URI_x86_64_v2_rust-zerofrom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom-devel-0.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom-devel}"
SRC_URI[x86_64_v2_rust-zerofrom-devel.sha256sum] = "7908222b0bb7322f01dc2b17d8bde9c14dc912c8fc3ba0f84906cb2dd153057f"

URI_aarch64_rust-zerofrom+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom+alloc-devel-0.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-zerofrom+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom+alloc-devel}"
SRC_URI[aarch64_rust-zerofrom+alloc-devel.sha256sum] = "b94d601982076d47047f0a6eb2058d2b66521a2a39fe059190b771926c93f15a"

URI_aarch64_rust-zerofrom+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom+default-devel-0.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-zerofrom+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom+default-devel}"
SRC_URI[aarch64_rust-zerofrom+default-devel.sha256sum] = "b03458ab3cb072a159b363431f1c22f6d4ee0ae5d78c97ae11da5b9bbe5e855b"

URI_aarch64_rust-zerofrom+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom+derive-devel-0.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-zerofrom+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom+derive-devel}"
SRC_URI[aarch64_rust-zerofrom+derive-devel.sha256sum] = "4a5766262bcbf392380269f6fd236af263054957365557b8c4491f1535efe8ed"

URI_aarch64_rust-zerofrom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom-devel-0.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom-devel}"
SRC_URI[aarch64_rust-zerofrom-devel.sha256sum] = "b42525895c9c61839a90b4be01e5e29737bb796b5b7beb5ba64ba5a42e06adbc"

RDEPENDS:rust-zerofrom+alloc-devel = " \
 cargo \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-zerofrom+default-devel = " \
 cargo \
 rust-zerofrom+alloc-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-zerofrom+derive-devel = " \
 cargo \
 rust-zerofrom-derive-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-zerofrom-devel = " \
 cargo \
 rust \
 "
