# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stratis-cli"
PV = "3.8.3"
PR = "2.el10"
PACKAGES = " \
 stratis-cli \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/stratis-cli-3.8.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38584ba640d122ebe30a307ff45bc13e00781ad4302ad6a71f02bdfbb2f601bf"

URI_x86_64_v2_stratis-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/stratis-cli-3.8.3-2.el10.noarch.rpm;name=x86_64_v2_stratis-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stratis-cli}"
SRC_URI[x86_64_v2_stratis-cli.sha256sum] = "e2a5b3dd6df78a69df59d159a0d01eaaa40afa932d844fb2ce4b4eb8975636d4"

URI_aarch64_stratis-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/stratis-cli-3.8.3-2.el10.noarch.rpm;name=aarch64_stratis-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_stratis-cli}"
SRC_URI[aarch64_stratis-cli.sha256sum] = "e2a5b3dd6df78a69df59d159a0d01eaaa40afa932d844fb2ce4b4eb8975636d4"

RDEPENDS:stratis-cli = " \
 python3 \
 python3-dateutil \
 python3-dbus-client-gen \
 python3-dbus-python-client-gen \
 python3-justbytes \
 python3-packaging \
 python3-psutil \
 python3-wcwidth \
 stratisd \
 "
