# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "proftpd"
PV = "1.3.9d"
PR = "2.el10_3"
PACKAGES = " \
 proftpd \
 proftpd-devel \
 proftpd-ldap \
 proftpd-mysql \
 proftpd-postgresql \
 proftpd-proxy \
 proftpd-sqlite \
 proftpd-utils \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/proftpd-1.3.9d-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4f3b2ad4584e82091cfc6f1bc0d1daf8c204f977e6c6df8de89a27f9031de69d"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - proftpd-devel: libcap-devel
# - proftpd: libcap.so.2()(64bit)

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-1.3.9d-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd;unpack=0"
SRC_URI[x86_64_v2_proftpd.sha256sum] = "6a36e541b3c21d979accec57352fc4be56c3461c9a1dab4750031ac9f59bc8d9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-devel-1.3.9d-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-devel;unpack=0"
SRC_URI[x86_64_v2_proftpd-devel.sha256sum] = "aaa9d2edca1b30bcbca95f2e7918801c3406e2479b60bbb230a6233d1a96bd7f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-ldap-1.3.9d-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-ldap;unpack=0"
SRC_URI[x86_64_v2_proftpd-ldap.sha256sum] = "6f6b7f1ba74a63a0dc2816c8c56e2e1acb71b76546b26638da9470e6708418ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-mysql-1.3.9d-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-mysql;unpack=0"
SRC_URI[x86_64_v2_proftpd-mysql.sha256sum] = "ab5148b5476feba9798b13b1c28b8ebdf5783234f510be8b987cd7eb84f92f62"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-postgresql-1.3.9d-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-postgresql;unpack=0"
SRC_URI[x86_64_v2_proftpd-postgresql.sha256sum] = "af3e442e8726fc8ad066b58065aefb3d37e1cd1e6dbddb06b52789aed94936fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-proxy-1.3.9d-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-proxy;unpack=0"
SRC_URI[x86_64_v2_proftpd-proxy.sha256sum] = "4418a4f25809ce492ebbc59d3acd6220fb9fdb236241f6bd4a127e2298517eb8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-sqlite-1.3.9d-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-sqlite;unpack=0"
SRC_URI[x86_64_v2_proftpd-sqlite.sha256sum] = "9d501aaab9851ff7813bd156e513bd9a5271b60fb1be7f86ca75e80ac80ae3ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-utils-1.3.9d-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-utils;unpack=0"
SRC_URI[x86_64_v2_proftpd-utils.sha256sum] = "8b92eb828e8ee266f53f70a226c7dbba4912000eaf6c3519faeaf39491c0b2bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-1.3.9d-2.el10_3.aarch64.rpm;name=aarch64_proftpd;unpack=0"
SRC_URI[aarch64_proftpd.sha256sum] = "c29d221500f0840aee3791e22038509db750f939d94005ee0ba26bd340016ed7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-devel-1.3.9d-2.el10_3.aarch64.rpm;name=aarch64_proftpd-devel;unpack=0"
SRC_URI[aarch64_proftpd-devel.sha256sum] = "9eea830fe30c14b7cb1648784a098320065e1e28365cfa49f7dd2497f5be62b0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-ldap-1.3.9d-2.el10_3.aarch64.rpm;name=aarch64_proftpd-ldap;unpack=0"
SRC_URI[aarch64_proftpd-ldap.sha256sum] = "bb6d36f9dd679c856c506d6e71e5b5d4904de478cb3395b2b627b7774f404b78"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-mysql-1.3.9d-2.el10_3.aarch64.rpm;name=aarch64_proftpd-mysql;unpack=0"
SRC_URI[aarch64_proftpd-mysql.sha256sum] = "aa0b36ba4156764d2f1cf25ddb9a9db2bbfb01f5cdfa6a113fef887495f72734"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-postgresql-1.3.9d-2.el10_3.aarch64.rpm;name=aarch64_proftpd-postgresql;unpack=0"
SRC_URI[aarch64_proftpd-postgresql.sha256sum] = "30394e67f59ede5d617440afa73fb9957d801e04f89028bd4b92fffb1b84f640"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-proxy-1.3.9d-2.el10_3.aarch64.rpm;name=aarch64_proftpd-proxy;unpack=0"
SRC_URI[aarch64_proftpd-proxy.sha256sum] = "604665c105b4362e68b7841842fd6010462f884ab560f3e736085ad6165ca5f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-sqlite-1.3.9d-2.el10_3.aarch64.rpm;name=aarch64_proftpd-sqlite;unpack=0"
SRC_URI[aarch64_proftpd-sqlite.sha256sum] = "e928dde5b5d3598a68bf58b98b8142df34a142cadbdc52a7511deb6a8648b4d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-utils-1.3.9d-2.el10_3.aarch64.rpm;name=aarch64_proftpd-utils;unpack=0"
SRC_URI[aarch64_proftpd-utils.sha256sum] = "0b8aeac1e21ba38052b86eaa3b5180357836536dea9dea972d82983869983489"

RDEPENDS:proftpd:x86_64_v2 = " \
 bash \
 findutils \
 glibc \
 libacl \
 libcap \
 libidn2 \
 libmemcached-awesome \
 libsodium \
 libxcrypt \
 logrotate \
 openssl-libs \
 pam-libs \
 pcre2 \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:proftpd:aarch64 = " \
 bash \
 findutils \
 glibc \
 libacl \
 libidn2 \
 libmemcached-awesome \
 libsodium \
 libxcrypt \
 logrotate \
 openssl-libs \
 pam-libs \
 pcre2 \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:proftpd-devel:x86_64_v2 = " \
 gcc \
 libacl-devel \
 libcap-devel \
 libmemcached-awesome-devel \
 libpq-devel \
 libsodium-devel \
 mariadb-connector-c-devel \
 ncurses-devel \
 openldap-devel \
 openssl-devel \
 pam-devel \
 pcre2-devel \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 proftpd \
 sqlite-devel \
 zlib-ng-compat-devel \
"
RDEPENDS:proftpd-devel:aarch64 = " \
 gcc \
 libacl-devel \
 libmemcached-awesome-devel \
 libpq-devel \
 libsodium-devel \
 mariadb-connector-c-devel \
 ncurses-devel \
 openldap-devel \
 openssl-devel \
 pam-devel \
 pcre2-devel \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 proftpd \
 sqlite-devel \
 zlib-ng-compat-devel \
"
RDEPENDS:proftpd-ldap = " \
 glibc \
 libidn2 \
 libsodium \
 openldap \
 proftpd \
 "
RDEPENDS:proftpd-mysql = " \
 glibc \
 libidn2 \
 libsodium \
 mariadb-connector-c \
 proftpd \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-postgresql = " \
 glibc \
 libidn2 \
 libpq \
 libsodium \
 proftpd \
 "
RDEPENDS:proftpd-proxy = " \
 glibc \
 libidn2 \
 libsodium \
 openssl-libs \
 proftpd \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-sqlite = " \
 glibc \
 libidn2 \
 libsodium \
 proftpd \
 sqlite-libs \
 "
RDEPENDS:proftpd-utils = " \
 glibc \
 ncurses-libs \
 perl-Crypt-Cracklib \
 perl-Fcntl \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-IO \
 perl-MIME-Base64 \
 perl-Mail-Sendmail \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 proftpd \
 "
