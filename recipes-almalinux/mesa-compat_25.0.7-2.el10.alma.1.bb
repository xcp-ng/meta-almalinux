# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mesa-compat"
PV = "25.0.7"
PR = "2.el10.alma.1"
PACKAGES = " \
 mesa-compat-libOSMesa \
 mesa-compat-libOSMesa-devel \
 mesa-compat-libxatracker \
 mesa-compat-libxatracker-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mesa-compat-25.0.7-2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9812d98f2754f2f272dcf4a19e56be940d21ffa535659548d27a7d54d98ecbe8"

URI_x86_64_v2_mesa-compat-libOSMesa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-compat-libOSMesa-25.0.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-compat-libOSMesa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-compat-libOSMesa}"
SRC_URI[x86_64_v2_mesa-compat-libOSMesa.sha256sum] = "71c3d1a19366664e9a381dc37a98f5363a8698fe1b77747eda5760ec2887d0e7"

URI_x86_64_v2_mesa-compat-libOSMesa-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-compat-libOSMesa-devel-25.0.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-compat-libOSMesa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-compat-libOSMesa-devel}"
SRC_URI[x86_64_v2_mesa-compat-libOSMesa-devel.sha256sum] = "0ede82dd3d37020a84480c724b3782e1643211c434a35011ca8143a975c4e018"

URI_x86_64_v2_mesa-compat-libxatracker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-compat-libxatracker-25.0.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-compat-libxatracker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-compat-libxatracker}"
SRC_URI[x86_64_v2_mesa-compat-libxatracker.sha256sum] = "9e43aeeb72721901365f7fe75dd0ebbd8219b10c5a12ece9d7043f68ff9b4812"

URI_x86_64_v2_mesa-compat-libxatracker-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-compat-libxatracker-devel-25.0.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-compat-libxatracker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-compat-libxatracker-devel}"
SRC_URI[x86_64_v2_mesa-compat-libxatracker-devel.sha256sum] = "92bb638ce570399e5870c8bf849bc09bc9f35657fd3ddf3c3478ff012e1e5868"

URI_aarch64_mesa-compat-libOSMesa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-compat-libOSMesa-25.0.7-2.el10.alma.1.aarch64.rpm;name=aarch64_mesa-compat-libOSMesa;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-compat-libOSMesa}"
SRC_URI[aarch64_mesa-compat-libOSMesa.sha256sum] = "d7a07d480a5f5639e3aeb217f5b83a24a98509d1a712276d92cb8e5bd60d8e56"

URI_aarch64_mesa-compat-libOSMesa-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-compat-libOSMesa-devel-25.0.7-2.el10.alma.1.aarch64.rpm;name=aarch64_mesa-compat-libOSMesa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-compat-libOSMesa-devel}"
SRC_URI[aarch64_mesa-compat-libOSMesa-devel.sha256sum] = "13bdef7b21d12aee0b9dff634afe4f75c66f653d072a75eb1e5095701d45bf1a"

URI_aarch64_mesa-compat-libxatracker = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-compat-libxatracker-25.0.7-2.el10.alma.1.aarch64.rpm;name=aarch64_mesa-compat-libxatracker;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-compat-libxatracker}"
SRC_URI[aarch64_mesa-compat-libxatracker.sha256sum] = "0abeb06631faf3cb2413939c7cb0936b2b3f6001acbd3a4769bcadd407da9359"

URI_aarch64_mesa-compat-libxatracker-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-compat-libxatracker-devel-25.0.7-2.el10.alma.1.aarch64.rpm;name=aarch64_mesa-compat-libxatracker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-compat-libxatracker-devel}"
SRC_URI[aarch64_mesa-compat-libxatracker-devel.sha256sum] = "83af388a7d2de8eeda6598e23147875b8cad8a8bd34eed3e106232b73bfb2e2b"

RDEPENDS:mesa-compat-libOSMesa = " \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:mesa-compat-libOSMesa-devel = " \
 mesa-compat-libOSMesa \
 pkgconf-pkg-config \
 "
RDEPENDS:mesa-compat-libxatracker = " \
 expat \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:mesa-compat-libxatracker-devel = " \
 mesa-compat-libxatracker \
 pkgconf-pkg-config \
 "
