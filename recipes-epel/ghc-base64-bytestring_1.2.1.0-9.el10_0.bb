# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-base64-bytestring"
PV = "1.2.1.0"
PR = "9.el10_0"
PACKAGES = " \
 ghc-base64-bytestring \
 ghc-base64-bytestring-devel \
 ghc-base64-bytestring-doc \
 ghc-base64-bytestring-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-base64-bytestring-1.2.1.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2019dad61245189478b26027362100a63f7278f73c1c982f15ca230cb4601096"

URI_x86_64_v2_ghc-base64-bytestring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base64-bytestring-1.2.1.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base64-bytestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base64-bytestring}"
SRC_URI[x86_64_v2_ghc-base64-bytestring.sha256sum] = "7cb8af4e6dd5e35779a66fde981b0a2afde439854c852dedb340c564667101ce"

URI_x86_64_v2_ghc-base64-bytestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base64-bytestring-devel-1.2.1.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base64-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base64-bytestring-devel}"
SRC_URI[x86_64_v2_ghc-base64-bytestring-devel.sha256sum] = "9281349650f38bb49a48df50b94fac0c4cbfd09d1cf31767218d23a1bd947ef6"

URI_x86_64_v2_ghc-base64-bytestring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base64-bytestring-doc-1.2.1.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-base64-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base64-bytestring-doc}"
SRC_URI[x86_64_v2_ghc-base64-bytestring-doc.sha256sum] = "aa2a2a527574075199e2b76e8bbca01b5bd70a3169a2e808b750a9522ad74c6b"

URI_x86_64_v2_ghc-base64-bytestring-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base64-bytestring-prof-1.2.1.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base64-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base64-bytestring-prof}"
SRC_URI[x86_64_v2_ghc-base64-bytestring-prof.sha256sum] = "01be5f7d53274d48fc1e6386037362de97b2d526c7c05c608746ad53250bb5cb"

URI_aarch64_ghc-base64-bytestring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base64-bytestring-1.2.1.0-9.el10_0.aarch64.rpm;name=aarch64_ghc-base64-bytestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base64-bytestring}"
SRC_URI[aarch64_ghc-base64-bytestring.sha256sum] = "e973a500e495812550272a60565d3b34031485b99eee010a0125cd20d5396a45"

URI_aarch64_ghc-base64-bytestring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base64-bytestring-devel-1.2.1.0-9.el10_0.aarch64.rpm;name=aarch64_ghc-base64-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base64-bytestring-devel}"
SRC_URI[aarch64_ghc-base64-bytestring-devel.sha256sum] = "eb54cc2d070a0f9955b96453e7d43012b4b60b024da35b1ca609672ba15f8162"

URI_aarch64_ghc-base64-bytestring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base64-bytestring-doc-1.2.1.0-9.el10_0.noarch.rpm;name=aarch64_ghc-base64-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base64-bytestring-doc}"
SRC_URI[aarch64_ghc-base64-bytestring-doc.sha256sum] = "d2760bdb97b44b00b1d449d0035af722bdef54a515db052dbedebb70df949f0d"

URI_aarch64_ghc-base64-bytestring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base64-bytestring-prof-1.2.1.0-9.el10_0.aarch64.rpm;name=aarch64_ghc-base64-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base64-bytestring-prof}"
SRC_URI[aarch64_ghc-base64-bytestring-prof.sha256sum] = "d43657d18e213368373695721585cb6c47d4c4672907a482a84b65cce8a18821"

RDEPENDS:ghc-base64-bytestring = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-base64-bytestring-devel = " \
 ghc-base-devel \
 ghc-base64-bytestring \
 ghc-bytestring-devel \
 ghc-compiler \
 "
RDEPENDS:ghc-base64-bytestring-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-base64-bytestring-prof = " \
 ghc-base-prof \
 ghc-base64-bytestring-devel \
 ghc-bytestring-prof \
 "
