# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-data-reify"
PV = "0.6.3"
PR = "15.el10_0"
PACKAGES = " \
 ghc-data-reify \
 ghc-data-reify-devel \
 ghc-data-reify-doc \
 ghc-data-reify-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-data-reify-0.6.3-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c45da5ef13ca1fc8c4a8f0aab6a7c768d4db59ca6b09501172afd8b72e76c6c"

URI_x86_64_v2_ghc-data-reify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-reify-0.6.3-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-reify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-reify}"
SRC_URI[x86_64_v2_ghc-data-reify.sha256sum] = "191bf237e6b5e2e14e7c41a12f18cbf1ba299978b5597bc545d224e0c2951d5b"

URI_x86_64_v2_ghc-data-reify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-reify-devel-0.6.3-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-reify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-reify-devel}"
SRC_URI[x86_64_v2_ghc-data-reify-devel.sha256sum] = "f68e63593dedca937b34a9ab05696fe6f0c0663dc025f1bd62d066dfba12202f"

URI_x86_64_v2_ghc-data-reify-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-reify-doc-0.6.3-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-data-reify-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-reify-doc}"
SRC_URI[x86_64_v2_ghc-data-reify-doc.sha256sum] = "f1dec78d34cd5e8409e5b955ee1e242f2bdb1164892f68cf2dbc2c49b1cea712"

URI_x86_64_v2_ghc-data-reify-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-reify-prof-0.6.3-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-reify-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-reify-prof}"
SRC_URI[x86_64_v2_ghc-data-reify-prof.sha256sum] = "5abd45a85e25f60bc812a00212a1cd9464783e6575b25e7af2d28cdf23e1c9cd"

URI_aarch64_ghc-data-reify = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-reify-0.6.3-15.el10_0.aarch64.rpm;name=aarch64_ghc-data-reify;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-reify}"
SRC_URI[aarch64_ghc-data-reify.sha256sum] = "8d1b22bb1a8ae60192c0462da384f9b7668c685b630af9b7db17f7270c57f2bd"

URI_aarch64_ghc-data-reify-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-reify-devel-0.6.3-15.el10_0.aarch64.rpm;name=aarch64_ghc-data-reify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-reify-devel}"
SRC_URI[aarch64_ghc-data-reify-devel.sha256sum] = "c822a05e0d4179b8532c7f1f6ee86d8fa871f73dc2cf6c41935f99405d2bebf6"

URI_aarch64_ghc-data-reify-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-reify-doc-0.6.3-15.el10_0.noarch.rpm;name=aarch64_ghc-data-reify-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-reify-doc}"
SRC_URI[aarch64_ghc-data-reify-doc.sha256sum] = "ee039adb2192d1dd8f8a5f192131865d94062c9c0183a312c0da73bd89607216"

URI_aarch64_ghc-data-reify-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-reify-prof-0.6.3-15.el10_0.aarch64.rpm;name=aarch64_ghc-data-reify-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-reify-prof}"
SRC_URI[aarch64_ghc-data-reify-prof.sha256sum] = "240537804738b9b5ddf622a69cb8fb2db9f2f12ec83d3aa1db5276f24efcd645"

RDEPENDS:ghc-data-reify = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-unordered-containers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-data-reify-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-data-reify \
 ghc-hashable-devel \
 ghc-unordered-containers-devel \
 "
RDEPENDS:ghc-data-reify-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-data-reify-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-data-reify-devel \
 ghc-hashable-prof \
 ghc-unordered-containers-prof \
 "
