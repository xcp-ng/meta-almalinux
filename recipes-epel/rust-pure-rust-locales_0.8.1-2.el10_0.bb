# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pure-rust-locales"
PV = "0.8.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-pure-rust-locales+default-devel \
 rust-pure-rust-locales-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pure-rust-locales-0.8.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2279848a2fac261ea325ae48ff83380eea96cf310eb6007ff1ce970a4a142c78"

URI_x86_64_v2_rust-pure-rust-locales+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pure-rust-locales+default-devel-0.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pure-rust-locales+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pure-rust-locales+default-devel}"
SRC_URI[x86_64_v2_rust-pure-rust-locales+default-devel.sha256sum] = "04ce106ce0eb7847b0f2bc1fea03e93ba3bde56243dd72f775371bfd0ce6a532"

URI_x86_64_v2_rust-pure-rust-locales-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pure-rust-locales-devel-0.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pure-rust-locales-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pure-rust-locales-devel}"
SRC_URI[x86_64_v2_rust-pure-rust-locales-devel.sha256sum] = "773a6d3e3eca0068b7cc60a980450a33bb79e653d44c4337973750347859b434"

URI_aarch64_rust-pure-rust-locales+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pure-rust-locales+default-devel-0.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-pure-rust-locales+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pure-rust-locales+default-devel}"
SRC_URI[aarch64_rust-pure-rust-locales+default-devel.sha256sum] = "21453f1621413db82af4aae2953d8b457356b1355dad17b420c6d42cd6278b41"

URI_aarch64_rust-pure-rust-locales-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pure-rust-locales-devel-0.8.1-2.el10_0.noarch.rpm;name=aarch64_rust-pure-rust-locales-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pure-rust-locales-devel}"
SRC_URI[aarch64_rust-pure-rust-locales-devel.sha256sum] = "7e239286f7739fe04f79843935d85703a55e277d6565e664697856e069e406c4"

RDEPENDS:rust-pure-rust-locales+default-devel = " \
 cargo \
 rust-pure-rust-locales-devel \
 "
RDEPENDS:rust-pure-rust-locales-devel = " \
 cargo \
 rust \
 "
