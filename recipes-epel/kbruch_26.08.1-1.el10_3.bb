# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbruch"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kbruch \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kbruch-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f21b9b0ae9b8dbc579c9defed6c221a186b3ac31ec4fbc7c22612b57a8293892"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbruch-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbruch;unpack=0"
SRC_URI[x86_64_v2_kbruch.sha256sum] = "a968841a2370f86cbe148807bec4f19f43c895f08c7ebaab0f8763022f9b8a00"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kbruch-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kbruch;unpack=0"
SRC_URI[aarch64_kbruch.sha256sum] = "52863c99ceda5b2c7ad56ac2329cfea1b6cf8b3a562d16122a95227dbe1be4cb"

RDEPENDS:kbruch = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
