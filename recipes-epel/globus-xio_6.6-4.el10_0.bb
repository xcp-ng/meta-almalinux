# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-xio"
PV = "6.6"
PR = "4.el10_0"
PACKAGES = " \
 globus-xio \
 globus-xio-devel \
 globus-xio-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-xio-6.6-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00191e2c19bd63ca48a18137444358d7845ff9eea5a3779573522b98e4d9d6ba"

URI_x86_64_v2_globus-xio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-6.6-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio}"
SRC_URI[x86_64_v2_globus-xio.sha256sum] = "cafbadad992560b30b1151b9c7e1195af360ddd3cbeaf8abbd3bfac96acfe0e4"

URI_x86_64_v2_globus-xio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-devel-6.6-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-devel}"
SRC_URI[x86_64_v2_globus-xio-devel.sha256sum] = "b8516ffe4c7c537c22fc737218c5478d15a71024b2beeba9f9d8d6ede2538439"

URI_x86_64_v2_globus-xio-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-doc-6.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-xio-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-doc}"
SRC_URI[x86_64_v2_globus-xio-doc.sha256sum] = "389b19057cddcb6a8b2269fc81663f11b0d59ff8f0698686027bb092fc461167"

URI_aarch64_globus-xio = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-6.6-4.el10_0.aarch64.rpm;name=aarch64_globus-xio;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio}"
SRC_URI[aarch64_globus-xio.sha256sum] = "85e6d7dc97ab778c3b0c15ff3c490c64560ccc1c69bafa804dae92203bbf02f2"

URI_aarch64_globus-xio-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-devel-6.6-4.el10_0.aarch64.rpm;name=aarch64_globus-xio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-devel}"
SRC_URI[aarch64_globus-xio-devel.sha256sum] = "48831d62b2a9f94d6d18c7d232167065bbc041e4dd7baa572a69f5818b9eedd3"

URI_aarch64_globus-xio-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-doc-6.6-4.el10_0.noarch.rpm;name=aarch64_globus-xio-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-doc}"
SRC_URI[aarch64_globus-xio-doc.sha256sum] = "ba2882f313a37c6d1970c77e85b8e3632c451d61b52975039bc98a5bc867e311"

RDEPENDS:globus-xio = " \
 glibc \
 globus-common \
 "
RDEPENDS:globus-xio-devel = " \
 globus-common-devel \
 globus-xio \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-xio-doc = " \
 "
