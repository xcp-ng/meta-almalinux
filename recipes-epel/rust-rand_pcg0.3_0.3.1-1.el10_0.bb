# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_pcg0.3"
PV = "0.3.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-rand_pcg0.3+default-devel \
 rust-rand_pcg0.3+serde-devel \
 rust-rand_pcg0.3+serde1-devel \
 rust-rand_pcg0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_pcg0.3-0.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "888e25d34987771812168c8fde8923ea78fb289bf7c78b15d55f99bb66e45b9b"

URI_x86_64_v2_rust-rand_pcg0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg0.3+default-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg0.3+default-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg0.3+default-devel.sha256sum] = "b60af2c4f8f43b9846609db1ea51a32d3dbfb5e4d2bcc585d63a88e157c8127d"

URI_x86_64_v2_rust-rand_pcg0.3+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg0.3+serde-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg0.3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg0.3+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg0.3+serde-devel.sha256sum] = "5e656b9958efec2beb4833417ac77778129c1e7498395fcc2a47ad243ab9677b"

URI_x86_64_v2_rust-rand_pcg0.3+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg0.3+serde1-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg0.3+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg0.3+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg0.3+serde1-devel.sha256sum] = "0db374e33a14300b2adc0b99055ff0e22c7a4865233717ca8310251f12381237"

URI_x86_64_v2_rust-rand_pcg0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg0.3-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg0.3-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg0.3-devel.sha256sum] = "5e80ebe6f3ee50342e84d3ed1181dde92092a38c9a8ef611dbcd4219515084ea"

URI_aarch64_rust-rand_pcg0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg0.3+default-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_pcg0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg0.3+default-devel}"
SRC_URI[aarch64_rust-rand_pcg0.3+default-devel.sha256sum] = "bf78bf2fa41dd23e0800a223a2bea15f4d55b3284b01cf49b8bf5db39542858c"

URI_aarch64_rust-rand_pcg0.3+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg0.3+serde-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_pcg0.3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg0.3+serde-devel}"
SRC_URI[aarch64_rust-rand_pcg0.3+serde-devel.sha256sum] = "f1be06da8725f10c6da6098efd601cdf8629715d3b43ddc0e0d8ae20b2ec3a48"

URI_aarch64_rust-rand_pcg0.3+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg0.3+serde1-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_pcg0.3+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg0.3+serde1-devel}"
SRC_URI[aarch64_rust-rand_pcg0.3+serde1-devel.sha256sum] = "31ab29e96b641ef5961e1bcd4e51d8680298c5673516a34243cb7637c0b7fa0d"

URI_aarch64_rust-rand_pcg0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg0.3-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_pcg0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg0.3-devel}"
SRC_URI[aarch64_rust-rand_pcg0.3-devel.sha256sum] = "95987af7c3c7c6204495675473748c96fb533948adaadde15a90b917f4b4d4ba"

RDEPENDS:rust-rand_pcg0.3+default-devel = " \
 cargo \
 rust-rand_pcg0.3-devel \
 "
RDEPENDS:rust-rand_pcg0.3+serde-devel = " \
 cargo \
 rust-rand_pcg0.3-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_pcg0.3+serde1-devel = " \
 cargo \
 rust-rand_pcg0.3+serde-devel \
 rust-rand_pcg0.3-devel \
 "
RDEPENDS:rust-rand_pcg0.3-devel = " \
 cargo \
 rust-rand_core0.6+default-devel \
 "
