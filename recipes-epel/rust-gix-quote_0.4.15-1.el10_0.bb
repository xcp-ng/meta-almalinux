# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-quote"
PV = "0.4.15"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-quote+default-devel \
 rust-gix-quote-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-quote-0.4.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ed1b5b263ed452de475c1c07d522790b7a871477cc0dc04063e34172e503790"

URI_x86_64_v2_rust-gix-quote+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-quote+default-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-quote+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-quote+default-devel}"
SRC_URI[x86_64_v2_rust-gix-quote+default-devel.sha256sum] = "10acdc40c368f1caca4f8341df9b4bda511d06193b377e47d0a851a1e642051f"

URI_x86_64_v2_rust-gix-quote-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-quote-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-quote-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-quote-devel}"
SRC_URI[x86_64_v2_rust-gix-quote-devel.sha256sum] = "1245fcde955cc184b56d89e7f3978fc8e7463d441be087e16f7d9eb7a864edff"

URI_aarch64_rust-gix-quote+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-quote+default-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-gix-quote+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-quote+default-devel}"
SRC_URI[aarch64_rust-gix-quote+default-devel.sha256sum] = "08cb08a5f1a9dcebb4e3613a987a3c224d6a9fc0799f378b6b329300d49df136"

URI_aarch64_rust-gix-quote-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-quote-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-gix-quote-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-quote-devel}"
SRC_URI[aarch64_rust-gix-quote-devel.sha256sum] = "27cbef4544b7991fc33283d63684a89370ccf72798eafec2e5017da1a0f2616d"

RDEPENDS:rust-gix-quote+default-devel = " \
 cargo \
 rust-gix-quote-devel \
 "
RDEPENDS:rust-gix-quote-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-utils+default-devel \
 rust-thiserror+default-devel \
 "
