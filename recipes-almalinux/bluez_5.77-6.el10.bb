# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluez"
PV = "5.77"
PR = "6.el10"
PACKAGES = " \
 bluez \
 bluez-cups \
 bluez-libs \
 bluez-libs-devel \
 bluez-obexd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/bluez-5.77-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "564642bb75e9e458b3caabf7c172f21be4b2d8059e8f4f14635c8478b065bb9e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/bluez-5.77-6.el10.x86_64_v2.rpm;name=x86_64_v2_bluez;unpack=0"
SRC_URI[x86_64_v2_bluez.sha256sum] = "d8feb923bd15b16a1c554eddf61881d8c1c02562ffb2421d04e1056badad1fde"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bluez-cups-5.77-6.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-cups;unpack=0"
SRC_URI[x86_64_v2_bluez-cups.sha256sum] = "3fbb6587ca7088d955bf435191daaccd930043ab5b934ae2d5b9ab5fbbc5e2be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/bluez-libs-5.77-6.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-libs;unpack=0"
SRC_URI[x86_64_v2_bluez-libs.sha256sum] = "bb47c35df47758606f83e6728e8ec3ff2c46fbb71a1d1bcc6ecea2cb73f43f1c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bluez-libs-devel-5.77-6.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-libs-devel;unpack=0"
SRC_URI[x86_64_v2_bluez-libs-devel.sha256sum] = "b935e5432642ec93ada1d960e8b53977ae9e73fd17eb292cdda3d87a665349ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bluez-obexd-5.77-6.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-obexd;unpack=0"
SRC_URI[x86_64_v2_bluez-obexd.sha256sum] = "86a97a473f5a5f2a58845b113690aef38386cf0f1d208b4fe2c5b85ff5692e7b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/bluez-5.77-6.el10.aarch64.rpm;name=aarch64_bluez;unpack=0"
SRC_URI[aarch64_bluez.sha256sum] = "c2b4a20251e18ed9b2655a19724bdacab12ca507846a75c4153afd16939cc452"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bluez-cups-5.77-6.el10.aarch64.rpm;name=aarch64_bluez-cups;unpack=0"
SRC_URI[aarch64_bluez-cups.sha256sum] = "4c10f76bb8efaf3e7c967e2fa266ebd9667749f00e90ca0b5c7b8aece410842d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/bluez-libs-5.77-6.el10.aarch64.rpm;name=aarch64_bluez-libs;unpack=0"
SRC_URI[aarch64_bluez-libs.sha256sum] = "eb701651996a23fdb8348a1711268c8d463645650b7e125262ec58129ae74e95"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bluez-libs-devel-5.77-6.el10.aarch64.rpm;name=aarch64_bluez-libs-devel;unpack=0"
SRC_URI[aarch64_bluez-libs-devel.sha256sum] = "1723b1e36810a6fddb516c0832cff7e815f1f988bce268d53c5c09f4e00adb0a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bluez-obexd-5.77-6.el10.aarch64.rpm;name=aarch64_bluez-obexd;unpack=0"
SRC_URI[aarch64_bluez-obexd.sha256sum] = "00046af74f6b5589dc74bb01fdfa99352cf85918d45847f18ac47ac63ebe3e75"

RDEPENDS:bluez = " \
 bash \
 dbus \
 dbus-libs \
 glib2 \
 glibc \
 readline \
 systemd \
 systemd-libs \
 "
RDEPENDS:bluez-cups = " \
 bluez \
 cups \
 dbus-libs \
 glib2 \
 glibc \
 "
RDEPENDS:bluez-libs = " \
 glibc \
 "
RDEPENDS:bluez-libs-devel = " \
 bluez-libs \
 glibc \
 pkgconf-pkg-config \
 "
RDEPENDS:bluez-obexd = " \
 bash \
 bluez \
 bluez-libs \
 dbus-libs \
 glib2 \
 glibc \
 libical \
 "
