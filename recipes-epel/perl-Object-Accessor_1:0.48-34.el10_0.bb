# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Object-Accessor"
PE = "1"
PV = "0.48"
PR = "34.el10_0"
PACKAGES = " \
 perl-Object-Accessor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Object-Accessor-0.48-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "094a7fd9304690fcd0eb12a42a2e305b6da0a6116e7450f7b486cf346084ecf3"

URI_x86_64_v2_perl-Object-Accessor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Object-Accessor-0.48-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Object-Accessor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Object-Accessor}"
SRC_URI[x86_64_v2_perl-Object-Accessor.sha256sum] = "1e34d990e03a42c8eed467a9e154cb8abbd4e625052b3811ea1a0d7967b34d61"

URI_aarch64_perl-Object-Accessor = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Object-Accessor-0.48-34.el10_0.noarch.rpm;name=aarch64_perl-Object-Accessor;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Object-Accessor}"
SRC_URI[aarch64_perl-Object-Accessor.sha256sum] = "82b16ce37396929830d80bf7a2b8a6ea51785f5e41e033ad58556dbb26910298"

RDEPENDS:perl-Object-Accessor = " \
 perl-Carp \
 perl-Params-Check \
 perl-Tie \
 perl-base \
 perl-constant \
 perl-deprecate \
 perl-if \
 perl-libs \
 perl-overload \
 perl-vars \
 "
