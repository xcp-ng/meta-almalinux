# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php8.4-extras"
PV = "8.4.21"
PR = "1.el10_3"
PACKAGES = " \
 php8.4-pdo-dblib \
 php8.4-pdo-firebird \
 php8.4-sodium \
 php8.4-sodium-devel \
 php8.4-tidy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php8.4-extras-8.4.21-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cd00b75f6a3ae7a71dadff1710a23eeda237d8f09b786cc8aa10d9e6c6d0809"

URI_x86_64_v2_php8.4-pdo-dblib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php8.4-pdo-dblib-8.4.21-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php8.4-pdo-dblib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-pdo-dblib}"
SRC_URI[x86_64_v2_php8.4-pdo-dblib.sha256sum] = "79200858e82f2fe3ed582c37d7eeb3824ccbb4c574d63f29c887274c1cdc4848"

URI_x86_64_v2_php8.4-pdo-firebird = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php8.4-pdo-firebird-8.4.21-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php8.4-pdo-firebird;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-pdo-firebird}"
SRC_URI[x86_64_v2_php8.4-pdo-firebird.sha256sum] = "69e37119faa9668fb76c8a41653ed7226e6f6c8a2b3025031432976b1faa732b"

URI_x86_64_v2_php8.4-sodium = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php8.4-sodium-8.4.21-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php8.4-sodium;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-sodium}"
SRC_URI[x86_64_v2_php8.4-sodium.sha256sum] = "70d04d508d728ce51f091127e3b4fac3a242979dd027c1224e9e10e1dd91ac2f"
RPROVIDES:php8.4-sodium:x86_64_v2 = "virtual/php-sodium"

URI_x86_64_v2_php8.4-sodium-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php8.4-sodium-devel-8.4.21-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php8.4-sodium-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-sodium-devel}"
SRC_URI[x86_64_v2_php8.4-sodium-devel.sha256sum] = "b0bf551905e29bbae2318d54b3c07f6234c82730045dd0e1b12295dc791bbd33"

URI_x86_64_v2_php8.4-tidy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php8.4-tidy-8.4.21-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php8.4-tidy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-tidy}"
SRC_URI[x86_64_v2_php8.4-tidy.sha256sum] = "b61d90740a46d113c3d9f0bcb9c26d022376d7297bafb4e4043aba793ed821e8"

URI_aarch64_php8.4-pdo-dblib = "${EPEL_MIRROR}/aarch64/Packages/p/php8.4-pdo-dblib-8.4.21-1.el10_3.aarch64.rpm;name=aarch64_php8.4-pdo-dblib;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-pdo-dblib}"
SRC_URI[aarch64_php8.4-pdo-dblib.sha256sum] = "7a720c45cc9f8c986d4f614379a34bc314448692d4ce27a2e98e28776d7deea0"

URI_aarch64_php8.4-pdo-firebird = "${EPEL_MIRROR}/aarch64/Packages/p/php8.4-pdo-firebird-8.4.21-1.el10_3.aarch64.rpm;name=aarch64_php8.4-pdo-firebird;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-pdo-firebird}"
SRC_URI[aarch64_php8.4-pdo-firebird.sha256sum] = "67972630700fe7aefdaafa0d0c8cbcb4c07c62ef7c8c8234bf1b9b161c04f9b0"

URI_aarch64_php8.4-sodium = "${EPEL_MIRROR}/aarch64/Packages/p/php8.4-sodium-8.4.21-1.el10_3.aarch64.rpm;name=aarch64_php8.4-sodium;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-sodium}"
SRC_URI[aarch64_php8.4-sodium.sha256sum] = "ff7ae2164e10a58a2bc78077f01ed78734238381dd79075c16aa20faca3fb5dd"
RPROVIDES:php8.4-sodium:aarch64 = "virtual/php-sodium"

URI_aarch64_php8.4-sodium-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php8.4-sodium-devel-8.4.21-1.el10_3.aarch64.rpm;name=aarch64_php8.4-sodium-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-sodium-devel}"
SRC_URI[aarch64_php8.4-sodium-devel.sha256sum] = "4687a949e96a8c37c33d92deb3e1567c90a623828bb9c54881f540036414dafb"

URI_aarch64_php8.4-tidy = "${EPEL_MIRROR}/aarch64/Packages/p/php8.4-tidy-8.4.21-1.el10_3.aarch64.rpm;name=aarch64_php8.4-tidy;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-tidy}"
SRC_URI[aarch64_php8.4-tidy.sha256sum] = "2ac8c291b2c0d8aa19467b931951ed2d3f1bc73d6fc5680c74f4e0e420bd1c85"

RDEPENDS:php8.4-pdo-dblib = " \
 freetds-libs \
 glibc \
 php8.4-common \
 php8.4-pdo \
 "
RDEPENDS:php8.4-pdo-firebird = " \
 glibc \
 libfbclient2 \
 libgcc \
 libstdc++ \
 php8.4-common \
 php8.4-pdo \
 "
RDEPENDS:php8.4-sodium = " \
 glibc \
 libsodium \
 php8.4-common \
 "
RDEPENDS:php8.4-sodium-devel = " \
 php8.4-common \
 php8.4-devel \
 php8.4-sodium \
 "
RDEPENDS:php8.4-tidy = " \
 glibc \
 libtidy \
 php8.4-common \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/php-sodium"

PROVIDES:append:aarch64 = " rpm/virtual/php-sodium"
