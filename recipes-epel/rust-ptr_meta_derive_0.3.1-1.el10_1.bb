# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ptr_meta_derive"
PV = "0.3.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-ptr_meta_derive+default-devel \
 rust-ptr_meta_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ptr_meta_derive-0.3.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8671101489e09842f377f58c36a90fffbb27201fe527614ee4501b96322f3fe8"

URI_x86_64_v2_rust-ptr_meta_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta_derive+default-devel-0.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta_derive+default-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta_derive+default-devel.sha256sum] = "7e093b0f303925193b6c3f42455cf867ec435e96625c3fc64794a96a61738c42"

URI_x86_64_v2_rust-ptr_meta_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta_derive-devel-0.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta_derive-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta_derive-devel.sha256sum] = "b4c1f98eab2f5e6589296be4b79b4e8e3754605ee798b1daa5e70b785156e195"

URI_aarch64_rust-ptr_meta_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta_derive+default-devel-0.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-ptr_meta_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta_derive+default-devel}"
SRC_URI[aarch64_rust-ptr_meta_derive+default-devel.sha256sum] = "a27f3e7ff528859c543f4e7c8f70b78262abe10166563d53db82a4ab556b7d64"

URI_aarch64_rust-ptr_meta_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta_derive-devel-0.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta_derive-devel}"
SRC_URI[aarch64_rust-ptr_meta_derive-devel.sha256sum] = "1d473efcd92fa6c1f956b3cdde2fa0df7f06c88ac0f92293b560e8b608cf0fea"

RDEPENDS:rust-ptr_meta_derive+default-devel = " \
 cargo \
 rust-ptr_meta_derive-devel \
 "
RDEPENDS:rust-ptr_meta_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
