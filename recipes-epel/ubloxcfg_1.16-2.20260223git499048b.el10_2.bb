# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ubloxcfg"
PV = "1.16"
PR = "2.20260223git499048b.el10_2"
PACKAGES = " \
 ubloxcfg \
 ubloxcfg-devel \
 ubloxcfg-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/ubloxcfg-1.16-2.20260223git499048b.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3942355fef36a6187390cc18f529e87f781ef7ce6fd9f0eddc92ca3f180e2437"

URI_aarch64_ubloxcfg = "${EPEL_MIRROR}/aarch64/Packages/u/ubloxcfg-1.16-2.20260223git499048b.el10_2.aarch64.rpm;name=aarch64_ubloxcfg;unpack=0"
SRC_URI:append = " ${URI_aarch64_ubloxcfg}"
SRC_URI[aarch64_ubloxcfg.sha256sum] = "aae4046f3cb9911cb805910189bd3a7359127c96f1b4828ac0e0eebe9973dd34"

URI_aarch64_ubloxcfg-devel = "${EPEL_MIRROR}/aarch64/Packages/u/ubloxcfg-devel-1.16-2.20260223git499048b.el10_2.aarch64.rpm;name=aarch64_ubloxcfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ubloxcfg-devel}"
SRC_URI[aarch64_ubloxcfg-devel.sha256sum] = "9eb7851e2afb68d0c68a5a7e1f67050a7085e2ac958453a3e9f500293df0ae17"

URI_aarch64_ubloxcfg-doc = "${EPEL_MIRROR}/aarch64/Packages/u/ubloxcfg-doc-1.16-2.20260223git499048b.el10_2.noarch.rpm;name=aarch64_ubloxcfg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ubloxcfg-doc}"
SRC_URI[aarch64_ubloxcfg-doc.sha256sum] = "13c1835900bc889364a2fda68e6d5bc6e5958a38abbacfe8dc7d81029c705f5d"

RDEPENDS:ubloxcfg = " \
 glibc \
 "
RDEPENDS:ubloxcfg-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 ubloxcfg \
 "
RDEPENDS:ubloxcfg-doc = " \
 ubloxcfg \
 "
