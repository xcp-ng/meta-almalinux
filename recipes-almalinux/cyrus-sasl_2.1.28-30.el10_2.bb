# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cyrus-sasl"
PV = "2.1.28"
PR = "30.el10_2"
PACKAGES = " \
 cyrus-sasl \
 cyrus-sasl-devel \
 cyrus-sasl-gs2 \
 cyrus-sasl-gssapi \
 cyrus-sasl-ldap \
 cyrus-sasl-lib \
 cyrus-sasl-md5 \
 cyrus-sasl-plain \
 cyrus-sasl-scram \
 cyrus-sasl-sql \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cyrus-sasl-2.1.28-30.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b978f226ad7bb4d3a79d836f6eda536091e8d2413031405c321d9c07be38c97"

URI_x86_64_v2_cyrus-sasl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-2.1.28-30.el10_2.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl}"
SRC_URI[x86_64_v2_cyrus-sasl.sha256sum] = "218fffff4f92ba5d91147263acfde1dd51262986f3c0c939257bcb105401baeb"

URI_x86_64_v2_cyrus-sasl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cyrus-sasl-devel-2.1.28-30.el10_2.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-devel}"
SRC_URI[x86_64_v2_cyrus-sasl-devel.sha256sum] = "a50be8367cb967ec445935bbe26cd002a569783d3594c94dca1435c1e37b27a6"

URI_x86_64_v2_cyrus-sasl-gs2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cyrus-sasl-gs2-2.1.28-30.el10_2.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-gs2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-gs2}"
SRC_URI[x86_64_v2_cyrus-sasl-gs2.sha256sum] = "51ddce7560ec183cf10726ddbedb7df7bc9cb2789802312c1b88db122af3245b"

URI_x86_64_v2_cyrus-sasl-gssapi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-gssapi-2.1.28-30.el10_2.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-gssapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-gssapi}"
SRC_URI[x86_64_v2_cyrus-sasl-gssapi.sha256sum] = "510957e5bd7477d4c9efe17517fa6641a9a28875521b8d436daaf0a26d8477ff"

URI_x86_64_v2_cyrus-sasl-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cyrus-sasl-ldap-2.1.28-30.el10_2.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-ldap}"
SRC_URI[x86_64_v2_cyrus-sasl-ldap.sha256sum] = "7b060dd46ad039470012073b5e8b55a4a3d0d922e8e243870b8aa9f5fa27bc41"

URI_x86_64_v2_cyrus-sasl-lib = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-lib-2.1.28-30.el10_2.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-lib}"
SRC_URI[x86_64_v2_cyrus-sasl-lib.sha256sum] = "ef2d7524b165f412bcedcbcf3236d28e2d0989965c76801cc17930cad0d0549d"

URI_x86_64_v2_cyrus-sasl-md5 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cyrus-sasl-md5-2.1.28-30.el10_2.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-md5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-md5}"
SRC_URI[x86_64_v2_cyrus-sasl-md5.sha256sum] = "7acae4ea6436ede25d80fe28d6110d0f26c4ab8bb7f4039e136903c9c18c7327"

URI_x86_64_v2_cyrus-sasl-plain = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-plain-2.1.28-30.el10_2.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-plain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-plain}"
SRC_URI[x86_64_v2_cyrus-sasl-plain.sha256sum] = "42652e8db517b5ba4b3dff5add1d7b0172d12db1aa7b9f2f7252eef9b0894dcf"

URI_x86_64_v2_cyrus-sasl-scram = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-scram-2.1.28-30.el10_2.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-scram;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-scram}"
SRC_URI[x86_64_v2_cyrus-sasl-scram.sha256sum] = "b26ff85315f0cbe9dfacdecfe98a2e375036f0dc6b8986e5a5d2ec8d3c08392a"

URI_x86_64_v2_cyrus-sasl-sql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cyrus-sasl-sql-2.1.28-30.el10_2.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-sql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-sql}"
SRC_URI[x86_64_v2_cyrus-sasl-sql.sha256sum] = "bd3cc3dcb63eaac834a0723fe78ca8fa2fe8dd9d62769d2c117f4a2101b0fd13"

URI_aarch64_cyrus-sasl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cyrus-sasl-2.1.28-30.el10_2.aarch64.rpm;name=aarch64_cyrus-sasl;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl}"
SRC_URI[aarch64_cyrus-sasl.sha256sum] = "70b87a14e31da4ff4218113ac972fda709c6eedc605dc21c1dd18abe4fa7aaac"

URI_aarch64_cyrus-sasl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cyrus-sasl-devel-2.1.28-30.el10_2.aarch64.rpm;name=aarch64_cyrus-sasl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-devel}"
SRC_URI[aarch64_cyrus-sasl-devel.sha256sum] = "756349ec8648733ae73b6a08348a49203e0b13a63a838f5d59d02a923e2c010a"

URI_aarch64_cyrus-sasl-gs2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cyrus-sasl-gs2-2.1.28-30.el10_2.aarch64.rpm;name=aarch64_cyrus-sasl-gs2;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-gs2}"
SRC_URI[aarch64_cyrus-sasl-gs2.sha256sum] = "445b30d6164575864d8cb3bebfbe15c4a3f2c61b70e699f7c573183a5006dec9"

URI_aarch64_cyrus-sasl-gssapi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cyrus-sasl-gssapi-2.1.28-30.el10_2.aarch64.rpm;name=aarch64_cyrus-sasl-gssapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-gssapi}"
SRC_URI[aarch64_cyrus-sasl-gssapi.sha256sum] = "556a2142a1d6a2ac4458c70eabdf83e68b3ecd6b5042c7e29f5ea9284e13cf95"

URI_aarch64_cyrus-sasl-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cyrus-sasl-ldap-2.1.28-30.el10_2.aarch64.rpm;name=aarch64_cyrus-sasl-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-ldap}"
SRC_URI[aarch64_cyrus-sasl-ldap.sha256sum] = "bdf714b48d944d6b82f1ef33ead246a1153a7f25cb9c33183801f2ea5c8c4aa0"

URI_aarch64_cyrus-sasl-lib = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cyrus-sasl-lib-2.1.28-30.el10_2.aarch64.rpm;name=aarch64_cyrus-sasl-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-lib}"
SRC_URI[aarch64_cyrus-sasl-lib.sha256sum] = "ddeea6b6a2b441e21957d4f75e2851def0ed21f9d02b5852974a4bcf0a089aaf"

URI_aarch64_cyrus-sasl-md5 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cyrus-sasl-md5-2.1.28-30.el10_2.aarch64.rpm;name=aarch64_cyrus-sasl-md5;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-md5}"
SRC_URI[aarch64_cyrus-sasl-md5.sha256sum] = "c79d57b88c35755767301c4de3b370f531dbd070e4226fee51bc6b0dffa711d4"

URI_aarch64_cyrus-sasl-plain = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cyrus-sasl-plain-2.1.28-30.el10_2.aarch64.rpm;name=aarch64_cyrus-sasl-plain;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-plain}"
SRC_URI[aarch64_cyrus-sasl-plain.sha256sum] = "11fcba75f34331ed1270254ceec88b090f2a6f23f0cfb066dfade5e2fe5eaee8"

URI_aarch64_cyrus-sasl-scram = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cyrus-sasl-scram-2.1.28-30.el10_2.aarch64.rpm;name=aarch64_cyrus-sasl-scram;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-scram}"
SRC_URI[aarch64_cyrus-sasl-scram.sha256sum] = "fbc0976ce3836e7482479770447b93cf3dbff626e6eff8fee1ed496cf8ace504"

URI_aarch64_cyrus-sasl-sql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cyrus-sasl-sql-2.1.28-30.el10_2.aarch64.rpm;name=aarch64_cyrus-sasl-sql;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-sql}"
SRC_URI[aarch64_cyrus-sasl-sql.sha256sum] = "b0e682a9f1ed61af70868f2dd90962b520f25b5c1c49be87798f6afc8a77a1a5"

RDEPENDS:cyrus-sasl = " \
 bash \
 cyrus-sasl-lib \
 gdbm-libs \
 glibc \
 krb5-libs \
 libxcrypt \
 openldap \
 openssl-libs \
 pam-libs \
 shadow-utils \
 util-linux \
 "
RDEPENDS:cyrus-sasl-devel = " \
 cyrus-sasl \
 cyrus-sasl-lib \
 glibc \
 krb5-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:cyrus-sasl-gs2 = " \
 cyrus-sasl-lib \
 glibc \
 krb5-libs \
 libcom_err \
 libxcrypt \
 "
RDEPENDS:cyrus-sasl-gssapi = " \
 cyrus-sasl-lib \
 glibc \
 krb5-libs \
 libcom_err \
 libxcrypt \
 "
RDEPENDS:cyrus-sasl-ldap = " \
 cyrus-sasl-lib \
 glibc \
 libxcrypt \
 openldap \
 "
RDEPENDS:cyrus-sasl-lib = " \
 gdbm-libs \
 glibc \
 libxcrypt \
 "
RDEPENDS:cyrus-sasl-md5 = " \
 cyrus-sasl-lib \
 glibc \
 libxcrypt \
 openssl-libs \
 "
RDEPENDS:cyrus-sasl-plain = " \
 cyrus-sasl-lib \
 glibc \
 libxcrypt \
 "
RDEPENDS:cyrus-sasl-scram = " \
 cyrus-sasl-lib \
 glibc \
 libxcrypt \
 openssl-libs \
 "
RDEPENDS:cyrus-sasl-sql = " \
 cyrus-sasl-lib \
 glibc \
 libpq \
 libxcrypt \
 mariadb-connector-c \
 "
