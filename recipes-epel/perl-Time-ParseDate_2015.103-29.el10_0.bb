# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Time-ParseDate"
PV = "2015.103"
PR = "29.el10_0"
PACKAGES = " \
 perl-Time-ParseDate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Time-ParseDate-2015.103-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5af125ad129872c1c626c0ffae1d91c1d0f4b39a077fd636ead2c6ca5417584"

URI_x86_64_v2_perl-Time-ParseDate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Time-ParseDate-2015.103-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Time-ParseDate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Time-ParseDate}"
SRC_URI[x86_64_v2_perl-Time-ParseDate.sha256sum] = "b537814f7e5d28db69ec93e85afb20b02da3927a564b893aab59fa7cbe5b7831"

URI_aarch64_perl-Time-ParseDate = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Time-ParseDate-2015.103-29.el10_0.noarch.rpm;name=aarch64_perl-Time-ParseDate;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Time-ParseDate}"
SRC_URI[aarch64_perl-Time-ParseDate.sha256sum] = "a7212517f41361eaac55a3e7e688922b25935a6e717a4ed741c7fd10dc3fbbc9"

RDEPENDS:perl-Time-ParseDate = " \
 perl-Carp \
 perl-Exporter \
 perl-Time-ParseDate \
 perl-libs \
 perl-vars \
 "
