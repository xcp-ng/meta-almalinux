# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libassuan"
PV = "2.5.6"
PR = "6.el10"
PACKAGES = " \
 libassuan \
 libassuan-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libassuan-2.5.6-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f327c3ca740b46d79e22b0801d2fb3e842934b567666a45a13f373fc696912ee"

URI_x86_64_v2_libassuan = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libassuan-2.5.6-6.el10.x86_64_v2.rpm;name=x86_64_v2_libassuan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libassuan}"
SRC_URI[x86_64_v2_libassuan.sha256sum] = "973a9407ad42671e06b77c224f71b136a214f3e7e490e2085834226e7ff135cd"

URI_x86_64_v2_libassuan-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libassuan-devel-2.5.6-6.el10.x86_64_v2.rpm;name=x86_64_v2_libassuan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libassuan-devel}"
SRC_URI[x86_64_v2_libassuan-devel.sha256sum] = "667553b11ebaab9787fabcc7ccbd033c756ae6a04e1d9ac5e8db27128fc690e3"

URI_aarch64_libassuan = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libassuan-2.5.6-6.el10.aarch64.rpm;name=aarch64_libassuan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libassuan}"
SRC_URI[aarch64_libassuan.sha256sum] = "9bd7e3ee9cc2d9f7f287f1f852a1404b50843acb31f6957e92545b6497bd0bad"

URI_aarch64_libassuan-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libassuan-devel-2.5.6-6.el10.aarch64.rpm;name=aarch64_libassuan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libassuan-devel}"
SRC_URI[aarch64_libassuan-devel.sha256sum] = "77c30517095fae8c50e4022a82be3c6203081eb9baf4648ebb620486568706bb"

RDEPENDS:libassuan = " \
 glibc \
 libgpg-error \
 "
RDEPENDS:libassuan-devel = " \
 bash \
 libassuan \
 libgpg-error-devel \
 pkgconf-pkg-config \
 "
