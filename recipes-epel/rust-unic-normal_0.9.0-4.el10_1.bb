# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-normal"
PV = "0.9.0"
PR = "4.el10_1"
PACKAGES = " \
 rust-unic-normal+default-devel \
 rust-unic-normal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-normal-0.9.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18484d3275457a316ba2d904969bb3e318ed1e1a00b503f88799174e93d26833"

URI_x86_64_v2_rust-unic-normal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-normal+default-devel-0.9.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-normal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-normal+default-devel}"
SRC_URI[x86_64_v2_rust-unic-normal+default-devel.sha256sum] = "fcecfd8b12bb6101d30d4de684900d08b79654c25a321a50ffefc4ef2f83bae6"

URI_x86_64_v2_rust-unic-normal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-normal-devel-0.9.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-normal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-normal-devel}"
SRC_URI[x86_64_v2_rust-unic-normal-devel.sha256sum] = "e2a59ee15ad7be8c0cc91c936a26218f59f0a0b57375c219cd1a6f2ca6259a5c"

URI_aarch64_rust-unic-normal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-normal+default-devel-0.9.0-4.el10_1.noarch.rpm;name=aarch64_rust-unic-normal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-normal+default-devel}"
SRC_URI[aarch64_rust-unic-normal+default-devel.sha256sum] = "b6e85d79427303b8137b6a2ae379e68b3b093a7f96dacdca22ff14195a79c5d4"

URI_aarch64_rust-unic-normal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-normal-devel-0.9.0-4.el10_1.noarch.rpm;name=aarch64_rust-unic-normal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-normal-devel}"
SRC_URI[aarch64_rust-unic-normal-devel.sha256sum] = "31df15ddb43de1d181b3c7a6f096ce624a90761adfae8c80bf49d4bba5ec2536"

RDEPENDS:rust-unic-normal+default-devel = " \
 cargo \
 rust-unic-normal-devel \
 "
RDEPENDS:rust-unic-normal-devel = " \
 cargo \
 rust-unic-ucd-normal+default-devel \
 "
