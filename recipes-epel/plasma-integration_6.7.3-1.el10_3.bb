# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-integration"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-integration \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-integration-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e28621c78894548b46e3bdcdeecaf027cbf031ec33c0fba48f4d041022d065f"

URI_x86_64_v2_plasma-integration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-integration-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-integration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-integration}"
SRC_URI[x86_64_v2_plasma-integration.sha256sum] = "f5670e56706dc5c75b349af7699e4e33cc2b75ec666188102d0ed22d4af8f17f"

URI_aarch64_plasma-integration = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-integration-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-integration;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-integration}"
SRC_URI[aarch64_plasma-integration.sha256sum] = "4b739ca95cf8bde3576912b891ad84b42efc21794525e39a020ead249de31965"

RDEPENDS:plasma-integration = " \
 breeze-cursor-theme \
 breeze-icon-theme \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-qqc2-desktop-style \
 libXcursor \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-breeze \
 qqc2-breeze-style \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
