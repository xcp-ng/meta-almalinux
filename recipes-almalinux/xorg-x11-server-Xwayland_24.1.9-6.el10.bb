# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xorg-x11-server-Xwayland"
PV = "24.1.9"
PR = "6.el10"
PACKAGES = " \
 xorg-x11-server-Xwayland \
 xorg-x11-server-Xwayland-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xorg-x11-server-Xwayland-24.1.9-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44b4622ad043b32cc102799225e52df1ddfd2c1ea49cbc3e8a0f1831551e1766"

URI_x86_64_v2_xorg-x11-server-Xwayland = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xorg-x11-server-Xwayland-24.1.9-6.el10.x86_64_v2.rpm;name=x86_64_v2_xorg-x11-server-Xwayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-server-Xwayland}"
SRC_URI[x86_64_v2_xorg-x11-server-Xwayland.sha256sum] = "455af957024731f8fc572b89b9d75b31c3ec0b1fe34e5ed7c710b6c7daedaaa5"

URI_x86_64_v2_xorg-x11-server-Xwayland-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xorg-x11-server-Xwayland-devel-24.1.9-6.el10.x86_64_v2.rpm;name=x86_64_v2_xorg-x11-server-Xwayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-server-Xwayland-devel}"
SRC_URI[x86_64_v2_xorg-x11-server-Xwayland-devel.sha256sum] = "e0fbd7c8c2089ab66d40101f56b24b21b9b6a4caf93b86ee4826997548e0bb43"

URI_aarch64_xorg-x11-server-Xwayland = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xorg-x11-server-Xwayland-24.1.9-6.el10.aarch64.rpm;name=aarch64_xorg-x11-server-Xwayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-server-Xwayland}"
SRC_URI[aarch64_xorg-x11-server-Xwayland.sha256sum] = "729bfcb4d028ab5d558fa90bbf472cded6baa84758538c31553d193cd4824f37"

URI_aarch64_xorg-x11-server-Xwayland-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xorg-x11-server-Xwayland-devel-24.1.9-6.el10.aarch64.rpm;name=aarch64_xorg-x11-server-Xwayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-server-Xwayland-devel}"
SRC_URI[aarch64_xorg-x11-server-Xwayland-devel.sha256sum] = "ea3d97b3234d530d3002986534b9e8e7938fb2f87ba6c5c31aac8af16e7ccd49"

RDEPENDS:xorg-x11-server-Xwayland = " \
 audit-libs \
 glibc \
 libXau \
 libXdmcp \
 libXfont2 \
 libdecor \
 libdrm \
 libei \
 libepoxy \
 libglvnd-egl \
 libglvnd-glx \
 liboeffis \
 libselinux \
 libtirpc \
 libwayland-client \
 libxcvt \
 libxshmfence \
 mesa-libgbm \
 openssl-libs \
 pixman \
 xkbcomp \
 xkeyboard-config \
 "
RDEPENDS:xorg-x11-server-Xwayland-devel = " \
 pkgconf-pkg-config \
 xorg-x11-server-Xwayland \
 "
