# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle"
PV = "1.0.14"
PR = "1.el10_2"
PACKAGES = " \
 rust-anstyle+default-devel \
 rust-anstyle+std-devel \
 rust-anstyle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-1.0.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f884d168d36bdb6ddb2d88d55a7a8db55827a060b7969eccdb82201f3d762876"

URI_x86_64_v2_rust-anstyle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle+default-devel-1.0.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle+default-devel.sha256sum] = "13e0421c38e14b2144d006601ef33bc0d5a8e0229a3260dc5b331c1663a23ab8"

URI_x86_64_v2_rust-anstyle+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle+std-devel-1.0.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle+std-devel}"
SRC_URI[x86_64_v2_rust-anstyle+std-devel.sha256sum] = "8aaa1f61dffcfad7ddfda564333ffc0c635e6678dbd403cff9204eac17df30db"

URI_x86_64_v2_rust-anstyle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-devel-1.0.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-devel}"
SRC_URI[x86_64_v2_rust-anstyle-devel.sha256sum] = "d7d0f57204864d3b31728acff776e6d8830c2fb021dcc8ab6beca8bb7ab47cec"

URI_aarch64_rust-anstyle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle+default-devel-1.0.14-1.el10_2.noarch.rpm;name=aarch64_rust-anstyle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle+default-devel}"
SRC_URI[aarch64_rust-anstyle+default-devel.sha256sum] = "708d8380ecd66fe2751e71eda044e5cd757447ec02fd65ddf0b8523ac9088ca4"

URI_aarch64_rust-anstyle+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle+std-devel-1.0.14-1.el10_2.noarch.rpm;name=aarch64_rust-anstyle+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle+std-devel}"
SRC_URI[aarch64_rust-anstyle+std-devel.sha256sum] = "ecd9b81c15fc1f380e63b2223ff1e3abfad1d1690b213cf5e734519d31e1ec49"

URI_aarch64_rust-anstyle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-devel-1.0.14-1.el10_2.noarch.rpm;name=aarch64_rust-anstyle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-devel}"
SRC_URI[aarch64_rust-anstyle-devel.sha256sum] = "fe498e7931aedc25a55d4337322b9ac52ae713ab60477606948f07a9f37b6f5c"

RDEPENDS:rust-anstyle+default-devel = " \
 cargo \
 rust-anstyle+std-devel \
 rust-anstyle-devel \
 "
RDEPENDS:rust-anstyle+std-devel = " \
 cargo \
 rust-anstyle-devel \
 "
RDEPENDS:rust-anstyle-devel = " \
 cargo \
 rust \
 "
