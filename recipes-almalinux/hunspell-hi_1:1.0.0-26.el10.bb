# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-hi"
PE = "1"
PV = "1.0.0"
PR = "26.el10"
PACKAGES = " \
 hunspell-hi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-hi-1.0.0-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4feeced296f1f0e67f8ee839d8b4612404d7ff8be04468743d58cd2ee701b5a"

URI_x86_64_v2_hunspell-hi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-hi-1.0.0-26.el10.noarch.rpm;name=x86_64_v2_hunspell-hi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-hi}"
SRC_URI[x86_64_v2_hunspell-hi.sha256sum] = "2138a0a84f487196d5b5c0786662f116a6cfb4e61bb7b4a2da8bf0d980a5970a"

URI_aarch64_hunspell-hi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-hi-1.0.0-26.el10.noarch.rpm;name=aarch64_hunspell-hi;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-hi}"
SRC_URI[aarch64_hunspell-hi.sha256sum] = "2138a0a84f487196d5b5c0786662f116a6cfb4e61bb7b4a2da8bf0d980a5970a"

RDEPENDS:hunspell-hi = " \
 hunspell-filesystem \
 "
