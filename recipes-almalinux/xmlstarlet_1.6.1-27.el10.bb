# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xmlstarlet"
PV = "1.6.1"
PR = "27.el10"
PACKAGES = " \
 xmlstarlet \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xmlstarlet-1.6.1-27.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1deca509e1f94c23acbad31112a13d3f384616f09e49ca98b143183f375c92b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xmlstarlet-1.6.1-27.el10.x86_64_v2.rpm;name=x86_64_v2_xmlstarlet;unpack=0"
SRC_URI[x86_64_v2_xmlstarlet.sha256sum] = "365d2b8340a2a9bb0324a1f2f1306eac35fbf45a9fe863c3ad41ee3d5031b192"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xmlstarlet-1.6.1-27.el10.aarch64.rpm;name=aarch64_xmlstarlet;unpack=0"
SRC_URI[aarch64_xmlstarlet.sha256sum] = "5c4acc6636203a6ac434fcf52aaab4cc014a257c8ca9842d6e739f402ca56d31"

RDEPENDS:xmlstarlet = " \
 glibc \
 libxml2 \
 libxslt \
 "
