# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lldpd"
PV = "1.0.19"
PR = "1.el10"
PACKAGES = " \
 lldpd \
 lldpd-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lldpd-1.0.19-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d99af15a4ff01393e09e1c9e24a3b0602e0a020c57ebaddc888f84d30bc0a478"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lldpd-1.0.19-1.el10.x86_64_v2.rpm;name=x86_64_v2_lldpd;unpack=0"
SRC_URI[x86_64_v2_lldpd.sha256sum] = "c85447af070a47470eb7bdea7ddbb3335a92ceaceba4f04af0fc0a4552400db8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lldpd-devel-1.0.19-1.el10.x86_64_v2.rpm;name=x86_64_v2_lldpd-devel;unpack=0"
SRC_URI[x86_64_v2_lldpd-devel.sha256sum] = "1050346093e0496db54adddfc73d18141295f343ff47f0cc872795f7fe11a089"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lldpd-1.0.19-1.el10.aarch64.rpm;name=aarch64_lldpd;unpack=0"
SRC_URI[aarch64_lldpd.sha256sum] = "8600fc5ef6e0564ea7e2a781f50714cb6a01854e0a940fcb758230706ed1aa9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lldpd-devel-1.0.19-1.el10.aarch64.rpm;name=aarch64_lldpd-devel;unpack=0"
SRC_URI[aarch64_lldpd-devel.sha256sum] = "c958490df179221222be476d83672c57dd94b50709b809d254ff7655b7dcf3e0"

RDEPENDS:lldpd = " \
 bash \
 glibc \
 libevent \
 libxml2 \
 net-snmp-agent-libs \
 net-snmp-libs \
 readline \
 shadow-utils \
 systemd \
 "
RDEPENDS:lldpd-devel = " \
 lldpd \
 pkgconf-pkg-config \
 "
