# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "HepMC3"
PV = "3.3.1"
PR = "12.el10_2"
PACKAGES = " \
 HepMC3 \
 HepMC3-devel \
 HepMC3-doc \
 HepMC3-interfaces-devel \
 HepMC3-protobufIO \
 HepMC3-protobufIO-devel \
 HepMC3-rootIO \
 HepMC3-rootIO-devel \
 HepMC3-search \
 HepMC3-search-devel \
 python3-HepMC3 \
 python3-HepMC3-protobufIO \
 python3-HepMC3-rootIO \
 python3-HepMC3-search \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/HepMC3-3.3.1-12.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed70ea59110b9a6a7d4c051099209ff86d97937f54c3ada59e733e54607eac65"

URI_x86_64_v2_HepMC3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-3.3.1-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3}"
SRC_URI[x86_64_v2_HepMC3.sha256sum] = "2a26d0e7fd24443657360f93b9b979b320f6da3dbd1c7d7d1875179085fe360b"

URI_x86_64_v2_HepMC3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-devel-3.3.1-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-devel}"
SRC_URI[x86_64_v2_HepMC3-devel.sha256sum] = "bc436f7864b71f1c3978f6a202fdeb49076fd70afcd32da0b00d71a6b1002b34"

URI_x86_64_v2_HepMC3-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-doc-3.3.1-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_HepMC3-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-doc}"
SRC_URI[x86_64_v2_HepMC3-doc.sha256sum] = "7211caa75d632efb0457da12ffbea98f2ba226c4fd93416862a0d6ab1abb1048"

URI_x86_64_v2_HepMC3-interfaces-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-interfaces-devel-3.3.1-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_HepMC3-interfaces-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-interfaces-devel}"
SRC_URI[x86_64_v2_HepMC3-interfaces-devel.sha256sum] = "5a5ad5909ff10b04163ab5139f63e13e0faa9549e1f34e91392e2f249d8345c3"

URI_x86_64_v2_HepMC3-protobufIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-protobufIO-3.3.1-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-protobufIO}"
SRC_URI[x86_64_v2_HepMC3-protobufIO.sha256sum] = "553089cf440fd1ef792b326d050e71c72ce079574c60094e59fc24343f66fd78"

URI_x86_64_v2_HepMC3-protobufIO-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-protobufIO-devel-3.3.1-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-protobufIO-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-protobufIO-devel}"
SRC_URI[x86_64_v2_HepMC3-protobufIO-devel.sha256sum] = "96128d0b915cb1550faec36107d1a8747a089c6fb04295dd5d16fd8c11cb649d"

URI_x86_64_v2_HepMC3-rootIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-rootIO-3.3.1-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-rootIO}"
SRC_URI[x86_64_v2_HepMC3-rootIO.sha256sum] = "d85ba5764547a970eebe6e4c623336c1a4ef1e357ef6d0d2dfea9937cc100826"

URI_x86_64_v2_HepMC3-rootIO-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-rootIO-devel-3.3.1-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-rootIO-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-rootIO-devel}"
SRC_URI[x86_64_v2_HepMC3-rootIO-devel.sha256sum] = "dd080f464a73445510e0a13ab951d578d5123afe01f209a1f215ed4edc1a6695"

URI_x86_64_v2_HepMC3-search = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-search-3.3.1-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-search}"
SRC_URI[x86_64_v2_HepMC3-search.sha256sum] = "7c55025259828989f431a4cc4f4c1938468caa8b4eccbdb1b9423dba7158450e"

URI_x86_64_v2_HepMC3-search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-search-devel-3.3.1-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-search-devel}"
SRC_URI[x86_64_v2_HepMC3-search-devel.sha256sum] = "ebb04020478755b5a261aa1e194767e22d764a8ee7379aad6f2cbf1cc2b66e54"

URI_x86_64_v2_python3-HepMC3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-3.3.1-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3}"
SRC_URI[x86_64_v2_python3-HepMC3.sha256sum] = "877545b26f3c705114051675360f8373da16f4d13ae1ff801b4e9bb238ca76f5"

URI_x86_64_v2_python3-HepMC3-protobufIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-protobufIO-3.3.1-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3-protobufIO}"
SRC_URI[x86_64_v2_python3-HepMC3-protobufIO.sha256sum] = "0dcc89d8f10aa9ad5222deded52ca19301c7792761d7085a87b991db331ce95d"

URI_x86_64_v2_python3-HepMC3-rootIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-rootIO-3.3.1-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3-rootIO}"
SRC_URI[x86_64_v2_python3-HepMC3-rootIO.sha256sum] = "d68c9e78fc02868d176b6b6a419f3bc38dfa367b666a2dcf47291ccee7fc94e5"

URI_x86_64_v2_python3-HepMC3-search = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-search-3.3.1-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3-search}"
SRC_URI[x86_64_v2_python3-HepMC3-search.sha256sum] = "ccd989e690c8fdb03a2c0915a90e005dd57fa5eb8a72a6b1d67648b2d72b9d41"

URI_aarch64_HepMC3 = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-3.3.1-12.el10_2.aarch64.rpm;name=aarch64_HepMC3;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3}"
SRC_URI[aarch64_HepMC3.sha256sum] = "9f2feec8f69b4f5e5e02770064e97d7de56c2956faaf0f0edb673020f9d4d342"

URI_aarch64_HepMC3-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-devel-3.3.1-12.el10_2.aarch64.rpm;name=aarch64_HepMC3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-devel}"
SRC_URI[aarch64_HepMC3-devel.sha256sum] = "b8892aa9d59a6d8d51c2b3e8b1a4cd37c5b1029c16ab48c64fec5ba2f7a7e811"

URI_aarch64_HepMC3-doc = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-doc-3.3.1-12.el10_2.noarch.rpm;name=aarch64_HepMC3-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-doc}"
SRC_URI[aarch64_HepMC3-doc.sha256sum] = "f228c11f14afbd10807db919010a9f25e6b78b377160a01f93b6e84b9e975cd3"

URI_aarch64_HepMC3-interfaces-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-interfaces-devel-3.3.1-12.el10_2.noarch.rpm;name=aarch64_HepMC3-interfaces-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-interfaces-devel}"
SRC_URI[aarch64_HepMC3-interfaces-devel.sha256sum] = "1d14730e06c794acc78326493ffe5d5ca7ca400e08c6dc5ac811fd6029c03faa"

URI_aarch64_HepMC3-protobufIO = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-protobufIO-3.3.1-12.el10_2.aarch64.rpm;name=aarch64_HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-protobufIO}"
SRC_URI[aarch64_HepMC3-protobufIO.sha256sum] = "0b1137df1fc4ff22ee8d04ac9ad7562db9833a5112f448a864e5e5ab80b6fa08"

URI_aarch64_HepMC3-protobufIO-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-protobufIO-devel-3.3.1-12.el10_2.aarch64.rpm;name=aarch64_HepMC3-protobufIO-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-protobufIO-devel}"
SRC_URI[aarch64_HepMC3-protobufIO-devel.sha256sum] = "0f79a7db1a6e582793b142871b6ab364fe5b43e6cb400c8f030a2c7919e6a815"

URI_aarch64_HepMC3-rootIO = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-rootIO-3.3.1-12.el10_2.aarch64.rpm;name=aarch64_HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-rootIO}"
SRC_URI[aarch64_HepMC3-rootIO.sha256sum] = "d25cbde4596edcca83187a756dbf7775b831f2b772542dc53cb1c56bc614afca"

URI_aarch64_HepMC3-rootIO-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-rootIO-devel-3.3.1-12.el10_2.aarch64.rpm;name=aarch64_HepMC3-rootIO-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-rootIO-devel}"
SRC_URI[aarch64_HepMC3-rootIO-devel.sha256sum] = "8e6a31b77a9baebd374af3ee57154a436743e576e2e41dd1d38d3d1f95a56474"

URI_aarch64_HepMC3-search = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-search-3.3.1-12.el10_2.aarch64.rpm;name=aarch64_HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-search}"
SRC_URI[aarch64_HepMC3-search.sha256sum] = "b8dd881e57649df6b725b32daad01263c7ae4246d74848c604c78030bc6608c2"

URI_aarch64_HepMC3-search-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-search-devel-3.3.1-12.el10_2.aarch64.rpm;name=aarch64_HepMC3-search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-search-devel}"
SRC_URI[aarch64_HepMC3-search-devel.sha256sum] = "09670bc1b03741896466943062d2ec4777959fea2687cbf6445c647de3480f14"

URI_aarch64_python3-HepMC3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-3.3.1-12.el10_2.aarch64.rpm;name=aarch64_python3-HepMC3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3}"
SRC_URI[aarch64_python3-HepMC3.sha256sum] = "7324896b3ab826708ad1c4c563b85be216bcd839f9ebb12a0bc46a4987996eb7"

URI_aarch64_python3-HepMC3-protobufIO = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-protobufIO-3.3.1-12.el10_2.aarch64.rpm;name=aarch64_python3-HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3-protobufIO}"
SRC_URI[aarch64_python3-HepMC3-protobufIO.sha256sum] = "8b00e213a64a2afb99849c59f99f2914147c1d7c5fcf34ed65d55392cd267975"

URI_aarch64_python3-HepMC3-rootIO = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-rootIO-3.3.1-12.el10_2.aarch64.rpm;name=aarch64_python3-HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3-rootIO}"
SRC_URI[aarch64_python3-HepMC3-rootIO.sha256sum] = "9157e6d9dfb501199f2a87992a5759e39817e815ba05bba0aefbd65ea6767415"

URI_aarch64_python3-HepMC3-search = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-search-3.3.1-12.el10_2.aarch64.rpm;name=aarch64_python3-HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3-search}"
SRC_URI[aarch64_python3-HepMC3-search.sha256sum] = "88bac207245ba2f56d12dfd6a329eb813a1e0eab9784b7d6f75d13b11678df32"

RDEPENDS:HepMC3 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:HepMC3-devel = " \
 HepMC3 \
 bash \
 "
RDEPENDS:HepMC3-doc = " \
 "
RDEPENDS:HepMC3-interfaces-devel = " \
 HepMC3-devel \
 "
RDEPENDS:HepMC3-protobufIO = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 "
RDEPENDS:HepMC3-protobufIO-devel = " \
 HepMC3-devel \
 HepMC3-protobufIO \
 "
RDEPENDS:HepMC3-rootIO = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-tree \
 "
RDEPENDS:HepMC3-rootIO-devel = " \
 HepMC3-devel \
 HepMC3-rootIO \
 "
RDEPENDS:HepMC3-search = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:HepMC3-search-devel = " \
 HepMC3-devel \
 HepMC3-search \
 "
RDEPENDS:python3-HepMC3 = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:python3-HepMC3-protobufIO = " \
 HepMC3 \
 HepMC3-protobufIO \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 python3 \
 python3-HepMC3 \
 "
RDEPENDS:python3-HepMC3-rootIO = " \
 HepMC3 \
 HepMC3-rootIO \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-HepMC3 \
 root-core \
 "
RDEPENDS:python3-HepMC3-search = " \
 HepMC3 \
 HepMC3-search \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-HepMC3 \
 "
