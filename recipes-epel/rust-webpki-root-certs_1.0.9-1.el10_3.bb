# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-webpki-root-certs"
PV = "1.0.9"
PR = "1.el10_3"
PACKAGES = " \
 rust-webpki-root-certs+default-devel \
 rust-webpki-root-certs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-webpki-root-certs-1.0.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb919b9507cabd73fec3668bee033495e43e316d82eee8d7a5f1f9b2cda5fc58"

URI_x86_64_v2_rust-webpki-root-certs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webpki-root-certs+default-devel-1.0.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webpki-root-certs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webpki-root-certs+default-devel}"
SRC_URI[x86_64_v2_rust-webpki-root-certs+default-devel.sha256sum] = "85ca3fa77452f99bea1ef8bf16fc95d11c76e77649805b2a52d807c3c3bdf13d"

URI_x86_64_v2_rust-webpki-root-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webpki-root-certs-devel-1.0.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webpki-root-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webpki-root-certs-devel}"
SRC_URI[x86_64_v2_rust-webpki-root-certs-devel.sha256sum] = "65869848d0db72cf6aa334fbb33062e5dbe4a01ac9718e2c98abae98a08fb2a7"

URI_aarch64_rust-webpki-root-certs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webpki-root-certs+default-devel-1.0.9-1.el10_3.noarch.rpm;name=aarch64_rust-webpki-root-certs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webpki-root-certs+default-devel}"
SRC_URI[aarch64_rust-webpki-root-certs+default-devel.sha256sum] = "74c1b7b18c24439ac8844630295af73d641eb7c07146016c73a323ef95383e98"

URI_aarch64_rust-webpki-root-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webpki-root-certs-devel-1.0.9-1.el10_3.noarch.rpm;name=aarch64_rust-webpki-root-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webpki-root-certs-devel}"
SRC_URI[aarch64_rust-webpki-root-certs-devel.sha256sum] = "6e37ca7143d18228a7c4254f3c30a523e3f77e143d1d94bb126012c6b523f120"

RDEPENDS:rust-webpki-root-certs+default-devel = " \
 cargo \
 rust-webpki-root-certs-devel \
 "
RDEPENDS:rust-webpki-root-certs-devel = " \
 cargo \
 rust \
 rust-rustls-pki-types-devel \
 "
