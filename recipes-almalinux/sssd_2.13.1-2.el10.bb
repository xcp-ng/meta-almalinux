# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sssd"
PV = "2.13.1"
PR = "2.el10"
PACKAGES = " \
 libipa_hbac \
 libsss_autofs \
 libsss_certmap \
 libsss_idmap \
 libsss_nss_idmap \
 libsss_nss_idmap-devel \
 libsss_sudo \
 python3-libipa_hbac \
 python3-libsss_nss_idmap \
 python3-sss \
 python3-sss-murmur \
 python3-sssdconfig \
 sssd \
 sssd-ad \
 sssd-client \
 sssd-common \
 sssd-common-pac \
 sssd-dbus \
 sssd-idp \
 sssd-ipa \
 sssd-kcm \
 sssd-krb5 \
 sssd-krb5-common \
 sssd-ldap \
 sssd-nfs-idmap \
 sssd-passkey \
 sssd-proxy \
 sssd-tools \
 sssd-winbind-idmap \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sssd-2.13.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e4af1b48171de412acee42fd8b0ed98028d9c8724e20bd5313fb42964743ee7"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - python3-sss: libcap.so.2()(64bit)
# - sssd-ad: libcap.so.2()(64bit)
# - sssd-common: libcap.so.2()(64bit)
# - sssd-idp: libcap.so.2()(64bit)
# - sssd-ipa: libcap.so.2()(64bit)
# - sssd-krb5-common: libcap.so.2()(64bit)
# - sssd-krb5: libcap.so.2()(64bit)
# - sssd-ldap: libcap.so.2()(64bit)
# - sssd-proxy: libcap.so.2()(64bit)

URI_x86_64_v2_libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libipa_hbac-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libipa_hbac}"
SRC_URI[x86_64_v2_libipa_hbac.sha256sum] = "171bc6341aa70780f31fecd31276ff65d7fe4626cda416f85b564e6a19d9a610"

URI_x86_64_v2_libsss_autofs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_autofs-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_libsss_autofs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_autofs}"
SRC_URI[x86_64_v2_libsss_autofs.sha256sum] = "e34640e3bf779b05e6dfbd4ee439e1db77ffd7fa81db41e84ad3d328396eaa3e"

URI_x86_64_v2_libsss_certmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_certmap-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_libsss_certmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_certmap}"
SRC_URI[x86_64_v2_libsss_certmap.sha256sum] = "1f3c59ea71465d90683e7f78b5e71cda8e594c1c272556be3ce9c390f7b02fe5"

URI_x86_64_v2_libsss_idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_idmap-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_libsss_idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_idmap}"
SRC_URI[x86_64_v2_libsss_idmap.sha256sum] = "14e9974589e22056fd9f4e7d9b8c5ff31c2c968076442e02296c58fd4f8fc75f"

URI_x86_64_v2_libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_nss_idmap-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_nss_idmap}"
SRC_URI[x86_64_v2_libsss_nss_idmap.sha256sum] = "d79861fbbf5b100bb44735d5baa76498316a6c3d7f833c034b25bf9bf627d3cf"

URI_x86_64_v2_libsss_nss_idmap-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsss_nss_idmap-devel-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_libsss_nss_idmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_nss_idmap-devel}"
SRC_URI[x86_64_v2_libsss_nss_idmap-devel.sha256sum] = "63d216b974c43a783709afc1f71256204ffc9356b79a572a46c5ba67575fb18f"

URI_x86_64_v2_libsss_sudo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_sudo-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_libsss_sudo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_sudo}"
SRC_URI[x86_64_v2_libsss_sudo.sha256sum] = "8878ff2b1208c91ea27c6d10b41681fb429aa05887b6d2f7398a9c5da8a3d36e"

URI_x86_64_v2_python3-libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libipa_hbac-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libipa_hbac}"
SRC_URI[x86_64_v2_python3-libipa_hbac.sha256sum] = "2a65c24b521a6433b1633432c03841876ac95a92205a23a52f55d07666470b3c"

URI_x86_64_v2_python3-libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libsss_nss_idmap-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libsss_nss_idmap}"
SRC_URI[x86_64_v2_python3-libsss_nss_idmap.sha256sum] = "a892c286da61f81e639f876b9da26869178a90ad8bf88567ca9697f35334bb9f"

URI_x86_64_v2_python3-sss = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-sss-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-sss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sss}"
SRC_URI[x86_64_v2_python3-sss.sha256sum] = "4124f0ad8df32fa221588c52b88c6295be28c71cc8c6030e9417439667426bf9"

URI_x86_64_v2_python3-sss-murmur = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-sss-murmur-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-sss-murmur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sss-murmur}"
SRC_URI[x86_64_v2_python3-sss-murmur.sha256sum] = "639fa6fba48bc5f217fcb3e71731085b327cb1a9d4d18efca4169ea91efb6e27"

URI_x86_64_v2_python3-sssdconfig = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-sssdconfig-2.13.1-2.el10.noarch.rpm;name=x86_64_v2_python3-sssdconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sssdconfig}"
SRC_URI[x86_64_v2_python3-sssdconfig.sha256sum] = "c399e0e376ff60fbac316a78c6503fdeb6fea1f96eed5a4e97c188af5bf8e7a7"

URI_x86_64_v2_sssd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd}"
SRC_URI[x86_64_v2_sssd.sha256sum] = "2216ff0fc26067a7cc69f234f9ee0164f87567b8f6f93b2d84b440976a7828dc"

URI_x86_64_v2_sssd-ad = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-ad-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-ad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-ad}"
SRC_URI[x86_64_v2_sssd-ad.sha256sum] = "9bbdfaa894996065ba24e04c38e2ab37f97b7c886cd6e171c3aebfcd106dd254"

URI_x86_64_v2_sssd-client = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-client-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-client}"
SRC_URI[x86_64_v2_sssd-client.sha256sum] = "526fe31f07eaa13f791cf055114c365cfa3c2d7489da442863b2361e7c24b305"

URI_x86_64_v2_sssd-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-common-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-common}"
SRC_URI[x86_64_v2_sssd-common.sha256sum] = "a7be635906bdb6bf13f3c928c793ec7dca3ae9545f2331f3d6a927f3918425a1"

URI_x86_64_v2_sssd-common-pac = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-common-pac-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-common-pac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-common-pac}"
SRC_URI[x86_64_v2_sssd-common-pac.sha256sum] = "e5797aa1ff1be5b14196611f4402789bbb868eec1671685dc046a9b940d7d9da"

URI_x86_64_v2_sssd-dbus = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-dbus-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-dbus}"
SRC_URI[x86_64_v2_sssd-dbus.sha256sum] = "046a21c3fd7d7157e074753742839493422bd74c33962df9b9dbb5c78488cfb8"

URI_x86_64_v2_sssd-idp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sssd-idp-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-idp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-idp}"
SRC_URI[x86_64_v2_sssd-idp.sha256sum] = "07908bae2df6372a599a3bc2b9eec4898c2c0d56ea54e81c8afa1ebd707592f8"

URI_x86_64_v2_sssd-ipa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-ipa-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-ipa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-ipa}"
SRC_URI[x86_64_v2_sssd-ipa.sha256sum] = "b1d4796f164fc52f701459e0a902d655b035f64b3c3d4e0ebdcedaefe590b907"

URI_x86_64_v2_sssd-kcm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-kcm-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-kcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-kcm}"
SRC_URI[x86_64_v2_sssd-kcm.sha256sum] = "f1e103bfd052a56c6b97af810a54e12246314d52dd44d403b4006dac28612caa"

URI_x86_64_v2_sssd-krb5 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-krb5-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-krb5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-krb5}"
SRC_URI[x86_64_v2_sssd-krb5.sha256sum] = "3674e282d735a3f22bf863e1ff3e45b0989e1ac607a2262aa7873790ad5a7daf"

URI_x86_64_v2_sssd-krb5-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-krb5-common-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-krb5-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-krb5-common}"
SRC_URI[x86_64_v2_sssd-krb5-common.sha256sum] = "05361636196d05184f622f58de7530e2ae3193a7d7fee866cbe1a568a484cb39"

URI_x86_64_v2_sssd-ldap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-ldap-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-ldap}"
SRC_URI[x86_64_v2_sssd-ldap.sha256sum] = "48f4bcce22edbc795ec4c6adfcc4bf8fa2b247771bbe85156e04ccb7e572f288"

URI_x86_64_v2_sssd-nfs-idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-nfs-idmap-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-nfs-idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-nfs-idmap}"
SRC_URI[x86_64_v2_sssd-nfs-idmap.sha256sum] = "530b657fa163a861b10d5ef4a477d7c39dbd7129f00e3b1f49787ded22489988"

URI_x86_64_v2_sssd-passkey = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-passkey-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-passkey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-passkey}"
SRC_URI[x86_64_v2_sssd-passkey.sha256sum] = "038efe2e5ab877bee4356712f668c593c8b394ab4ef3bbce7de5ffa525146372"

URI_x86_64_v2_sssd-proxy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-proxy-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-proxy}"
SRC_URI[x86_64_v2_sssd-proxy.sha256sum] = "9914cd064e9ed8f2a11c88dcbd4bd243f2a7ce13643e1f44bbedf82a8c37dbc0"

URI_x86_64_v2_sssd-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-tools-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-tools}"
SRC_URI[x86_64_v2_sssd-tools.sha256sum] = "1c9e165eaead7bdaebc7151f9b590c185ba02c0e8f72ed0ae855f5439b4e1134"

URI_x86_64_v2_sssd-winbind-idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-winbind-idmap-2.13.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_sssd-winbind-idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-winbind-idmap}"
SRC_URI[x86_64_v2_sssd-winbind-idmap.sha256sum] = "37339405814fc4e881b453e8b42ab54be4207ff9c416856543650f35c4641dfa"

URI_aarch64_libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libipa_hbac-2.13.1-2.el10.aarch64.rpm;name=aarch64_libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_aarch64_libipa_hbac}"
SRC_URI[aarch64_libipa_hbac.sha256sum] = "1721bdd562b62e015b0a27acd603213b3e5437e54fed1abbf9cea7216f3b42e5"

URI_aarch64_libsss_autofs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_autofs-2.13.1-2.el10.aarch64.rpm;name=aarch64_libsss_autofs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_autofs}"
SRC_URI[aarch64_libsss_autofs.sha256sum] = "6429f3f81cc387c45561304961cfea931b5d410354edea2e7090ad7ada9b11eb"

URI_aarch64_libsss_certmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_certmap-2.13.1-2.el10.aarch64.rpm;name=aarch64_libsss_certmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_certmap}"
SRC_URI[aarch64_libsss_certmap.sha256sum] = "00b85a11eefab29df108b6205ee5eb8022fca9aa3456f35d46b46b4b26e0a219"

URI_aarch64_libsss_idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_idmap-2.13.1-2.el10.aarch64.rpm;name=aarch64_libsss_idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_idmap}"
SRC_URI[aarch64_libsss_idmap.sha256sum] = "c7fc4a0a9477c7cffb1038d417a2d1fac1fda07152e57a383b720eb77d1e44c3"

URI_aarch64_libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_nss_idmap-2.13.1-2.el10.aarch64.rpm;name=aarch64_libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_nss_idmap}"
SRC_URI[aarch64_libsss_nss_idmap.sha256sum] = "7fd9851260b65101fe6061e76f1ae83a0773926e67af1acf64e1ab700d050a2e"

URI_aarch64_libsss_nss_idmap-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsss_nss_idmap-devel-2.13.1-2.el10.aarch64.rpm;name=aarch64_libsss_nss_idmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_nss_idmap-devel}"
SRC_URI[aarch64_libsss_nss_idmap-devel.sha256sum] = "43cbd4d0faf2cd718d87a2c8f3c3cabb9a3a34e07cfeaa65924f67818e29682e"

URI_aarch64_libsss_sudo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_sudo-2.13.1-2.el10.aarch64.rpm;name=aarch64_libsss_sudo;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_sudo}"
SRC_URI[aarch64_libsss_sudo.sha256sum] = "ad417e366f8ac0c4e9cc7cf6c3ac2040bbda54551d4c49810261e96c4c36892d"

URI_aarch64_python3-libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libipa_hbac-2.13.1-2.el10.aarch64.rpm;name=aarch64_python3-libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libipa_hbac}"
SRC_URI[aarch64_python3-libipa_hbac.sha256sum] = "3c184abbe94fb0bbd4ecebc24c41f1e086bb0d10a180a0fc73101132d4caf7ff"

URI_aarch64_python3-libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libsss_nss_idmap-2.13.1-2.el10.aarch64.rpm;name=aarch64_python3-libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libsss_nss_idmap}"
SRC_URI[aarch64_python3-libsss_nss_idmap.sha256sum] = "1cf61c8ff64af4628abb0e358a677b4426df3aa0d5c954145f00d74b2321ad99"

URI_aarch64_python3-sss = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-sss-2.13.1-2.el10.aarch64.rpm;name=aarch64_python3-sss;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sss}"
SRC_URI[aarch64_python3-sss.sha256sum] = "7d1360cf722ea66b3bb450c61b104c8fc87304a51eb9e8ad7f504ad937770c83"

URI_aarch64_python3-sss-murmur = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-sss-murmur-2.13.1-2.el10.aarch64.rpm;name=aarch64_python3-sss-murmur;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sss-murmur}"
SRC_URI[aarch64_python3-sss-murmur.sha256sum] = "46d64ad7b422f82ad72ff93956fc018b7fc2c71fc497540600ea3ced043da049"

URI_aarch64_python3-sssdconfig = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-sssdconfig-2.13.1-2.el10.noarch.rpm;name=aarch64_python3-sssdconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sssdconfig}"
SRC_URI[aarch64_python3-sssdconfig.sha256sum] = "c399e0e376ff60fbac316a78c6503fdeb6fea1f96eed5a4e97c188af5bf8e7a7"

URI_aarch64_sssd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd}"
SRC_URI[aarch64_sssd.sha256sum] = "c3e34bb5c8924011ba121ffbcb38ec56cc70d199757caa9a1e18643c022565eb"

URI_aarch64_sssd-ad = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-ad-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-ad;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-ad}"
SRC_URI[aarch64_sssd-ad.sha256sum] = "a807f63e94b6ae06f37d15f28af427f3d55b455d7e2dff4fcd4d3570b814552f"

URI_aarch64_sssd-client = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-client-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-client}"
SRC_URI[aarch64_sssd-client.sha256sum] = "fe8e4d98249a854859be9661874e3c0f8c5b1978bf6bb02428023a59910c5a4a"

URI_aarch64_sssd-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-common-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-common}"
SRC_URI[aarch64_sssd-common.sha256sum] = "230cdb34d885d968839a7b6b0e7e51195e35997c4c9bcd7d3b45fa3a6278aa4d"

URI_aarch64_sssd-common-pac = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-common-pac-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-common-pac;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-common-pac}"
SRC_URI[aarch64_sssd-common-pac.sha256sum] = "1b63ae471f4297bfa5cdb99bb3e3410f170c580b4a4ffa9e78cbda260a5c188e"

URI_aarch64_sssd-dbus = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-dbus-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-dbus}"
SRC_URI[aarch64_sssd-dbus.sha256sum] = "07d0f4cae9fe55e8472c26085eb6d5acfd3668336593b5c1c8016e9c268a32da"

URI_aarch64_sssd-idp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sssd-idp-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-idp;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-idp}"
SRC_URI[aarch64_sssd-idp.sha256sum] = "20b2f5ff6c953724ed81902c4d571a77da1120123f598f27506e22bb4f049be8"

URI_aarch64_sssd-ipa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-ipa-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-ipa;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-ipa}"
SRC_URI[aarch64_sssd-ipa.sha256sum] = "33b757460c636de5012e9fbdd36eaa46980542ab81280a82b39fb315c38d8962"

URI_aarch64_sssd-kcm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-kcm-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-kcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-kcm}"
SRC_URI[aarch64_sssd-kcm.sha256sum] = "43ba529ed8a15a919092778a8b652bc5d7eec32443af3340419fd049eb4f4583"

URI_aarch64_sssd-krb5 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-krb5-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-krb5;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-krb5}"
SRC_URI[aarch64_sssd-krb5.sha256sum] = "88a3a492a4a5e5b9c622dd985bdbf0f77bbdf80a6d3c9b3acee2337055ced76d"

URI_aarch64_sssd-krb5-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-krb5-common-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-krb5-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-krb5-common}"
SRC_URI[aarch64_sssd-krb5-common.sha256sum] = "5ec642067bb5caec88f20b927a766e44e11aff8f53901e8b8fe5360c83bd49bd"

URI_aarch64_sssd-ldap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-ldap-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-ldap}"
SRC_URI[aarch64_sssd-ldap.sha256sum] = "8a31b9748054fc65c8b629e1781f4c9dc294b33fd4e065e0332b9b8cc86770cd"

URI_aarch64_sssd-nfs-idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-nfs-idmap-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-nfs-idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-nfs-idmap}"
SRC_URI[aarch64_sssd-nfs-idmap.sha256sum] = "c980748841c4102ede7726eed91282688907208d7ba49ad97c36476f13169937"

URI_aarch64_sssd-passkey = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-passkey-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-passkey;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-passkey}"
SRC_URI[aarch64_sssd-passkey.sha256sum] = "9174ed94d9c246c28568a36d8a1e7dc58363a1e059076f77488c34636768f283"

URI_aarch64_sssd-proxy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-proxy-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-proxy}"
SRC_URI[aarch64_sssd-proxy.sha256sum] = "00ff9d0b54402dcb49f063631094e2a57419ddb4955678c1769c98fe32469ec3"

URI_aarch64_sssd-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-tools-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-tools}"
SRC_URI[aarch64_sssd-tools.sha256sum] = "e85035dcaa56c3f10e292ace34092923e0533aa340e2c369de09a0b4956d0e09"

URI_aarch64_sssd-winbind-idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-winbind-idmap-2.13.1-2.el10.aarch64.rpm;name=aarch64_sssd-winbind-idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-winbind-idmap}"
SRC_URI[aarch64_sssd-winbind-idmap.sha256sum] = "0a22e8bcece467a6e900a1a7382e9f72ec0a90132b59b4b4c8b617e21ab92c05"

RDEPENDS:libipa_hbac = " \
 glibc \
 libunistring \
 "
RDEPENDS:libsss_autofs = " \
 glibc \
 "
RDEPENDS:libsss_certmap = " \
 glibc \
 libtalloc \
 openssl-libs \
 "
RDEPENDS:libsss_idmap = " \
 glibc \
 libunistring \
 "
RDEPENDS:libsss_nss_idmap = " \
 glibc \
 "
RDEPENDS:libsss_nss_idmap-devel = " \
 libsss_nss_idmap \
 pkgconf-pkg-config \
 "
RDEPENDS:libsss_sudo = " \
 glibc \
 "
RDEPENDS:python3-libipa_hbac = " \
 glibc \
 libipa_hbac \
 libunistring \
 python3 \
 "
RDEPENDS:python3-libsss_nss_idmap = " \
 glibc \
 libsss_nss_idmap \
 python3 \
 "
RDEPENDS:python3-sss:x86_64_v2 = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcap \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 python3 \
 sssd-common \
 systemd-libs \
"
RDEPENDS:python3-sss:aarch64 = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 python3 \
 sssd-common \
 systemd-libs \
"
RDEPENDS:python3-sss-murmur = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-sssdconfig = " \
 python3 \
 "
RDEPENDS:sssd = " \
 shadow-utils \
 sssd-ad \
 sssd-common \
 sssd-ipa \
 sssd-krb5 \
 sssd-ldap \
 sssd-proxy \
 "
RDEPENDS:sssd-ad:x86_64_v2 = " \
 cyrus-sasl-lib \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsmbclient \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-ad:aarch64 = " \
 cyrus-sasl-lib \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsmbclient \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-client = " \
 alternatives \
 bash \
 glibc \
 krb5-libs \
 libcom_err \
 libsss_idmap \
 libsss_nss_idmap \
 libunistring \
 pam-libs \
 "
RDEPENDS:sssd-common:x86_64_v2 = " \
 bash \
 c-ares \
 dbus-libs \
 glibc \
 jansson \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libnl3 \
 libref_array \
 libselinux \
 libsss_autofs \
 libsss_certmap \
 libsss_idmap \
 libsss_sudo \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 p11-kit \
 pam-libs \
 pcre2 \
 popt \
 samba-ndr-libs \
 shadow-utils \
 sssd-client \
 sssd-nfs-idmap \
 systemd \
 systemd-libs \
 virtual/coreutils \
"
RDEPENDS:sssd-common:aarch64 = " \
 bash \
 c-ares \
 dbus-libs \
 glibc \
 jansson \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libnl3 \
 libref_array \
 libselinux \
 libsss_autofs \
 libsss_certmap \
 libsss_idmap \
 libsss_sudo \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 p11-kit \
 pam-libs \
 pcre2 \
 popt \
 samba-ndr-libs \
 shadow-utils \
 sssd-client \
 sssd-nfs-idmap \
 systemd \
 systemd-libs \
 virtual/coreutils \
"
RDEPENDS:sssd-common-pac = " \
 glibc \
 libldb \
 libselinux \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 popt \
 samba-ndr-libs \
 sssd-common \
 systemd-libs \
 "
RDEPENDS:sssd-dbus = " \
 bash \
 dbus-libs \
 glibc \
 libdhash \
 libldb \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 popt \
 sssd-common \
 systemd \
 systemd-libs \
 "
RDEPENDS:sssd-idp:x86_64_v2 = " \
 dbus-libs \
 glibc \
 jansson \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libjose \
 libldb \
 libref_array \
 libselinux \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 libuuid \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:sssd-idp:aarch64 = " \
 dbus-libs \
 glibc \
 jansson \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libjose \
 libldb \
 libref_array \
 libselinux \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 libuuid \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:sssd-ipa:x86_64_v2 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libipa_hbac \
 libldb \
 libref_array \
 libselinux \
 libsemanage \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-ipa:aarch64 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libipa_hbac \
 libldb \
 libref_array \
 libselinux \
 libsemanage \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-kcm = " \
 bash \
 glibc \
 krb5-libs \
 libdhash \
 libldb \
 libselinux \
 libtalloc \
 libtevent \
 libuuid \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd \
 systemd-libs \
 "
RDEPENDS:sssd-krb5:x86_64_v2 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-krb5:aarch64 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-krb5-common:x86_64_v2 = " \
 cyrus-sasl-gssapi \
 glibc \
 jansson \
 krb5-libs \
 libcap \
 libtalloc \
 popt \
 sssd-common \
 systemd-libs \
"
RDEPENDS:sssd-krb5-common:aarch64 = " \
 cyrus-sasl-gssapi \
 glibc \
 jansson \
 krb5-libs \
 libtalloc \
 popt \
 sssd-common \
 systemd-libs \
"
RDEPENDS:sssd-ldap:x86_64_v2 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-ldap:aarch64 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
"
RDEPENDS:sssd-nfs-idmap = " \
 glibc \
 libnfsidmap \
 "
RDEPENDS:sssd-passkey = " \
 acl \
 glibc \
 jansson \
 krb5-libs \
 libcom_err \
 libfido2 \
 libtalloc \
 openssl-libs \
 popt \
 sssd-common \
 "
RDEPENDS:sssd-proxy:x86_64_v2 = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcap \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pam-libs \
 pcre2 \
 popt \
 sssd-common \
 systemd-libs \
"
RDEPENDS:sssd-proxy:aarch64 = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pam-libs \
 pcre2 \
 popt \
 sssd-common \
 systemd-libs \
"
RDEPENDS:sssd-tools = " \
 bash \
 glibc \
 libdhash \
 libldb \
 libref_array \
 libsss_certmap \
 libtalloc \
 pam-libs \
 popt \
 python3 \
 python3-sss \
 python3-sssdconfig \
 python3-systemd \
 sssd-common \
 sssd-dbus \
 "
RDEPENDS:sssd-winbind-idmap = " \
 glibc \
 libsss_idmap \
 libsss_nss_idmap \
 libtalloc \
 libunistring \
 "
