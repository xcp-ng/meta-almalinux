# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdecoration"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 kdecoration \
 kdecoration-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdecoration-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2cf20edef5d8071209dfb510a0cde834b3b3f0ae9823dc468d7dfe6e14e8a1d"

URI_x86_64_v2_kdecoration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdecoration-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdecoration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdecoration}"
SRC_URI[x86_64_v2_kdecoration.sha256sum] = "06f91fd3bf8d1647a2415a4af7cea671724275a9c0d3248db55d3d933c516b7b"

URI_x86_64_v2_kdecoration-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdecoration-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdecoration-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdecoration-devel}"
SRC_URI[x86_64_v2_kdecoration-devel.sha256sum] = "ae34537bfec65fa71f5ae1d6ae5227e4f0964c5a936dc07606e5682bc7f60d68"

URI_aarch64_kdecoration = "${EPEL_MIRROR}/aarch64/Packages/k/kdecoration-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kdecoration;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdecoration}"
SRC_URI[aarch64_kdecoration.sha256sum] = "5cc34b237603b2c74154b909c519faecf2adf46a083e32e8dd65fe3a64396fa2"

URI_aarch64_kdecoration-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdecoration-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kdecoration-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdecoration-devel}"
SRC_URI[aarch64_kdecoration-devel.sha256sum] = "979011f25732cde3c9f0fec66a8ebae88cbfb53bf02becf961d9bb1c71ef4558"

RDEPENDS:kdecoration = " \
 glibc \
 kf6-filesystem \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kdecoration-devel = " \
 cmake-filesystem \
 kdecoration \
 "
