# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rusty-fork"
PV = "0.3.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-rusty-fork+default-devel \
 rust-rusty-fork+timeout-devel \
 rust-rusty-fork+wait-timeout-devel \
 rust-rusty-fork-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rusty-fork-0.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "514c3a36cab15eef6241b8ca89d9d7f1a18b9930323e0560b6f54e124952619b"

URI_x86_64_v2_rust-rusty-fork+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty-fork+default-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty-fork+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty-fork+default-devel}"
SRC_URI[x86_64_v2_rust-rusty-fork+default-devel.sha256sum] = "e4dc42dbef767549ba0138cc244bb1bb3d86da4cfd1bf98b4464ea684a1dba9e"

URI_x86_64_v2_rust-rusty-fork+timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty-fork+timeout-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty-fork+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty-fork+timeout-devel}"
SRC_URI[x86_64_v2_rust-rusty-fork+timeout-devel.sha256sum] = "926b501f643e9763107c3d3bc025f80c72de80d820b2ef1d9e90401b06be723d"

URI_x86_64_v2_rust-rusty-fork+wait-timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty-fork+wait-timeout-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty-fork+wait-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty-fork+wait-timeout-devel}"
SRC_URI[x86_64_v2_rust-rusty-fork+wait-timeout-devel.sha256sum] = "83cd1fcee669ff39b2d17ff0fa7047e3f63c6001496e92973b576c64db77ef86"

URI_x86_64_v2_rust-rusty-fork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty-fork-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty-fork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty-fork-devel}"
SRC_URI[x86_64_v2_rust-rusty-fork-devel.sha256sum] = "0c6a44b5aab88ce2260657f20a10abc49757e15d05e1be803676f0c61fd44583"

URI_aarch64_rust-rusty-fork+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty-fork+default-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-rusty-fork+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty-fork+default-devel}"
SRC_URI[aarch64_rust-rusty-fork+default-devel.sha256sum] = "cdea7c2271a3ab1e985c730368b1f97017d0edb5fce0a1e026feec07c6d81c9e"

URI_aarch64_rust-rusty-fork+timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty-fork+timeout-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-rusty-fork+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty-fork+timeout-devel}"
SRC_URI[aarch64_rust-rusty-fork+timeout-devel.sha256sum] = "3706798a00dc5b485381fd6e24b5c10bf9d650056c86a7bff835e89862ea307f"

URI_aarch64_rust-rusty-fork+wait-timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty-fork+wait-timeout-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-rusty-fork+wait-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty-fork+wait-timeout-devel}"
SRC_URI[aarch64_rust-rusty-fork+wait-timeout-devel.sha256sum] = "b644e12db729dc828983e03e6707a3ff49776845068a5ab6bda49d867d1931cc"

URI_aarch64_rust-rusty-fork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty-fork-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-rusty-fork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty-fork-devel}"
SRC_URI[aarch64_rust-rusty-fork-devel.sha256sum] = "15d2c34b7b1ff11f42bfa3a377c609ff681d1934b6e0ffa2fbcdb8e6d77716ea"

RDEPENDS:rust-rusty-fork+default-devel = " \
 cargo \
 rust-rusty-fork+timeout-devel \
 rust-rusty-fork-devel \
 "
RDEPENDS:rust-rusty-fork+timeout-devel = " \
 cargo \
 rust-rusty-fork+wait-timeout-devel \
 rust-rusty-fork-devel \
 "
RDEPENDS:rust-rusty-fork+wait-timeout-devel = " \
 cargo \
 rust-rusty-fork-devel \
 rust-wait-timeout+default-devel \
 "
RDEPENDS:rust-rusty-fork-devel = " \
 cargo \
 rust-fnv+default-devel \
 rust-quick-error1+default-devel \
 rust-tempfile+default-devel \
 "
