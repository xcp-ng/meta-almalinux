# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kbookmarks"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kbookmarks \
 kf6-kbookmarks-devel \
 kf6-kbookmarks-doc \
 kf6-kbookmarks-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kbookmarks-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2a719ee510424ab6e9d29c21a14a91f6cdf7f45147a0e7fd3a98d26958b8a2b"

URI_x86_64_v2_kf6-kbookmarks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kbookmarks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kbookmarks}"
SRC_URI[x86_64_v2_kf6-kbookmarks.sha256sum] = "eafe87451c06543ce60f0e2726f10bfa03f25f5399235a71d5f44b1aa9ef540f"

URI_x86_64_v2_kf6-kbookmarks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kbookmarks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kbookmarks-devel}"
SRC_URI[x86_64_v2_kf6-kbookmarks-devel.sha256sum] = "d20708877a118dc76d02265069d3d31c5ec6f54528117bef5a027d84f6fb92a9"

URI_x86_64_v2_kf6-kbookmarks-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kbookmarks-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kbookmarks-doc}"
SRC_URI[x86_64_v2_kf6-kbookmarks-doc.sha256sum] = "d28fdf53cc416064898cdf99048780e29cf3b5d2d7fcd07ec4c11793efa7f91e"

URI_x86_64_v2_kf6-kbookmarks-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kbookmarks-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kbookmarks-html}"
SRC_URI[x86_64_v2_kf6-kbookmarks-html.sha256sum] = "f5eecc1e2ade865400bfd8cd410d16da4e134b4e0133ad75ebbd2b48f85a8cbe"

URI_aarch64_kf6-kbookmarks = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kbookmarks;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kbookmarks}"
SRC_URI[aarch64_kf6-kbookmarks.sha256sum] = "4c654fd388b9c5865d1c0ed453056e21540fe6836ae9f0db52883d6528c90a8c"

URI_aarch64_kf6-kbookmarks-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kbookmarks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kbookmarks-devel}"
SRC_URI[aarch64_kf6-kbookmarks-devel.sha256sum] = "fadabfb9eed815cad38930d3f79dee366529fe9c54f008b0b02a0dfbeb3301a8"

URI_aarch64_kf6-kbookmarks-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kbookmarks-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kbookmarks-doc}"
SRC_URI[aarch64_kf6-kbookmarks-doc.sha256sum] = "de8fbbce17486faa598335b811fc283f6baf19dbe57c9da64e2bf90430b4c99d"

URI_aarch64_kf6-kbookmarks-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kbookmarks-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kbookmarks-html}"
SRC_URI[aarch64_kf6-kbookmarks-html.sha256sum] = "6d28ace547dc9e4341e57957ed835545f724ec0474ece61f72fe79b9ed5830f7"

RDEPENDS:kf6-kbookmarks = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kbookmarks-devel = " \
 cmake-filesystem \
 kf6-kbookmarks \
 kf6-kwidgetsaddons-devel \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kbookmarks-doc = " \
 "
RDEPENDS:kf6-kbookmarks-html = " \
 "
