# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-damo"
PV = "3.3.0"
PR = "1.el10_3"
PACKAGES = " \
 damo \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-damo-3.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "09f475f3fed67b40e5b0c7ea590abe0f3bdf6b34a13c1d7c162cf806747594ae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/damo-3.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_damo;unpack=0"
SRC_URI[x86_64_v2_damo.sha256sum] = "10d68464d6ec09dde8ff834c440e6817fa69ef877c32beae1d5129ed1d66711e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/damo-3.3.0-1.el10_3.noarch.rpm;name=aarch64_damo;unpack=0"
SRC_URI[aarch64_damo.sha256sum] = "2612a797074a3583a1942f5292d509f99613361cf4a8810235090105a742f4e4"

RDEPENDS:damo = " \
 python3 \
 "
