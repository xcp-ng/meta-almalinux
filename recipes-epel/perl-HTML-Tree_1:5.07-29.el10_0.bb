# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTML-Tree"
PE = "1"
PV = "5.07"
PR = "29.el10_0"
PACKAGES = " \
 perl-HTML-Tree \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTML-Tree-5.07-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70497d981db86be3e13c36f546ecbf080398b71d5f73dd523b3cb447982a076b"

URI_x86_64_v2_perl-HTML-Tree = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTML-Tree-5.07-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTML-Tree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTML-Tree}"
SRC_URI[x86_64_v2_perl-HTML-Tree.sha256sum] = "3072a6be9631eacbf3211f08527408254415765c074fb2b776dfc0bd348b3ee3"

URI_aarch64_perl-HTML-Tree = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTML-Tree-5.07-29.el10_0.noarch.rpm;name=aarch64_perl-HTML-Tree;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTML-Tree}"
SRC_URI[aarch64_perl-HTML-Tree.sha256sum] = "c0b1a5650cb466e37e32feb48dbcd573157aaa9d856d71d68728ff7ab7806f1f"

RDEPENDS:perl-HTML-Tree = " \
 perl-Carp \
 perl-Exporter \
 perl-HTML-Parser \
 perl-HTML-Tagset \
 perl-HTML-Tree \
 perl-Pod-Usage \
 perl-Scalar-List-Utils \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
