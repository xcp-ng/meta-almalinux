# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde"
PV = "1.0.228"
PR = "1.el10_0"
PACKAGES = " \
 rust-serde+alloc-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde+serde_derive-devel \
 rust-serde+std-devel \
 rust-serde+unstable-devel \
 rust-serde-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde-1.0.228-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9e43790c804fcc7cfede349268a05ca645cf9f0efd70cdcf5184fc3afbf605c"

URI_x86_64_v2_rust-serde+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+alloc-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde+alloc-devel.sha256sum] = "551961e1dae0ce52d40ed197f2e3de4ed0ef9cd7c94b14dec7fdbf353f4d63a3"

URI_x86_64_v2_rust-serde+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+default-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+default-devel}"
SRC_URI[x86_64_v2_rust-serde+default-devel.sha256sum] = "8a70e65d14eb9c7c3e6c4f810c6b2698a196c992ad416233a7a3bde4d86bfb71"

URI_x86_64_v2_rust-serde+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+derive-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+derive-devel}"
SRC_URI[x86_64_v2_rust-serde+derive-devel.sha256sum] = "ce4c4ec5fc74c06fa6f71e68cf1b42cff906b276b0e3394d4a962619a237799c"

URI_x86_64_v2_rust-serde+rc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+rc-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+rc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+rc-devel}"
SRC_URI[x86_64_v2_rust-serde+rc-devel.sha256sum] = "db7d98e07ba8a7a443183665149a35bc82486231257ab9be6594e1c7afffa292"

URI_x86_64_v2_rust-serde+serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+serde_derive-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+serde_derive-devel}"
SRC_URI[x86_64_v2_rust-serde+serde_derive-devel.sha256sum] = "269efa5e44b7217e1ed0c0df80892e304497f411cf51fefe7354cfe69c72ef54"

URI_x86_64_v2_rust-serde+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+std-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+std-devel}"
SRC_URI[x86_64_v2_rust-serde+std-devel.sha256sum] = "cc551b4eb8f187e29028705217f5728fa657e01c502729d288bc88cfe94c08e0"

URI_x86_64_v2_rust-serde+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+unstable-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+unstable-devel}"
SRC_URI[x86_64_v2_rust-serde+unstable-devel.sha256sum] = "2aa11b02f076c132b2c686ba2d87aac37d1b22aba6f4ce5c88cf699f68188d93"

URI_x86_64_v2_rust-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde-devel}"
SRC_URI[x86_64_v2_rust-serde-devel.sha256sum] = "de63225e1bdb53fea36812fb068ced6c81f67781073c793001696cab34c63b24"

URI_aarch64_rust-serde+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+alloc-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+alloc-devel}"
SRC_URI[aarch64_rust-serde+alloc-devel.sha256sum] = "733df5233779cd9914b664cea058b6225fc23b7d3992957b1bb4857cb3344348"

URI_aarch64_rust-serde+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+default-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+default-devel}"
SRC_URI[aarch64_rust-serde+default-devel.sha256sum] = "fb60be59052333f1085a41b198fd1adda6cef050766f3e76c19899f2fe110846"

URI_aarch64_rust-serde+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+derive-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+derive-devel}"
SRC_URI[aarch64_rust-serde+derive-devel.sha256sum] = "b2442a7a9a0afec2151ec68efd26613f98cf2ebf76599523f67171b14d871f77"

URI_aarch64_rust-serde+rc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+rc-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde+rc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+rc-devel}"
SRC_URI[aarch64_rust-serde+rc-devel.sha256sum] = "5f8f274e7a41ef8118dfc586873c9516b1bbf05c2ede2cc5a805d96f1562274b"

URI_aarch64_rust-serde+serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+serde_derive-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+serde_derive-devel}"
SRC_URI[aarch64_rust-serde+serde_derive-devel.sha256sum] = "6edec0923d428c090018744c6309ab3c13c48c6e873f534769c717071048233a"

URI_aarch64_rust-serde+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+std-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+std-devel}"
SRC_URI[aarch64_rust-serde+std-devel.sha256sum] = "5235a1ae107d3bebbe7da972881a4d5db59f3366aa787c589b74f2b83c1c66b3"

URI_aarch64_rust-serde+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+unstable-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+unstable-devel}"
SRC_URI[aarch64_rust-serde+unstable-devel.sha256sum] = "6c4508101f54a6e888bc9e5e9eff14e54759daa995f7eb0a9eced6a01f8b1e82"

URI_aarch64_rust-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde-devel}"
SRC_URI[aarch64_rust-serde-devel.sha256sum] = "784eb02ecb98a4890a06b37be9c66fc312f09ebe952166ee5cdbfd4b91255684"

RDEPENDS:rust-serde+alloc-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+alloc-devel \
 "
RDEPENDS:rust-serde+default-devel = " \
 cargo \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-serde+derive-devel = " \
 cargo \
 rust-serde+serde_derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-serde+rc-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+rc-devel \
 "
RDEPENDS:rust-serde+serde_derive-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-serde+std-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+std-devel \
 "
RDEPENDS:rust-serde+unstable-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+unstable-devel \
 "
RDEPENDS:rust-serde-devel = " \
 cargo \
 rust \
 rust-serde_core+result-devel \
 rust-serde_core-devel \
 "
