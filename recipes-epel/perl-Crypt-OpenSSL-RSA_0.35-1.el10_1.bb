# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-OpenSSL-RSA"
PV = "0.35"
PR = "1.el10_1"
PACKAGES = " \
 perl-Crypt-OpenSSL-RSA \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-OpenSSL-RSA-0.35-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fb619eb178bd68a396eb71ef02d7011708d2a2e7d56fb095a23b7388909070f"

URI_x86_64_v2_perl-Crypt-OpenSSL-RSA = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-RSA-0.35-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-RSA;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-RSA}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-RSA.sha256sum] = "b813aa0ce0402fb6c01495f742e3d7195fc729c8fc0a7148d1738a49c69a8399"

URI_aarch64_perl-Crypt-OpenSSL-RSA = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-RSA-0.35-1.el10_1.aarch64.rpm;name=aarch64_perl-Crypt-OpenSSL-RSA;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-RSA}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-RSA.sha256sum] = "d3b5643b541d48635eaea0d2a5083da5cedbcb1d8927e1ee23d7f0d6b3c7d086"

RDEPENDS:perl-Crypt-OpenSSL-RSA = " \
 glibc \
 openssl-libs \
 perl-Carp \
 perl-Crypt-OpenSSL-Bignum \
 perl-Crypt-OpenSSL-Random \
 perl-libs \
 "
