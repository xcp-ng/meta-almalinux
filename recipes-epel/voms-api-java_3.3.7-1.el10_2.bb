# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "voms-api-java"
PV = "3.3.7"
PR = "1.el10_2"
PACKAGES = " \
 voms-api-java \
 voms-api-java-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/voms-api-java-3.3.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13a00cded63cb46a1e8692ca31453815f681181ef39c385f0a19f446b7bae121"

URI_x86_64_v2_voms-api-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-api-java-3.3.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_voms-api-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-api-java}"
SRC_URI[x86_64_v2_voms-api-java.sha256sum] = "e5783a7ebdd77970deae8dc9365f65531b41b994d8a5be87677636875f4df66f"

URI_x86_64_v2_voms-api-java-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-api-java-javadoc-3.3.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_voms-api-java-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-api-java-javadoc}"
SRC_URI[x86_64_v2_voms-api-java-javadoc.sha256sum] = "ff318c86f42f7b8be9a3e48badbfdcfab0f6ab98fa1505d7fe4a9af7fbd08987"

URI_aarch64_voms-api-java = "${EPEL_MIRROR}/aarch64/Packages/v/voms-api-java-3.3.7-1.el10_2.noarch.rpm;name=aarch64_voms-api-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-api-java}"
SRC_URI[aarch64_voms-api-java.sha256sum] = "5350f2faff5d174bfb6628acfde44c000c7fb6ce6d46ed4f377312873726f9e1"

URI_aarch64_voms-api-java-javadoc = "${EPEL_MIRROR}/aarch64/Packages/v/voms-api-java-javadoc-3.3.7-1.el10_2.noarch.rpm;name=aarch64_voms-api-java-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-api-java-javadoc}"
SRC_URI[aarch64_voms-api-java-javadoc.sha256sum] = "85e6de278b679571bda142fb5b799faa5fafd9a7914123ef86b278423f91f52d"

RDEPENDS:voms-api-java = " \
 bouncycastle \
 bouncycastle-pkix \
 canl-java \
 javapackages-filesystem \
 "
RDEPENDS:voms-api-java-javadoc = " \
 javapackages-filesystem \
 "
