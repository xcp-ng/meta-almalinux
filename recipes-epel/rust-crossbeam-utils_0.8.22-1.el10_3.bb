# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-utils"
PV = "0.8.22"
PR = "1.el10_3"
PACKAGES = " \
 rust-crossbeam-utils+default-devel \
 rust-crossbeam-utils+nightly-devel \
 rust-crossbeam-utils+std-devel \
 rust-crossbeam-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-utils-0.8.22-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96a1b910bf7bd068afb22c9d7136adc6de32e70709da88a239b13a9ce02b3654"

URI_x86_64_v2_rust-crossbeam-utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils+default-devel-0.8.22-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-utils+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-utils+default-devel.sha256sum] = "d90f53eec7807ce477b37af6485eddfdc4f1a4264954de00665a70a3dd6f02da"

URI_x86_64_v2_rust-crossbeam-utils+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils+nightly-devel-0.8.22-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-utils+nightly-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-utils+nightly-devel.sha256sum] = "416f5f4ef1818491b6f8c5d853520902fe99dc839e23fa0701e3ae265a22d3e4"

URI_x86_64_v2_rust-crossbeam-utils+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils+std-devel-0.8.22-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-utils+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-utils+std-devel.sha256sum] = "55769c245cbc2b9275a1ca3d3c39ab7be30d6a12576330d49f3c9a0f712ed491"

URI_x86_64_v2_rust-crossbeam-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils-devel-0.8.22-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-utils-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-utils-devel.sha256sum] = "87d020fe1dc0ae755ea4e5c12221975db52e42ed1c08a46d4b45710b5f42e604"

URI_aarch64_rust-crossbeam-utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils+default-devel-0.8.22-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-utils+default-devel}"
SRC_URI[aarch64_rust-crossbeam-utils+default-devel.sha256sum] = "13e0351978c77acf626df7015775884fde55b146e96aa1423fa019193342b838"

URI_aarch64_rust-crossbeam-utils+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils+nightly-devel-0.8.22-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-utils+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-utils+nightly-devel}"
SRC_URI[aarch64_rust-crossbeam-utils+nightly-devel.sha256sum] = "38d24c58e239f274a2ad6c744b4a7961354b875d35552cf679aaac9553055fc6"

URI_aarch64_rust-crossbeam-utils+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils+std-devel-0.8.22-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-utils+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-utils+std-devel}"
SRC_URI[aarch64_rust-crossbeam-utils+std-devel.sha256sum] = "9a370814fd2f1627435cd65c57ef62a33b8d56bdc51c48ece1c5460bf858a380"

URI_aarch64_rust-crossbeam-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils-devel-0.8.22-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-utils-devel}"
SRC_URI[aarch64_rust-crossbeam-utils-devel.sha256sum] = "a651ec784ceec84962973451619f2f069d6cc0578b33f303cc7ba1bdba5e65e0"

RDEPENDS:rust-crossbeam-utils+default-devel = " \
 cargo \
 rust-crossbeam-utils+std-devel \
 rust-crossbeam-utils-devel \
 "
RDEPENDS:rust-crossbeam-utils+nightly-devel = " \
 cargo \
 rust-crossbeam-utils-devel \
 "
RDEPENDS:rust-crossbeam-utils+std-devel = " \
 cargo \
 rust-crossbeam-utils-devel \
 "
RDEPENDS:rust-crossbeam-utils-devel = " \
 cargo \
 rust \
 "
