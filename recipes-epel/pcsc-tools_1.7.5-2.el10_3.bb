# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcsc-tools"
PV = "1.7.5"
PR = "2.el10_3"
PACKAGES = " \
 pcsc-tools \
 pcsc-tools-gscriptor \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pcsc-tools-1.7.5-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d976c49084f5a24bef6601448719e934377347c8315f246fb41321e1e8c5756a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcsc-tools-1.7.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pcsc-tools;unpack=0"
SRC_URI[x86_64_v2_pcsc-tools.sha256sum] = "e20639a236b5487c02aef7a87bf07d0e23daf27f8d8ed1aa33fa043b638a72df"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcsc-tools-gscriptor-1.7.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pcsc-tools-gscriptor;unpack=0"
SRC_URI[x86_64_v2_pcsc-tools-gscriptor.sha256sum] = "34a2686554416da2b643e40c112202309bf5d65f279052cb09f4ac9e00d88c4c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pcsc-tools-1.7.5-2.el10_3.aarch64.rpm;name=aarch64_pcsc-tools;unpack=0"
SRC_URI[aarch64_pcsc-tools.sha256sum] = "399af8619dcece531d1b4eb70a6870431d626b4aea7d14a41e14d8146bc45f89"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pcsc-tools-gscriptor-1.7.5-2.el10_3.aarch64.rpm;name=aarch64_pcsc-tools-gscriptor;unpack=0"
SRC_URI[aarch64_pcsc-tools-gscriptor.sha256sum] = "f968efaeae34fb165fb64b4a991f4603b047c529d5506a3e92d186c9702fa617"

RDEPENDS:pcsc-tools = " \
 glibc \
 pcsc-lite \
 pcsc-lite-libs \
 pcsc-perl \
 perl-File-stat \
 perl-Getopt-Std \
 perl-POSIX \
 perl-interpreter \
 perl-libintl-perl \
 perl-libs \
 "
RDEPENDS:pcsc-tools-gscriptor = " \
 pcsc-perl \
 pcsc-tools \
 perl-Carp \
 perl-File-Basename \
 perl-Glib \
 perl-Gtk3 \
 perl-POSIX \
 perl-interpreter \
 perl-libintl-perl \
 perl-libs \
 "
