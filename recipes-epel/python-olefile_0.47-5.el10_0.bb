# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-olefile"
PV = "0.47"
PR = "5.el10_0"
PACKAGES = " \
 python-olefile-doc \
 python3-olefile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-olefile-0.47-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7af75ee900701c79c84343fd71b850ab8a0179ea4f6c477a6ee5285a4dff290e"

URI_x86_64_v2_python-olefile-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-olefile-doc-0.47-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-olefile-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-olefile-doc}"
SRC_URI[x86_64_v2_python-olefile-doc.sha256sum] = "641e43262d10c9c2bdb6467a1f15960c00473d78137b0678f982d2c9f8f803ed"

URI_x86_64_v2_python3-olefile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-olefile-0.47-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-olefile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-olefile}"
SRC_URI[x86_64_v2_python3-olefile.sha256sum] = "38001beef552d10cd958ce280539dae313a9d21cc251d662f5a6a62a2f183fac"

URI_aarch64_python-olefile-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-olefile-doc-0.47-5.el10_0.noarch.rpm;name=aarch64_python-olefile-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-olefile-doc}"
SRC_URI[aarch64_python-olefile-doc.sha256sum] = "0700345e311a68f60ba88970c72489b28175ebeac490019db182f01015d8735a"

URI_aarch64_python3-olefile = "${EPEL_MIRROR}/aarch64/Packages/p/python3-olefile-0.47-5.el10_0.noarch.rpm;name=aarch64_python3-olefile;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-olefile}"
SRC_URI[aarch64_python3-olefile.sha256sum] = "dd3ac33bfffde087e5a1163a0af35f401bce35c50c896cee7b230194c266e61f"

RDEPENDS:python-olefile-doc = " \
 "
RDEPENDS:python3-olefile = " \
 python3 \
 "
