# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-signal-hook-registry"
PV = "1.4.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-signal-hook-registry+default-devel \
 rust-signal-hook-registry-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-signal-hook-registry-1.4.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0082e322a4629bc5d5d8fb9e13463755346ba1a65fc434311f9431f5595d10ca"

URI_x86_64_v2_rust-signal-hook-registry+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-registry+default-devel-1.4.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-registry+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-registry+default-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-registry+default-devel.sha256sum] = "149530b1bb1b71c59a6beee27d65b72545683f7c83472da7664c8acfdf6a17b4"

URI_x86_64_v2_rust-signal-hook-registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-registry-devel-1.4.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-registry-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-registry-devel.sha256sum] = "a1c9fea62dbf9a73690e928ca45320bb0b4827e0c9f56128c3d490a236d0db93"

URI_aarch64_rust-signal-hook-registry+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-registry+default-devel-1.4.8-1.el10_1.noarch.rpm;name=aarch64_rust-signal-hook-registry+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-registry+default-devel}"
SRC_URI[aarch64_rust-signal-hook-registry+default-devel.sha256sum] = "f0224e4b27bf6f076ac8d180be3d71699e108c7dbbae7047995c32df0a6442c4"

URI_aarch64_rust-signal-hook-registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-registry-devel-1.4.8-1.el10_1.noarch.rpm;name=aarch64_rust-signal-hook-registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-registry-devel}"
SRC_URI[aarch64_rust-signal-hook-registry-devel.sha256sum] = "b26de3970d45013d5792d4d497305e506488d1196865f471b3efdc4316087f41"

RDEPENDS:rust-signal-hook-registry+default-devel = " \
 cargo \
 rust-signal-hook-registry-devel \
 "
RDEPENDS:rust-signal-hook-registry-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 virtual/crate_errno/default__ge_0.2.0_with_crate_errno/default__lt_0.4.0~ \
 "
