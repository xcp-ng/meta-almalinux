# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "figlet"
PV = "2.2.5"
PR = "38.el10_1"
PACKAGES = " \
 figlet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/figlet-2.2.5-38.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "970580af72f8a3ffc93a8c4f86027ae9bc7599a2a13e6bdbd5a8c7cb5daadd02"

URI_x86_64_v2_figlet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/figlet-2.2.5-38.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_figlet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_figlet}"
SRC_URI[x86_64_v2_figlet.sha256sum] = "e35d16b0f7ebde42c8fffd0176bd3d191a6137b8ffe467076b7d022fab15c57b"

URI_aarch64_figlet = "${EPEL_MIRROR}/aarch64/Packages/f/figlet-2.2.5-38.el10_1.aarch64.rpm;name=aarch64_figlet;unpack=0"
SRC_URI:append = " ${URI_aarch64_figlet}"
SRC_URI[aarch64_figlet.sha256sum] = "1e2d79dbe032ad0058b0afb8dd604149b44470d603d378f56ef3a64fc63d6b2a"

RDEPENDS:figlet = " \
 bash \
 glibc \
 "
