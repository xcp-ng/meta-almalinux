# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-signal-hook0.3"
PV = "0.3.18"
PR = "1.el10_3"
PACKAGES = " \
 rust-signal-hook0.3+cc-devel \
 rust-signal-hook0.3+channel-devel \
 rust-signal-hook0.3+default-devel \
 rust-signal-hook0.3+extended-siginfo-devel \
 rust-signal-hook0.3+extended-siginfo-raw-devel \
 rust-signal-hook0.3+iterator-devel \
 rust-signal-hook0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-signal-hook0.3-0.3.18-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19cb77a71e5f29fea0339ab204de0e04b5a7466db4492e7af4fb9623be5de1d2"

URI_x86_64_v2_rust-signal-hook0.3+cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook0.3+cc-devel-0.3.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook0.3+cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook0.3+cc-devel}"
SRC_URI[x86_64_v2_rust-signal-hook0.3+cc-devel.sha256sum] = "5a3981a772627a876f86d15ecf8cfcc2f06bd4780dd576bb97b5790197fd409a"

URI_x86_64_v2_rust-signal-hook0.3+channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook0.3+channel-devel-0.3.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook0.3+channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook0.3+channel-devel}"
SRC_URI[x86_64_v2_rust-signal-hook0.3+channel-devel.sha256sum] = "2707d4dda0b269e10c4fe44299413524531c5d0d999f2c1ed41607d0641ab280"

URI_x86_64_v2_rust-signal-hook0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook0.3+default-devel-0.3.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook0.3+default-devel}"
SRC_URI[x86_64_v2_rust-signal-hook0.3+default-devel.sha256sum] = "8dd4a034166d85bdce0a648af9c9e9517ce499c08612f5d59e4fcbf9f5874645"

URI_x86_64_v2_rust-signal-hook0.3+extended-siginfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook0.3+extended-siginfo-devel-0.3.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook0.3+extended-siginfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook0.3+extended-siginfo-devel}"
SRC_URI[x86_64_v2_rust-signal-hook0.3+extended-siginfo-devel.sha256sum] = "4f37b68d4378ae2f71f276a61f109c73d12b6a332a305a90daa63c83ff67b764"

URI_x86_64_v2_rust-signal-hook0.3+extended-siginfo-raw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook0.3+extended-siginfo-raw-devel-0.3.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook0.3+extended-siginfo-raw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook0.3+extended-siginfo-raw-devel}"
SRC_URI[x86_64_v2_rust-signal-hook0.3+extended-siginfo-raw-devel.sha256sum] = "eabc53dceef1bdb160cf7b65418ec2a825cc83d3d5333a567ad2f1712d0eda9f"

URI_x86_64_v2_rust-signal-hook0.3+iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook0.3+iterator-devel-0.3.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook0.3+iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook0.3+iterator-devel}"
SRC_URI[x86_64_v2_rust-signal-hook0.3+iterator-devel.sha256sum] = "a28d281057b2bd5eae22d911ff24d30eb8ab222f8bee8f329450bdfeb3a4c8d8"

URI_x86_64_v2_rust-signal-hook0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook0.3-devel-0.3.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook0.3-devel}"
SRC_URI[x86_64_v2_rust-signal-hook0.3-devel.sha256sum] = "1e919ceed062fa4148fffb674c98bb2ab890c0e6ae993b58debbe1bacfd7a518"

URI_aarch64_rust-signal-hook0.3+cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook0.3+cc-devel-0.3.18-1.el10_3.noarch.rpm;name=aarch64_rust-signal-hook0.3+cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook0.3+cc-devel}"
SRC_URI[aarch64_rust-signal-hook0.3+cc-devel.sha256sum] = "d84eb36d34554c9ca1b1cceb6633acb46997009540e4cf536656ed05331af42d"

URI_aarch64_rust-signal-hook0.3+channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook0.3+channel-devel-0.3.18-1.el10_3.noarch.rpm;name=aarch64_rust-signal-hook0.3+channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook0.3+channel-devel}"
SRC_URI[aarch64_rust-signal-hook0.3+channel-devel.sha256sum] = "e937d557bee9798e7c7d0837b8b835b17a3cd9bb0f407e0e63f3cbd59c6cd74a"

URI_aarch64_rust-signal-hook0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook0.3+default-devel-0.3.18-1.el10_3.noarch.rpm;name=aarch64_rust-signal-hook0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook0.3+default-devel}"
SRC_URI[aarch64_rust-signal-hook0.3+default-devel.sha256sum] = "c2ec4622eb3f06ef356463daac3469829f6c9dd72d44cdcafd9d2a3bfa7fc85c"

URI_aarch64_rust-signal-hook0.3+extended-siginfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook0.3+extended-siginfo-devel-0.3.18-1.el10_3.noarch.rpm;name=aarch64_rust-signal-hook0.3+extended-siginfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook0.3+extended-siginfo-devel}"
SRC_URI[aarch64_rust-signal-hook0.3+extended-siginfo-devel.sha256sum] = "656dd02d6b36f01e08530f96963ad96999e19013450a3a5d22beab74770c4079"

URI_aarch64_rust-signal-hook0.3+extended-siginfo-raw-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook0.3+extended-siginfo-raw-devel-0.3.18-1.el10_3.noarch.rpm;name=aarch64_rust-signal-hook0.3+extended-siginfo-raw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook0.3+extended-siginfo-raw-devel}"
SRC_URI[aarch64_rust-signal-hook0.3+extended-siginfo-raw-devel.sha256sum] = "bf04aa92b7c745660ddaeb30b01cc4921784303d24fae0d9aff8f1d2fb4fdd79"

URI_aarch64_rust-signal-hook0.3+iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook0.3+iterator-devel-0.3.18-1.el10_3.noarch.rpm;name=aarch64_rust-signal-hook0.3+iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook0.3+iterator-devel}"
SRC_URI[aarch64_rust-signal-hook0.3+iterator-devel.sha256sum] = "38af392baee334aa540bb00ffe582c306163642f3ce67e4a3a18b69a71c8520d"

URI_aarch64_rust-signal-hook0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook0.3-devel-0.3.18-1.el10_3.noarch.rpm;name=aarch64_rust-signal-hook0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook0.3-devel}"
SRC_URI[aarch64_rust-signal-hook0.3-devel.sha256sum] = "86aaae7b4c61d634c35a337ddd408bcccfbc38e98f7b4be8df3cf368afa91884"

RDEPENDS:rust-signal-hook0.3+cc-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-signal-hook0.3-devel \
 "
RDEPENDS:rust-signal-hook0.3+channel-devel = " \
 cargo \
 rust-signal-hook0.3-devel \
 "
RDEPENDS:rust-signal-hook0.3+default-devel = " \
 cargo \
 rust-signal-hook0.3+channel-devel \
 rust-signal-hook0.3+iterator-devel \
 rust-signal-hook0.3-devel \
 "
RDEPENDS:rust-signal-hook0.3+extended-siginfo-devel = " \
 cargo \
 rust-signal-hook0.3+channel-devel \
 rust-signal-hook0.3+extended-siginfo-raw-devel \
 rust-signal-hook0.3+iterator-devel \
 rust-signal-hook0.3-devel \
 "
RDEPENDS:rust-signal-hook0.3+extended-siginfo-raw-devel = " \
 cargo \
 rust-signal-hook0.3+cc-devel \
 rust-signal-hook0.3-devel \
 "
RDEPENDS:rust-signal-hook0.3+iterator-devel = " \
 cargo \
 rust-signal-hook0.3+channel-devel \
 rust-signal-hook0.3-devel \
 "
RDEPENDS:rust-signal-hook0.3-devel = " \
 bash \
 cargo \
 rust-libc+default-devel \
 rust-signal-hook-registry+default-devel \
 "
