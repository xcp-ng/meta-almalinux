# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "h5py"
PV = "3.12.1"
PR = "3.el10_0"
PACKAGES = " \
 python3-h5py \
 python3-h5py-mpich \
 python3-h5py-openmpi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/h5py-3.12.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78bdd1c92937e6b398ae74fa6b475fd7dd91538a6a7e224d834ecee533fcb98f"

URI_x86_64_v2_python3-h5py = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-h5py-3.12.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-h5py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-h5py}"
SRC_URI[x86_64_v2_python3-h5py.sha256sum] = "31cb71f6d31c80020f52f156dd5bc66bd2ba391b4cf573fc5b576b58f0558745"

URI_x86_64_v2_python3-h5py-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-h5py-mpich-3.12.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-h5py-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-h5py-mpich}"
SRC_URI[x86_64_v2_python3-h5py-mpich.sha256sum] = "8cba33ff31361a9dbb36e5fa79b1deac1bdb163a1845a94ea1064f85e69bd2b2"

URI_x86_64_v2_python3-h5py-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-h5py-openmpi-3.12.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-h5py-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-h5py-openmpi}"
SRC_URI[x86_64_v2_python3-h5py-openmpi.sha256sum] = "1216f887e826498df6e53e47388e88b1693b1978ba963c4931bbcb8b795cb5cb"

URI_aarch64_python3-h5py = "${EPEL_MIRROR}/aarch64/Packages/p/python3-h5py-3.12.1-3.el10_0.aarch64.rpm;name=aarch64_python3-h5py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-h5py}"
SRC_URI[aarch64_python3-h5py.sha256sum] = "be86e5d758f7e3a225f1697e4677f7c844df114c56992da345d8e534416f4988"

URI_aarch64_python3-h5py-mpich = "${EPEL_MIRROR}/aarch64/Packages/p/python3-h5py-mpich-3.12.1-3.el10_0.aarch64.rpm;name=aarch64_python3-h5py-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-h5py-mpich}"
SRC_URI[aarch64_python3-h5py-mpich.sha256sum] = "fcb6e5d646d200b0515df1bae26f4847ff81b9e31f526312713db2056bbd11a3"

URI_aarch64_python3-h5py-openmpi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-h5py-openmpi-3.12.1-3.el10_0.aarch64.rpm;name=aarch64_python3-h5py-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-h5py-openmpi}"
SRC_URI[aarch64_python3-h5py-openmpi.sha256sum] = "d973cbfd4c992b13255b0ac804ab39ec9227203d6bb177bd479affe7c2eccb00"

RDEPENDS:python3-h5py = " \
 glibc \
 hdf5 \
 liblzf \
 python3 \
 python3-cached_property \
 python3-numpy \
 python3-six \
 "
RDEPENDS:python3-h5py-mpich = " \
 glibc \
 hdf5 \
 hdf5-mpich \
 liblzf \
 mpich \
 python3 \
 python3-cached_property \
 python3-mpi4py-mpich \
 python3-mpi4py-openmpi \
 python3-numpy \
 python3-six \
 "
RDEPENDS:python3-h5py-openmpi = " \
 glibc \
 hdf5 \
 hdf5-openmpi \
 liblzf \
 openmpi \
 python3 \
 python3-cached_property \
 python3-mpi4py-openmpi \
 python3-numpy \
 python3-six \
 "
