# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-segmentation"
PV = "1.12.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-unicode-segmentation+default-devel \
 rust-unicode-segmentation+no_std-devel \
 rust-unicode-segmentation-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-segmentation-1.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffc2780b19b6ae219c121250221f9abb8cb83c5ef439696908907b4a8131f57e"

URI_x86_64_v2_rust-unicode-segmentation+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-segmentation+default-devel-1.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-segmentation+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-segmentation+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-segmentation+default-devel.sha256sum] = "ea693c51f3ff0e1c51926b920ec541d77b04924cfa4417c02140d3810c9f93f0"

URI_x86_64_v2_rust-unicode-segmentation+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-segmentation+no_std-devel-1.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-segmentation+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-segmentation+no_std-devel}"
SRC_URI[x86_64_v2_rust-unicode-segmentation+no_std-devel.sha256sum] = "1fa79df32a4ee90c454bff37ccf1c11f492186a7ec1b28238b401b2623cad564"

URI_x86_64_v2_rust-unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-segmentation-devel-1.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-unicode-segmentation-devel.sha256sum] = "58c35ff4c1d23769f960fa7ec7cc68437d0f8f7af66693923507606073c6ed19"

URI_aarch64_rust-unicode-segmentation+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-segmentation+default-devel-1.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-segmentation+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-segmentation+default-devel}"
SRC_URI[aarch64_rust-unicode-segmentation+default-devel.sha256sum] = "e59c79402e3d5e371cf077c5a403c7332d3c1d8cc00b1609d89f1d7c3b8c0c29"

URI_aarch64_rust-unicode-segmentation+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-segmentation+no_std-devel-1.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-segmentation+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-segmentation+no_std-devel}"
SRC_URI[aarch64_rust-unicode-segmentation+no_std-devel.sha256sum] = "b75e137cdc0b4b7c3c9b0304dd9f1ab1fc069e804981a518ab8953e5d58f4876"

URI_aarch64_rust-unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-segmentation-devel-1.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-segmentation-devel}"
SRC_URI[aarch64_rust-unicode-segmentation-devel.sha256sum] = "57a684b036e8393a2f8f08c09aef76e88f975fb58c37ee9beb631d954f8c059a"

RDEPENDS:rust-unicode-segmentation+default-devel = " \
 cargo \
 rust-unicode-segmentation-devel \
 "
RDEPENDS:rust-unicode-segmentation+no_std-devel = " \
 cargo \
 rust-unicode-segmentation-devel \
 "
RDEPENDS:rust-unicode-segmentation-devel = " \
 cargo \
 "
