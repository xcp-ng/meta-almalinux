# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-krata-tokio-tar"
PV = "0.4.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-krata-tokio-tar+default-devel \
 rust-krata-tokio-tar+xattr-devel \
 rust-krata-tokio-tar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-krata-tokio-tar-0.4.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47fefc9432c124d8a6d00dd6908af64bf9fc942820108afdf8ecbe9303ccb3a0"

URI_x86_64_v2_rust-krata-tokio-tar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-krata-tokio-tar+default-devel-0.4.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-krata-tokio-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-krata-tokio-tar+default-devel}"
SRC_URI[x86_64_v2_rust-krata-tokio-tar+default-devel.sha256sum] = "5bd5eca79bca39e28a82512ed079d2e7eba4ae0eb7394fcf2d1bf1e4c29f71ad"

URI_x86_64_v2_rust-krata-tokio-tar+xattr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-krata-tokio-tar+xattr-devel-0.4.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-krata-tokio-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-krata-tokio-tar+xattr-devel}"
SRC_URI[x86_64_v2_rust-krata-tokio-tar+xattr-devel.sha256sum] = "b024660b4e1fea539d811a16259ba326e1898ff0a02fb1aaf696b85a24aa2d91"

URI_x86_64_v2_rust-krata-tokio-tar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-krata-tokio-tar-devel-0.4.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-krata-tokio-tar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-krata-tokio-tar-devel}"
SRC_URI[x86_64_v2_rust-krata-tokio-tar-devel.sha256sum] = "46b9b06c62764bc8c5d47c145909491424b95f80b1edc9752cf8a57b1ecbee14"

URI_aarch64_rust-krata-tokio-tar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-krata-tokio-tar+default-devel-0.4.2-2.el10_0.noarch.rpm;name=aarch64_rust-krata-tokio-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-krata-tokio-tar+default-devel}"
SRC_URI[aarch64_rust-krata-tokio-tar+default-devel.sha256sum] = "5e24adc0edb16cdaf560379e6edd3c53aad9ebd7806e8267836ee8770e9d9fe4"

URI_aarch64_rust-krata-tokio-tar+xattr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-krata-tokio-tar+xattr-devel-0.4.2-2.el10_0.noarch.rpm;name=aarch64_rust-krata-tokio-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-krata-tokio-tar+xattr-devel}"
SRC_URI[aarch64_rust-krata-tokio-tar+xattr-devel.sha256sum] = "d7209423fb61e002d6ea08bd540a2060d70b7daa01e9ddd2ed379e18c3b69b62"

URI_aarch64_rust-krata-tokio-tar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-krata-tokio-tar-devel-0.4.2-2.el10_0.noarch.rpm;name=aarch64_rust-krata-tokio-tar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-krata-tokio-tar-devel}"
SRC_URI[aarch64_rust-krata-tokio-tar-devel.sha256sum] = "ce751fe47e5b71a42301887ea9c319884aaf22bf7bd7cb83babe8f23036e6938"

RDEPENDS:rust-krata-tokio-tar+default-devel = " \
 cargo \
 rust-krata-tokio-tar+xattr-devel \
 rust-krata-tokio-tar-devel \
 "
RDEPENDS:rust-krata-tokio-tar+xattr-devel = " \
 cargo \
 rust-krata-tokio-tar-devel \
 rust-xattr+default-devel \
 "
RDEPENDS:rust-krata-tokio-tar-devel = " \
 cargo \
 rust-filetime+default-devel \
 rust-futures-core+default-devel \
 rust-libc+default-devel \
 rust-portable-atomic+default-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 rust-tokio+rt-devel \
 rust-tokio-stream+default-devel \
 "
