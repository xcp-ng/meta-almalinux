# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-seahash"
PV = "4.1.0"
PR = "9.el10_0"
PACKAGES = " \
 rust-seahash+default-devel \
 rust-seahash+use_std-devel \
 rust-seahash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-seahash-4.1.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f020de0be9b9fd20b42d99249c42cb7d2ec01e38f1b154c0bdc5c30e092ee472"

URI_x86_64_v2_rust-seahash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-seahash+default-devel-4.1.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-seahash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-seahash+default-devel}"
SRC_URI[x86_64_v2_rust-seahash+default-devel.sha256sum] = "0cd1d576aaa95091171ade7cede828eb62714ba60303a941965e18c8d14deed2"

URI_x86_64_v2_rust-seahash+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-seahash+use_std-devel-4.1.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-seahash+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-seahash+use_std-devel}"
SRC_URI[x86_64_v2_rust-seahash+use_std-devel.sha256sum] = "6c7adf1e8d93cda2f6a591a9254219201869210897c0b47158f3921ab843f674"

URI_x86_64_v2_rust-seahash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-seahash-devel-4.1.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-seahash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-seahash-devel}"
SRC_URI[x86_64_v2_rust-seahash-devel.sha256sum] = "fac94216913f203e68e9f0fba3f1028b1847b13840d6ed55480ae94e68f78ae5"

URI_aarch64_rust-seahash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-seahash+default-devel-4.1.0-9.el10_0.noarch.rpm;name=aarch64_rust-seahash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-seahash+default-devel}"
SRC_URI[aarch64_rust-seahash+default-devel.sha256sum] = "e8149528d5ec99bd850c39258cdcf624f8878acdc3b60b98f964bc3d6d2e07d7"

URI_aarch64_rust-seahash+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-seahash+use_std-devel-4.1.0-9.el10_0.noarch.rpm;name=aarch64_rust-seahash+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-seahash+use_std-devel}"
SRC_URI[aarch64_rust-seahash+use_std-devel.sha256sum] = "6d99dee2f767819fb94eef7d10de283b0efa6b9df50b9e55fa093718a7a0fd1a"

URI_aarch64_rust-seahash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-seahash-devel-4.1.0-9.el10_0.noarch.rpm;name=aarch64_rust-seahash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-seahash-devel}"
SRC_URI[aarch64_rust-seahash-devel.sha256sum] = "6f8d4042b96a531b34bb7292fe06593e39d81d89792f57ee4497a306bf35d66d"

RDEPENDS:rust-seahash+default-devel = " \
 cargo \
 rust-seahash-devel \
 "
RDEPENDS:rust-seahash+use_std-devel = " \
 cargo \
 rust-seahash-devel \
 "
RDEPENDS:rust-seahash-devel = " \
 cargo \
 "
