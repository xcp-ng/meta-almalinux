# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snapm"
PV = "0.7.0"
PR = "2.el10"
PACKAGES = " \
 python3-snapm \
 python3-snapm-doc \
 snapm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/snapm-0.7.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9cbfbf796434467a35f1d68d2ff5e443d607ec2a88c9eefafeaf078c7414af0"

URI_x86_64_v2_python3-snapm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-snapm-0.7.0-2.el10.noarch.rpm;name=x86_64_v2_python3-snapm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-snapm}"
SRC_URI[x86_64_v2_python3-snapm.sha256sum] = "b24b6d853e2d15e79a57fc77914331085b9b7f1f353281ea22a960bfc52a510e"

URI_x86_64_v2_python3-snapm-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-snapm-doc-0.7.0-2.el10.noarch.rpm;name=x86_64_v2_python3-snapm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-snapm-doc}"
SRC_URI[x86_64_v2_python3-snapm-doc.sha256sum] = "b97cb3424d1a9cc0dc315fb8809216dd01663ae4f161ca6e01b09442ea438da3"

URI_x86_64_v2_snapm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/snapm-0.7.0-2.el10.noarch.rpm;name=x86_64_v2_snapm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapm}"
SRC_URI[x86_64_v2_snapm.sha256sum] = "a2ab0e5dbb4e2a3a412fdcf1428025131274dec9586bf5e5f2c79fb5dc82aaec"

URI_aarch64_python3-snapm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-snapm-0.7.0-2.el10.noarch.rpm;name=aarch64_python3-snapm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-snapm}"
SRC_URI[aarch64_python3-snapm.sha256sum] = "b24b6d853e2d15e79a57fc77914331085b9b7f1f353281ea22a960bfc52a510e"

URI_aarch64_python3-snapm-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-snapm-doc-0.7.0-2.el10.noarch.rpm;name=aarch64_python3-snapm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-snapm-doc}"
SRC_URI[aarch64_python3-snapm-doc.sha256sum] = "b97cb3424d1a9cc0dc315fb8809216dd01663ae4f161ca6e01b09442ea438da3"

URI_aarch64_snapm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/snapm-0.7.0-2.el10.noarch.rpm;name=aarch64_snapm;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapm}"
SRC_URI[aarch64_snapm.sha256sum] = "a2ab0e5dbb4e2a3a412fdcf1428025131274dec9586bf5e5f2c79fb5dc82aaec"

RDEPENDS:python3-snapm = " \
 python3 \
 python3-boom \
 python3-dateutil \
 python3-dbus-client-gen \
 python3-dbus-python-client-gen \
 python3-file-magic \
 python3-justbytes \
 python3-packaging \
 python3-wcwidth \
 "
RDEPENDS:python3-snapm-doc = " \
 "
RDEPENDS:snapm = " \
 python3 \
 python3-snapm \
 "
