# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kolf"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kolf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kolf-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21d402edf0625ea5992c20dcef00d9f16f3b2159bbad99c1177e32c41c902e32"

URI_x86_64_v2_kolf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kolf-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kolf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kolf}"
SRC_URI[x86_64_v2_kolf.sha256sum] = "68fb65d95a97db2c320a86a0e2c6418044987efddcf7ff20080b5ad00c0c40a7"

URI_aarch64_kolf = "${EPEL_MIRROR}/aarch64/Packages/k/kolf-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kolf;unpack=0"
SRC_URI:append = " ${URI_aarch64_kolf}"
SRC_URI[aarch64_kolf.sha256sum] = "0fcf4cbebce0e6654b58aca2cbb060c1df2ce4cb2d8e623f1c6b5cd5f8ee8476"

RDEPENDS:kolf = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
