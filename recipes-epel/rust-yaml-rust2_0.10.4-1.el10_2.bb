# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-yaml-rust2"
PV = "0.10.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-yaml-rust2+debug_prints-devel \
 rust-yaml-rust2+default-devel \
 rust-yaml-rust2+encoding-devel \
 rust-yaml-rust2-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-yaml-rust2-0.10.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d0354b8dbdafe4ff55b7bce7025d96af74f5cc6dce46ffc521ff0d501d69d0c1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yaml-rust2+debug_prints-devel-0.10.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yaml-rust2+debug_prints-devel;unpack=0"
SRC_URI[x86_64_v2_rust-yaml-rust2+debug_prints-devel.sha256sum] = "538184be115eaf2973e7e377d0033609c91524316466ecf1577ba0d6cd8bb53c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yaml-rust2+default-devel-0.10.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yaml-rust2+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-yaml-rust2+default-devel.sha256sum] = "70c3d1958640640ad967711844df289a61b3bd5fb8c7ba89ab790f66f79af00a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yaml-rust2+encoding-devel-0.10.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yaml-rust2+encoding-devel;unpack=0"
SRC_URI[x86_64_v2_rust-yaml-rust2+encoding-devel.sha256sum] = "63ec258a5dccb125e63fa8470b1f64c0e725bc823077c432c10ec9ff7b2dd54e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yaml-rust2-devel-0.10.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yaml-rust2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-yaml-rust2-devel.sha256sum] = "190e3235924a8e1ac661f747f4695333de45a063f891d6e98719da287ea4e283"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-yaml-rust2+debug_prints-devel-0.10.4-1.el10_2.noarch.rpm;name=aarch64_rust-yaml-rust2+debug_prints-devel;unpack=0"
SRC_URI[aarch64_rust-yaml-rust2+debug_prints-devel.sha256sum] = "8db3c6391f4b873760a606fb2b4d70d58cf554fe9ce98fd59c0b7c9573dc2a7b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-yaml-rust2+default-devel-0.10.4-1.el10_2.noarch.rpm;name=aarch64_rust-yaml-rust2+default-devel;unpack=0"
SRC_URI[aarch64_rust-yaml-rust2+default-devel.sha256sum] = "766ef95803a84632a2ba0434b1736dbdc99aa9a8400bd57221a061957082c8be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-yaml-rust2+encoding-devel-0.10.4-1.el10_2.noarch.rpm;name=aarch64_rust-yaml-rust2+encoding-devel;unpack=0"
SRC_URI[aarch64_rust-yaml-rust2+encoding-devel.sha256sum] = "51696c339ceeda3400b2fa953d41bfafaa9b50d7e24f4f991a7989e18b5f1238"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-yaml-rust2-devel-0.10.4-1.el10_2.noarch.rpm;name=aarch64_rust-yaml-rust2-devel;unpack=0"
SRC_URI[aarch64_rust-yaml-rust2-devel.sha256sum] = "7f248efc819cfb3ad051c7e4e35f4f0913f481f7c68a6c2a57ee97cf8717c45d"

RDEPENDS:rust-yaml-rust2+debug_prints-devel = " \
 cargo \
 rust-yaml-rust2-devel \
 "
RDEPENDS:rust-yaml-rust2+default-devel = " \
 cargo \
 rust-yaml-rust2+encoding-devel \
 rust-yaml-rust2-devel \
 "
RDEPENDS:rust-yaml-rust2+encoding-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-yaml-rust2-devel \
 "
RDEPENDS:rust-yaml-rust2-devel = " \
 cargo \
 rust \
 rust-arraydeque+default-devel \
 rust-hashlink0.10+default-devel \
 "
