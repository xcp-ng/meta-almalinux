# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-util"
PV = "0.2.25"
PR = "1.el10_2"
PACKAGES = " \
 rust-cargo-util+default-devel \
 rust-cargo-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-util-0.2.25-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db3f05a5b7bab5fb21c12bef137296bf40f5ca313bedbbb054dbca5dad5e948f"

URI_x86_64_v2_rust-cargo-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util+default-devel-0.2.25-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-util+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-util+default-devel.sha256sum] = "4348a584da3374285e74fca184fc4087aa618654091b3923088518a78cfd6b29"

URI_x86_64_v2_rust-cargo-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util-devel-0.2.25-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-util-devel}"
SRC_URI[x86_64_v2_rust-cargo-util-devel.sha256sum] = "a7c87959a950aeb4d76710b36489a89a637f35b4ebaff504ab398ef873314a34"

URI_aarch64_rust-cargo-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util+default-devel-0.2.25-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-util+default-devel}"
SRC_URI[aarch64_rust-cargo-util+default-devel.sha256sum] = "d79f044bbf5b314b9e13e069d81484a915dd03012f4c5734e4e4d14760768fb6"

URI_aarch64_rust-cargo-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util-devel-0.2.25-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-util-devel}"
SRC_URI[aarch64_rust-cargo-util-devel.sha256sum] = "d6e8dbe9281604168545d03def342ceb6a560630cfc4c8b5e9f434f2ba878eb7"

RDEPENDS:rust-cargo-util+default-devel = " \
 cargo \
 rust-cargo-util-devel \
 "
RDEPENDS:rust-cargo-util-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-filetime+default-devel \
 rust-hex+default-devel \
 rust-ignore+default-devel \
 rust-jobserver+default-devel \
 rust-libc+default-devel \
 rust-same-file+default-devel \
 rust-sha2+default-devel \
 rust-shell-escape+default-devel \
 rust-tempfile+default-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 rust-walkdir+default-devel \
 "
