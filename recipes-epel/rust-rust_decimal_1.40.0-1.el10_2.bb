# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust_decimal"
PV = "1.40.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rust_decimal+align16-devel \
 rust-rust_decimal+c-repr-devel \
 rust-rust_decimal+default-devel \
 rust-rust_decimal+legacy-ops-devel \
 rust-rust_decimal+macros-devel \
 rust-rust_decimal+maths-devel \
 rust-rust_decimal+maths-nopanic-devel \
 rust-rust_decimal+proptest-devel \
 rust-rust_decimal+rand-0_9-devel \
 rust-rust_decimal+rand-devel \
 rust-rust_decimal+rkyv-devel \
 rust-rust_decimal+rkyv-safe-devel \
 rust-rust_decimal+ryu-devel \
 rust-rust_decimal+serde-arbitrary-precision-devel \
 rust-rust_decimal+serde-bincode-devel \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal+serde-float-devel \
 rust-rust_decimal+serde-str-devel \
 rust-rust_decimal+serde-with-arbitrary-precision-devel \
 rust-rust_decimal+serde-with-float-devel \
 rust-rust_decimal+serde-with-str-devel \
 rust-rust_decimal+serde_json-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust_decimal-1.40.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d711bd045b0a9c419b5781c96e1e495fa7a613de7f7f13613f92ac3a23322a4d"

URI_x86_64_v2_rust-rust_decimal+align16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+align16-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+align16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+align16-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+align16-devel.sha256sum] = "82613bf547b429c8178d7672dd3bd9a60ebff18a919723abfa743ed310054a2c"

URI_x86_64_v2_rust-rust_decimal+c-repr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+c-repr-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+c-repr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+c-repr-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+c-repr-devel.sha256sum] = "9613291e14ee21cc4447c434d1b4e22e1528bf6e2ec568df0f5bee44decad452"

URI_x86_64_v2_rust-rust_decimal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+default-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+default-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+default-devel.sha256sum] = "3b206e0a8d2f2bc3d159bd2580e47286b1f3f22151b69245df554c1dbde4e9c8"

URI_x86_64_v2_rust-rust_decimal+legacy-ops-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+legacy-ops-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+legacy-ops-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+legacy-ops-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+legacy-ops-devel.sha256sum] = "6cdfef028fe60b32eacb883b4cad405c7bb0a61c2cfa40001833f78ab82e6bba"

URI_x86_64_v2_rust-rust_decimal+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+macros-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+macros-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+macros-devel.sha256sum] = "0781cedca7c8636c7d671e02252c5f5c8e201431644b20d2b52b61bc3736d978"

URI_x86_64_v2_rust-rust_decimal+maths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+maths-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+maths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+maths-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+maths-devel.sha256sum] = "e9ddd3565815925992a86b9a6c243ffbdf0906aa7d4eaffe9f21dd0472166995"

URI_x86_64_v2_rust-rust_decimal+maths-nopanic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+maths-nopanic-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+maths-nopanic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+maths-nopanic-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+maths-nopanic-devel.sha256sum] = "5ec5daf50ae5361d52832c5baf0dc17d7b62be0b6300a8b0ac6a3ce17cb93ce3"

URI_x86_64_v2_rust-rust_decimal+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+proptest-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+proptest-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+proptest-devel.sha256sum] = "06050016ac0235225f991f3e1f152af7601c938692229b08c3cdf465f36e34e3"

URI_x86_64_v2_rust-rust_decimal+rand-0_9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rand-0_9-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rand-0_9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rand-0_9-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rand-0_9-devel.sha256sum] = "77fc5aae86db9bb036218786a0e7b43950cc9b27fbb4b378c74e678d85ed7e3e"

URI_x86_64_v2_rust-rust_decimal+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rand-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rand-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rand-devel.sha256sum] = "1584a10988b5b4d69f183950d12d90f01b18aef6e886472c1c3d682807e6172b"

URI_x86_64_v2_rust-rust_decimal+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rkyv-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rkyv-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rkyv-devel.sha256sum] = "18d936ad1e275fdef29f88227b819daaa5569ee84adad869643bc3bc9671d3a7"

URI_x86_64_v2_rust-rust_decimal+rkyv-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rkyv-safe-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rkyv-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rkyv-safe-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rkyv-safe-devel.sha256sum] = "63b82505acaef005c7266f528a9764e1500ca5e3f71f6f4caad5ee083ad13c24"

URI_x86_64_v2_rust-rust_decimal+ryu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+ryu-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+ryu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+ryu-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+ryu-devel.sha256sum] = "28d6f0476cf12f0478c6dbc9466b9cb7891d7ec0d0e777803cbac5ac786cdd3c"

URI_x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-arbitrary-precision-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel.sha256sum] = "de63f0905986e833670ea5d2e6758a8f70c99662a1e01e77fe37caf5c93661d4"

URI_x86_64_v2_rust-rust_decimal+serde-bincode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-bincode-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-bincode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-bincode-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-bincode-devel.sha256sum] = "e5274a3edeb6c653ca4b0578bffde43690b85cba29c651cce136216731e70d02"

URI_x86_64_v2_rust-rust_decimal+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-devel.sha256sum] = "217cec9a29260e35f704f83ab523e7ee2f0bda3a5f97f2a659a004d9fa7514fe"

URI_x86_64_v2_rust-rust_decimal+serde-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-float-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-float-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-float-devel.sha256sum] = "a51e8a6626acca28c24d169ec811980a34b3679ef7687c59d1fbe5b1e933fbee"

URI_x86_64_v2_rust-rust_decimal+serde-str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-str-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-str-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-str-devel.sha256sum] = "f1a87e270d13066ae981a437f65c63bfd8736b51ec43d2d284365ddc5a1c2abc"

URI_x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-with-arbitrary-precision-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel.sha256sum] = "d1f68f8b7e682cb1114c24345a9ed131d4f2dac241fa8a45eaa98e11c2faad31"

URI_x86_64_v2_rust-rust_decimal+serde-with-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-with-float-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-with-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-with-float-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-with-float-devel.sha256sum] = "d6c2c94a5d3882174659650de9d6fbf1e2ab56d2630ebba3430a57ca153bd32b"

URI_x86_64_v2_rust-rust_decimal+serde-with-str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-with-str-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-with-str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-with-str-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-with-str-devel.sha256sum] = "1df2807937ee573432b0deeb96c79dd0b6ce18d7cac2e92ad30f289426580ab3"

URI_x86_64_v2_rust-rust_decimal+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde_json-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde_json-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde_json-devel.sha256sum] = "aac3014e84121ba7adadd951894ed238dba98283e21d052c688eec5062d01c1c"

URI_x86_64_v2_rust-rust_decimal+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+std-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+std-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+std-devel.sha256sum] = "aa7ab970c2b6f6ff9d7dface88360b35da97a92fa6994f1b3e0e364186393278"

URI_x86_64_v2_rust-rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal-devel.sha256sum] = "1e6387e7d24a4c61ac85035756b00ecb7aba379d38df8204315adbdd0896a6f7"

URI_aarch64_rust-rust_decimal+align16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+align16-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+align16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+align16-devel}"
SRC_URI[aarch64_rust-rust_decimal+align16-devel.sha256sum] = "257ba2f697e1da5fb6f82791a6281b9d9b21b89bbc0d48ea2a70d561ca65ef8c"

URI_aarch64_rust-rust_decimal+c-repr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+c-repr-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+c-repr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+c-repr-devel}"
SRC_URI[aarch64_rust-rust_decimal+c-repr-devel.sha256sum] = "6ca729bdecff130b0d674b4bc06e76b7543891c2d2a146829088fadf36983ee3"

URI_aarch64_rust-rust_decimal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+default-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+default-devel}"
SRC_URI[aarch64_rust-rust_decimal+default-devel.sha256sum] = "2cd78c104307ba0822e46004b4e724347ed5c3c847d83aec2a963275c80906f2"

URI_aarch64_rust-rust_decimal+legacy-ops-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+legacy-ops-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+legacy-ops-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+legacy-ops-devel}"
SRC_URI[aarch64_rust-rust_decimal+legacy-ops-devel.sha256sum] = "b1766aeea53f3ebd04c5a396c2831484752a7381548dbaa3480def59badb47e5"

URI_aarch64_rust-rust_decimal+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+macros-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+macros-devel}"
SRC_URI[aarch64_rust-rust_decimal+macros-devel.sha256sum] = "3f2094a0907f23086b4f8a08410145ea1349121833ba6ef4b38fb1e4b91bbeed"

URI_aarch64_rust-rust_decimal+maths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+maths-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+maths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+maths-devel}"
SRC_URI[aarch64_rust-rust_decimal+maths-devel.sha256sum] = "f067be68eddf361bfd9635874de9e1f029140a599e8216fb4d96b00197bd1ee0"

URI_aarch64_rust-rust_decimal+maths-nopanic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+maths-nopanic-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+maths-nopanic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+maths-nopanic-devel}"
SRC_URI[aarch64_rust-rust_decimal+maths-nopanic-devel.sha256sum] = "bbc0b43b9fa8de1576dba61edbf381b83fb5c143ea2510d267cf9fbe2e559e1e"

URI_aarch64_rust-rust_decimal+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+proptest-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+proptest-devel}"
SRC_URI[aarch64_rust-rust_decimal+proptest-devel.sha256sum] = "a1a0f3eae24993e569b4e177bab284f418d7aeb366b326ee38b28a5256392c71"

URI_aarch64_rust-rust_decimal+rand-0_9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rand-0_9-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+rand-0_9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rand-0_9-devel}"
SRC_URI[aarch64_rust-rust_decimal+rand-0_9-devel.sha256sum] = "40fc310df8752e670778efbcb9e20588367088222a321c365e3e2854cf289783"

URI_aarch64_rust-rust_decimal+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rand-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rand-devel}"
SRC_URI[aarch64_rust-rust_decimal+rand-devel.sha256sum] = "242067525603c4d261e2d39a48faa31ed4d9dc8d69cf9e246de710944ed329bd"

URI_aarch64_rust-rust_decimal+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rkyv-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rkyv-devel}"
SRC_URI[aarch64_rust-rust_decimal+rkyv-devel.sha256sum] = "c85a6f598a3e15020bdcb5084e1c08aab24287e3ccb6b9571430c6575c1b3fe7"

URI_aarch64_rust-rust_decimal+rkyv-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rkyv-safe-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+rkyv-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rkyv-safe-devel}"
SRC_URI[aarch64_rust-rust_decimal+rkyv-safe-devel.sha256sum] = "cc2dc2dadc73f9b20370092c4663018ba6be08cc96b7d83e7776e4d41e382aa4"

URI_aarch64_rust-rust_decimal+ryu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+ryu-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+ryu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+ryu-devel}"
SRC_URI[aarch64_rust-rust_decimal+ryu-devel.sha256sum] = "7fce376c854794536f04a55411400fa389f9cf7af762eb75de35db9ffa4bf0d0"

URI_aarch64_rust-rust_decimal+serde-arbitrary-precision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-arbitrary-precision-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+serde-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-arbitrary-precision-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-arbitrary-precision-devel.sha256sum] = "4cd98a50ec8b4b25780e281c1ed4b12a33b2d601ae29e54454399005548b1066"

URI_aarch64_rust-rust_decimal+serde-bincode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-bincode-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+serde-bincode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-bincode-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-bincode-devel.sha256sum] = "fc4ceb678299d940acad907c42dd1cde65046dbd05005a076eab419f42c4e605"

URI_aarch64_rust-rust_decimal+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-devel.sha256sum] = "dd2127fd602e15b08abe429e7d71c86224aa7f5a31018d842f8ab8704b276f12"

URI_aarch64_rust-rust_decimal+serde-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-float-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+serde-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-float-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-float-devel.sha256sum] = "dcfdaf18400b37ad37835c53020f70c9da1d83f02b107a82684b6f14cf63adea"

URI_aarch64_rust-rust_decimal+serde-str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-str-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+serde-str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-str-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-str-devel.sha256sum] = "3eb71f15b577412f33a1cea0b0dc4eec96d407ef090f481f79ab7b1a17ab850f"

URI_aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-with-arbitrary-precision-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel.sha256sum] = "c5cc4836a6471e1b8b67ddeefc63fb17453532a7a5f590d63a412d372992dc95"

URI_aarch64_rust-rust_decimal+serde-with-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-with-float-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+serde-with-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-with-float-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-with-float-devel.sha256sum] = "c6c46c5e7e0ae1e5b696ed2333aab538776bd83e168453d4450f6f507eadb07d"

URI_aarch64_rust-rust_decimal+serde-with-str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-with-str-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+serde-with-str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-with-str-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-with-str-devel.sha256sum] = "1fffc9be3e09738360aabf4e4a13b19ec8c1f17a3072634c77082c6f0c947e7c"

URI_aarch64_rust-rust_decimal+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde_json-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde_json-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde_json-devel.sha256sum] = "63c48047741e7998e2e69565d132bd0ed6e96553d5eb7ac1db90bfd5dc270de8"

URI_aarch64_rust-rust_decimal+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+std-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+std-devel}"
SRC_URI[aarch64_rust-rust_decimal+std-devel.sha256sum] = "2867e95feccb74bd6293b5bfd715232fcea55344856af2ede97e09d0ff1b8fff"

URI_aarch64_rust-rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal-devel}"
SRC_URI[aarch64_rust-rust_decimal-devel.sha256sum] = "e2ffba766c41a47ac0ea6916a003f94e576372518ece74bc61a4b9d5a7215fb3"

RDEPENDS:rust-rust_decimal+align16-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+c-repr-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+default-devel = " \
 cargo \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+legacy-ops-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+macros-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-rust_decimal_macros-devel \
 "
RDEPENDS:rust-rust_decimal+maths-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+maths-nopanic-devel = " \
 cargo \
 rust-rust_decimal+maths-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+proptest-devel = " \
 cargo \
 rust-proptest+std-devel \
 rust-proptest-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rand-0_9-devel = " \
 cargo \
 rust-rand0.9-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rand-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rkyv-devel = " \
 cargo \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rkyv-safe-devel = " \
 cargo \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7+validation-devel \
 rust-rkyv0.7-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+ryu-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-ryu-devel \
 "
RDEPENDS:rust-rust_decimal+serde-arbitrary-precision-devel = " \
 cargo \
 rust-rust_decimal+serde-with-arbitrary-precision-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-bincode-devel = " \
 cargo \
 rust-rust_decimal+serde-str-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rust_decimal+serde-float-devel = " \
 cargo \
 rust-rust_decimal+serde-with-float-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-str-devel = " \
 cargo \
 rust-rust_decimal+serde-with-str-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-with-arbitrary-precision-devel = " \
 cargo \
 rust-rust_decimal+ryu-devel \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal-devel \
 rust-serde_json+arbitrary_precision-devel \
 rust-serde_json+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-rust_decimal+serde-with-float-devel = " \
 cargo \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-with-str-devel = " \
 cargo \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde_json-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-rust_decimal+std-devel = " \
 cargo \
 rust-arrayvec+std-devel \
 rust-bytes+std-devel \
 rust-bytes-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7-devel \
 rust-rust_decimal-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-serde_json+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-rust_decimal-devel = " \
 cargo \
 rust \
 rust-arrayvec-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
