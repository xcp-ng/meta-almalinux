# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "subscription-manager"
PV = "1.30.10.1"
PR = "1.el10_1.alma.1"
PACKAGES = " \
 libdnf-plugin-subscription-manager \
 python3-cloud-what \
 python3-subscription-manager-rhsm \
 subscription-manager \
 subscription-manager-plugin-ostree \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/subscription-manager-1.30.10.1-1.el10_1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c949a3d2e232e29950e53e73782947b9fdf417185665fe371f0e20658ed4fe1"

URI_x86_64_v2_libdnf-plugin-subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libdnf-plugin-subscription-manager-1.30.10.1-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_libdnf-plugin-subscription-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdnf-plugin-subscription-manager}"
SRC_URI[x86_64_v2_libdnf-plugin-subscription-manager.sha256sum] = "50445b2315262363cbce120e86039ddc04068667d7338dfa7364c24b5efb0fc9"

URI_x86_64_v2_python3-cloud-what = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-cloud-what-1.30.10.1-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-cloud-what;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cloud-what}"
SRC_URI[x86_64_v2_python3-cloud-what.sha256sum] = "bf0373668166e3c3575508a2968e593bf943f9a3e985bce4feb0b6f7f2ecaa5b"

URI_x86_64_v2_python3-subscription-manager-rhsm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-subscription-manager-rhsm-1.30.10.1-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-subscription-manager-rhsm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-subscription-manager-rhsm}"
SRC_URI[x86_64_v2_python3-subscription-manager-rhsm.sha256sum] = "f4078bc56c62eefe6a8a66058601edb4444603285e89f16e93127eb5bdec43bd"

URI_x86_64_v2_subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/subscription-manager-1.30.10.1-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_subscription-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subscription-manager}"
SRC_URI[x86_64_v2_subscription-manager.sha256sum] = "f47f2c2d8f72d0b5b1bf06aa99e1d7da49245574d82baec8bbe0750a5c74d652"

URI_x86_64_v2_subscription-manager-plugin-ostree = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/subscription-manager-plugin-ostree-1.30.10.1-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_subscription-manager-plugin-ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subscription-manager-plugin-ostree}"
SRC_URI[x86_64_v2_subscription-manager-plugin-ostree.sha256sum] = "311234d9b7258595cc9eef6f0ffec6f09a135453ee0cc914ffee90e0e123c19f"

URI_aarch64_libdnf-plugin-subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libdnf-plugin-subscription-manager-1.30.10.1-1.el10_1.alma.1.aarch64.rpm;name=aarch64_libdnf-plugin-subscription-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdnf-plugin-subscription-manager}"
SRC_URI[aarch64_libdnf-plugin-subscription-manager.sha256sum] = "c50e245841b8872699761fe79632c2534db7f00886f4a510689e57dbc4199c0e"

URI_aarch64_python3-cloud-what = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-cloud-what-1.30.10.1-1.el10_1.alma.1.aarch64.rpm;name=aarch64_python3-cloud-what;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cloud-what}"
SRC_URI[aarch64_python3-cloud-what.sha256sum] = "d1ddac92f908673a606f9fbb582b65868900e5fb092177aa3cd4ded0388b7fdc"

URI_aarch64_python3-subscription-manager-rhsm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-subscription-manager-rhsm-1.30.10.1-1.el10_1.alma.1.aarch64.rpm;name=aarch64_python3-subscription-manager-rhsm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-subscription-manager-rhsm}"
SRC_URI[aarch64_python3-subscription-manager-rhsm.sha256sum] = "c1623d4d6503e1fe0b03b7f14c038f95e6b23df5f5318eb7ad72a1a997481961"

URI_aarch64_subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/subscription-manager-1.30.10.1-1.el10_1.alma.1.aarch64.rpm;name=aarch64_subscription-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_subscription-manager}"
SRC_URI[aarch64_subscription-manager.sha256sum] = "18c42a0cd557db22756f2f75c96a27459538882be610d1370fe8c55a0ac04012"

URI_aarch64_subscription-manager-plugin-ostree = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/subscription-manager-plugin-ostree-1.30.10.1-1.el10_1.alma.1.aarch64.rpm;name=aarch64_subscription-manager-plugin-ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_subscription-manager-plugin-ostree}"
SRC_URI[aarch64_subscription-manager-plugin-ostree.sha256sum] = "bfce00a1398a21df94dbf5e9b4d5b2515ffa6c143f046b68f510252f3058c857"

RDEPENDS:libdnf-plugin-subscription-manager = " \
 glib2 \
 glibc \
 json-c \
 libdnf \
 librepo \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-cloud-what = " \
 dmidecode \
 python3 \
 python3-requests \
 "
RDEPENDS:python3-subscription-manager-rhsm = " \
 glibc \
 openssl-libs \
 python3 \
 python3-cloud-what \
 python3-dateutil \
 python3-iniparse \
 python3-rpm \
 subscription-manager-rhsm-certificates \
 "
RDEPENDS:subscription-manager = " \
 bash \
 dmidecode \
 findutils \
 glib2 \
 glibc \
 iproute \
 libdnf-plugin-subscription-manager \
 python3 \
 python3-cloud-what \
 python3-dateutil \
 python3-dbus \
 python3-decorator \
 python3-dnf \
 python3-dnf-plugins-core \
 python3-gobject-base \
 python3-iniparse \
 python3-inotify \
 python3-librepo \
 python3-subscription-manager-rhsm \
 subscription-manager-rhsm-certificates \
 systemd \
 virt-what \
 "
RDEPENDS:subscription-manager-plugin-ostree = " \
 python3 \
 python3-gobject-base \
 python3-iniparse \
 subscription-manager \
 "
