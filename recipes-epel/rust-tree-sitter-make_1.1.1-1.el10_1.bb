# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-make"
PV = "1.1.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-make+default-devel \
 rust-tree-sitter-make-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-make-1.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "079c2f304d85b21f555b124ff4f2cd9a8f63e77e5a37f81044721d849a631926"

URI_x86_64_v2_rust-tree-sitter-make+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-make+default-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-make+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-make+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-make+default-devel.sha256sum] = "bfa8d72572093d2ac4e9869681e0606ead6e595cbaeba54b07f9c2d00a60e727"

URI_x86_64_v2_rust-tree-sitter-make-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-make-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-make-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-make-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-make-devel.sha256sum] = "0fac5ebc2cf6c7317faf7be045f1b26df17e378cecea6f9ed7a29d6db87b9954"

URI_aarch64_rust-tree-sitter-make+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-make+default-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-make+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-make+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-make+default-devel.sha256sum] = "11d09e94d587b0ee2612e2e06823e20fdb9b0be5e1652613a1d61f438d712287"

URI_aarch64_rust-tree-sitter-make-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-make-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-make-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-make-devel}"
SRC_URI[aarch64_rust-tree-sitter-make-devel.sha256sum] = "32ec06c408f9db6646c43cfaa6b6c58a564b6e17f5af61fa484d2b693db767e5"

RDEPENDS:rust-tree-sitter-make+default-devel = " \
 cargo \
 rust-tree-sitter-make-devel \
 "
RDEPENDS:rust-tree-sitter-make-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
