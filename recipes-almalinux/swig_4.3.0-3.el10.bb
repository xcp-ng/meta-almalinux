# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "swig"
PV = "4.3.0"
PR = "3.el10"
PACKAGES = " \
 swig \
 swig-doc \
 swig-gdb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/swig-4.3.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9816537a9eb9ca1bd1e5f1b86daab245f3b681c87843a122f3739e6f348afba"

URI_x86_64_v2_swig = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/swig-4.3.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_swig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_swig}"
SRC_URI[x86_64_v2_swig.sha256sum] = "5a593c5deb6c6ad8ab52f24a7feb2fdc9e55bbea0dc6142da77b627f1dcb9f61"

URI_x86_64_v2_swig-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/swig-doc-4.3.0-3.el10.noarch.rpm;name=x86_64_v2_swig-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_swig-doc}"
SRC_URI[x86_64_v2_swig-doc.sha256sum] = "bc263923523364ea726df2a397c6e16472b86ba8cb9cfe1ba41c5b09a14e6396"

URI_x86_64_v2_swig-gdb = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/swig-gdb-4.3.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_swig-gdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_swig-gdb}"
SRC_URI[x86_64_v2_swig-gdb.sha256sum] = "344ed56414943c3f64aaa2252e9689bfabc57e294d6a3aee9ab2983417f6e853"

URI_aarch64_swig = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/swig-4.3.0-3.el10.aarch64.rpm;name=aarch64_swig;unpack=0"
SRC_URI:append = " ${URI_aarch64_swig}"
SRC_URI[aarch64_swig.sha256sum] = "c66c6bd260d09ebd081612e71725876466fb44e614a177cd4e7a11af8d430ef0"

URI_aarch64_swig-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/swig-doc-4.3.0-3.el10.noarch.rpm;name=aarch64_swig-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_swig-doc}"
SRC_URI[aarch64_swig-doc.sha256sum] = "bc263923523364ea726df2a397c6e16472b86ba8cb9cfe1ba41c5b09a14e6396"

URI_aarch64_swig-gdb = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/swig-gdb-4.3.0-3.el10.aarch64.rpm;name=aarch64_swig-gdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_swig-gdb}"
SRC_URI[aarch64_swig-gdb.sha256sum] = "2462f2c4f59b78041cc1a460bdb3e133dd5ac28896ad052138b6f2e30e9f540a"

RDEPENDS:swig = " \
 glibc \
 libgcc \
 libstdc++ \
 pcre2 \
 "
RDEPENDS:swig-doc = " \
 "
RDEPENDS:swig-gdb = " \
 swig \
 "
