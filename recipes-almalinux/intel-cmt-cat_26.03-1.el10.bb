# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-cmt-cat"
PV = "26.03"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 intel-cmt-cat \
 intel-cmt-cat-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/intel-cmt-cat-26.03-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3766c7ea1957364d0025b01f546d839e4f30aa536bb78a8fed01fcf6344a9fad"

URI_x86_64_v2_intel-cmt-cat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-cmt-cat-26.03-1.el10.x86_64_v2.rpm;name=x86_64_v2_intel-cmt-cat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-cmt-cat}"
SRC_URI[x86_64_v2_intel-cmt-cat.sha256sum] = "f29b52fa1f7c1782a021c06e6784a731302e41dcecee79e26e9544448bbd39f7"

URI_x86_64_v2_intel-cmt-cat-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/intel-cmt-cat-devel-26.03-1.el10.x86_64_v2.rpm;name=x86_64_v2_intel-cmt-cat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-cmt-cat-devel}"
SRC_URI[x86_64_v2_intel-cmt-cat-devel.sha256sum] = "91c3dfd747125481e72606901414eb2f7fb9f9ecc8528e7c4cd45af45735f514"

RDEPENDS:intel-cmt-cat = " \
 bash \
 glibc \
 "
RDEPENDS:intel-cmt-cat-devel = " \
 intel-cmt-cat \
 "
