# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-vsprintf"
PV = "2.0.0"
PR = "11.el10_0"
PACKAGES = " \
 rust-vsprintf+default-devel \
 rust-vsprintf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-vsprintf-2.0.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6014c831455c36ee0c7eb4f4d5fa15b7c2742f9af86954d1486f91af2c1c1823"

URI_x86_64_v2_rust-vsprintf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vsprintf+default-devel-2.0.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vsprintf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vsprintf+default-devel}"
SRC_URI[x86_64_v2_rust-vsprintf+default-devel.sha256sum] = "89af247b8ee656d26b873dbe648260857583d5bb1e12de7a0bebce4a08d8b73d"

URI_x86_64_v2_rust-vsprintf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vsprintf-devel-2.0.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vsprintf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vsprintf-devel}"
SRC_URI[x86_64_v2_rust-vsprintf-devel.sha256sum] = "645aef82200a88e3173387693ee15abe8a16be9d3ee6fcdfc2a46713dd8b98a3"

URI_aarch64_rust-vsprintf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vsprintf+default-devel-2.0.0-11.el10_0.noarch.rpm;name=aarch64_rust-vsprintf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vsprintf+default-devel}"
SRC_URI[aarch64_rust-vsprintf+default-devel.sha256sum] = "3426cb39cd03199705d878088ac44a3bf01885c62112b55099e798846ec1be80"

URI_aarch64_rust-vsprintf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vsprintf-devel-2.0.0-11.el10_0.noarch.rpm;name=aarch64_rust-vsprintf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vsprintf-devel}"
SRC_URI[aarch64_rust-vsprintf-devel.sha256sum] = "95656f2f3fca7f0e0ec13ae3bad4b45d64f472731083df2a77f17eb45ea53207"

RDEPENDS:rust-vsprintf+default-devel = " \
 cargo \
 rust-vsprintf-devel \
 "
RDEPENDS:rust-vsprintf-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-libc+default-devel \
 "
