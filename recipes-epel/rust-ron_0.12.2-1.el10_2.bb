# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ron"
PV = "0.12.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-ron+default-devel \
 rust-ron+indexmap-devel \
 rust-ron+integer128-devel \
 rust-ron+std-devel \
 rust-ron+unicode-segmentation-devel \
 rust-ron-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ron-0.12.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a45d44c74cc9143af9c1175246b706a45487ace135a0da324d7120f3f7331dfb"

URI_x86_64_v2_rust-ron+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+default-devel-0.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+default-devel}"
SRC_URI[x86_64_v2_rust-ron+default-devel.sha256sum] = "046287eb3e90a7fd14dd85cb2c15061b4975224c0f73354f161dabe4193f95b9"

URI_x86_64_v2_rust-ron+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+indexmap-devel-0.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+indexmap-devel}"
SRC_URI[x86_64_v2_rust-ron+indexmap-devel.sha256sum] = "b040167ef193debebe9ee49eb1b9c2c38bb846ac1bc9f96fb0f50f8006d8627a"

URI_x86_64_v2_rust-ron+integer128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+integer128-devel-0.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+integer128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+integer128-devel}"
SRC_URI[x86_64_v2_rust-ron+integer128-devel.sha256sum] = "9b7f1306a894ec658940e6ae4f2b420bc20a0da36edfb442292d2bf5a226e096"

URI_x86_64_v2_rust-ron+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+std-devel-0.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+std-devel}"
SRC_URI[x86_64_v2_rust-ron+std-devel.sha256sum] = "0bd60d0f2b62959dbcc2101a515746a1620383dff848428584189eafa1e30e00"

URI_x86_64_v2_rust-ron+unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+unicode-segmentation-devel-0.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-ron+unicode-segmentation-devel.sha256sum] = "e970ad615eb58d9011738efa21d1500a7d2637cedd0a850ea84cba8b27c2ab50"

URI_x86_64_v2_rust-ron-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron-devel-0.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron-devel}"
SRC_URI[x86_64_v2_rust-ron-devel.sha256sum] = "e3caf064756ec282db8c5c652ed4d46b4ca546a9b212c08515f92b7dc5908e67"

URI_aarch64_rust-ron+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+default-devel-0.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-ron+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+default-devel}"
SRC_URI[aarch64_rust-ron+default-devel.sha256sum] = "733b7e82692da255310b9a62b638688ba634adfd57f248d993aa8a66b0ed8959"

URI_aarch64_rust-ron+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+indexmap-devel-0.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-ron+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+indexmap-devel}"
SRC_URI[aarch64_rust-ron+indexmap-devel.sha256sum] = "eda49d6fe8b415e23d11bbf340ac9dc19256bf4ffd5fbb1e94330a761024c5d1"

URI_aarch64_rust-ron+integer128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+integer128-devel-0.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-ron+integer128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+integer128-devel}"
SRC_URI[aarch64_rust-ron+integer128-devel.sha256sum] = "f46b9402041812966b2a476d35f6e961ffdc00765a64c50d9e95a6d346d2a8ab"

URI_aarch64_rust-ron+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+std-devel-0.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-ron+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+std-devel}"
SRC_URI[aarch64_rust-ron+std-devel.sha256sum] = "38d8f00422323665851b739508f9ed226826c7a72497d5074aa7e70d68cd0132"

URI_aarch64_rust-ron+unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+unicode-segmentation-devel-0.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-ron+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+unicode-segmentation-devel}"
SRC_URI[aarch64_rust-ron+unicode-segmentation-devel.sha256sum] = "f54a5cef798edb9a5e68917089d53e2b452f37ebd2542535ec21acefa66421c2"

URI_aarch64_rust-ron-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron-devel-0.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-ron-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron-devel}"
SRC_URI[aarch64_rust-ron-devel.sha256sum] = "68e32de0b9651537bff4ce7526c6b29ac2b70081a93c51557564fdcbd130d954"

RDEPENDS:rust-ron+default-devel = " \
 cargo \
 rust-ron+std-devel \
 rust-ron-devel \
 "
RDEPENDS:rust-ron+indexmap-devel = " \
 cargo \
 rust-indexmap+serde-devel \
 rust-indexmap-devel \
 rust-ron+std-devel \
 rust-ron-devel \
 "
RDEPENDS:rust-ron+integer128-devel = " \
 cargo \
 rust-ron-devel \
 "
RDEPENDS:rust-ron+std-devel = " \
 cargo \
 rust-ron-devel \
 rust-serde+std-devel \
 "
RDEPENDS:rust-ron+unicode-segmentation-devel = " \
 cargo \
 rust-ron-devel \
 rust-unicode-segmentation-devel \
 "
RDEPENDS:rust-ron-devel = " \
 cargo \
 rust \
 rust-bitflags+serde-devel \
 rust-bitflags-devel \
 rust-once_cell+alloc-devel \
 rust-once_cell+race-devel \
 rust-once_cell-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-serde_derive-devel \
 rust-typeid-devel \
 rust-unicode-ident-devel \
 "
