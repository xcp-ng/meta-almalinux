# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pocketfft"
PV = "1.0^git20230214.076cb3d"
PR = "7.el10_1"
PACKAGES = " \
 pocketfft-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pocketfft-1.0^git20230214.076cb3d-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb681699711daec5dec117bbeb7a203d53d196ee81c458662f312b56303b6e45"

URI_x86_64_v2_pocketfft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pocketfft-devel-1.0^git20230214.076cb3d-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pocketfft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pocketfft-devel}"
SRC_URI[x86_64_v2_pocketfft-devel.sha256sum] = "3cd44e07898842df6cbe4ebfea8300abbbe4594b64ee476bac46d5b93f177e3c"

URI_aarch64_pocketfft-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pocketfft-devel-1.0^git20230214.076cb3d-7.el10_1.noarch.rpm;name=aarch64_pocketfft-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pocketfft-devel}"
SRC_URI[aarch64_pocketfft-devel.sha256sum] = "a1859df7a9b75b5783a0513ebef1f540c8e9e828b77e20704058be0376d99157"

RDEPENDS:pocketfft-devel = " \
 "
