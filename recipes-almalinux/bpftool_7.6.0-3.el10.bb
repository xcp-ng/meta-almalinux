# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bpftool"
PV = "7.6.0"
PR = "3.el10"
PACKAGES = " \
 bpftool \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bpftool-7.6.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04caeb50ec3879ea62258cd9f6c0c7efd5b859adb370fb74305ac94e148acf88"

URI_x86_64_v2_bpftool = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bpftool-7.6.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_bpftool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bpftool}"
SRC_URI[x86_64_v2_bpftool.sha256sum] = "3603c01253362b65ae425add70d9569bc2e4373739924a7cac5bf86846ea978e"

URI_aarch64_bpftool = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bpftool-7.6.0-3.el10.aarch64.rpm;name=aarch64_bpftool;unpack=0"
SRC_URI:append = " ${URI_aarch64_bpftool}"
SRC_URI[aarch64_bpftool.sha256sum] = "84932045a5c6ecbc3c68c691cdacb5352f5a934d71c48fd011a4026e0d42a391"

RDEPENDS:bpftool:x86_64_v2 = " \
 elfutils-libelf \
 glibc \
 libcap \
 zlib-ng-compat \
"
RDEPENDS:bpftool:aarch64 = " \
 elfutils-libelf \
 glibc \
 libcap \
 llvm-libs \
 zlib-ng-compat \
"
