# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "SLOF"
PV = "20220719"
PR = "5.git6b6c16b4.el10_0"
PACKAGES = " \
 SLOF \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/SLOF-20220719-5.git6b6c16b4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1608c941bb5adb032bd6e862a6a23360090a13d833076c82ffc2e4b12f691fe"

URI_x86_64_v2_SLOF = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SLOF-20220719-5.git6b6c16b4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_SLOF;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SLOF}"
SRC_URI[x86_64_v2_SLOF.sha256sum] = "731c526ec7bbd1be40b7e52fda18711f477d83ecb51c9169614bc3d62d4348e0"

URI_aarch64_SLOF = "${EPEL_MIRROR}/aarch64/Packages/s/SLOF-20220719-5.git6b6c16b4.el10_0.noarch.rpm;name=aarch64_SLOF;unpack=0"
SRC_URI:append = " ${URI_aarch64_SLOF}"
SRC_URI[aarch64_SLOF.sha256sum] = "8dd49968e9e8a9824c43e747ae2f5a4f4142818bab8ebf4cfd626f16f6dfe6a4"

RDEPENDS:SLOF = " \
 "
