# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ratatui-macros"
PV = "0.7.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-ratatui-macros+default-devel \
 rust-ratatui-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ratatui-macros-0.7.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cd59fc2cf56e73736c6f5a82bc12d84f822a5a9d950f7d770f0be62013cff05"

URI_x86_64_v2_rust-ratatui-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-macros+default-devel-0.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-macros+default-devel}"
SRC_URI[x86_64_v2_rust-ratatui-macros+default-devel.sha256sum] = "e0a03b316206c8e00301633999b712882ffec52881aff54c8c9f8018cd1cfbcc"

URI_x86_64_v2_rust-ratatui-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-macros-devel-0.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-macros-devel}"
SRC_URI[x86_64_v2_rust-ratatui-macros-devel.sha256sum] = "5919845b39bfd677c375d22463eb7db5f776afa4f5bae4cda501a45fae54353b"

URI_aarch64_rust-ratatui-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-macros+default-devel-0.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-macros+default-devel}"
SRC_URI[aarch64_rust-ratatui-macros+default-devel.sha256sum] = "1f83b3459d92df8c2a26cabd0a3f97a8c86823d99c6f06e64faee8fc83d8a372"

URI_aarch64_rust-ratatui-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-macros-devel-0.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-macros-devel}"
SRC_URI[aarch64_rust-ratatui-macros-devel.sha256sum] = "4ff22814350b8c5bfe496f40f3b13a8a369a6757efbdd0fff1480420da845582"

RDEPENDS:rust-ratatui-macros+default-devel = " \
 cargo \
 rust-ratatui-macros-devel \
 "
RDEPENDS:rust-ratatui-macros-devel = " \
 cargo \
 rust-ratatui-core+default-devel \
 rust-ratatui-widgets+default-devel \
 "
