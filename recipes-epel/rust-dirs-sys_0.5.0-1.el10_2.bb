# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dirs-sys"
PV = "0.5.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-dirs-sys+default-devel \
 rust-dirs-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dirs-sys-0.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e13fa21616667626110c4402d0c7419bff76f40cc1414d562400a72d2e195958"

URI_x86_64_v2_rust-dirs-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dirs-sys+default-devel-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dirs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dirs-sys+default-devel}"
SRC_URI[x86_64_v2_rust-dirs-sys+default-devel.sha256sum] = "1ad792a495f6b422b01c54f1cdfea5bd0efde51f6048791ec70891f221654ebe"

URI_x86_64_v2_rust-dirs-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dirs-sys-devel-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dirs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dirs-sys-devel}"
SRC_URI[x86_64_v2_rust-dirs-sys-devel.sha256sum] = "8ab7acd7c6d5b4766ab5f47e495231aefcf64d908bd0c8cb761b93b176c0ec40"

URI_aarch64_rust-dirs-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dirs-sys+default-devel-0.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-dirs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dirs-sys+default-devel}"
SRC_URI[aarch64_rust-dirs-sys+default-devel.sha256sum] = "77652758c285b425f831fef8126550ad3d867e7c2a556e009f932ffa49d67047"

URI_aarch64_rust-dirs-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dirs-sys-devel-0.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-dirs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dirs-sys-devel}"
SRC_URI[aarch64_rust-dirs-sys-devel.sha256sum] = "cf7e91cd420369b30da577899a3724ee472752a3a7d4f899d07ab497e1c48329"

RDEPENDS:rust-dirs-sys+default-devel = " \
 cargo \
 rust-dirs-sys-devel \
 "
RDEPENDS:rust-dirs-sys-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-option-ext+default-devel \
 "
