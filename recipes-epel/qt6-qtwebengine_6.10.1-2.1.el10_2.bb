# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtwebengine"
PV = "6.10.1"
PR = "2.1.el10_2"
PACKAGES = " \
 qt6-qtpdf \
 qt6-qtpdf-devel \
 qt6-qtpdf-examples \
 qt6-qtwebengine \
 qt6-qtwebengine-devel \
 qt6-qtwebengine-devtools \
 qt6-qtwebengine-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtwebengine-6.10.1-2.1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e77fb18f30368b0c27cabdd108053b534de7f4ad922dbcc2bc804cfad70daa5"

URI_x86_64_v2_qt6-qtpdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtpdf-6.10.1-2.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtpdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtpdf}"
SRC_URI[x86_64_v2_qt6-qtpdf.sha256sum] = "18e455a895d6b7ca2e6da2039f45c9f917d065a318ec744d09c332d48f56fc97"

URI_x86_64_v2_qt6-qtpdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtpdf-devel-6.10.1-2.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtpdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtpdf-devel}"
SRC_URI[x86_64_v2_qt6-qtpdf-devel.sha256sum] = "19ba6437c2be0a88350d272286fc54b3ca7d1904d1b9039671c2cd48a3481c85"

URI_x86_64_v2_qt6-qtpdf-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtpdf-examples-6.10.1-2.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtpdf-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtpdf-examples}"
SRC_URI[x86_64_v2_qt6-qtpdf-examples.sha256sum] = "aaaff2f7dad74e7f8fd393aa14a29532d5db82887f7035c573aa3d6b49d65735"

URI_x86_64_v2_qt6-qtwebengine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebengine-6.10.1-2.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebengine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebengine}"
SRC_URI[x86_64_v2_qt6-qtwebengine.sha256sum] = "9a82b1ae9120ebf753f184c2dcadbdacbaadb1fae6ad3ca9487f006085ff1e29"

URI_x86_64_v2_qt6-qtwebengine-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebengine-devel-6.10.1-2.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebengine-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebengine-devel}"
SRC_URI[x86_64_v2_qt6-qtwebengine-devel.sha256sum] = "47986af9043bd142d9279ffbb1deb63b03ae6aaa9cbe73441c8f65147fac87a7"

URI_x86_64_v2_qt6-qtwebengine-devtools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebengine-devtools-6.10.1-2.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebengine-devtools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebengine-devtools}"
SRC_URI[x86_64_v2_qt6-qtwebengine-devtools.sha256sum] = "5765e783356e02a24ff385c8dbf7ba553499b8a8d09ea8ee8fa71e9e4626928d"

URI_x86_64_v2_qt6-qtwebengine-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebengine-examples-6.10.1-2.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebengine-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebengine-examples}"
SRC_URI[x86_64_v2_qt6-qtwebengine-examples.sha256sum] = "5b56e27a5786661524eeee09aa4b25e5c6b6c2f001fc00583ed8bed40e1102df"

URI_aarch64_qt6-qtpdf = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtpdf-6.10.1-2.1.el10_2.aarch64.rpm;name=aarch64_qt6-qtpdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtpdf}"
SRC_URI[aarch64_qt6-qtpdf.sha256sum] = "8e8f8f3f5713a9f5c28f5a8c0f493128e5ab0097a5ac1cdcc2904d844692f188"

URI_aarch64_qt6-qtpdf-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtpdf-devel-6.10.1-2.1.el10_2.aarch64.rpm;name=aarch64_qt6-qtpdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtpdf-devel}"
SRC_URI[aarch64_qt6-qtpdf-devel.sha256sum] = "4d7c5eedaf20653a41bfd1d6be9530b1538689e393bdc2bb87fbbf8195d342fc"

URI_aarch64_qt6-qtpdf-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtpdf-examples-6.10.1-2.1.el10_2.aarch64.rpm;name=aarch64_qt6-qtpdf-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtpdf-examples}"
SRC_URI[aarch64_qt6-qtpdf-examples.sha256sum] = "4728270ed91f5a9097fb7c80402bdee78325b94f29568021e82397447fafbe23"

URI_aarch64_qt6-qtwebengine = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebengine-6.10.1-2.1.el10_2.aarch64.rpm;name=aarch64_qt6-qtwebengine;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebengine}"
SRC_URI[aarch64_qt6-qtwebengine.sha256sum] = "c58fd0405f77d5f2b0fd3d19dab6214135a47eadcec7bfa2d8647dec1b0e5ae8"

URI_aarch64_qt6-qtwebengine-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebengine-devel-6.10.1-2.1.el10_2.aarch64.rpm;name=aarch64_qt6-qtwebengine-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebengine-devel}"
SRC_URI[aarch64_qt6-qtwebengine-devel.sha256sum] = "66cb7e5a4d21c24cd30eb03f755717fe634824f0880ff44906633b5e93be4f7f"

URI_aarch64_qt6-qtwebengine-devtools = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebengine-devtools-6.10.1-2.1.el10_2.aarch64.rpm;name=aarch64_qt6-qtwebengine-devtools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebengine-devtools}"
SRC_URI[aarch64_qt6-qtwebengine-devtools.sha256sum] = "b0ee37d6b4e222da0d1db8cab91333c074e25f0505b8616ac6bf80733c890e20"

URI_aarch64_qt6-qtwebengine-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebengine-examples-6.10.1-2.1.el10_2.aarch64.rpm;name=aarch64_qt6-qtwebengine-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebengine-examples}"
SRC_URI[aarch64_qt6-qtwebengine-examples.sha256sum] = "7a9d3ba4e3227aaf73f81cc42e53c94d652d4c035dd7ae1fa1098a2b03e2e1ea"

RDEPENDS:qt6-qtpdf = " \
 glibc \
 libgcc \
 libicu \
 libpng \
 libstdc++ \
 libtiff \
 openjpeg2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtpdf-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtpdf \
 qt6-qtpdf-devel \
 "
RDEPENDS:qt6-qtpdf-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpdf \
 qt6-qtsvg \
 "
RDEPENDS:qt6-qtwebengine = " \
 alsa-lib \
 bash \
 dbus-libs \
 expat \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 harfbuzz \
 lcms2 \
 libX11 \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libXtst \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libgcc \
 libglvnd-glx \
 libicu \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 libwebp \
 libxcb \
 libxkbcommon \
 libxkbfile \
 libxml2 \
 libxslt \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-util \
 openjpeg2 \
 opus \
 pipewire-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpdf \
 qt6-qtpositioning \
 qt6-qtwebchannel \
 re2 \
 snappy \
 systemd-libs \
 "
RDEPENDS:qt6-qtwebengine-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qtdeclarative-devel \
 qt6-qtpdf-devel \
 qt6-qtpositioning-devel \
 qt6-qtwebchannel-devel \
 qt6-qtwebengine \
 qt6-qtwebengine-devel \
 qt6-qtwebengine-devtools \
 "
RDEPENDS:qt6-qtwebengine-devtools = " \
 qt6-qtwebengine \
 "
RDEPENDS:qt6-qtwebengine-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 "
