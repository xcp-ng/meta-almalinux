# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "voms-clients-java"
PV = "3.3.7"
PR = "1.el10_2"
PACKAGES = " \
 voms-clients-java \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/voms-clients-java-3.3.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a79b5ce0385876100ae5819aea67fad9fd7fdc58c30d8bf2fb5b690ff9dfcd96"

URI_x86_64_v2_voms-clients-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-clients-java-3.3.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_voms-clients-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-clients-java}"
SRC_URI[x86_64_v2_voms-clients-java.sha256sum] = "323da8b33d087b756464e1fa31047e2101c10abbce1a3ea7ea992027dc7e350a"
RPROVIDES:voms-clients-java:x86_64_v2 = "virtual/voms-clients"

URI_aarch64_voms-clients-java = "${EPEL_MIRROR}/aarch64/Packages/v/voms-clients-java-3.3.7-1.el10_2.noarch.rpm;name=aarch64_voms-clients-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-clients-java}"
SRC_URI[aarch64_voms-clients-java.sha256sum] = "dde68a1c8552db2328ec6a06e2fd80e6cb973860e80350f0870dc5c0f11b473a"
RPROVIDES:voms-clients-java:aarch64 = "virtual/voms-clients"

RDEPENDS:voms-clients-java = " \
 alternatives \
 apache-commons-cli \
 apache-commons-io \
 bash \
 javapackages-filesystem \
 javapackages-tools \
 virtual/java-headless_or_java-21-headless_or_java-25-headless \
 voms-api-java \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/voms-clients"

PROVIDES:append:aarch64 = " rpm/virtual/voms-clients"
