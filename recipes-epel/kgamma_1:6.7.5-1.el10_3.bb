# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgamma"
PE = "1"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kgamma \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kgamma-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2bf129cc3227861c01c62cc373d16ba7d12888ed897a6b9db7689d2728965eb9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgamma-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgamma;unpack=0"
SRC_URI[x86_64_v2_kgamma.sha256sum] = "0eb3ae7ad18f7f71a6796272139be71392e77e3724b6d3abea57aa5e009005b7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kgamma-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kgamma;unpack=0"
SRC_URI[aarch64_kgamma.sha256sum] = "0a08b85aefac5323d4da1bee3b17aadc3d553c5922abfd48a21d471207c75738"

RDEPENDS:kgamma = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libX11 \
 libXxf86vm \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
