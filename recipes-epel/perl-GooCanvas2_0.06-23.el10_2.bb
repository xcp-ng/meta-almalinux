# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-GooCanvas2"
PV = "0.06"
PR = "23.el10_2"
PACKAGES = " \
 perl-GooCanvas2 \
 perl-GooCanvas2-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-GooCanvas2-0.06-23.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc432f7ac0b4ce5d7838413798dc6d0675b45502ab96bcea8d88200ce8b5318b"

URI_x86_64_v2_perl-GooCanvas2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GooCanvas2-0.06-23.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GooCanvas2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GooCanvas2}"
SRC_URI[x86_64_v2_perl-GooCanvas2.sha256sum] = "32e82b7e4dc39061f4b8c2eda1cad8a552e6a0efbacbcc7b98901b3806dc669d"

URI_x86_64_v2_perl-GooCanvas2-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GooCanvas2-tests-0.06-23.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GooCanvas2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GooCanvas2-tests}"
SRC_URI[x86_64_v2_perl-GooCanvas2-tests.sha256sum] = "527014be80d13fa11b07391ba82ab2c368312caacad73a7391009688a6afbb4d"

URI_aarch64_perl-GooCanvas2 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GooCanvas2-0.06-23.el10_2.noarch.rpm;name=aarch64_perl-GooCanvas2;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GooCanvas2}"
SRC_URI[aarch64_perl-GooCanvas2.sha256sum] = "b29a128930e2a30badc2c81f4479022956d978bd153ed2caeaa709a387d58b7c"

URI_aarch64_perl-GooCanvas2-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GooCanvas2-tests-0.06-23.el10_2.noarch.rpm;name=aarch64_perl-GooCanvas2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GooCanvas2-tests}"
SRC_URI[aarch64_perl-GooCanvas2-tests.sha256sum] = "d5411e7ca68dd946aac2f0931ed7db2700b5fc91e763e071e59b783c3ebe605b"

RDEPENDS:perl-GooCanvas2 = " \
 goocanvas2 \
 perl-Glib-Object-Introspection \
 perl-libs \
 "
RDEPENDS:perl-GooCanvas2-tests = " \
 bash \
 perl-GooCanvas2 \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 "
