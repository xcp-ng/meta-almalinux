# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rich-toolkit"
PV = "0.19.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-rich-toolkit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rich-toolkit-0.19.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bfad807ad69a349d73dba0115301e8c1d7702bd9b761fde189a749ec6854d03"

URI_x86_64_v2_python3-rich-toolkit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rich-toolkit-0.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rich-toolkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rich-toolkit}"
SRC_URI[x86_64_v2_python3-rich-toolkit.sha256sum] = "6cc248e4281f48743f4685396ddcd75bc75934c481e9e30f50a71308be7be017"

URI_aarch64_python3-rich-toolkit = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rich-toolkit-0.19.0-1.el10_1.noarch.rpm;name=aarch64_python3-rich-toolkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rich-toolkit}"
SRC_URI[aarch64_python3-rich-toolkit.sha256sum] = "776229209101b33e32829b5b23c703018ab161311b1f51bd1ad8c94be3e4cca8"

RDEPENDS:python3-rich-toolkit = " \
 python3 \
 python3-click \
 python3-rich \
 python3-typing-extensions \
 "
