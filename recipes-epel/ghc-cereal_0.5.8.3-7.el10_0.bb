# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-cereal"
PV = "0.5.8.3"
PR = "7.el10_0"
PACKAGES = " \
 ghc-cereal \
 ghc-cereal-devel \
 ghc-cereal-doc \
 ghc-cereal-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-cereal-0.5.8.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "14f2575b5056fb37188b23e2eca708a10b50f8783eeaa689096550fba13d0ad8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cereal-0.5.8.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cereal;unpack=0"
SRC_URI[x86_64_v2_ghc-cereal.sha256sum] = "29fe205e1a5b9de15724bb4cb5d6bc71631d0c8d90b23bf32130a43c1ec050b3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cereal-devel-0.5.8.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cereal-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-cereal-devel.sha256sum] = "49b424f100cc696d6eedfdaa347f4db3f2b2c28d818cbfec98d7adb2ce10780a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cereal-doc-0.5.8.3-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-cereal-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-cereal-doc.sha256sum] = "12cec42bfecf46db8eda0292f062613bd7a85a5711755d1fc91f6305a6a24178"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cereal-prof-0.5.8.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cereal-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-cereal-prof.sha256sum] = "4063b96e8c63eaa4d97bb1a664c50bb6381c626359c38650bd1cd691d5643d0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-cereal-0.5.8.3-7.el10_0.aarch64.rpm;name=aarch64_ghc-cereal;unpack=0"
SRC_URI[aarch64_ghc-cereal.sha256sum] = "336e33372ae24eb3a9a793f0f86e8b96f79866cb5e5ba1e33dc4b072640b22ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-cereal-devel-0.5.8.3-7.el10_0.aarch64.rpm;name=aarch64_ghc-cereal-devel;unpack=0"
SRC_URI[aarch64_ghc-cereal-devel.sha256sum] = "105332f3dd6e6b08fd03a98118290c05c8a4f993b9b3a3b825fca806aa2a0abd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-cereal-doc-0.5.8.3-7.el10_0.noarch.rpm;name=aarch64_ghc-cereal-doc;unpack=0"
SRC_URI[aarch64_ghc-cereal-doc.sha256sum] = "d64558654a8631b014ff25ba6356981dbd70fe86f5eb80b3a998bddb64884fb9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-cereal-prof-0.5.8.3-7.el10_0.aarch64.rpm;name=aarch64_ghc-cereal-prof;unpack=0"
SRC_URI[aarch64_ghc-cereal-prof.sha256sum] = "dc812cb871f0ca7358612d56720af8305173a9afc40b3569efa1bd04ce04e57e"

RDEPENDS:ghc-cereal = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-cereal-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-cereal \
 ghc-compiler \
 ghc-containers-devel \
 "
RDEPENDS:ghc-cereal-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-cereal-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cereal-devel \
 ghc-containers-prof \
 "
