# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-URI-Find"
PV = "20160806"
PR = "27.el10_3"
PACKAGES = " \
 perl-URI-Find \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-URI-Find-20160806-27.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ed621799e0328fc7582169976be2e3e2e0311eaaaa87816bf83c71f006765de"

URI_x86_64_v2_perl-URI-Find = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-URI-Find-20160806-27.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-URI-Find;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-URI-Find}"
SRC_URI[x86_64_v2_perl-URI-Find.sha256sum] = "1bce234da40209b3664b1da3c2f4f50a9a265eb69cee9de32830f1368f4ed864"

URI_aarch64_perl-URI-Find = "${EPEL_MIRROR}/aarch64/Packages/p/perl-URI-Find-20160806-27.el10_3.noarch.rpm;name=aarch64_perl-URI-Find;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-URI-Find}"
SRC_URI[aarch64_perl-URI-Find.sha256sum] = "a9ae0a21f3f7d5deae79a97a040e8114ee44993cb734f6f352f6547a6cf6960b"

RDEPENDS:perl-URI-Find = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-IO \
 perl-URI \
 perl-URI-Find \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
