# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clearsilver"
PV = "0.10.5"
PR = "80.el10_2"
PACKAGES = " \
 clearsilver \
 clearsilver-devel \
 perl-clearsilver \
 ruby-clearsilver \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clearsilver-0.10.5-80.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4cad227f3e8e087f0f3f08928da6aabe3aafc06b67dfe7f6c7d050b4645ed44"

URI_x86_64_v2_clearsilver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clearsilver-0.10.5-80.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clearsilver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clearsilver}"
SRC_URI[x86_64_v2_clearsilver.sha256sum] = "bf73bd15b9619ff3accea123c64e270680c462719d1a4a713df49ddf215ae225"

URI_x86_64_v2_clearsilver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clearsilver-devel-0.10.5-80.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clearsilver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clearsilver-devel}"
SRC_URI[x86_64_v2_clearsilver-devel.sha256sum] = "7f141259bb7b55b5e8bbe39ba33e65784ce31e7cadb542a821fd8095a06ccda6"

URI_x86_64_v2_perl-clearsilver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-clearsilver-0.10.5-80.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-clearsilver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-clearsilver}"
SRC_URI[x86_64_v2_perl-clearsilver.sha256sum] = "1575c9412c299d6c214e9732198419e12b5e7be1a31eeebeeca7619031a0cf23"

URI_x86_64_v2_ruby-clearsilver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-clearsilver-0.10.5-80.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ruby-clearsilver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-clearsilver}"
SRC_URI[x86_64_v2_ruby-clearsilver.sha256sum] = "b1509035750c8eb6e583019fa8d6142a2992bcffffe968d3fd4e0d5ba1bf9287"

URI_aarch64_clearsilver = "${EPEL_MIRROR}/aarch64/Packages/c/clearsilver-0.10.5-80.el10_2.aarch64.rpm;name=aarch64_clearsilver;unpack=0"
SRC_URI:append = " ${URI_aarch64_clearsilver}"
SRC_URI[aarch64_clearsilver.sha256sum] = "13bf0f5bca02b7e83365ee9e581b7b2363aeb8c554f6ac9ce7d4bb50c43979d3"

URI_aarch64_clearsilver-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clearsilver-devel-0.10.5-80.el10_2.aarch64.rpm;name=aarch64_clearsilver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clearsilver-devel}"
SRC_URI[aarch64_clearsilver-devel.sha256sum] = "40dab6bd5f6328df00354845d156d3879f7433f738a72c7d427891fb74526f6b"

URI_aarch64_perl-clearsilver = "${EPEL_MIRROR}/aarch64/Packages/p/perl-clearsilver-0.10.5-80.el10_2.aarch64.rpm;name=aarch64_perl-clearsilver;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-clearsilver}"
SRC_URI[aarch64_perl-clearsilver.sha256sum] = "0198e7792e3065db09ba1a08a6302082aa0cb921456184bbe6e9938455f9188e"

URI_aarch64_ruby-clearsilver = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-clearsilver-0.10.5-80.el10_2.aarch64.rpm;name=aarch64_ruby-clearsilver;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-clearsilver}"
SRC_URI[aarch64_ruby-clearsilver.sha256sum] = "33e6fb334607b3da067faad669ca5800c2efc2f244b61cd435cfccfa36570231"

RDEPENDS:clearsilver = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:clearsilver-devel = " \
 clearsilver \
 "
RDEPENDS:perl-clearsilver = " \
 clearsilver \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 zlib-ng-compat \
 "
RDEPENDS:ruby-clearsilver = " \
 clearsilver \
 glibc \
 ruby-libs \
 zlib-ng-compat \
 "
