# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libheif"
PV = "1.20.2"
PR = "6.el10_3"
PACKAGES = " \
 libheif \
 libheif-devel \
 libheif-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libheif-1.20.2-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3dea4467d16bc0d023e0953c9ee35c8264c6b3a482175abe9a04626433822a2b"

URI_x86_64_v2_libheif = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libheif-1.20.2-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libheif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libheif}"
SRC_URI[x86_64_v2_libheif.sha256sum] = "f255dd59ec195829d087db5bc6eb659d4cb1700a53ec38728166942bfa575f07"

URI_x86_64_v2_libheif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libheif-devel-1.20.2-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libheif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libheif-devel}"
SRC_URI[x86_64_v2_libheif-devel.sha256sum] = "96096abe7385778e12adb4f48e7130cfa111228da7fbf5c506f7ae6573a483e2"

URI_x86_64_v2_libheif-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libheif-tools-1.20.2-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libheif-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libheif-tools}"
SRC_URI[x86_64_v2_libheif-tools.sha256sum] = "341cb00c684e0df05fbacab09929774940d9fd5ebc7c8380498c4978d475d26a"

URI_aarch64_libheif = "${EPEL_MIRROR}/aarch64/Packages/l/libheif-1.20.2-6.el10_3.aarch64.rpm;name=aarch64_libheif;unpack=0"
SRC_URI:append = " ${URI_aarch64_libheif}"
SRC_URI[aarch64_libheif.sha256sum] = "f1c9e38a7e796a1a257d87d9a7686a8ca8c41726f9f102de97debd8395f894e4"

URI_aarch64_libheif-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libheif-devel-1.20.2-6.el10_3.aarch64.rpm;name=aarch64_libheif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libheif-devel}"
SRC_URI[aarch64_libheif-devel.sha256sum] = "450b46cc52416b40cab300a90491ac88c572d6de9790f43850c900447ee1e552"

URI_aarch64_libheif-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libheif-tools-1.20.2-6.el10_3.aarch64.rpm;name=aarch64_libheif-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libheif-tools}"
SRC_URI[aarch64_libheif-tools.sha256sum] = "bbbd33cfd3a9be063d28174c29819d400bded8c8f1db59f854b7c884b2ca4d3d"

RDEPENDS:libheif = " \
 glibc \
 libaom \
 libbrotli \
 libdav1d \
 libgcc \
 libjpeg-turbo \
 libopenjph \
 libstdc++ \
 libwebp \
 noopenh264 \
 openjpeg2 \
 rav1e-libs \
 svt-av1-libs \
 zlib-ng-compat \
 "
RDEPENDS:libheif-devel = " \
 brotli-devel \
 cmake-filesystem \
 libaom-devel \
 libdav1d-devel \
 libheif \
 libjpeg-turbo-devel \
 libopenjph-devel \
 libwebp-devel \
 noopenh264-devel \
 openjpeg2-devel \
 pkgconf-pkg-config \
 rav1e-devel \
 svt-av1-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:libheif-tools = " \
 glibc \
 libgcc \
 libheif \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 shared-mime-info \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
