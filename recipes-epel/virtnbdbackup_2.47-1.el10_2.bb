# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virtnbdbackup"
PV = "2.47"
PR = "1.el10_2"
PACKAGES = " \
 virtnbdbackup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/virtnbdbackup-2.47-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bf7ac542829b72de9405a86d2cfe5b19fc24ee63c9ab1099543e1f6fb15d05d"

URI_x86_64_v2_virtnbdbackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/virtnbdbackup-2.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_virtnbdbackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virtnbdbackup}"
SRC_URI[x86_64_v2_virtnbdbackup.sha256sum] = "5c5ecf19a4b49ac9c8d849f6d33648237ff90ce95a58261942472fc933c67c7c"

URI_aarch64_virtnbdbackup = "${EPEL_MIRROR}/aarch64/Packages/v/virtnbdbackup-2.47-1.el10_2.noarch.rpm;name=aarch64_virtnbdbackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_virtnbdbackup}"
SRC_URI[aarch64_virtnbdbackup.sha256sum] = "765f45b8b7a4b2c287f6bb6128c3530d9b2f220e32287db7a83b97196326d232"

RDEPENDS:virtnbdbackup = " \
 nbdkit-python-plugin \
 nbdkit-server \
 openssh-clients \
 python3 \
 python3-colorlog \
 python3-libnbd \
 python3-libvirt \
 python3-lxml \
 python3-lz4 \
 python3-paramiko \
 python3-tqdm \
 python3-typing-extensions \
 qemu-img \
 "
