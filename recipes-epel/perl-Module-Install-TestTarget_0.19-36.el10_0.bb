# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Install-TestTarget"
PV = "0.19"
PR = "36.el10_0"
PACKAGES = " \
 perl-Module-Install-TestTarget \
 perl-Module-Install-TestTarget-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-Install-TestTarget-0.19-36.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6639a9b194e6a41ff7ac6308ea81bd2597374fbcc9153fcd65b71f5711f3b8b6"

URI_x86_64_v2_perl-Module-Install-TestTarget = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Install-TestTarget-0.19-36.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Install-TestTarget;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Install-TestTarget}"
SRC_URI[x86_64_v2_perl-Module-Install-TestTarget.sha256sum] = "aaf780c4d7a91a77b316411c1089902f69889cf1ec255c1d59baf92468c27b50"

URI_x86_64_v2_perl-Module-Install-TestTarget-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Install-TestTarget-tests-0.19-36.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Install-TestTarget-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Install-TestTarget-tests}"
SRC_URI[x86_64_v2_perl-Module-Install-TestTarget-tests.sha256sum] = "4e821b4114ebfd294a9f4b54c1d2499042b77835ad5e5926953b1e9a8b7eb3a6"

URI_aarch64_perl-Module-Install-TestTarget = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Install-TestTarget-0.19-36.el10_0.noarch.rpm;name=aarch64_perl-Module-Install-TestTarget;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Install-TestTarget}"
SRC_URI[aarch64_perl-Module-Install-TestTarget.sha256sum] = "5e521fff134ba35158ff41a8063db4d8fd832287d77aaf9354da522394bc62ef"

URI_aarch64_perl-Module-Install-TestTarget-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Install-TestTarget-tests-0.19-36.el10_0.noarch.rpm;name=aarch64_perl-Module-Install-TestTarget-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Install-TestTarget-tests}"
SRC_URI[aarch64_perl-Module-Install-TestTarget-tests.sha256sum] = "0eb0b5c114fbddedd4fab48bef04feb5818d88a9e51978e58315462d2440fea0"

RDEPENDS:perl-Module-Install-TestTarget = " \
 perl-B \
 perl-Carp \
 perl-Module-Install \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-Module-Install-TestTarget-tests = " \
 bash \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Path \
 perl-File-Temp \
 perl-Module-Install \
 perl-Module-Install-ExtraTests \
 perl-Module-Install-TestTarget \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Requires \
 perl-Test-Simple \
 perl-base \
 perl-constant \
 perl-lib \
 perl-libs \
 "
