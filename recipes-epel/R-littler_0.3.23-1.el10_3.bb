# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-littler"
PV = "0.3.23"
PR = "1.el10_3"
PACKAGES = " \
 R-littler \
 R-littler-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-littler-0.3.23-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d2faede99dafd2ab1174a11ff0d7c35dd62583878d49142f60d4740c4b1a9e6"

URI_x86_64_v2_R-littler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-littler-0.3.23-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-littler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-littler}"
SRC_URI[x86_64_v2_R-littler.sha256sum] = "0b58e36bd1aded02b69551ec6011f9418384cf7302dd036df6db8432b83e944b"

URI_x86_64_v2_R-littler-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-littler-examples-0.3.23-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-littler-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-littler-examples}"
SRC_URI[x86_64_v2_R-littler-examples.sha256sum] = "c5d7517b83dd951dbc2f5a8bea2e0b39fbcff4c5114218747eb5c2c661a0974f"

URI_aarch64_R-littler = "${EPEL_MIRROR}/aarch64/Packages/r/R-littler-0.3.23-1.el10_3.aarch64.rpm;name=aarch64_R-littler;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-littler}"
SRC_URI[aarch64_R-littler.sha256sum] = "870dad357fdcd8651df2e6b4acb6bb4e0185aa3b2c6ec368534083cc3b467205"

URI_aarch64_R-littler-examples = "${EPEL_MIRROR}/aarch64/Packages/r/R-littler-examples-0.3.23-1.el10_3.aarch64.rpm;name=aarch64_R-littler-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-littler-examples}"
SRC_URI[aarch64_R-littler-examples.sha256sum] = "c277b4ef6b7319d0bb5203b75dfe569435046ed73df73bcd61e6e3c9a5a614d6"

RDEPENDS:R-littler = " \
 R-core \
 glibc \
 "
RDEPENDS:R-littler-examples = " \
 R-littler \
 "
