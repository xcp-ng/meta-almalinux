# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpinyin"
PV = "2.8.1"
PR = "9.el10"
PACKAGES = " \
 libpinyin \
 libpinyin-data \
 libpinyin-devel \
 libzhuyin \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libpinyin-2.8.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f81e2854d6b2e2b9c9023dde19a5e496419551a04170aab2211f057ee5bc2c7"

URI_x86_64_v2_libpinyin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpinyin-2.8.1-9.el10.x86_64_v2.rpm;name=x86_64_v2_libpinyin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpinyin}"
SRC_URI[x86_64_v2_libpinyin.sha256sum] = "a5e040605dd2fb022e7334abad412433011c5bc71bc184eec60cef58e17a3183"

URI_x86_64_v2_libpinyin-data = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpinyin-data-2.8.1-9.el10.x86_64_v2.rpm;name=x86_64_v2_libpinyin-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpinyin-data}"
SRC_URI[x86_64_v2_libpinyin-data.sha256sum] = "4da90df2a0d7429758e26d4a33b24bf49e8f667a201797b004a2044326ec8c76"

URI_x86_64_v2_libpinyin-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libpinyin-devel-2.8.1-9.el10.x86_64_v2.rpm;name=x86_64_v2_libpinyin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpinyin-devel}"
SRC_URI[x86_64_v2_libpinyin-devel.sha256sum] = "97d236cede536b6fd91a90cfe5643b9570f942771ae12aff5727fb336b634b90"

URI_x86_64_v2_libzhuyin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libzhuyin-2.8.1-9.el10.x86_64_v2.rpm;name=x86_64_v2_libzhuyin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libzhuyin}"
SRC_URI[x86_64_v2_libzhuyin.sha256sum] = "1b20fe9aae25558d8b187cdd01ed62dc632c474788d631027872ec656537f84c"

URI_aarch64_libpinyin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpinyin-2.8.1-9.el10.aarch64.rpm;name=aarch64_libpinyin;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpinyin}"
SRC_URI[aarch64_libpinyin.sha256sum] = "b2602f0674f333dac9b2d19487fb00af08f43eb3354d5818e77daab78f513b25"

URI_aarch64_libpinyin-data = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpinyin-data-2.8.1-9.el10.aarch64.rpm;name=aarch64_libpinyin-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpinyin-data}"
SRC_URI[aarch64_libpinyin-data.sha256sum] = "863a44d7f6d8021ac574aa4324f15826dba45ac1a054e857c0884bc6821b859f"

URI_aarch64_libpinyin-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libpinyin-devel-2.8.1-9.el10.aarch64.rpm;name=aarch64_libpinyin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpinyin-devel}"
SRC_URI[aarch64_libpinyin-devel.sha256sum] = "b961ac78d4ef2372912a7489178ed2419b313b79ead26e9cb2f2f9749b462e77"

URI_aarch64_libzhuyin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libzhuyin-2.8.1-9.el10.aarch64.rpm;name=aarch64_libzhuyin;unpack=0"
SRC_URI:append = " ${URI_aarch64_libzhuyin}"
SRC_URI[aarch64_libzhuyin.sha256sum] = "a461afa6aa9d943a8ca9dec1c6069851d746db79cfb23ee2f7de8df91287fd6b"

RDEPENDS:libpinyin = " \
 glib2 \
 glibc \
 kyotocabinet-libs \
 libgcc \
 libpinyin-data \
 libstdc++ \
 "
RDEPENDS:libpinyin-data = " \
 libpinyin \
 "
RDEPENDS:libpinyin-devel = " \
 glib2-devel \
 libpinyin \
 libzhuyin \
 pkgconf-pkg-config \
 "
RDEPENDS:libzhuyin = " \
 glib2 \
 glibc \
 kyotocabinet-libs \
 libgcc \
 libpinyin \
 libstdc++ \
 "
