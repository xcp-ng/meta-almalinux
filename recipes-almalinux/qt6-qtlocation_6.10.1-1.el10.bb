# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtlocation"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtlocation \
 qt6-qtlocation-devel \
 qt6-qtlocation-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtlocation-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f80294bf64aca90e11f56d5ccc71275d3de7fd5b1a19dd0796f1b666f099b58"

URI_x86_64_v2_qt6-qtlocation = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtlocation-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlocation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtlocation}"
SRC_URI[x86_64_v2_qt6-qtlocation.sha256sum] = "4a265d275872449c5ef2ac263ed710e8388367e96bc3d9281e8e1e4dc1d94f6b"

URI_x86_64_v2_qt6-qtlocation-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtlocation-devel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlocation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtlocation-devel}"
SRC_URI[x86_64_v2_qt6-qtlocation-devel.sha256sum] = "3989e692ac28b334b47e088176e485d112c1d92895f6cf45e723dea9ba67a144"

URI_x86_64_v2_qt6-qtlocation-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtlocation-examples-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlocation-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtlocation-examples}"
SRC_URI[x86_64_v2_qt6-qtlocation-examples.sha256sum] = "94bf89f4d791e4c748a581984b81dd635c7ebf43b3c38c52c8922859f3302a6b"

URI_aarch64_qt6-qtlocation = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtlocation-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtlocation;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtlocation}"
SRC_URI[aarch64_qt6-qtlocation.sha256sum] = "d257a773c7da14ed8b804812c00b30757485e0930e9aba0da6d867eff9f08a40"

URI_aarch64_qt6-qtlocation-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtlocation-devel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtlocation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtlocation-devel}"
SRC_URI[aarch64_qt6-qtlocation-devel.sha256sum] = "9dfc89e7fc1fe9f1f4e4b526fbcd68d7bc14490279247ea599db5fce4c452855"

URI_aarch64_qt6-qtlocation-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtlocation-examples-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtlocation-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtlocation-examples}"
SRC_URI[aarch64_qt6-qtlocation-examples.sha256sum] = "701279cb11b6d73b4fd8e12375cbe48b140cd9f278de00129b500d05de4ee541"

RDEPENDS:qt6-qtlocation = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 "
RDEPENDS:qt6-qtlocation-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtlocation \
 qt6-qtpositioning-devel \
 "
RDEPENDS:qt6-qtlocation-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtpositioning \
 "
