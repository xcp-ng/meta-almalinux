# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shim"
PV = "15.8"
PR = "5.el10_0.alma.1"
PACKAGES:x86_64_v2 = " \
 shim-x64 \
"
PACKAGES:aarch64 = " \
 shim-aa64 \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/shim-15.8-5.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32c0094e1531b12c47892fdf485d82036bee6ede001c66713b2a508df86c7f43"

URI_x86_64_v2_shim-x64 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/shim-x64-15.8-5.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_shim-x64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shim-x64}"
SRC_URI[x86_64_v2_shim-x64.sha256sum] = "35e95d08c2d3ce7da90c38ace20f2c730a06ef7439a630536a5c570ad0622c73"

URI_aarch64_shim-aa64 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/shim-aa64-15.8-5.el10_0.alma.1.aarch64.rpm;name=aarch64_shim-aa64;unpack=0"
SRC_URI:append = " ${URI_aarch64_shim-aa64}"
SRC_URI[aarch64_shim-aa64.sha256sum] = "05e4525c2b021cfb830b953fd6a376a69579924c23b6a72cd3414017e85348c1"

RDEPENDS:shim-x64 = " \
 efi-filesystem \
 fwupd \
 mokutil \
 "
RDEPENDS:shim-aa64 = " \
 efi-filesystem \
 fwupd \
 mokutil \
 "
