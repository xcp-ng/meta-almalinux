# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sane-frontends"
PV = "1.0.14"
PR = "52.el10_0"
PACKAGES = " \
 sane-frontends \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sane-frontends-1.0.14-52.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d60e39c223500ee351b26139d5d8b1c9460d3ffdd1b0bea4fbea4bdfdfa6ffb4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sane-frontends-1.0.14-52.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sane-frontends;unpack=0"
SRC_URI[x86_64_v2_sane-frontends.sha256sum] = "fa6fb1a35e5ab9f3f22ab6b670d93a5b99f9546f34e73534fed51d59ec4087fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sane-frontends-1.0.14-52.el10_0.aarch64.rpm;name=aarch64_sane-frontends;unpack=0"
SRC_URI[aarch64_sane-frontends.sha256sum] = "e15575f8f804266c78b40dca7316dfd15efdbb6c94c0d8c12612942eeb1c91d8"

RDEPENDS:sane-frontends = " \
 glib2 \
 glibc \
 gtk2 \
 sane-backends-libs \
 "
