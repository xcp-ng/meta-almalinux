# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-bash"
PV = "0.23.3"
PR = "8.el10_1"
PACKAGES = " \
 rust-tree-sitter-bash+default-devel \
 rust-tree-sitter-bash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-bash-0.23.3-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2527400b77350cc0cc6cb17d9e59074ff6c816e482012595a4ebdf11fc0cdb0a"

URI_x86_64_v2_rust-tree-sitter-bash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-bash+default-devel-0.23.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-bash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-bash+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-bash+default-devel.sha256sum] = "f08f67a02e25afc633873656208fab015a1a038b0c6892cadff344237266c3bf"

URI_x86_64_v2_rust-tree-sitter-bash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-bash-devel-0.23.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-bash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-bash-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-bash-devel.sha256sum] = "a7c1f8894fcd20c312631a142b2640feb52ed049cd45ec66d26219965eee804d"

URI_aarch64_rust-tree-sitter-bash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-bash+default-devel-0.23.3-8.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-bash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-bash+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-bash+default-devel.sha256sum] = "1ffd2fd64d044a84f225476a5cd18b43b88aa796e4104d555f7858014fa40fc8"

URI_aarch64_rust-tree-sitter-bash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-bash-devel-0.23.3-8.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-bash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-bash-devel}"
SRC_URI[aarch64_rust-tree-sitter-bash-devel.sha256sum] = "1074ddbd4a6030e878f60bd4cbce740ac1926f52a28230915023a72095231e61"

RDEPENDS:rust-tree-sitter-bash+default-devel = " \
 cargo \
 rust-tree-sitter-bash-devel \
 "
RDEPENDS:rust-tree-sitter-bash-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
