# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enumflags2_derive"
PV = "0.7.12"
PR = "2.el10_1"
PACKAGES = " \
 rust-enumflags2_derive+default-devel \
 rust-enumflags2_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enumflags2_derive-0.7.12-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03b6da672e3f25d1480085e1bb693c29ec5ac368689c48643e6f1376a7937759"

URI_x86_64_v2_rust-enumflags2_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumflags2_derive+default-devel-0.7.12-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumflags2_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumflags2_derive+default-devel}"
SRC_URI[x86_64_v2_rust-enumflags2_derive+default-devel.sha256sum] = "ca8863784344f1a6fc8952edf84825451d6e070f7245e078302acd473babae5e"

URI_x86_64_v2_rust-enumflags2_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumflags2_derive-devel-0.7.12-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumflags2_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumflags2_derive-devel}"
SRC_URI[x86_64_v2_rust-enumflags2_derive-devel.sha256sum] = "14cec8ea128fc9621b73c66495ecc7475a2938d89f8b56454a2b3710fa62cbac"

URI_aarch64_rust-enumflags2_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumflags2_derive+default-devel-0.7.12-2.el10_1.noarch.rpm;name=aarch64_rust-enumflags2_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumflags2_derive+default-devel}"
SRC_URI[aarch64_rust-enumflags2_derive+default-devel.sha256sum] = "3906c14cbe2e1123197b8fcdcce7c2d43aa66d347068f5915db551531f74d336"

URI_aarch64_rust-enumflags2_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumflags2_derive-devel-0.7.12-2.el10_1.noarch.rpm;name=aarch64_rust-enumflags2_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumflags2_derive-devel}"
SRC_URI[aarch64_rust-enumflags2_derive-devel.sha256sum] = "66d85626ffd9bf09a0261da03e23d9aebbf6017d80fc557dc7e03ca5ddf64682"

RDEPENDS:rust-enumflags2_derive+default-devel = " \
 cargo \
 rust-enumflags2_derive-devel \
 "
RDEPENDS:rust-enumflags2_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
