# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cabextract"
PV = "1.11"
PR = "7.el10_1"
PACKAGES = " \
 cabextract \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cabextract-1.11-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ccd137b62ec0ab4e9a5613632d91047bf6ac3815635f474e3c8ce701f247421"

URI_x86_64_v2_cabextract = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cabextract-1.11-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cabextract;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cabextract}"
SRC_URI[x86_64_v2_cabextract.sha256sum] = "c9f7db17c7a61159c088916fe9026ad22a46fc746c2f2e2d3610c052e06f86d3"

URI_aarch64_cabextract = "${EPEL_MIRROR}/aarch64/Packages/c/cabextract-1.11-7.el10_1.aarch64.rpm;name=aarch64_cabextract;unpack=0"
SRC_URI:append = " ${URI_aarch64_cabextract}"
SRC_URI[aarch64_cabextract.sha256sum] = "c3fee6f707639bcd400939cd4f82dff5815e4fd3ab0d3a98d344bbd69a84991b"

RDEPENDS:cabextract = " \
 glibc \
 "
