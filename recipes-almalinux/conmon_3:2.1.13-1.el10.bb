# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "conmon"
PE = "3"
PV = "2.1.13"
PR = "1.el10"
PACKAGES = " \
 conmon \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/conmon-2.1.13-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12f3309f37b110944f8355d7177cd1b027940c70e1f071df79d22f95b44c3364"

URI_x86_64_v2_conmon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/conmon-2.1.13-1.el10.x86_64_v2.rpm;name=x86_64_v2_conmon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_conmon}"
SRC_URI[x86_64_v2_conmon.sha256sum] = "9a989960bf9ab9416e406da7872b8125f2c9904baffdd0f4b8f3514c9f64dd14"

URI_aarch64_conmon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/conmon-2.1.13-1.el10.aarch64.rpm;name=aarch64_conmon;unpack=0"
SRC_URI:append = " ${URI_aarch64_conmon}"
SRC_URI[aarch64_conmon.sha256sum] = "3f3c0f27691c74693ac6d45c3d18a72f9a6c2812a81ae90421d08be6abd98231"

RDEPENDS:conmon = " \
 glib2 \
 glibc \
 libgcc \
 libseccomp \
 systemd-libs \
 "
