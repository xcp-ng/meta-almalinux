# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-util"
PV = "0.3.32"
PR = "1.el10_2"
PACKAGES = " \
 rust-futures-util+alloc-devel \
 rust-futures-util+async-await-devel \
 rust-futures-util+async-await-macro-devel \
 rust-futures-util+bilock-devel \
 rust-futures-util+cfg-target-has-atomic-devel \
 rust-futures-util+channel-devel \
 rust-futures-util+default-devel \
 rust-futures-util+futures-channel-devel \
 rust-futures-util+futures-io-devel \
 rust-futures-util+futures-macro-devel \
 rust-futures-util+futures-sink-devel \
 rust-futures-util+io-devel \
 rust-futures-util+libc-devel \
 rust-futures-util+memchr-devel \
 rust-futures-util+portable-atomic-devel \
 rust-futures-util+sink-devel \
 rust-futures-util+slab-devel \
 rust-futures-util+spin-devel \
 rust-futures-util+std-devel \
 rust-futures-util+unstable-devel \
 rust-futures-util+write-all-vectored-devel \
 rust-futures-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-util-0.3.32-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5421f90e14dde1a1bc7ddfd16b00ccd4d9b5e182f1ed0f2016e976c8d09e444a"

URI_x86_64_v2_rust-futures-util+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+alloc-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-util+alloc-devel.sha256sum] = "c598d05164231c50d6295c84d4b8a4da9ed281b3fc2eaae0fe77fbc7a3d39d0f"

URI_x86_64_v2_rust-futures-util+async-await-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+async-await-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+async-await-devel}"
SRC_URI[x86_64_v2_rust-futures-util+async-await-devel.sha256sum] = "336bc32dfa7151fd22471d557e6369cbe70983454fe73a6625445a98d6d325f6"

URI_x86_64_v2_rust-futures-util+async-await-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+async-await-macro-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+async-await-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+async-await-macro-devel}"
SRC_URI[x86_64_v2_rust-futures-util+async-await-macro-devel.sha256sum] = "da47fbac2a80a8d2d5b7b6f843276da1af68957790f93f3ba9874bc654e48c96"

URI_x86_64_v2_rust-futures-util+bilock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+bilock-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+bilock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+bilock-devel}"
SRC_URI[x86_64_v2_rust-futures-util+bilock-devel.sha256sum] = "d488085f3f86efcd60028d8492ee16a86b687b4ed818c0d31f0c71372f7459f4"

URI_x86_64_v2_rust-futures-util+cfg-target-has-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+cfg-target-has-atomic-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+cfg-target-has-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-util+cfg-target-has-atomic-devel.sha256sum] = "de0b9e56b6eda65b2be96b7c9672337d8107e15d47b431b7090ccb59b46c092a"

URI_x86_64_v2_rust-futures-util+channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+channel-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+channel-devel}"
SRC_URI[x86_64_v2_rust-futures-util+channel-devel.sha256sum] = "4e04a0607674752df246fe603e11012b7691a66e4a9e729e216c452278ef2c84"

URI_x86_64_v2_rust-futures-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+default-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+default-devel}"
SRC_URI[x86_64_v2_rust-futures-util+default-devel.sha256sum] = "1858ca3611da41e4331c7697eaffe3b4184244aa5505e4481de55fe4cc0a3992"

URI_x86_64_v2_rust-futures-util+futures-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-channel-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+futures-channel-devel}"
SRC_URI[x86_64_v2_rust-futures-util+futures-channel-devel.sha256sum] = "706e5012de266208600d51d673e09b97f702268cce53881c3a86d6ed7ccbb8f2"

URI_x86_64_v2_rust-futures-util+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-io-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+futures-io-devel}"
SRC_URI[x86_64_v2_rust-futures-util+futures-io-devel.sha256sum] = "bd9c5221b0dd8c14d54b84cbaaf42c8e9d2f4b6b179640ac4441dac94e802cf4"

URI_x86_64_v2_rust-futures-util+futures-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-macro-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+futures-macro-devel}"
SRC_URI[x86_64_v2_rust-futures-util+futures-macro-devel.sha256sum] = "42c7b89ae73299c2b21f452f684d78b7d3a70a9335905fceb1d2bb9b518554a6"

URI_x86_64_v2_rust-futures-util+futures-sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-sink-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+futures-sink-devel}"
SRC_URI[x86_64_v2_rust-futures-util+futures-sink-devel.sha256sum] = "88abead3e3008cb5d8d67c6d51385d5087ce0917a6288a65e1b35e2416b5d6b1"

URI_x86_64_v2_rust-futures-util+io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+io-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+io-devel}"
SRC_URI[x86_64_v2_rust-futures-util+io-devel.sha256sum] = "0db672a757a373fdc85d51e72afbd8f02b4a43ce83a117cea2686ccae3b43f78"

URI_x86_64_v2_rust-futures-util+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+libc-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+libc-devel}"
SRC_URI[x86_64_v2_rust-futures-util+libc-devel.sha256sum] = "737ad9cf304820261d5de29f329d5755309427e55a6c5bef25bd68fda5b8c061"

URI_x86_64_v2_rust-futures-util+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+memchr-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+memchr-devel}"
SRC_URI[x86_64_v2_rust-futures-util+memchr-devel.sha256sum] = "cc054a3be5ad6db558477a4a41bb50fb68f74571f6d4ec28cd5380b28debac97"

URI_x86_64_v2_rust-futures-util+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+portable-atomic-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-util+portable-atomic-devel.sha256sum] = "5bf47d07c81c8f3cea0c159fd2730db6bf84cba3044d3286c19bfe8e11726bff"

URI_x86_64_v2_rust-futures-util+sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+sink-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+sink-devel}"
SRC_URI[x86_64_v2_rust-futures-util+sink-devel.sha256sum] = "fe77713a084725054cdec1bd56529710d2767ca3ef550a1999fba5fe10188391"

URI_x86_64_v2_rust-futures-util+slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+slab-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+slab-devel}"
SRC_URI[x86_64_v2_rust-futures-util+slab-devel.sha256sum] = "cbe9b75b121c4cb38c2ef01df9e4654aa08cce0467dcb5b1aeaa8a2f5f0c8cee"

URI_x86_64_v2_rust-futures-util+spin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+spin-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+spin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+spin-devel}"
SRC_URI[x86_64_v2_rust-futures-util+spin-devel.sha256sum] = "d55e49a06c1f7ea8b69120e3e926dccd5eca4250dbe0fdd22788d0b79291d883"

URI_x86_64_v2_rust-futures-util+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+std-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+std-devel}"
SRC_URI[x86_64_v2_rust-futures-util+std-devel.sha256sum] = "39be998fbdeb304757f5531422adc7c96601890059de0fcbf22e409912b18f22"

URI_x86_64_v2_rust-futures-util+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+unstable-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures-util+unstable-devel.sha256sum] = "7a29fbdf0fcf8efc8dcc90b2e4426b7f5abbdfb34c17f947a87dad15ace707f4"

URI_x86_64_v2_rust-futures-util+write-all-vectored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+write-all-vectored-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+write-all-vectored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+write-all-vectored-devel}"
SRC_URI[x86_64_v2_rust-futures-util+write-all-vectored-devel.sha256sum] = "0e306974a3f248c646046c55e3ce81627369336b4f8d8779744fa165599f7128"

URI_x86_64_v2_rust-futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util-devel}"
SRC_URI[x86_64_v2_rust-futures-util-devel.sha256sum] = "4be9bffb6413b77063ed43dcbc883bff5ebb6e96adf076b5fb7c2837db95fb4d"

URI_aarch64_rust-futures-util+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+alloc-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+alloc-devel}"
SRC_URI[aarch64_rust-futures-util+alloc-devel.sha256sum] = "d4c4adc29d8db93fe38ba0039e13e660abe782355bef1c552e5ca40580e25e39"

URI_aarch64_rust-futures-util+async-await-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+async-await-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+async-await-devel}"
SRC_URI[aarch64_rust-futures-util+async-await-devel.sha256sum] = "3848490db40a7106977d863f1e28229adfe8494b343a5520892bd7e9b3f76321"

URI_aarch64_rust-futures-util+async-await-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+async-await-macro-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+async-await-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+async-await-macro-devel}"
SRC_URI[aarch64_rust-futures-util+async-await-macro-devel.sha256sum] = "a936f9c9d039cdde235129b3c58fe0ed50f1aa7d78fe3c63bf3cda891767d67a"

URI_aarch64_rust-futures-util+bilock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+bilock-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+bilock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+bilock-devel}"
SRC_URI[aarch64_rust-futures-util+bilock-devel.sha256sum] = "c0f19c10ca4a6a77aef57ab57333376dbe2b71fa0df660abb659cb95c14145f3"

URI_aarch64_rust-futures-util+cfg-target-has-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+cfg-target-has-atomic-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+cfg-target-has-atomic-devel}"
SRC_URI[aarch64_rust-futures-util+cfg-target-has-atomic-devel.sha256sum] = "5ac578d05ceab5653394647e2fd6ac788ec28c34640de823d2ca9f70ec7ef999"

URI_aarch64_rust-futures-util+channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+channel-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+channel-devel}"
SRC_URI[aarch64_rust-futures-util+channel-devel.sha256sum] = "9e6f84e1b77893774609f91683b338725ed0330b514e41811e3bd0ea39e9c95a"

URI_aarch64_rust-futures-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+default-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+default-devel}"
SRC_URI[aarch64_rust-futures-util+default-devel.sha256sum] = "c4ce7812a0c397be8a88c1f125a63fece72ffa58c0d27fba8b965d1d18a3d98e"

URI_aarch64_rust-futures-util+futures-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-channel-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+futures-channel-devel}"
SRC_URI[aarch64_rust-futures-util+futures-channel-devel.sha256sum] = "0346826b2ff003664ec875b9f36d2a71674570bfcd802839e2e0b46cb74be8eb"

URI_aarch64_rust-futures-util+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-io-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+futures-io-devel}"
SRC_URI[aarch64_rust-futures-util+futures-io-devel.sha256sum] = "decf172bad44b3ab211632118af00308c0de7d4ed74061dd8dcc9dd0b0f22ac9"

URI_aarch64_rust-futures-util+futures-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-macro-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+futures-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+futures-macro-devel}"
SRC_URI[aarch64_rust-futures-util+futures-macro-devel.sha256sum] = "e6ebc3a3d2ac60b0bdd28315601474214fa595d7bb06b2081c84af25539a5014"

URI_aarch64_rust-futures-util+futures-sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-sink-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+futures-sink-devel}"
SRC_URI[aarch64_rust-futures-util+futures-sink-devel.sha256sum] = "ded7b6158b7671e66b131fd4e23d6869b62d356c7a5390e47c36b90ab8f0000c"

URI_aarch64_rust-futures-util+io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+io-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+io-devel}"
SRC_URI[aarch64_rust-futures-util+io-devel.sha256sum] = "3b484bdeafb8a5877f3b5a40df97371975c068279779893eb70e9890610868c4"

URI_aarch64_rust-futures-util+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+libc-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+libc-devel}"
SRC_URI[aarch64_rust-futures-util+libc-devel.sha256sum] = "96ca497750dd92f4bb9f636c272795122f65f5097fdb9b5253a9882f2afca58d"

URI_aarch64_rust-futures-util+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+memchr-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+memchr-devel}"
SRC_URI[aarch64_rust-futures-util+memchr-devel.sha256sum] = "2b687611749ff0dc7fa89a7bceb0d7e11c86b35813fc28058b4d986ec66503b7"

URI_aarch64_rust-futures-util+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+portable-atomic-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+portable-atomic-devel}"
SRC_URI[aarch64_rust-futures-util+portable-atomic-devel.sha256sum] = "5e843660af867b7c080ca2d840cad0de52e4a30d2f7e2572b4faee872acd193f"

URI_aarch64_rust-futures-util+sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+sink-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+sink-devel}"
SRC_URI[aarch64_rust-futures-util+sink-devel.sha256sum] = "9752c58b098882c0570f0df88d55cde3ba2382b8103397ab581b08da1c0a516f"

URI_aarch64_rust-futures-util+slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+slab-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+slab-devel}"
SRC_URI[aarch64_rust-futures-util+slab-devel.sha256sum] = "194e1343fb8b43490fe073d2f7da9d0471d609a580709f8f6c0bd2c5e65c6b54"

URI_aarch64_rust-futures-util+spin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+spin-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+spin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+spin-devel}"
SRC_URI[aarch64_rust-futures-util+spin-devel.sha256sum] = "2177d9a73ba94e846379f360e88d6a875536800f5064a904d3d4de2f07f056d4"

URI_aarch64_rust-futures-util+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+std-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+std-devel}"
SRC_URI[aarch64_rust-futures-util+std-devel.sha256sum] = "a9ddaac5f38033789d53df913712066bad630018f97a5e9e8740181a3d105842"

URI_aarch64_rust-futures-util+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+unstable-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+unstable-devel}"
SRC_URI[aarch64_rust-futures-util+unstable-devel.sha256sum] = "abc999872f35addf32ebfcce8eba74c723e1b9ac5e2025ab4f63d3c85cbce349"

URI_aarch64_rust-futures-util+write-all-vectored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+write-all-vectored-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util+write-all-vectored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+write-all-vectored-devel}"
SRC_URI[aarch64_rust-futures-util+write-all-vectored-devel.sha256sum] = "95d430bd3098f7ae5ddda48d3e67e7c8af9517ea3fbae027744e53d4cb099853"

URI_aarch64_rust-futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util-devel}"
SRC_URI[aarch64_rust-futures-util-devel.sha256sum] = "e17d2214760bb8454af7f468e945ae4c8437693582b91a0a1078a8b2e7f26f31"

RDEPENDS:rust-futures-util+alloc-devel = " \
 cargo \
 rust-futures-core+alloc-devel \
 rust-futures-task+alloc-devel \
 rust-futures-util+slab-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+async-await-devel = " \
 cargo \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+async-await-macro-devel = " \
 cargo \
 rust-futures-util+async-await-devel \
 rust-futures-util+futures-macro-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+bilock-devel = " \
 cargo \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+channel-devel = " \
 cargo \
 rust-futures-util+futures-channel-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+default-devel = " \
 cargo \
 rust-futures-util+async-await-devel \
 rust-futures-util+async-await-macro-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-channel-devel = " \
 cargo \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-io-devel = " \
 cargo \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-macro-devel = " \
 cargo \
 rust-futures-macro-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-sink-devel = " \
 cargo \
 rust-futures-sink-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+io-devel = " \
 cargo \
 rust-futures-util+futures-io-devel \
 rust-futures-util+memchr-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+libc-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-futures-util+memchr-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-memchr+default-devel \
 "
RDEPENDS:rust-futures-util+portable-atomic-devel = " \
 cargo \
 rust-futures-core+portable-atomic-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+sink-devel = " \
 cargo \
 rust-futures-util+futures-sink-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+slab-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-slab-devel \
 "
RDEPENDS:rust-futures-util+spin-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-spin+default-devel \
 "
RDEPENDS:rust-futures-util+std-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-task+std-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-slab+std-devel \
 rust-slab-devel \
 "
RDEPENDS:rust-futures-util+unstable-devel = " \
 cargo \
 rust-futures-core+unstable-devel \
 rust-futures-task+unstable-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+write-all-vectored-devel = " \
 cargo \
 rust-futures-util+io-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-futures-task-devel \
 rust-pin-project-lite+default-devel \
 "
