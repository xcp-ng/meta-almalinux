# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "volume_key"
PV = "0.3.12"
PR = "27.el10"
PACKAGES = " \
 python3-volume_key \
 volume_key \
 volume_key-devel \
 volume_key-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/volume_key-0.3.12-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ad2186aa18f9ebc49b30d4fa4afcd45294a87508a48a9d9726979e1e514fecf"

URI_x86_64_v2_python3-volume_key = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-volume_key-0.3.12-27.el10.x86_64_v2.rpm;name=x86_64_v2_python3-volume_key;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-volume_key}"
SRC_URI[x86_64_v2_python3-volume_key.sha256sum] = "7d1d8e3d903d1d26ade23b971029b8b5a1863902e6aeda9b77b2103d358c02c6"

URI_x86_64_v2_volume_key = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/volume_key-0.3.12-27.el10.x86_64_v2.rpm;name=x86_64_v2_volume_key;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_volume_key}"
SRC_URI[x86_64_v2_volume_key.sha256sum] = "ceb1e38f55e97f155bc0247844cc2cb152830a1cacdb5ceb3fe5d35eb060d1e0"

URI_x86_64_v2_volume_key-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/volume_key-devel-0.3.12-27.el10.x86_64_v2.rpm;name=x86_64_v2_volume_key-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_volume_key-devel}"
SRC_URI[x86_64_v2_volume_key-devel.sha256sum] = "9ed011dbfca848db45b2eb648099b9d7ac96d15e2b19ecc15360bb0a56996cf5"

URI_x86_64_v2_volume_key-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/volume_key-libs-0.3.12-27.el10.x86_64_v2.rpm;name=x86_64_v2_volume_key-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_volume_key-libs}"
SRC_URI[x86_64_v2_volume_key-libs.sha256sum] = "564d429c5493f33b682a462326a73a2bccb01a568098ea74dde773ba137fe91c"

URI_aarch64_python3-volume_key = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-volume_key-0.3.12-27.el10.aarch64.rpm;name=aarch64_python3-volume_key;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-volume_key}"
SRC_URI[aarch64_python3-volume_key.sha256sum] = "361839db023cf9fefabca8c7916c9912de021e28d41e6201ef2aa3386456b3a9"

URI_aarch64_volume_key = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/volume_key-0.3.12-27.el10.aarch64.rpm;name=aarch64_volume_key;unpack=0"
SRC_URI:append = " ${URI_aarch64_volume_key}"
SRC_URI[aarch64_volume_key.sha256sum] = "da7f1a724ff021beebc742a0b23cb61b0c67cf0648fc214deb693dd3b97787e8"

URI_aarch64_volume_key-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/volume_key-devel-0.3.12-27.el10.aarch64.rpm;name=aarch64_volume_key-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_volume_key-devel}"
SRC_URI[aarch64_volume_key-devel.sha256sum] = "a6fa399874a0c446817cd30bb7414aa7d945daefb01069bef12e5e35154aba2b"

URI_aarch64_volume_key-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/volume_key-libs-0.3.12-27.el10.aarch64.rpm;name=aarch64_volume_key-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_volume_key-libs}"
SRC_URI[aarch64_volume_key-libs.sha256sum] = "bce1ba072129f911821ffa80ad53c7e34045f16ddb93417da566a0b398919f79"

RDEPENDS:python3-volume_key = " \
 cryptsetup-libs \
 glib2 \
 glibc \
 libblkid \
 nspr \
 nss \
 nss-util \
 python3 \
 volume_key-libs \
 "
RDEPENDS:volume_key = " \
 glib2 \
 glibc \
 nspr \
 nss \
 volume_key-libs \
 "
RDEPENDS:volume_key-devel = " \
 volume_key-libs \
 "
RDEPENDS:volume_key-libs = " \
 cryptsetup-libs \
 glib2 \
 glibc \
 libblkid \
 nspr \
 nss \
 nss-util \
 sequoia-sq \
 "
