# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clamav"
PV = "1.4.3"
PR = "2.el10_1"
PACKAGES = " \
 clamav \
 clamav-data \
 clamav-devel \
 clamav-doc \
 clamav-filesystem \
 clamav-freshclam \
 clamav-lib \
 clamav-milter \
 clamd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clamav-1.4.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ce51c38a08edbbcdc868d4bef032782b5741eed2780e027d14f3ee807ab7171"

URI_x86_64_v2_clamav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-1.4.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav}"
SRC_URI[x86_64_v2_clamav.sha256sum] = "d4adedaae08e0d66196d538fe18ee4fb27091572fe9feb4a92e60b035d6337db"

URI_x86_64_v2_clamav-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-data-1.4.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-data}"
SRC_URI[x86_64_v2_clamav-data.sha256sum] = "02e08d5aa34cac822df66b60e0014c0f0aea69bf0947081cfae8a4df74305209"
RPROVIDES:clamav-data:x86_64_v2 = "virtual/data_clamav_"

URI_x86_64_v2_clamav-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-devel-1.4.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-devel}"
SRC_URI[x86_64_v2_clamav-devel.sha256sum] = "be442416904345eff8875de3f1e39f370f190d7d5e90b81f0476f7982d1a6aa9"

URI_x86_64_v2_clamav-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-doc-1.4.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-doc}"
SRC_URI[x86_64_v2_clamav-doc.sha256sum] = "87eb256274840605b79da6f7f0018f9e6d37a608773ea70574b3d4f9a554522c"

URI_x86_64_v2_clamav-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-filesystem-1.4.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-filesystem}"
SRC_URI[x86_64_v2_clamav-filesystem.sha256sum] = "405fd7e847993b0a016fb0c16e800f85a310ce7353b9ef8e8a7696b07ad9e299"

URI_x86_64_v2_clamav-freshclam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-freshclam-1.4.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-freshclam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-freshclam}"
SRC_URI[x86_64_v2_clamav-freshclam.sha256sum] = "f4106034965f3af027dd163e8ae1faf4e3bdd429c1fc4608dbf029e9a96048a4"
RPROVIDES:clamav-freshclam:x86_64_v2 = "virtual/data_clamav_"

URI_x86_64_v2_clamav-lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-lib-1.4.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-lib}"
SRC_URI[x86_64_v2_clamav-lib.sha256sum] = "831c04cd13a353caf7d20e1ef6e8ab1361b5a8fb22b86ea0c241fdaf1bfb861f"

URI_x86_64_v2_clamav-milter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-milter-1.4.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-milter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-milter}"
SRC_URI[x86_64_v2_clamav-milter.sha256sum] = "946ebf3833b5bb108d989cb75e1a3139385e030123a068650caf7ca4f87b39ef"

URI_x86_64_v2_clamd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamd-1.4.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamd}"
SRC_URI[x86_64_v2_clamd.sha256sum] = "49e280c1c2d63c314154d8f102e929451db0af77dd5115f2d9a38f69eb969df1"

URI_aarch64_clamav = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-1.4.3-2.el10_1.aarch64.rpm;name=aarch64_clamav;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav}"
SRC_URI[aarch64_clamav.sha256sum] = "111e2c9cbcea3531ee801c277a43ea55048fc614f4753a7e427cfaa6303af7df"

URI_aarch64_clamav-data = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-data-1.4.3-2.el10_1.noarch.rpm;name=aarch64_clamav-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-data}"
SRC_URI[aarch64_clamav-data.sha256sum] = "05f42577c56064602aa55ddc6ecc772293e3389f882b33f4bc213fa45828f7bb"
RPROVIDES:clamav-data:aarch64 = "virtual/data_clamav_"

URI_aarch64_clamav-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-devel-1.4.3-2.el10_1.aarch64.rpm;name=aarch64_clamav-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-devel}"
SRC_URI[aarch64_clamav-devel.sha256sum] = "2278b023b6d1bb98ca521efcfca043f23b9d812c6ddbd9ed334610e56606d0c8"

URI_aarch64_clamav-doc = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-doc-1.4.3-2.el10_1.noarch.rpm;name=aarch64_clamav-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-doc}"
SRC_URI[aarch64_clamav-doc.sha256sum] = "f1fb5bbbdde60bc5d10e00bda91357dddd8ee2c2ccb92486398a3ab730cf42cd"

URI_aarch64_clamav-filesystem = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-filesystem-1.4.3-2.el10_1.noarch.rpm;name=aarch64_clamav-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-filesystem}"
SRC_URI[aarch64_clamav-filesystem.sha256sum] = "b1924a3942d088f4cdf23e650def53e7293a9a0a6ef47a267f37dc4bd5a94b57"

URI_aarch64_clamav-freshclam = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-freshclam-1.4.3-2.el10_1.aarch64.rpm;name=aarch64_clamav-freshclam;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-freshclam}"
SRC_URI[aarch64_clamav-freshclam.sha256sum] = "a499829cf8babd70bbfb61f83776dadc91b563c73e477c36e204203411a3572f"
RPROVIDES:clamav-freshclam:aarch64 = "virtual/data_clamav_"

URI_aarch64_clamav-lib = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-lib-1.4.3-2.el10_1.aarch64.rpm;name=aarch64_clamav-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-lib}"
SRC_URI[aarch64_clamav-lib.sha256sum] = "cc5b1e3599cb1b17e9a737f1304ba9add54a4d24b854325fa9ed739587f98193"

URI_aarch64_clamav-milter = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-milter-1.4.3-2.el10_1.aarch64.rpm;name=aarch64_clamav-milter;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-milter}"
SRC_URI[aarch64_clamav-milter.sha256sum] = "91e45bfbf3cbed6d568aafd9697f9fe71f9234ff16b9881d957b6997792bcbee"

URI_aarch64_clamd = "${EPEL_MIRROR}/aarch64/Packages/c/clamd-1.4.3-2.el10_1.aarch64.rpm;name=aarch64_clamd;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamd}"
SRC_URI[aarch64_clamd.sha256sum] = "631f93eec948b9d64b42266ab4830235ee1b75be27109374cfae2f07e1ae6f31"

RDEPENDS:clamav = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 json-c \
 libgcc \
 ncurses-libs \
 systemd \
 virtual/data_clamav_ \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clamav-data = " \
 bash \
 clamav-filesystem \
 "
RDEPENDS:clamav-devel = " \
 bash \
 clamav-filesystem \
 clamav-freshclam \
 clamav-lib \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:clamav-doc = " \
 clamav-filesystem \
 "
RDEPENDS:clamav-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:clamav-freshclam = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 libgcc \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clamav-lib = " \
 bzip2-libs \
 glibc \
 json-c \
 libgcc \
 libxml2 \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:clamav-milter = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 sendmail-milter \
 shadow-utils \
 "
RDEPENDS:clamd = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 shadow-utils \
 systemd-libs \
 virtual/coreutils \
 virtual/data_clamav_ \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/data_clamav_"

PROVIDES:append:aarch64 = " rpm/virtual/data_clamav_"
