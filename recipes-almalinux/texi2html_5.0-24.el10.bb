# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "texi2html"
PV = "5.0"
PR = "24.el10"
PACKAGES = " \
 texi2html \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/texi2html-5.0-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fda205d960562801046256c9d1233251af1c592ff78020e01a42124696bf9db4"

URI_x86_64_v2_texi2html = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/texi2html-5.0-24.el10.noarch.rpm;name=x86_64_v2_texi2html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texi2html}"
SRC_URI[x86_64_v2_texi2html.sha256sum] = "65b3afa5cf2eb493b717517eaaf7eadfb98b949d7586439a7993f867a3d231d9"

URI_aarch64_texi2html = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/texi2html-5.0-24.el10.noarch.rpm;name=aarch64_texi2html;unpack=0"
SRC_URI:append = " ${URI_aarch64_texi2html}"
SRC_URI[aarch64_texi2html.sha256sum] = "65b3afa5cf2eb493b717517eaaf7eadfb98b949d7586439a7993f867a3d231d9"

RDEPENDS:texi2html = " \
 latex2html \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-POSIX \
 perl-PathTools \
 perl-Text-Unidecode \
 perl-Unicode-EastAsianWidth \
 perl-interpreter \
 perl-libintl-perl \
 perl-libs \
 perl-vars \
 "
