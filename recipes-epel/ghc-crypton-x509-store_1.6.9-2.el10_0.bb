# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-crypton-x509-store"
PV = "1.6.9"
PR = "2.el10_0"
PACKAGES = " \
 ghc-crypton-x509-store \
 ghc-crypton-x509-store-devel \
 ghc-crypton-x509-store-doc \
 ghc-crypton-x509-store-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-crypton-x509-store-1.6.9-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "134fbbb31476fe4784ed2afe1e428b5c992bf82d1cbe19f66e20a888adeedcbe"

URI_x86_64_v2_ghc-crypton-x509-store = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-x509-store-1.6.9-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypton-x509-store;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton-x509-store}"
SRC_URI[x86_64_v2_ghc-crypton-x509-store.sha256sum] = "e50e45c79786c6f8924e2cc0e39ce96ba599a1b908db7a7a0969528f2e0ff4ef"

URI_x86_64_v2_ghc-crypton-x509-store-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-x509-store-devel-1.6.9-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypton-x509-store-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton-x509-store-devel}"
SRC_URI[x86_64_v2_ghc-crypton-x509-store-devel.sha256sum] = "133e8912144e056833dba42a45121787ddb75d7759490069a6d12712a92b5f04"

URI_x86_64_v2_ghc-crypton-x509-store-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-x509-store-doc-1.6.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-crypton-x509-store-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton-x509-store-doc}"
SRC_URI[x86_64_v2_ghc-crypton-x509-store-doc.sha256sum] = "468c8d445992255ffb7748e8d2f7a5acecd883feec0e7e73050d41c1653a0740"

URI_x86_64_v2_ghc-crypton-x509-store-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-x509-store-prof-1.6.9-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypton-x509-store-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton-x509-store-prof}"
SRC_URI[x86_64_v2_ghc-crypton-x509-store-prof.sha256sum] = "986e02d888ff3932be6eaf272dbbc1c8e2d3728547bf23c3d1262ef3d609d46c"

URI_aarch64_ghc-crypton-x509-store = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-x509-store-1.6.9-2.el10_0.aarch64.rpm;name=aarch64_ghc-crypton-x509-store;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton-x509-store}"
SRC_URI[aarch64_ghc-crypton-x509-store.sha256sum] = "e47b46d9833fe746461800a1967430a0b8e12a5b8a25b3b9544bc6c608080393"

URI_aarch64_ghc-crypton-x509-store-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-x509-store-devel-1.6.9-2.el10_0.aarch64.rpm;name=aarch64_ghc-crypton-x509-store-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton-x509-store-devel}"
SRC_URI[aarch64_ghc-crypton-x509-store-devel.sha256sum] = "3c3077fba1f9f066a09831b30a9162b2743e2dfb586fc26d2ad4eff2f840f581"

URI_aarch64_ghc-crypton-x509-store-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-x509-store-doc-1.6.9-2.el10_0.noarch.rpm;name=aarch64_ghc-crypton-x509-store-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton-x509-store-doc}"
SRC_URI[aarch64_ghc-crypton-x509-store-doc.sha256sum] = "064b8d56f99ec87a6aa41aa9969bb973947ae44e0b22e90d04db11ca2bd6488f"

URI_aarch64_ghc-crypton-x509-store-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-x509-store-prof-1.6.9-2.el10_0.aarch64.rpm;name=aarch64_ghc-crypton-x509-store-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton-x509-store-prof}"
SRC_URI[aarch64_ghc-crypton-x509-store-prof.sha256sum] = "c9e0419939eb69fb1b77e89330a4e0e1fcfbd174d260d48fd08c228bf24db219"

RDEPENDS:ghc-crypton-x509-store = " \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-base \
 ghc-basement \
 ghc-bytestring \
 ghc-containers \
 ghc-crypton \
 ghc-crypton-x509 \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hourglass \
 ghc-memory \
 ghc-mtl \
 ghc-pem \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-crypton-x509-store-devel = " \
 ghc-asn1-encoding-devel \
 ghc-asn1-types-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-crypton-devel \
 ghc-crypton-x509-devel \
 ghc-crypton-x509-store \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-mtl-devel \
 ghc-pem-devel \
 "
RDEPENDS:ghc-crypton-x509-store-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-crypton-x509-store-prof = " \
 ghc-asn1-encoding-prof \
 ghc-asn1-types-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-crypton-prof \
 ghc-crypton-x509-prof \
 ghc-crypton-x509-store-devel \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-mtl-prof \
 ghc-pem-prof \
 "
