# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openpyxl"
PV = "3.1.2"
PR = "8.el10_0"
PACKAGES = " \
 python3-openpyxl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openpyxl-3.1.2-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a99b56319995a5dff84dda4840481a936a0ac90a9d206a9bca7848301ef7cbc1"

URI_x86_64_v2_python3-openpyxl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openpyxl-3.1.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openpyxl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openpyxl}"
SRC_URI[x86_64_v2_python3-openpyxl.sha256sum] = "374f247f196660a7a4e370af757130a8a9994f6bfea5c33c686d8d2bae00fd7b"

URI_aarch64_python3-openpyxl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openpyxl-3.1.2-8.el10_0.noarch.rpm;name=aarch64_python3-openpyxl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openpyxl}"
SRC_URI[aarch64_python3-openpyxl.sha256sum] = "9012648e117bac4f448219fb34d9496183f746ea6ce6c6dc47634f3f13b49847"

RDEPENDS:python3-openpyxl = " \
 python3 \
 python3-et_xmlfile \
 "
