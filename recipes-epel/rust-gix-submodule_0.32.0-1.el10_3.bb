# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-submodule"
PV = "0.32.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-submodule+default-devel \
 rust-gix-submodule+sha1-devel \
 rust-gix-submodule+sha256-devel \
 rust-gix-submodule-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-submodule-0.32.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ecc09b21768e137009b72cab4be1c8460c4130f58bf464c2e1a4e3ae2d6c6cc"

URI_x86_64_v2_rust-gix-submodule+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-submodule+default-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-submodule+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-submodule+default-devel}"
SRC_URI[x86_64_v2_rust-gix-submodule+default-devel.sha256sum] = "4e5fad49427a57114f5a629d503bedffb46a0c391e27d14547b97c4132fe49a9"

URI_x86_64_v2_rust-gix-submodule+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-submodule+sha1-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-submodule+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-submodule+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-submodule+sha1-devel.sha256sum] = "137e72cdb301dfc979df1a274b88d3c1e0a98be2293539a28d18ad490b24f435"

URI_x86_64_v2_rust-gix-submodule+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-submodule+sha256-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-submodule+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-submodule+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-submodule+sha256-devel.sha256sum] = "79fe619ce644dcdac5f793f299eba57d3a6a24c1a9794b0a864e9635851af8ee"

URI_x86_64_v2_rust-gix-submodule-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-submodule-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-submodule-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-submodule-devel}"
SRC_URI[x86_64_v2_rust-gix-submodule-devel.sha256sum] = "c5304eca4f8b12b3554a29429af243593b7af4b8fd41ce9c1f42a3e0e8afaff7"

URI_aarch64_rust-gix-submodule+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-submodule+default-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-submodule+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-submodule+default-devel}"
SRC_URI[aarch64_rust-gix-submodule+default-devel.sha256sum] = "abe5f6e2b8c5051a795c2b7b8eaab1284178746a122ecb63c46a67b155ea6885"

URI_aarch64_rust-gix-submodule+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-submodule+sha1-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-submodule+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-submodule+sha1-devel}"
SRC_URI[aarch64_rust-gix-submodule+sha1-devel.sha256sum] = "06742a24235e351d55f2065cb02a94c931d730e96c5dd238145d0b0f2a4e4c5d"

URI_aarch64_rust-gix-submodule+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-submodule+sha256-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-submodule+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-submodule+sha256-devel}"
SRC_URI[aarch64_rust-gix-submodule+sha256-devel.sha256sum] = "457f3da66df63ab4c1f41b4af0ee3c32e0a5a0fb67725dca10db442cf0f47d60"

URI_aarch64_rust-gix-submodule-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-submodule-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-submodule-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-submodule-devel}"
SRC_URI[aarch64_rust-gix-submodule-devel.sha256sum] = "0feabbac654ce679b83663ab3362856c3630c83a72bd475ce432602cb3de3934"

RDEPENDS:rust-gix-submodule+default-devel = " \
 cargo \
 rust-gix-submodule-devel \
 "
RDEPENDS:rust-gix-submodule+sha1-devel = " \
 cargo \
 rust-gix-refspec+sha1-devel \
 rust-gix-submodule-devel \
 "
RDEPENDS:rust-gix-submodule+sha256-devel = " \
 cargo \
 rust-gix-refspec+sha256-devel \
 rust-gix-submodule-devel \
 "
RDEPENDS:rust-gix-submodule-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-config+default-devel \
 rust-gix-path+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-refspec+default-devel \
 rust-gix-url+default-devel \
 rust-thiserror+default-devel \
 "
