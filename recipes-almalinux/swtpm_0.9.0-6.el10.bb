# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "swtpm"
PV = "0.9.0"
PR = "6.el10"
PACKAGES = " \
 swtpm \
 swtpm-libs \
 swtpm-selinux \
 swtpm-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/swtpm-0.9.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "643b7e1b39b5e1fd554e2d9750228fb4db3945600bbb1a70ca6fd25204c78d37"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/swtpm-0.9.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_swtpm;unpack=0"
SRC_URI[x86_64_v2_swtpm.sha256sum] = "eb1baf4be3a72acc0248431f117a63d42584f991bed0279c40b083b2c5a51b05"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/swtpm-libs-0.9.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_swtpm-libs;unpack=0"
SRC_URI[x86_64_v2_swtpm-libs.sha256sum] = "d595ed266382174db184adcff04853c37e8b84a9ba26a0efc158ec8394f88acb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/swtpm-selinux-0.9.0-6.el10.noarch.rpm;name=x86_64_v2_swtpm-selinux;unpack=0"
SRC_URI[x86_64_v2_swtpm-selinux.sha256sum] = "a2d06291c633b541ac15f3ca5285a67cde9ed212a901cbaf5bfd9beee2ec2ba4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/swtpm-tools-0.9.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_swtpm-tools;unpack=0"
SRC_URI[x86_64_v2_swtpm-tools.sha256sum] = "4a11610b4b94d8f7079c42f4a23d213f5c4be53706e8ab0c750f5a280f9d120d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/swtpm-0.9.0-6.el10.aarch64.rpm;name=aarch64_swtpm;unpack=0"
SRC_URI[aarch64_swtpm.sha256sum] = "4acbb687c11c01ba459a8e3f3688fa4109903a0229fff48a72e3397ea6748ed0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/swtpm-libs-0.9.0-6.el10.aarch64.rpm;name=aarch64_swtpm-libs;unpack=0"
SRC_URI[aarch64_swtpm-libs.sha256sum] = "e85c168d9c12efb76415382d4988a59dfe61c3b71847bb2cd9b55f9a5c7c01a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/swtpm-selinux-0.9.0-6.el10.noarch.rpm;name=aarch64_swtpm-selinux;unpack=0"
SRC_URI[aarch64_swtpm-selinux.sha256sum] = "a2d06291c633b541ac15f3ca5285a67cde9ed212a901cbaf5bfd9beee2ec2ba4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/swtpm-tools-0.9.0-6.el10.aarch64.rpm;name=aarch64_swtpm-tools;unpack=0"
SRC_URI[aarch64_swtpm-tools.sha256sum] = "92049e0baf684fa622470f0b9b95a5425466687ccaad7ec1d1ccb703427036e2"

RDEPENDS:swtpm = " \
 glibc \
 libtpms \
 swtpm-libs \
 swtpm-selinux \
 "
RDEPENDS:swtpm-libs = " \
 glib2 \
 glibc \
 libseccomp \
 libtpms \
 openssl-libs \
 "
RDEPENDS:swtpm-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 swtpm \
 "
RDEPENDS:swtpm-tools = " \
 bash \
 glib2 \
 glibc \
 gmp \
 gnutls \
 gnutls-utils \
 json-glib \
 libgcc \
 libtasn1 \
 openssl-libs \
 swtpm \
 tpm2-tss \
 "
