# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lasso"
PV = "2.9.0"
PR = "1.el10_2"
PACKAGES = " \
 lasso \
 lasso-devel \
 perl-lasso \
 python3-lasso \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lasso-2.9.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fc55766f8d399d85a8746349b704f993f0df17931cf29ec41dd55bd46a57ea6"

URI_x86_64_v2_lasso = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lasso-2.9.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lasso;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lasso}"
SRC_URI[x86_64_v2_lasso.sha256sum] = "d5fd76d028ff00a2491df0af9d41664de1667c5b5dfca522bc141933c9488d31"

URI_x86_64_v2_lasso-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lasso-devel-2.9.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lasso-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lasso-devel}"
SRC_URI[x86_64_v2_lasso-devel.sha256sum] = "599450028ffe9e34682c5401892034ea38f29df20ce770cbabb5b608b4527953"

URI_x86_64_v2_perl-lasso = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-lasso-2.9.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-lasso;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-lasso}"
SRC_URI[x86_64_v2_perl-lasso.sha256sum] = "50c95b993d69f92f6df46b95b9e5831f8342085cace45acf97bdedf0d89e8152"

URI_x86_64_v2_python3-lasso = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lasso-2.9.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lasso;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lasso}"
SRC_URI[x86_64_v2_python3-lasso.sha256sum] = "8f4fe64ae24535e3901530b4c563cc1f21a739a33b9bc08df913530b4056d2e3"

URI_aarch64_lasso = "${EPEL_MIRROR}/aarch64/Packages/l/lasso-2.9.0-1.el10_2.aarch64.rpm;name=aarch64_lasso;unpack=0"
SRC_URI:append = " ${URI_aarch64_lasso}"
SRC_URI[aarch64_lasso.sha256sum] = "d06838f9225703930bbce0fb78739088e674ae2e641ba8fe987901b4db1b3bbc"

URI_aarch64_lasso-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lasso-devel-2.9.0-1.el10_2.aarch64.rpm;name=aarch64_lasso-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lasso-devel}"
SRC_URI[aarch64_lasso-devel.sha256sum] = "fcbff3f7be75dbe8da342e487a8a2504fec6285c68992b7d17e08b7e15bd9236"

URI_aarch64_perl-lasso = "${EPEL_MIRROR}/aarch64/Packages/p/perl-lasso-2.9.0-1.el10_2.aarch64.rpm;name=aarch64_perl-lasso;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-lasso}"
SRC_URI[aarch64_perl-lasso.sha256sum] = "f6c4d2e03ba437f020b3605b5a038f91b2c46e8ae67c1bd8eabd52d8d2b4a902"

URI_aarch64_python3-lasso = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lasso-2.9.0-1.el10_2.aarch64.rpm;name=aarch64_python3-lasso;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lasso}"
SRC_URI[aarch64_python3-lasso.sha256sum] = "18f90d6e1696c92dc7c92e59f68f8cd35ddb7d5dd1b491c475e6b5d2c32a07ae"

RDEPENDS:lasso = " \
 glib2 \
 glibc \
 libtool-ltdl \
 libxml2 \
 libxslt \
 openssl-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:lasso-devel = " \
 glib2-devel \
 lasso \
 libxml2-devel \
 libxslt-devel \
 pkgconf-pkg-config \
 xmlsec1-devel \
 "
RDEPENDS:perl-lasso = " \
 glib2 \
 glibc \
 lasso \
 libxml2 \
 perl-libs \
 "
RDEPENDS:python3-lasso = " \
 glib2 \
 glibc \
 lasso \
 libtool-ltdl \
 libxml2 \
 libxslt \
 openssl-libs \
 python3 \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
