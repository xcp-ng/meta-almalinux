# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-moby-patternmatcher"
PV = "0.5.0"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-moby-patternmatcher-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-moby-patternmatcher-0.5.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3486333898c738d8e89f7606342489255dc9588c8fb481f2a0ba488c1d12fc53"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-moby-patternmatcher-devel-0.5.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-moby-patternmatcher-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-moby-patternmatcher-devel.sha256sum] = "f22d3b523eff095f2cd7f28af44e22374886535d94ed091a3ef217a78fa48803"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-moby-patternmatcher-devel-0.5.0-6.el10_0.noarch.rpm;name=aarch64_golang-github-moby-patternmatcher-devel;unpack=0"
SRC_URI[aarch64_golang-github-moby-patternmatcher-devel.sha256sum] = "76722758b1c7662e06ada7191912b52e882b3aec0133257117cab0ef695a864b"

RDEPENDS:golang-github-moby-patternmatcher-devel = " \
 go-filesystem \
 "
