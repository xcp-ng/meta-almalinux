# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dhcpdump"
PV = "1.9"
PR = "4.el10_0"
PACKAGES = " \
 dhcpdump \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dhcpdump-1.9-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "068487c8d95f837519a22c97bdad9d7b0e5d07edc82a77f0c59e30862ec7c840"

URI_x86_64_v2_dhcpdump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dhcpdump-1.9-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dhcpdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dhcpdump}"
SRC_URI[x86_64_v2_dhcpdump.sha256sum] = "8a1d2a4d64f86ae70a2ba052c7cd707ecd39ba04f9e87e5878ce75dd1e822cf9"

URI_aarch64_dhcpdump = "${EPEL_MIRROR}/aarch64/Packages/d/dhcpdump-1.9-4.el10_0.aarch64.rpm;name=aarch64_dhcpdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_dhcpdump}"
SRC_URI[aarch64_dhcpdump.sha256sum] = "b162bdcb61e5be622aa67ac6a3fbaf31c07284a7ea0e9fc1d633de88c42f7588"

RDEPENDS:dhcpdump = " \
 glibc \
 libpcap \
 "
