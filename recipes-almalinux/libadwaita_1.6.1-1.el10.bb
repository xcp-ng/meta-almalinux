# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libadwaita"
PV = "1.6.1"
PR = "1.el10"
PACKAGES = " \
 libadwaita \
 libadwaita-devel \
 libadwaita-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libadwaita-1.6.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84bdc29629d519b7e01f8205e4e06ff6dac372048ed45710b57007071a26829b"

URI_x86_64_v2_libadwaita = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libadwaita-1.6.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libadwaita;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libadwaita}"
SRC_URI[x86_64_v2_libadwaita.sha256sum] = "9f966123b0e8f3d1c5516b650befa36e003cadc5a92c2bec69be57b91a1bf864"

URI_x86_64_v2_libadwaita-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libadwaita-devel-1.6.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libadwaita-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libadwaita-devel}"
SRC_URI[x86_64_v2_libadwaita-devel.sha256sum] = "6ee1b43c6f0ec822663d04d6a82f2e0740f7bd411ebdadb98aa6c2f5cd72def1"

URI_x86_64_v2_libadwaita-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libadwaita-doc-1.6.1-1.el10.noarch.rpm;name=x86_64_v2_libadwaita-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libadwaita-doc}"
SRC_URI[x86_64_v2_libadwaita-doc.sha256sum] = "bff62cb0ff2fdc0b1394ae6860edd5a99c699e6d959ad0c700fc069ae9f3c47c"

URI_aarch64_libadwaita = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libadwaita-1.6.1-1.el10.aarch64.rpm;name=aarch64_libadwaita;unpack=0"
SRC_URI:append = " ${URI_aarch64_libadwaita}"
SRC_URI[aarch64_libadwaita.sha256sum] = "d92e54e74501f2f1783b0c9e508e06f4788ecd9822f85625652ef1d5a423677a"

URI_aarch64_libadwaita-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libadwaita-devel-1.6.1-1.el10.aarch64.rpm;name=aarch64_libadwaita-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libadwaita-devel}"
SRC_URI[aarch64_libadwaita-devel.sha256sum] = "871b969cd491e8e0d5cfa32c19c394bf0a4b08854a0b58e31d922a086d323bec"

URI_aarch64_libadwaita-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libadwaita-doc-1.6.1-1.el10.noarch.rpm;name=aarch64_libadwaita-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libadwaita-doc}"
SRC_URI[aarch64_libadwaita-doc.sha256sum] = "bff62cb0ff2fdc0b1394ae6860edd5a99c699e6d959ad0c700fc069ae9f3c47c"

RDEPENDS:libadwaita = " \
 appstream \
 fribidi \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 pango \
 "
RDEPENDS:libadwaita-devel = " \
 appstream-devel \
 fribidi-devel \
 glib2-devel \
 gtk4-devel \
 libadwaita \
 pkgconf-pkg-config \
 vala \
 "
RDEPENDS:libadwaita-doc = " \
 "
