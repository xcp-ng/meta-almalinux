# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skanlite"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 skanlite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/skanlite-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d639c4997de249979624cb70a824ce23585627d9b722c77b543b8bf7ca6c49c"

URI_x86_64_v2_skanlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/skanlite-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_skanlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skanlite}"
SRC_URI[x86_64_v2_skanlite.sha256sum] = "59c2e72697b42184ed0eae4ec47da6614683098c5ee6730bafa3038cdf8e9a91"

URI_aarch64_skanlite = "${EPEL_MIRROR}/aarch64/Packages/s/skanlite-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_skanlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_skanlite}"
SRC_URI[aarch64_skanlite.sha256sum] = "608026c558b068b44709baf30933b988370d84e2c28f76fbc904aa8eb97888e8"

RDEPENDS:skanlite = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libksane \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
