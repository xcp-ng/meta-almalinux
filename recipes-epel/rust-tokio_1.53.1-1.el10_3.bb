# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio"
PV = "1.53.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-tokio+bytes-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+full-devel \
 rust-tokio+io-std-devel \
 rust-tokio+io-util-devel \
 rust-tokio+libc-devel \
 rust-tokio+macros-devel \
 rust-tokio+mio-devel \
 rust-tokio+net-devel \
 rust-tokio+parking_lot-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+signal-devel \
 rust-tokio+signal-hook-registry-devel \
 rust-tokio+socket2-devel \
 rust-tokio+sync-devel \
 rust-tokio+test-util-devel \
 rust-tokio+time-devel \
 rust-tokio+tokio-macros-devel \
 rust-tokio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-1.53.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47d02ff52fe90c5f1807ba312b31f938fcf8bee3b7cc17bfa7514c157699a9b6"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-tokio+tokio-macros-devel: (crate(tokio-macros/default) >= 2.7.0 with crate(tokio-macros/default) < 2.8.0~)

URI_x86_64_v2_rust-tokio+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+bytes-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+bytes-devel}"
SRC_URI[x86_64_v2_rust-tokio+bytes-devel.sha256sum] = "819296676423cea783eeb311a92e78663c9278be44f56ff0c585c2f885323195"

URI_x86_64_v2_rust-tokio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+default-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+default-devel}"
SRC_URI[x86_64_v2_rust-tokio+default-devel.sha256sum] = "0d69ab75924052de9b3024eb51dc9882caf99fa7d4ed509fb2b1f2acb8bd396c"

URI_x86_64_v2_rust-tokio+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+fs-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+fs-devel}"
SRC_URI[x86_64_v2_rust-tokio+fs-devel.sha256sum] = "547f440cc6de0976ede16b18f52f450674c9d61709492fb81eb07ae5be87578e"

URI_x86_64_v2_rust-tokio+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+full-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+full-devel}"
SRC_URI[x86_64_v2_rust-tokio+full-devel.sha256sum] = "9e5f90571fcbb12642ee78755e5fa76ed7dc839992f9e06972b780ae4a501276"

URI_x86_64_v2_rust-tokio+io-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+io-std-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+io-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+io-std-devel}"
SRC_URI[x86_64_v2_rust-tokio+io-std-devel.sha256sum] = "17126cc3fed9403a6aa6c9a0591d2682d45d76b745aa3f4afe6ad9b5431d1b86"

URI_x86_64_v2_rust-tokio+io-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+io-util-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+io-util-devel}"
SRC_URI[x86_64_v2_rust-tokio+io-util-devel.sha256sum] = "453d6b34c6cd4d25a9492bf989270ad30679e5cfd6453d5ee29fa74621f39640"

URI_x86_64_v2_rust-tokio+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+libc-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+libc-devel}"
SRC_URI[x86_64_v2_rust-tokio+libc-devel.sha256sum] = "6ccc5ef5b1f2f44e7211f7fddea8ad8ddf7bfa5d20a965a4b4cc6b6d5685e4f1"

URI_x86_64_v2_rust-tokio+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+macros-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+macros-devel}"
SRC_URI[x86_64_v2_rust-tokio+macros-devel.sha256sum] = "8ba04edb074dd6e32399eeb071042c2d7f85084e1ebc1ff68969465ff2d3b30d"

URI_x86_64_v2_rust-tokio+mio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+mio-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+mio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+mio-devel}"
SRC_URI[x86_64_v2_rust-tokio+mio-devel.sha256sum] = "aa5677eecee1c2bdd0ab4d3dc87d310fc197d517b187616ffc596182f45dbec9"

URI_x86_64_v2_rust-tokio+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+net-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+net-devel}"
SRC_URI[x86_64_v2_rust-tokio+net-devel.sha256sum] = "7326fb0ddab259a25bd24fb8d744482606aaa408abacba7fa164140e03c0f757"

URI_x86_64_v2_rust-tokio+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+parking_lot-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-tokio+parking_lot-devel.sha256sum] = "0cc173e400fb19179c7bbdce60cbabc18ad1b7b60340455f64805130aca7b121"

URI_x86_64_v2_rust-tokio+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+process-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+process-devel}"
SRC_URI[x86_64_v2_rust-tokio+process-devel.sha256sum] = "d3303bddc643c0609bfc08fb604a3260008b91098831210e78fb0d7c5ee29c12"

URI_x86_64_v2_rust-tokio+rt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+rt-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+rt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+rt-devel}"
SRC_URI[x86_64_v2_rust-tokio+rt-devel.sha256sum] = "df5a347766c2d60118dfa9a8881095562f26e979098129ca991f517bd2177e71"

URI_x86_64_v2_rust-tokio+rt-multi-thread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+rt-multi-thread-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+rt-multi-thread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+rt-multi-thread-devel}"
SRC_URI[x86_64_v2_rust-tokio+rt-multi-thread-devel.sha256sum] = "f887aba593063c598950bbbe8e6e23fcbbf6f82187364285c427d62e249e43dc"

URI_x86_64_v2_rust-tokio+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+signal-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+signal-devel}"
SRC_URI[x86_64_v2_rust-tokio+signal-devel.sha256sum] = "34d6a3b557207d292e088d2931ef0262c1ab46d9284b2651e7c429f90145a08c"

URI_x86_64_v2_rust-tokio+signal-hook-registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+signal-hook-registry-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+signal-hook-registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+signal-hook-registry-devel}"
SRC_URI[x86_64_v2_rust-tokio+signal-hook-registry-devel.sha256sum] = "abf1d9bc2da8a842fbe8fef7d9e36485326e243dbfe16909622b6a1b2f8445b9"

URI_x86_64_v2_rust-tokio+socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+socket2-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+socket2-devel}"
SRC_URI[x86_64_v2_rust-tokio+socket2-devel.sha256sum] = "53b218b1dc7b7016190677d7908f8dcb858e2c3d526a7a0184254eda318ec9bc"

URI_x86_64_v2_rust-tokio+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+sync-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+sync-devel}"
SRC_URI[x86_64_v2_rust-tokio+sync-devel.sha256sum] = "206f1437e007a18787492308f00e4a9c095784f39a5992601503128e7398e0b0"

URI_x86_64_v2_rust-tokio+test-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+test-util-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+test-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+test-util-devel}"
SRC_URI[x86_64_v2_rust-tokio+test-util-devel.sha256sum] = "a0d0332a5c01dc795dc406bffa69c0b2e55d309ca75e6fc991212bfc96f1514f"

URI_x86_64_v2_rust-tokio+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+time-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+time-devel}"
SRC_URI[x86_64_v2_rust-tokio+time-devel.sha256sum] = "279ea823ce590e2ae007acefd3abcb9aa97934eca804c0d74298bb181588f5bf"

URI_x86_64_v2_rust-tokio+tokio-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+tokio-macros-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+tokio-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+tokio-macros-devel}"
SRC_URI[x86_64_v2_rust-tokio+tokio-macros-devel.sha256sum] = "efc6261fc1cd07c7ec63dff7050eccdc41996183c6ac9e706e54d66d33b674a9"

URI_x86_64_v2_rust-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-devel-1.53.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-devel}"
SRC_URI[x86_64_v2_rust-tokio-devel.sha256sum] = "a1814ab191efe0074e9d4fb5cf588c0e02c1b8b80dc7b5902fdc9416a7a9f242"

URI_aarch64_rust-tokio+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+bytes-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+bytes-devel}"
SRC_URI[aarch64_rust-tokio+bytes-devel.sha256sum] = "0b71344386e062159a9e52cf7d001acfdbf244913d3fec4286f36ab8bdfdef93"

URI_aarch64_rust-tokio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+default-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+default-devel}"
SRC_URI[aarch64_rust-tokio+default-devel.sha256sum] = "572398e5ab471858d4e84250a0d96ceb99c9758becc23008a8734378b04bc90f"

URI_aarch64_rust-tokio+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+fs-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+fs-devel}"
SRC_URI[aarch64_rust-tokio+fs-devel.sha256sum] = "f65c087a8458a8b4a0bfd90ec2fc7055099b2a8a73916d9151a98f37ab1377b5"

URI_aarch64_rust-tokio+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+full-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+full-devel}"
SRC_URI[aarch64_rust-tokio+full-devel.sha256sum] = "f30d8f045ad0b4df1f7a876b00d24c5dd21b70d4ae706fdf03c060807a19e5ba"

URI_aarch64_rust-tokio+io-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+io-std-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+io-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+io-std-devel}"
SRC_URI[aarch64_rust-tokio+io-std-devel.sha256sum] = "1d78170cb2d67bdfc7aec5a64dddbfe96b74c4eba89a38acd29b908d6aa3701b"

URI_aarch64_rust-tokio+io-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+io-util-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+io-util-devel}"
SRC_URI[aarch64_rust-tokio+io-util-devel.sha256sum] = "4927bc4870b363f88bee2cdffb7f06b16850459823e0ae689b4bce0887594f57"

URI_aarch64_rust-tokio+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+libc-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+libc-devel}"
SRC_URI[aarch64_rust-tokio+libc-devel.sha256sum] = "1b8d81b41257f605482ef0ad13dad5f434231bbaff8f057aa1deced15279695d"

URI_aarch64_rust-tokio+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+macros-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+macros-devel}"
SRC_URI[aarch64_rust-tokio+macros-devel.sha256sum] = "3f9c501d3d44569f4feafd7ac8ea83d0f54b6f146d021b34db0a0f2f8509c8f8"

URI_aarch64_rust-tokio+mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+mio-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+mio-devel}"
SRC_URI[aarch64_rust-tokio+mio-devel.sha256sum] = "7971d227a6181715d0f0bf26239dbf330d4a4f7028ae968b1b1b49be080248e8"

URI_aarch64_rust-tokio+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+net-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+net-devel}"
SRC_URI[aarch64_rust-tokio+net-devel.sha256sum] = "0375b5c546c59e0e0c86e1ea57177eca1d4e9720be2b8ecd019cb684bda1f8c1"

URI_aarch64_rust-tokio+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+parking_lot-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+parking_lot-devel}"
SRC_URI[aarch64_rust-tokio+parking_lot-devel.sha256sum] = "9c42350c8ca6ba1e5580e66505624295eff37090139bfd6433f365c6cfb41612"

URI_aarch64_rust-tokio+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+process-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+process-devel}"
SRC_URI[aarch64_rust-tokio+process-devel.sha256sum] = "716dff30cf8c17c7a238a011c4a32b3b1f980db4c1c88442f57ee24e84e4c304"

URI_aarch64_rust-tokio+rt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+rt-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+rt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+rt-devel}"
SRC_URI[aarch64_rust-tokio+rt-devel.sha256sum] = "6ec99e3ae52d48de8ad12e78c6fde385db6fb3350f326a0e746bb530c3d9a2e9"

URI_aarch64_rust-tokio+rt-multi-thread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+rt-multi-thread-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+rt-multi-thread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+rt-multi-thread-devel}"
SRC_URI[aarch64_rust-tokio+rt-multi-thread-devel.sha256sum] = "1ac9b33cb93ec37a5ec482e8d197a046674fbd814fdfe8affd18fae4d1a268dd"

URI_aarch64_rust-tokio+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+signal-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+signal-devel}"
SRC_URI[aarch64_rust-tokio+signal-devel.sha256sum] = "493cf5762f3bd5a506d59b69238d7d02d349e2b820d5ca7ccc502fe0ede4db19"

URI_aarch64_rust-tokio+signal-hook-registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+signal-hook-registry-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+signal-hook-registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+signal-hook-registry-devel}"
SRC_URI[aarch64_rust-tokio+signal-hook-registry-devel.sha256sum] = "17a68617fcd81d50d8b45d96f59c708ace4185086c6c033beeca0b7dc2b10488"

URI_aarch64_rust-tokio+socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+socket2-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+socket2-devel}"
SRC_URI[aarch64_rust-tokio+socket2-devel.sha256sum] = "f29ed17c6bef5fdaeb8049c0f792d7d1b4e0c186c774dc32bf8a312f239fd9b6"

URI_aarch64_rust-tokio+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+sync-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+sync-devel}"
SRC_URI[aarch64_rust-tokio+sync-devel.sha256sum] = "cc4f54de5ee5a0acb1763a5a27839c22c3366746a0481b4949d42eb9b85affeb"

URI_aarch64_rust-tokio+test-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+test-util-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+test-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+test-util-devel}"
SRC_URI[aarch64_rust-tokio+test-util-devel.sha256sum] = "76b02d5f6112b5255d44fd9f21ae113cf82b6f2da871472342906306a9ed9641"

URI_aarch64_rust-tokio+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+time-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+time-devel}"
SRC_URI[aarch64_rust-tokio+time-devel.sha256sum] = "7b795aa2e67ecbc374891df402aa4fdd32f00c3f87120e072f3bc8cd620c38c0"

URI_aarch64_rust-tokio+tokio-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+tokio-macros-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio+tokio-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+tokio-macros-devel}"
SRC_URI[aarch64_rust-tokio+tokio-macros-devel.sha256sum] = "032a38403dc345838709d6d2c78b0cf6a1471470592f0ac61818b7b4ef3ed3ae"

URI_aarch64_rust-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-devel-1.53.1-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-devel}"
SRC_URI[aarch64_rust-tokio-devel.sha256sum] = "b90ccf51b75870664fbe93bb702c948f09e727600302428e375615a1c48d1eea"

RDEPENDS:rust-tokio+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+default-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+fs-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+full-devel = " \
 cargo \
 rust-tokio+fs-devel \
 rust-tokio+io-std-devel \
 rust-tokio+io-util-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+parking_lot-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+signal-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+io-std-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+io-util-devel = " \
 cargo \
 rust-tokio+bytes-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+macros-devel = " \
 cargo \
 rust-tokio+tokio-macros-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+mio-devel = " \
 cargo \
 rust-mio-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+net-devel = " \
 cargo \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 rust-tokio+libc-devel \
 rust-tokio+socket2-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+parking_lot-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+process-devel = " \
 cargo \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 rust-tokio+bytes-devel \
 rust-tokio+libc-devel \
 rust-tokio+signal-hook-registry-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+rt-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+rt-multi-thread-devel = " \
 cargo \
 rust-tokio+rt-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+signal-devel = " \
 cargo \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 rust-tokio+libc-devel \
 rust-tokio+signal-hook-registry-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+signal-hook-registry-devel = " \
 cargo \
 rust-signal-hook-registry+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+socket2-devel = " \
 cargo \
 rust-socket2+all-devel \
 rust-socket2+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+sync-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+test-util-devel = " \
 cargo \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+time-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+tokio-macros-devel:x86_64_v2 = " \
 cargo \
 rust-tokio-devel \
"
RDEPENDS:rust-tokio+tokio-macros-devel:aarch64 = " \
 cargo \
 rust-tokio-devel \
 rust-tokio-macros+default-devel \
"
RDEPENDS:rust-tokio-devel = " \
 cargo \
 rust \
 rust-pin-project-lite+default-devel \
 "
