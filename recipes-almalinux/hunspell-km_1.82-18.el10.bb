# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-km"
PV = "1.82"
PR = "18.el10"
PACKAGES = " \
 hunspell-km \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-km-1.82-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aaf8a83607181acb00df56fc184b1ef6330ee35325c8433c8c376d372a70c7f1"

URI_x86_64_v2_hunspell-km = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-km-1.82-18.el10.noarch.rpm;name=x86_64_v2_hunspell-km;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-km}"
SRC_URI[x86_64_v2_hunspell-km.sha256sum] = "6bdfe6c89a55fb1260a0f11dc6e0ce65dff70a7e6864420e2a8f19372de55ac7"

URI_aarch64_hunspell-km = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-km-1.82-18.el10.noarch.rpm;name=aarch64_hunspell-km;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-km}"
SRC_URI[aarch64_hunspell-km.sha256sum] = "6bdfe6c89a55fb1260a0f11dc6e0ce65dff70a7e6864420e2a8f19372de55ac7"

RDEPENDS:hunspell-km = " \
 hunspell-filesystem \
 "
