# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-epoch"
PV = "0.9.21"
PR = "1.el10_2"
PACKAGES = " \
 rust-crossbeam-epoch+alloc-devel \
 rust-crossbeam-epoch+default-devel \
 rust-crossbeam-epoch+nightly-devel \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-epoch-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-epoch-0.9.21-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7b5039142b767d0dd4ae0bfbc1a19aaca9f12010f7cd07b1fb486f3572ae4021"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+alloc-devel-0.9.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+alloc-devel.sha256sum] = "ec08be3fae761a8cd37c1ea141664d79aab46bee28407a37b637bce48413afac"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+default-devel-0.9.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+default-devel.sha256sum] = "c34c7566a1728ef64c9e56d9058867d963af7100c8be244094527417ce0f733d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+nightly-devel-0.9.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+nightly-devel.sha256sum] = "16a872b51dea72ff81503ef9a5313601fa7b1340b73ceae7b8f81b18d0c928cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+std-devel-0.9.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+std-devel.sha256sum] = "3c5da9faf5e8dc3fbefe484619a1f153661933fcab48e2d83d110a38b1de54bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch-devel-0.9.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-epoch-devel.sha256sum] = "3ecde9a663951ef6b7acb4ab8e1c4c145de84f2e0dd8ca9c1ae5e73f0efe18c1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+alloc-devel-0.9.21-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-epoch+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-epoch+alloc-devel.sha256sum] = "47fba0038ac8a0ecd1a5befdbddc98ec120bb0e94e19d99d9673825d4a00ff03"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+default-devel-0.9.21-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-epoch+default-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-epoch+default-devel.sha256sum] = "91d2c2ec832c1f6c92f07bbe85f5c95a44ab8e184178c1f55c749889cba7313b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+nightly-devel-0.9.21-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-epoch+nightly-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-epoch+nightly-devel.sha256sum] = "bf5f124db5eedc2e6d9a5add1ad63ff4b3a0020e978d61f0f09239cb1c2c17e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+std-devel-0.9.21-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-epoch+std-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-epoch+std-devel.sha256sum] = "d93bae94cb6a69cb61cfdc67a74569a8fcd00e891090757ff81a5dfadf133188"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch-devel-0.9.21-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-epoch-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-epoch-devel.sha256sum] = "decc5b58aecdc28da3f0fea27471d7a440acfc95ff9f4f9cdf7ee79eaa58e5a5"

RDEPENDS:rust-crossbeam-epoch+alloc-devel = " \
 cargo \
 rust-crossbeam-epoch-devel \
 "
RDEPENDS:rust-crossbeam-epoch+default-devel = " \
 cargo \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-epoch-devel \
 "
RDEPENDS:rust-crossbeam-epoch+nightly-devel = " \
 cargo \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-utils+nightly-devel \
 "
RDEPENDS:rust-crossbeam-epoch+std-devel = " \
 cargo \
 rust-crossbeam-epoch+alloc-devel \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-epoch-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
