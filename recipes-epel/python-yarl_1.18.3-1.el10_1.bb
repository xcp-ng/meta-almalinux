# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-yarl"
PV = "1.18.3"
PR = "1.el10_1"
PACKAGES = " \
 python3-yarl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-yarl-1.18.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1061915502d669c0ee503028adf8029ff8a645d8322ed8e27c2e00c1510f20e4"

URI_x86_64_v2_python3-yarl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-yarl-1.18.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-yarl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-yarl}"
SRC_URI[x86_64_v2_python3-yarl.sha256sum] = "fddc3cd64a4484f93c20252eaab8647204531cd6ded1519f7a281ec4ed636e23"

URI_aarch64_python3-yarl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-yarl-1.18.3-1.el10_1.aarch64.rpm;name=aarch64_python3-yarl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-yarl}"
SRC_URI[aarch64_python3-yarl.sha256sum] = "9f14f3b17dad8c3be9ce59ec0c6db60524ee2d3943a1baa50017119e1ff1f5b8"

RDEPENDS:python3-yarl = " \
 glibc \
 python3 \
 python3-idna \
 python3-multidict \
 python3-propcache \
 "
