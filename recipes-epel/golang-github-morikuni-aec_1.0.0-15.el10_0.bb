# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-morikuni-aec"
PV = "1.0.0"
PR = "15.el10_0"
PACKAGES = " \
 golang-github-morikuni-aec \
 golang-github-morikuni-aec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-morikuni-aec-1.0.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87b543b8358aaa51e2ae8078087dc9c5be765082146c9b3b7dbfe6a6c4540c51"

URI_x86_64_v2_golang-github-morikuni-aec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-morikuni-aec-1.0.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-morikuni-aec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-morikuni-aec}"
SRC_URI[x86_64_v2_golang-github-morikuni-aec.sha256sum] = "bd2913f72ab9d14ebabfd24e8b312928c192ffbc9ca0ef1ef02dc65fecdeb3ef"

URI_x86_64_v2_golang-github-morikuni-aec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-morikuni-aec-devel-1.0.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-morikuni-aec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-morikuni-aec-devel}"
SRC_URI[x86_64_v2_golang-github-morikuni-aec-devel.sha256sum] = "cf5a2ef0f590105c4c6c81d5c968d0bfef3f8e9dc652c525cbbab8dc8d7c6387"

URI_aarch64_golang-github-morikuni-aec = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-morikuni-aec-1.0.0-15.el10_0.aarch64.rpm;name=aarch64_golang-github-morikuni-aec;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-morikuni-aec}"
SRC_URI[aarch64_golang-github-morikuni-aec.sha256sum] = "eeeda53cbb26e76fa9165b58e764b7895a09af38a04da5064a2e582c37aa9882"

URI_aarch64_golang-github-morikuni-aec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-morikuni-aec-devel-1.0.0-15.el10_0.noarch.rpm;name=aarch64_golang-github-morikuni-aec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-morikuni-aec-devel}"
SRC_URI[aarch64_golang-github-morikuni-aec-devel.sha256sum] = "e5a3c10ef16b3f9d1e12300e5b8ae4dc2852bd5bb06fde7e8b01402ab37e06ed"

RDEPENDS:golang-github-morikuni-aec = " \
 glibc \
 "
RDEPENDS:golang-github-morikuni-aec-devel = " \
 go-filesystem \
 "
