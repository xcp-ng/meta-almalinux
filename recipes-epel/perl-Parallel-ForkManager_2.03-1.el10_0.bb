# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Parallel-ForkManager"
PV = "2.03"
PR = "1.el10_0"
PACKAGES = " \
 perl-Parallel-ForkManager \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Parallel-ForkManager-2.03-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e51ca469891df529556b0bf74017fe8c69d2d03edc6f70b4becae4d66a083ded"

URI_x86_64_v2_perl-Parallel-ForkManager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Parallel-ForkManager-2.03-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Parallel-ForkManager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Parallel-ForkManager}"
SRC_URI[x86_64_v2_perl-Parallel-ForkManager.sha256sum] = "5f22102c07779c4a3e9cfed7989349f26178b66ee24af9748d2b8077a3c444b4"

URI_aarch64_perl-Parallel-ForkManager = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Parallel-ForkManager-2.03-1.el10_0.noarch.rpm;name=aarch64_perl-Parallel-ForkManager;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Parallel-ForkManager}"
SRC_URI[aarch64_perl-Parallel-ForkManager.sha256sum] = "2b012980fa867291909b51a1de9134828c8f9549c986f26cd9996c049dfba4f9"

RDEPENDS:perl-Parallel-ForkManager = " \
 perl-Carp \
 perl-File-Path \
 perl-File-Temp \
 perl-Moo \
 perl-POSIX \
 perl-Parallel-ForkManager \
 perl-PathTools \
 perl-Storable \
 perl-libs \
 "
