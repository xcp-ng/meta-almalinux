# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-curl-sys"
PV = "0.4.89"
PR = "1.el10_2"
PACKAGES = " \
 rust-curl-sys+default-devel \
 rust-curl-sys+http2-devel \
 rust-curl-sys+ntlm-devel \
 rust-curl-sys+openssl-sys-devel \
 rust-curl-sys+poll_7_68_0-devel \
 rust-curl-sys+protocol-ftp-devel \
 rust-curl-sys+spnego-devel \
 rust-curl-sys+ssl-devel \
 rust-curl-sys+upkeep_7_62_0-devel \
 rust-curl-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-curl-sys-0.4.89-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85b160af296774cd46ea48f613f185ecc6cb468e366f802e689cf43b43b321f4"

URI_x86_64_v2_rust-curl-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+default-devel-0.4.89-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+default-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+default-devel.sha256sum] = "6bfa5b6825d09dc746d09d4925858de4813e0374898e452252a1aa2e6c44a1cc"

URI_x86_64_v2_rust-curl-sys+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+http2-devel-0.4.89-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+http2-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+http2-devel.sha256sum] = "9c230b1ff630f807963d7d5ddd50f328c9ef6efe494ddc3ca1acffe8c0ffccdf"

URI_x86_64_v2_rust-curl-sys+ntlm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+ntlm-devel-0.4.89-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+ntlm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+ntlm-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+ntlm-devel.sha256sum] = "b121f865e0a25e47e3f4673c6f6489f45bd66e0c01d34169c1a22fa557525f88"

URI_x86_64_v2_rust-curl-sys+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+openssl-sys-devel-0.4.89-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+openssl-sys-devel.sha256sum] = "3a57039ffa03a91ccf6cea2d0851c10523ad40b3665ddb1f918db8b32e6e8b90"

URI_x86_64_v2_rust-curl-sys+poll_7_68_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+poll_7_68_0-devel-0.4.89-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+poll_7_68_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+poll_7_68_0-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+poll_7_68_0-devel.sha256sum] = "8875ce8f8994ee2da7c0399d600db69307d5b802db3a96974c409f37f92f12b3"

URI_x86_64_v2_rust-curl-sys+protocol-ftp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+protocol-ftp-devel-0.4.89-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+protocol-ftp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+protocol-ftp-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+protocol-ftp-devel.sha256sum] = "103d0fc119fe6157c2d9cdec1d7c37e5eea7f50a0cb6be513c9729472ad2574f"

URI_x86_64_v2_rust-curl-sys+spnego-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+spnego-devel-0.4.89-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+spnego-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+spnego-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+spnego-devel.sha256sum] = "657e0baf8ace64d2dc5a0dcf8ce1c61a53cfcaead0e8ff499e3706ad733e82d3"

URI_x86_64_v2_rust-curl-sys+ssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+ssl-devel-0.4.89-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+ssl-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+ssl-devel.sha256sum] = "779178b4eb86a62e9b55c838c3dd6cde525de1acfab5f21483baa8cf6ab7c90c"

URI_x86_64_v2_rust-curl-sys+upkeep_7_62_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+upkeep_7_62_0-devel-0.4.89-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+upkeep_7_62_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+upkeep_7_62_0-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+upkeep_7_62_0-devel.sha256sum] = "0c5b5ccc55bd6f804924441051d537d083c599f029829d86e4e93f9bc0e99abf"

URI_x86_64_v2_rust-curl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys-devel-0.4.89-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys-devel}"
SRC_URI[x86_64_v2_rust-curl-sys-devel.sha256sum] = "40f2ca2ff1c89b9beaf5c5bc0ef76fb634a5095d6837fa9ff77a3c44e94cd4e4"

URI_aarch64_rust-curl-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+default-devel-0.4.89-1.el10_2.noarch.rpm;name=aarch64_rust-curl-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+default-devel}"
SRC_URI[aarch64_rust-curl-sys+default-devel.sha256sum] = "4894adc4511a924a55e88cfc1672d31b3134dfde9f204c8d9734286d3a791f6e"

URI_aarch64_rust-curl-sys+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+http2-devel-0.4.89-1.el10_2.noarch.rpm;name=aarch64_rust-curl-sys+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+http2-devel}"
SRC_URI[aarch64_rust-curl-sys+http2-devel.sha256sum] = "97632fb5fb06c235d8ee27683a2b03f74419c461489a9be92b78338007071b93"

URI_aarch64_rust-curl-sys+ntlm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+ntlm-devel-0.4.89-1.el10_2.noarch.rpm;name=aarch64_rust-curl-sys+ntlm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+ntlm-devel}"
SRC_URI[aarch64_rust-curl-sys+ntlm-devel.sha256sum] = "0d4e4d69f9fb34b84b0ad61b8a350fc0d6738cfd5dbb2288ffdd68fd53d32385"

URI_aarch64_rust-curl-sys+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+openssl-sys-devel-0.4.89-1.el10_2.noarch.rpm;name=aarch64_rust-curl-sys+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+openssl-sys-devel}"
SRC_URI[aarch64_rust-curl-sys+openssl-sys-devel.sha256sum] = "403f5d1350c19fc907d7cb3b2b39f65d36b02765f456bcdd188339015e715602"

URI_aarch64_rust-curl-sys+poll_7_68_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+poll_7_68_0-devel-0.4.89-1.el10_2.noarch.rpm;name=aarch64_rust-curl-sys+poll_7_68_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+poll_7_68_0-devel}"
SRC_URI[aarch64_rust-curl-sys+poll_7_68_0-devel.sha256sum] = "85496fec3216e16e13cddb93c64bf6a6786d0a274acab9d0c032be9de0147e5e"

URI_aarch64_rust-curl-sys+protocol-ftp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+protocol-ftp-devel-0.4.89-1.el10_2.noarch.rpm;name=aarch64_rust-curl-sys+protocol-ftp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+protocol-ftp-devel}"
SRC_URI[aarch64_rust-curl-sys+protocol-ftp-devel.sha256sum] = "248e1785916fcc8f27ff5cfe3a26b0d947978ee8d0c0a9a625ade8cc788a382c"

URI_aarch64_rust-curl-sys+spnego-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+spnego-devel-0.4.89-1.el10_2.noarch.rpm;name=aarch64_rust-curl-sys+spnego-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+spnego-devel}"
SRC_URI[aarch64_rust-curl-sys+spnego-devel.sha256sum] = "5e8fcfdf5657ec0c93adea521f34e54e857257308d0c63ad764cd61dfe099f8c"

URI_aarch64_rust-curl-sys+ssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+ssl-devel-0.4.89-1.el10_2.noarch.rpm;name=aarch64_rust-curl-sys+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+ssl-devel}"
SRC_URI[aarch64_rust-curl-sys+ssl-devel.sha256sum] = "3a6e4275cf3e8d6cf0b35de75713d4de43a3294f97ee0ca267a5821a912bc75a"

URI_aarch64_rust-curl-sys+upkeep_7_62_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+upkeep_7_62_0-devel-0.4.89-1.el10_2.noarch.rpm;name=aarch64_rust-curl-sys+upkeep_7_62_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+upkeep_7_62_0-devel}"
SRC_URI[aarch64_rust-curl-sys+upkeep_7_62_0-devel.sha256sum] = "122775df4aaf81328187fd70e51785b090144cf4bf3742616c58c3cffa435e19"

URI_aarch64_rust-curl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys-devel-0.4.89-1.el10_2.noarch.rpm;name=aarch64_rust-curl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys-devel}"
SRC_URI[aarch64_rust-curl-sys-devel.sha256sum] = "65aae1abc913a0aef6ac3d7a0a92afa9b223e7d09ccec28ce965b44d535ce25b"

RDEPENDS:rust-curl-sys+default-devel = " \
 cargo \
 rust-curl-sys+ssl-devel \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+http2-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+ntlm-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+openssl-sys-devel = " \
 cargo \
 rust-curl-sys-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-curl-sys+poll_7_68_0-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+protocol-ftp-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+spnego-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+ssl-devel = " \
 cargo \
 rust-curl-sys+openssl-sys-devel \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+upkeep_7_62_0-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys-devel = " \
 cargo \
 libcurl-devel \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
