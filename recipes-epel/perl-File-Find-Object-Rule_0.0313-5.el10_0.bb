# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-Find-Object-Rule"
PV = "0.0313"
PR = "5.el10_0"
PACKAGES = " \
 perl-File-Find-Object-Rule \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-Find-Object-Rule-0.0313-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6b117cbcf2ed993279dcefa5712a5458319998d6d420124570e948927d7ec2f"

URI_x86_64_v2_perl-File-Find-Object-Rule = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Find-Object-Rule-0.0313-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Find-Object-Rule;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Find-Object-Rule}"
SRC_URI[x86_64_v2_perl-File-Find-Object-Rule.sha256sum] = "5e1c041953e3f56e54dde7188b7dc5ddc49b9555ada57fccc13eaa8f67bb1d26"

URI_aarch64_perl-File-Find-Object-Rule = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Find-Object-Rule-0.0313-5.el10_0.noarch.rpm;name=aarch64_perl-File-Find-Object-Rule;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Find-Object-Rule}"
SRC_URI[aarch64_perl-File-Find-Object-Rule.sha256sum] = "57bb9038566157195240b6471b9b71208c4149b20b0d3cbbeea99b70716ed150"

RDEPENDS:perl-File-Find-Object-Rule = " \
 perl-Carp \
 perl-Class-XSAccessor \
 perl-File-Basename \
 perl-File-Find-Object \
 perl-File-Find-Object-Rule \
 perl-Number-Compare \
 perl-PathTools \
 perl-Text-Glob \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
