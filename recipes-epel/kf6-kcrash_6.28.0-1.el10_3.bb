# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcrash"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcrash \
 kf6-kcrash-devel \
 kf6-kcrash-doc \
 kf6-kcrash-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcrash-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "080de119f072b16f31e8525f2312a9a0b3532a5a51022586a0d7aedfa915b5f1"

URI_x86_64_v2_kf6-kcrash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcrash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcrash}"
SRC_URI[x86_64_v2_kf6-kcrash.sha256sum] = "b5a76f59b870384764d250cbab9937ac0c49a46b159b5663691b1f430458d041"

URI_x86_64_v2_kf6-kcrash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcrash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcrash-devel}"
SRC_URI[x86_64_v2_kf6-kcrash-devel.sha256sum] = "3c9135fe505c59c7963abc3728fa0b47aa935c5fa7b5e63e0afc767da7225923"

URI_x86_64_v2_kf6-kcrash-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcrash-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcrash-doc}"
SRC_URI[x86_64_v2_kf6-kcrash-doc.sha256sum] = "637c45a91a98430314c89f9d443c76eee4990902f9c011d42f188d1005cf9514"

URI_x86_64_v2_kf6-kcrash-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcrash-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcrash-html}"
SRC_URI[x86_64_v2_kf6-kcrash-html.sha256sum] = "61a844c93c60418b613ef4bd4649f746112f8adc329571124e619f27f076ee85"

URI_aarch64_kf6-kcrash = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcrash;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcrash}"
SRC_URI[aarch64_kf6-kcrash.sha256sum] = "683b1df8d69febe40fcae49f9589fde994dc928892d7e732e8df07db7bde44e0"

URI_aarch64_kf6-kcrash-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcrash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcrash-devel}"
SRC_URI[aarch64_kf6-kcrash-devel.sha256sum] = "a222f70ee9caad2f51bb75369f28463568374af71370aa7081924a200ff13aa7"

URI_aarch64_kf6-kcrash-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcrash-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcrash-doc}"
SRC_URI[aarch64_kf6-kcrash-doc.sha256sum] = "d50a83c045e98b547962d0803e201642d222dc703d405f3c311b332045acdf87"

URI_aarch64_kf6-kcrash-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcrash-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcrash-html}"
SRC_URI[aarch64_kf6-kcrash-html.sha256sum] = "e491d87817a49206bda453eeedd10501d713a28dedf201e3a6b1a9bb3cd76bc7"

RDEPENDS:kf6-kcrash = " \
 glibc \
 kf6-kcoreaddons \
 libX11 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcrash-devel = " \
 cmake-filesystem \
 kf6-kcrash \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcrash-doc = " \
 "
RDEPENDS:kf6-kcrash-html = " \
 "
