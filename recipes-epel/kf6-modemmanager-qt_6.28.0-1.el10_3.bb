# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-modemmanager-qt"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-modemmanager-qt \
 kf6-modemmanager-qt-devel \
 kf6-modemmanager-qt-doc \
 kf6-modemmanager-qt-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-modemmanager-qt-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15d9d74a49ad5d45c10038a1697d35dc7318a0f6411a88a558858127698ae0cf"

URI_x86_64_v2_kf6-modemmanager-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-modemmanager-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-modemmanager-qt}"
SRC_URI[x86_64_v2_kf6-modemmanager-qt.sha256sum] = "de3d3b5a14e4891adfd91950b924aa837c4910c84f37cc422d291b04487394e9"

URI_x86_64_v2_kf6-modemmanager-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-modemmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-modemmanager-qt-devel}"
SRC_URI[x86_64_v2_kf6-modemmanager-qt-devel.sha256sum] = "207b49273e2f266cc458153d90396e28f518c45cfe2bcbf775ca1e22be9c182f"

URI_x86_64_v2_kf6-modemmanager-qt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-modemmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-modemmanager-qt-doc}"
SRC_URI[x86_64_v2_kf6-modemmanager-qt-doc.sha256sum] = "1f34689e4262865f65b1672d91896dedda7cf00a16f1a524d9fe880cb60b04e2"

URI_x86_64_v2_kf6-modemmanager-qt-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-modemmanager-qt-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-modemmanager-qt-html}"
SRC_URI[x86_64_v2_kf6-modemmanager-qt-html.sha256sum] = "ac24468fa4395ed8f605558211a295fe839979dc0c3b9b564d393f600c63b15f"

URI_aarch64_kf6-modemmanager-qt = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-modemmanager-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-modemmanager-qt}"
SRC_URI[aarch64_kf6-modemmanager-qt.sha256sum] = "b16c83f4167e57d4180d1c5dbbc6cf96fabf70fda54c834173ec4e0742a5acb1"

URI_aarch64_kf6-modemmanager-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-modemmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-modemmanager-qt-devel}"
SRC_URI[aarch64_kf6-modemmanager-qt-devel.sha256sum] = "eafc697c23676b3239fc7cdf68ca8f5a6ceec3c4c51ddbf7361f548e2cfc9e74"

URI_aarch64_kf6-modemmanager-qt-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-modemmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-modemmanager-qt-doc}"
SRC_URI[aarch64_kf6-modemmanager-qt-doc.sha256sum] = "1a6cfb44974513eecd961eb3096130287c095f6686a9ac8e04a1c2ec452dc2c5"

URI_aarch64_kf6-modemmanager-qt-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-modemmanager-qt-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-modemmanager-qt-html}"
SRC_URI[aarch64_kf6-modemmanager-qt-html.sha256sum] = "c17764e3cbb1c95f6d5dc54d4bcc62dada4e9bdd33f8ddec65f7864692ad5e6e"

RDEPENDS:kf6-modemmanager-qt = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-modemmanager-qt-devel = " \
 ModemManager-devel \
 cmake-filesystem \
 kf6-modemmanager-qt \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-modemmanager-qt-doc = " \
 "
RDEPENDS:kf6-modemmanager-qt-html = " \
 "
