# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ibus-anthy"
PV = "1.5.17"
PR = "2.el10"
PACKAGES = " \
 ibus-anthy \
 ibus-anthy-python \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ibus-anthy-1.5.17-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a288abe6a1040c2b8b0fa02e9c6f344cd0d8aaffe2bda6c74291d3c400b935d2"

URI_x86_64_v2_ibus-anthy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-anthy-1.5.17-2.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-anthy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-anthy}"
SRC_URI[x86_64_v2_ibus-anthy.sha256sum] = "6147c4070f26c2617c59fb13f9ea87f82227c554ef1e8a6da3e6c1198d99531b"

URI_x86_64_v2_ibus-anthy-python = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-anthy-python-1.5.17-2.el10.noarch.rpm;name=x86_64_v2_ibus-anthy-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-anthy-python}"
SRC_URI[x86_64_v2_ibus-anthy-python.sha256sum] = "9531515cb20eaedc8aac399f713158ed60857d1346fc066a46b2e6c87bdd6f23"

URI_aarch64_ibus-anthy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-anthy-1.5.17-2.el10.aarch64.rpm;name=aarch64_ibus-anthy;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-anthy}"
SRC_URI[aarch64_ibus-anthy.sha256sum] = "5d48240d782f9607d1ea5799b024c3fa692561bb0e92254872d17e34f0ca8d04"

URI_aarch64_ibus-anthy-python = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-anthy-python-1.5.17-2.el10.noarch.rpm;name=aarch64_ibus-anthy-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-anthy-python}"
SRC_URI[aarch64_ibus-anthy-python.sha256sum] = "9531515cb20eaedc8aac399f713158ed60857d1346fc066a46b2e6c87bdd6f23"

RDEPENDS:ibus-anthy = " \
 anthy-unicode \
 glib2 \
 glibc \
 ibus \
 ibus-anthy-python \
 kasumi-unicode \
 "
RDEPENDS:ibus-anthy-python = " \
 bash \
 gtk3 \
 ibus-anthy \
 python3-cairo \
 python3-gobject \
 "
