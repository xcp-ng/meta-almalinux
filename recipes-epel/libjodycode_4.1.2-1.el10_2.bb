# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libjodycode"
PV = "4.1.2"
PR = "1.el10_2"
PACKAGES = " \
 libjodycode \
 libjodycode-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libjodycode-4.1.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0b8d14cf1d1e6bdccb722a4a6bda1526dbc04c3a6e5b8f67dbb349f4fc86e4c"

URI_x86_64_v2_libjodycode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjodycode-4.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjodycode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjodycode}"
SRC_URI[x86_64_v2_libjodycode.sha256sum] = "0ac92899b4068129c573eb9de4f5d55cd84b104e30bcef3579542c631fac1aba"

URI_x86_64_v2_libjodycode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjodycode-devel-4.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjodycode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjodycode-devel}"
SRC_URI[x86_64_v2_libjodycode-devel.sha256sum] = "a44bcad31172fe6782eb688b7ed41a4ac65d14eb44b74778d9f0bc7a16576535"

URI_aarch64_libjodycode = "${EPEL_MIRROR}/aarch64/Packages/l/libjodycode-4.1.2-1.el10_2.aarch64.rpm;name=aarch64_libjodycode;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjodycode}"
SRC_URI[aarch64_libjodycode.sha256sum] = "d3195f496e07d925524260743634a2372fdbbff840408a4f9ce8d3fca288f851"

URI_aarch64_libjodycode-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libjodycode-devel-4.1.2-1.el10_2.aarch64.rpm;name=aarch64_libjodycode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjodycode-devel}"
SRC_URI[aarch64_libjodycode-devel.sha256sum] = "9185fafb67020a367e54f130e7fd1b163727179ef45fc3f8f1dffaf2d17b8efb"

RDEPENDS:libjodycode = " \
 glibc \
 "
RDEPENDS:libjodycode-devel = " \
 libjodycode \
 "
