# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-json-post"
PV = "1.1.0"
PR = "15.el10_0"
PACKAGES = " \
 php-pecl-json-post \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-json-post-1.1.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f435e549f92594771611fc8191e1d023bf03c7c2c05165fcf70c64be9180acd4"

URI_x86_64_v2_php-pecl-json-post = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-json-post-1.1.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-json-post;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-json-post}"
SRC_URI[x86_64_v2_php-pecl-json-post.sha256sum] = "095a11ea1a6db166034618f897114cecf75b27c8206b08b403b631f91effe524"

URI_aarch64_php-pecl-json-post = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-json-post-1.1.0-15.el10_0.aarch64.rpm;name=aarch64_php-pecl-json-post;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-json-post}"
SRC_URI[aarch64_php-pecl-json-post.sha256sum] = "d94e86e5bb41a95bf2581d07fc7613ebbe9ff7b9871412b35dae1a173e3a8016"

RDEPENDS:php-pecl-json-post = " \
 glibc \
 php-common \
 "
