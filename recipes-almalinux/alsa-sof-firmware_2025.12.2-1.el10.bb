# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alsa-sof-firmware"
PV = "2025.12.2"
PR = "1.el10"
PACKAGES = " \
 alsa-sof-firmware \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/alsa-sof-firmware-2025.12.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cf9302f60c62a8b119def82e4d4a5f27f7fd73ad2beeec0b7ae26e795634577"

URI_x86_64_v2_alsa-sof-firmware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-sof-firmware-2025.12.2-1.el10.noarch.rpm;name=x86_64_v2_alsa-sof-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alsa-sof-firmware}"
SRC_URI[x86_64_v2_alsa-sof-firmware.sha256sum] = "c19718bdb34a54911a12fd9ab4a3e15c67be28a6f157989402cf9f99ac2b1ea4"

URI_aarch64_alsa-sof-firmware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-sof-firmware-2025.12.2-1.el10.noarch.rpm;name=aarch64_alsa-sof-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_alsa-sof-firmware}"
SRC_URI[aarch64_alsa-sof-firmware.sha256sum] = "c19718bdb34a54911a12fd9ab4a3e15c67be28a6f157989402cf9f99ac2b1ea4"

RDEPENDS:alsa-sof-firmware = " \
 "
