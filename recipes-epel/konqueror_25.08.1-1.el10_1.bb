# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konqueror"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 konqueror \
 konqueror-devel \
 konqueror-libs \
 kwebenginepart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/konqueror-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c1bcb72bac6f1cf20254c6d63f2f036c66c31b52c7faab9ef00a0a1becb1fa0"

URI_x86_64_v2_konqueror = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konqueror-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konqueror;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konqueror}"
SRC_URI[x86_64_v2_konqueror.sha256sum] = "af228641fc8f3a5e80188b35c70b2ee9f372533216f4209e910f869db5d16b1b"

URI_x86_64_v2_konqueror-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konqueror-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konqueror-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konqueror-devel}"
SRC_URI[x86_64_v2_konqueror-devel.sha256sum] = "b67532a817495ac6ea3e301bfdb98895bae23786f088f4c6ffa691ede6a976c3"

URI_x86_64_v2_konqueror-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konqueror-libs-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konqueror-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konqueror-libs}"
SRC_URI[x86_64_v2_konqueror-libs.sha256sum] = "549fc053533dedf85764b4cb1f027ede62c7d94147101d794d9cd8fbf128ed60"

URI_x86_64_v2_kwebenginepart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwebenginepart-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwebenginepart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwebenginepart}"
SRC_URI[x86_64_v2_kwebenginepart.sha256sum] = "003678436cb88404debf3d860c1aaf572b7b861aebaa1ca8305cbb35476c37bf"

URI_aarch64_konqueror = "${EPEL_MIRROR}/aarch64/Packages/k/konqueror-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_konqueror;unpack=0"
SRC_URI:append = " ${URI_aarch64_konqueror}"
SRC_URI[aarch64_konqueror.sha256sum] = "79fa52433bcd21cccc29c41dae20cb3e6a836e43e57f792ae2f66ed2486bdd4a"

URI_aarch64_konqueror-devel = "${EPEL_MIRROR}/aarch64/Packages/k/konqueror-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_konqueror-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_konqueror-devel}"
SRC_URI[aarch64_konqueror-devel.sha256sum] = "1cecde361f66b732920ff5087903027dd21f7c92d5af51c8d3599b7c84945dc8"

URI_aarch64_konqueror-libs = "${EPEL_MIRROR}/aarch64/Packages/k/konqueror-libs-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_konqueror-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_konqueror-libs}"
SRC_URI[aarch64_konqueror-libs.sha256sum] = "3ff12cf29e4f07c92828b4f20328316f411e2ccce78dd756b08a07ddc1ebe42d"

URI_aarch64_kwebenginepart = "${EPEL_MIRROR}/aarch64/Packages/k/kwebenginepart-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kwebenginepart;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwebenginepart}"
SRC_URI[aarch64_kwebenginepart.sha256sum] = "38f2a85225d648d537bbd6ffa123a26a126057977efcf2d4b4f12ad6921ee155"

RDEPENDS:konqueror = " \
 glibc \
 hicolor-icon-theme \
 keditbookmarks \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 konqueror-libs \
 kwebenginepart \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:konqueror-devel = " \
 cmake-filesystem \
 konqueror \
 konqueror-libs \
 "
RDEPENDS:konqueror-libs = " \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdesu \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 konqueror \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 zlib-ng-compat \
 "
RDEPENDS:kwebenginepart = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 konqueror-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
