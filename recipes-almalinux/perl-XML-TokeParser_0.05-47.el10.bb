# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-TokeParser"
PV = "0.05"
PR = "47.el10"
PACKAGES = " \
 perl-XML-TokeParser \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-XML-TokeParser-0.05-47.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcbcf7291e6dd217bd1bc8a67aa3922a2e3db04991ab7f65ef9a603899afe292"

URI_x86_64_v2_perl-XML-TokeParser = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-XML-TokeParser-0.05-47.el10.noarch.rpm;name=x86_64_v2_perl-XML-TokeParser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-TokeParser}"
SRC_URI[x86_64_v2_perl-XML-TokeParser.sha256sum] = "7118023b224c4f7e927c6168c0350b8a79b4e95a115295356f6053935e15ca85"

URI_aarch64_perl-XML-TokeParser = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-XML-TokeParser-0.05-47.el10.noarch.rpm;name=aarch64_perl-XML-TokeParser;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-TokeParser}"
SRC_URI[aarch64_perl-XML-TokeParser.sha256sum] = "7118023b224c4f7e927c6168c0350b8a79b4e95a115295356f6053935e15ca85"

RDEPENDS:perl-XML-TokeParser = " \
 perl-Carp \
 perl-IO \
 perl-XML-Catalog \
 perl-XML-Parser \
 perl-libs \
 perl-vars \
 "
