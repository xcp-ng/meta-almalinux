# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "slowhttptest"
PV = "1.9.0"
PR = "6.el10_0"
PACKAGES = " \
 slowhttptest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/slowhttptest-1.9.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce0fd3affd853fffec1667f68e700c38d477a7a397c32059286bd38a4a6e420c"

URI_x86_64_v2_slowhttptest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slowhttptest-1.9.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slowhttptest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slowhttptest}"
SRC_URI[x86_64_v2_slowhttptest.sha256sum] = "541d9ca63de4d3e476be3d3340b86b7d9028ea496a6ddf59053fa3996cc51614"

URI_aarch64_slowhttptest = "${EPEL_MIRROR}/aarch64/Packages/s/slowhttptest-1.9.0-6.el10_0.aarch64.rpm;name=aarch64_slowhttptest;unpack=0"
SRC_URI:append = " ${URI_aarch64_slowhttptest}"
SRC_URI[aarch64_slowhttptest.sha256sum] = "46c7b4bbf56fab0f0b3be18af9a6c1223642461b1b03a142709e8474d3647505"

RDEPENDS:slowhttptest = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 "
