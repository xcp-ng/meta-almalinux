# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ndarray"
PV = "0.16.1"
PR = "4.el10_2"
PACKAGES = " \
 rust-ndarray+approx-devel \
 rust-ndarray+default-devel \
 rust-ndarray+matrixmultiply-threading-devel \
 rust-ndarray+portable-atomic-critical-section-devel \
 rust-ndarray+rayon-devel \
 rust-ndarray+serde-devel \
 rust-ndarray+std-devel \
 rust-ndarray+test-devel \
 rust-ndarray-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ndarray-0.16.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c854866f722a1800f6e40f2afe7231abe4901ba84cf8954a5fa20c73e67f3fe4"

URI_x86_64_v2_rust-ndarray+approx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+approx-devel-0.16.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+approx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+approx-devel}"
SRC_URI[x86_64_v2_rust-ndarray+approx-devel.sha256sum] = "4e57b9aa17405f9871d05100118e8ca1b5a64bb4c712037172fda04aad0087ab"

URI_x86_64_v2_rust-ndarray+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+default-devel-0.16.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+default-devel}"
SRC_URI[x86_64_v2_rust-ndarray+default-devel.sha256sum] = "ff29eb685cb9e4a78d489754e30742cc8dd3d2736bef77549dd9b16a41bf67ab"

URI_x86_64_v2_rust-ndarray+matrixmultiply-threading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+matrixmultiply-threading-devel-0.16.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+matrixmultiply-threading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+matrixmultiply-threading-devel}"
SRC_URI[x86_64_v2_rust-ndarray+matrixmultiply-threading-devel.sha256sum] = "d3a9d71a2ab393d949a7f40b356b4bb647eef7c02c43b1d71b4faabb3cd33b18"

URI_x86_64_v2_rust-ndarray+portable-atomic-critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+portable-atomic-critical-section-devel-0.16.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+portable-atomic-critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+portable-atomic-critical-section-devel}"
SRC_URI[x86_64_v2_rust-ndarray+portable-atomic-critical-section-devel.sha256sum] = "3a85c06e1ae3e21a94df8e29fa89538dd3b9e98b04ae54b512d4917ba31c5a33"

URI_x86_64_v2_rust-ndarray+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+rayon-devel-0.16.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+rayon-devel}"
SRC_URI[x86_64_v2_rust-ndarray+rayon-devel.sha256sum] = "980899072490fb7af987f91487ed3327569b66a7945d30cc820cd62134c39fd7"

URI_x86_64_v2_rust-ndarray+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+serde-devel-0.16.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+serde-devel}"
SRC_URI[x86_64_v2_rust-ndarray+serde-devel.sha256sum] = "912cd88718a4fe73f2c3c7c27cd7f1ca976dae2d8eb8fb117632b2227bdc4142"

URI_x86_64_v2_rust-ndarray+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+std-devel-0.16.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+std-devel}"
SRC_URI[x86_64_v2_rust-ndarray+std-devel.sha256sum] = "54ad10320b53a63961b3621683b68145c107234ece477685591b550cfe8824c1"

URI_x86_64_v2_rust-ndarray+test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray+test-devel-0.16.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray+test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray+test-devel}"
SRC_URI[x86_64_v2_rust-ndarray+test-devel.sha256sum] = "afa872fe57004eb382637727635ac4f00071e633c6408ad90583b8d0af26d0aa"

URI_x86_64_v2_rust-ndarray-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ndarray-devel-0.16.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ndarray-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ndarray-devel}"
SRC_URI[x86_64_v2_rust-ndarray-devel.sha256sum] = "3d6add3429db601fe6497ea28a587b5bf63c2b0d2e4c52cc8225245174daacdc"

URI_aarch64_rust-ndarray+approx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+approx-devel-0.16.1-4.el10_2.noarch.rpm;name=aarch64_rust-ndarray+approx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+approx-devel}"
SRC_URI[aarch64_rust-ndarray+approx-devel.sha256sum] = "fd7759885e762a0282ff363a751d25c3c464765cee6878a2e1d89bb6b3c925f4"

URI_aarch64_rust-ndarray+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+default-devel-0.16.1-4.el10_2.noarch.rpm;name=aarch64_rust-ndarray+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+default-devel}"
SRC_URI[aarch64_rust-ndarray+default-devel.sha256sum] = "20b47d9df3c4512d9a8db11c2a23e77d0e6486c4e8ce628495fb0a98f3108f6b"

URI_aarch64_rust-ndarray+matrixmultiply-threading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+matrixmultiply-threading-devel-0.16.1-4.el10_2.noarch.rpm;name=aarch64_rust-ndarray+matrixmultiply-threading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+matrixmultiply-threading-devel}"
SRC_URI[aarch64_rust-ndarray+matrixmultiply-threading-devel.sha256sum] = "c51cc9893c91585e673bf8947c06e879f951d7c0e8a160259e573d612938bc36"

URI_aarch64_rust-ndarray+portable-atomic-critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+portable-atomic-critical-section-devel-0.16.1-4.el10_2.noarch.rpm;name=aarch64_rust-ndarray+portable-atomic-critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+portable-atomic-critical-section-devel}"
SRC_URI[aarch64_rust-ndarray+portable-atomic-critical-section-devel.sha256sum] = "37d646d95e5c579748f3b3eec853d9c3b8f60ec2797d9b08edaa23c58796e2c8"

URI_aarch64_rust-ndarray+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+rayon-devel-0.16.1-4.el10_2.noarch.rpm;name=aarch64_rust-ndarray+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+rayon-devel}"
SRC_URI[aarch64_rust-ndarray+rayon-devel.sha256sum] = "7a3bf7a7df206154ab3fa79c81961ea9abf52a8f37f367101d69abc10e68b366"

URI_aarch64_rust-ndarray+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+serde-devel-0.16.1-4.el10_2.noarch.rpm;name=aarch64_rust-ndarray+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+serde-devel}"
SRC_URI[aarch64_rust-ndarray+serde-devel.sha256sum] = "b91e17173ac81dc9eef87963549ad057f6691722e19a41753230be4298dcfe9f"

URI_aarch64_rust-ndarray+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+std-devel-0.16.1-4.el10_2.noarch.rpm;name=aarch64_rust-ndarray+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+std-devel}"
SRC_URI[aarch64_rust-ndarray+std-devel.sha256sum] = "d55e9eaacdf2333c2ec0354fb94d1e93a54a7cd0f2e24cf026658674576805b4"

URI_aarch64_rust-ndarray+test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray+test-devel-0.16.1-4.el10_2.noarch.rpm;name=aarch64_rust-ndarray+test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray+test-devel}"
SRC_URI[aarch64_rust-ndarray+test-devel.sha256sum] = "3bdf651504db9a94274acea4388e7b9c0d785e3142f7b7b8dab2c20f6327ede1"

URI_aarch64_rust-ndarray-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ndarray-devel-0.16.1-4.el10_2.noarch.rpm;name=aarch64_rust-ndarray-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ndarray-devel}"
SRC_URI[aarch64_rust-ndarray-devel.sha256sum] = "d7c380880bd7775fa4223f78a9f5ba75c115a3b31145cd44920af5fb97c63b79"

RDEPENDS:rust-ndarray+approx-devel = " \
 cargo \
 rust-approx-devel \
 rust-ndarray-devel \
 "
RDEPENDS:rust-ndarray+default-devel = " \
 cargo \
 rust-ndarray+std-devel \
 rust-ndarray-devel \
 "
RDEPENDS:rust-ndarray+matrixmultiply-threading-devel = " \
 cargo \
 rust-matrixmultiply+threading-devel \
 rust-ndarray-devel \
 "
RDEPENDS:rust-ndarray+portable-atomic-critical-section-devel = " \
 cargo \
 rust-ndarray-devel \
 "
RDEPENDS:rust-ndarray+rayon-devel = " \
 cargo \
 rust-ndarray+std-devel \
 rust-ndarray-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-ndarray+serde-devel = " \
 cargo \
 rust-ndarray-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ndarray+std-devel = " \
 cargo \
 rust-matrixmultiply+std-devel \
 rust-ndarray-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-ndarray+test-devel = " \
 cargo \
 rust-ndarray-devel \
 "
RDEPENDS:rust-ndarray-devel = " \
 cargo \
 rust \
 rust-matrixmultiply+cgemm-devel \
 rust-matrixmultiply-devel \
 rust-num-complex-devel \
 rust-num-integer-devel \
 rust-num-traits-devel \
 rust-rawpointer+default-devel \
 "
