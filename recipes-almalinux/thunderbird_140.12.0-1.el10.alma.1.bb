# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "thunderbird"
PV = "140.12.0"
PR = "1.el10.alma.1"
PACKAGES = " \
 thunderbird \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/thunderbird-140.12.0-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "860a1a0c49d37de06872e1bcaedb0fd07ac3ed78817436a263417979a5606b09"

URI_x86_64_v2_thunderbird = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/thunderbird-140.12.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_thunderbird;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_thunderbird}"
SRC_URI[x86_64_v2_thunderbird.sha256sum] = "3c599f2966af78e1b77262a821f1b204d0ed0a22f82a4af788975adc795bb285"

URI_aarch64_thunderbird = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/thunderbird-140.12.0-1.el10.alma.1.aarch64.rpm;name=aarch64_thunderbird;unpack=0"
SRC_URI:append = " ${URI_aarch64_thunderbird}"
SRC_URI[aarch64_thunderbird.sha256sum] = "0dc58f21bd8749199ea6d1b05d831ca8c3caa99c1e3b44ca398cb487aff96a7d"

RDEPENDS:thunderbird = " \
 alsa-lib \
 atk \
 bash \
 bzip2-libs \
 cairo \
 cairo-gobject \
 dbus-libs \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libX11 \
 libX11-xcb \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXrandr \
 libXrender \
 libffi \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 libxcb \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 p11-kit-trust \
 pango \
 pciutils-libs \
 zlib-ng-compat \
 "
