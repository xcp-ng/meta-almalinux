# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fluidsynth"
PV = "2.4.2"
PR = "1.el10_0"
PACKAGES = " \
 fluidsynth \
 fluidsynth-devel \
 fluidsynth-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fluidsynth-2.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "661268c129530baa8940ea59c0cbb092df982be145459d788dc0764f44e0247d"

URI_x86_64_v2_fluidsynth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fluidsynth-2.4.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fluidsynth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fluidsynth}"
SRC_URI[x86_64_v2_fluidsynth.sha256sum] = "4c842caa13bcbc9ef5dbf6d7436dad2a3b72d0915ca906adc73c36c700d53e78"

URI_x86_64_v2_fluidsynth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fluidsynth-devel-2.4.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fluidsynth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fluidsynth-devel}"
SRC_URI[x86_64_v2_fluidsynth-devel.sha256sum] = "1c0a1386108edfea7448549c29892b44291b3e9996329f3239cffa9ce631ab58"

URI_x86_64_v2_fluidsynth-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fluidsynth-libs-2.4.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fluidsynth-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fluidsynth-libs}"
SRC_URI[x86_64_v2_fluidsynth-libs.sha256sum] = "ad90e040bd5e79860f238a6ce6213fb1e4f275318d5c9757d7068daf286df9fb"

URI_aarch64_fluidsynth = "${EPEL_MIRROR}/aarch64/Packages/f/fluidsynth-2.4.2-1.el10_0.aarch64.rpm;name=aarch64_fluidsynth;unpack=0"
SRC_URI:append = " ${URI_aarch64_fluidsynth}"
SRC_URI[aarch64_fluidsynth.sha256sum] = "e4ee819660ff63f7ce335cb368e96e6daaf9a72bb85301a67ddd0da4ea2e5de4"

URI_aarch64_fluidsynth-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fluidsynth-devel-2.4.2-1.el10_0.aarch64.rpm;name=aarch64_fluidsynth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fluidsynth-devel}"
SRC_URI[aarch64_fluidsynth-devel.sha256sum] = "135a5a4004e26768701cf1143ca3e003b9ab3be1141f7f70fcfadae763ea0f87"

URI_aarch64_fluidsynth-libs = "${EPEL_MIRROR}/aarch64/Packages/f/fluidsynth-libs-2.4.2-1.el10_0.aarch64.rpm;name=aarch64_fluidsynth-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fluidsynth-libs}"
SRC_URI[aarch64_fluidsynth-libs.sha256sum] = "159b095456dd67df38b9956459655abda4d90795ba9bd78327265005efd14834"

RDEPENDS:fluidsynth = " \
 fluidsynth-libs \
 glib2 \
 glibc \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:fluidsynth-devel = " \
 alsa-lib-devel \
 cmake-filesystem \
 dbus-devel \
 fluidsynth \
 fluidsynth-libs \
 glib2-devel \
 libinstpatch-devel \
 libsndfile-devel \
 pipewire-devel \
 pipewire-jack-audio-connection-kit-devel \
 pkgconf-pkg-config \
 pulseaudio-libs-devel \
 readline-devel \
 systemd-devel \
 "
RDEPENDS:fluidsynth-libs = " \
 alsa-lib \
 dbus-libs \
 glib2 \
 glibc \
 libgcc \
 libgomp \
 libinstpatch \
 libsndfile \
 libstdc++ \
 pipewire-jack-audio-connection-kit-libs \
 pipewire-libs \
 pulseaudio-libs \
 readline \
 "
