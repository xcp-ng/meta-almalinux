# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-SessionData"
PV = "1.03"
PR = "26.el10_0"
PACKAGES = " \
 perl-IO-SessionData \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IO-SessionData-1.03-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "216939fdc16443a50318c17c939d4111da1e8ac80cbc173380188767d59125cf"

URI_x86_64_v2_perl-IO-SessionData = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IO-SessionData-1.03-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-IO-SessionData;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-SessionData}"
SRC_URI[x86_64_v2_perl-IO-SessionData.sha256sum] = "2f97cda0e5ba9dbafaf726a17effcafc1c6f951115396e69294e1afd0284269b"

URI_aarch64_perl-IO-SessionData = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IO-SessionData-1.03-26.el10_0.noarch.rpm;name=aarch64_perl-IO-SessionData;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-SessionData}"
SRC_URI[aarch64_perl-IO-SessionData.sha256sum] = "ca971d2ba3ab0221d47b757f20811cd53c5393e1080bc01df88842a36658d8e3"

RDEPENDS:perl-IO-SessionData = " \
 perl-Carp \
 perl-Errno \
 perl-IO \
 perl-IO-SessionData \
 perl-POSIX \
 perl-constant \
 perl-libs \
 perl-vars \
 "
