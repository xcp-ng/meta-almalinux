# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crypto-bigint0.5"
PV = "0.5.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-crypto-bigint0.5+alloc-devel \
 rust-crypto-bigint0.5+default-devel \
 rust-crypto-bigint0.5+der-devel \
 rust-crypto-bigint0.5+extra-sizes-devel \
 rust-crypto-bigint0.5+generic-array-devel \
 rust-crypto-bigint0.5+rand-devel \
 rust-crypto-bigint0.5+rand_core-devel \
 rust-crypto-bigint0.5+serde-devel \
 rust-crypto-bigint0.5+zeroize-devel \
 rust-crypto-bigint0.5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crypto-bigint0.5-0.5.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92b6d1833708fb14ff93fdccb5f76dec3670d16dc092d0727555b93c9b909b33"

URI_x86_64_v2_rust-crypto-bigint0.5+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint0.5+alloc-devel-0.5.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint0.5+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint0.5+alloc-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint0.5+alloc-devel.sha256sum] = "ebf28514122619a8dc2d8e1f84b0037bd6b27d2592b13fd3cacba1299bf71bdc"

URI_x86_64_v2_rust-crypto-bigint0.5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint0.5+default-devel-0.5.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint0.5+default-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint0.5+default-devel.sha256sum] = "f2c4e1b58e842942e4365f14c0b6fda5d6a922d4776fc49baf6c8a04f5c9dd1e"

URI_x86_64_v2_rust-crypto-bigint0.5+der-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint0.5+der-devel-0.5.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint0.5+der-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint0.5+der-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint0.5+der-devel.sha256sum] = "2ad0a8c5f4f5829f42e293ac6edd7e9b26d746f7669797ceed9b35d7582ba937"

URI_x86_64_v2_rust-crypto-bigint0.5+extra-sizes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint0.5+extra-sizes-devel-0.5.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint0.5+extra-sizes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint0.5+extra-sizes-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint0.5+extra-sizes-devel.sha256sum] = "2b842ba7d42e5ce85ba1eaad54dad792d832559236ae2502c0877cf9be6e06d0"

URI_x86_64_v2_rust-crypto-bigint0.5+generic-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint0.5+generic-array-devel-0.5.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint0.5+generic-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint0.5+generic-array-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint0.5+generic-array-devel.sha256sum] = "dd09c5854b21e41f9aa90bf1fa805c663bde6000b3e4867a512c5447935eca22"

URI_x86_64_v2_rust-crypto-bigint0.5+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint0.5+rand-devel-0.5.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint0.5+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint0.5+rand-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint0.5+rand-devel.sha256sum] = "08c096e0e11d4e7c576039a55bb16a9446fc7456fc7e31196e0cd811453abd2e"

URI_x86_64_v2_rust-crypto-bigint0.5+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint0.5+rand_core-devel-0.5.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint0.5+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint0.5+rand_core-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint0.5+rand_core-devel.sha256sum] = "d3f1a46e58f6a2d7f33b0cace28225470ed5e58efb18eb65fb3d84671feb54e1"

URI_x86_64_v2_rust-crypto-bigint0.5+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint0.5+serde-devel-0.5.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint0.5+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint0.5+serde-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint0.5+serde-devel.sha256sum] = "7bf6d231214a39ed88780a248124c8a0feba2812cd446da8580e7b4163fd23f2"

URI_x86_64_v2_rust-crypto-bigint0.5+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint0.5+zeroize-devel-0.5.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint0.5+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint0.5+zeroize-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint0.5+zeroize-devel.sha256sum] = "90ee854f2bb87a80a3d0d8f08e3852a5ef052a1877f10e122c56ff6617a21f1b"

URI_x86_64_v2_rust-crypto-bigint0.5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint0.5-devel-0.5.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint0.5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint0.5-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint0.5-devel.sha256sum] = "310b9bde3ea7dc1fa097f377719c0d2499b50bde97c8c70e19e97583aa748035"

URI_aarch64_rust-crypto-bigint0.5+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint0.5+alloc-devel-0.5.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint0.5+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint0.5+alloc-devel}"
SRC_URI[aarch64_rust-crypto-bigint0.5+alloc-devel.sha256sum] = "d41d53f13defa509facac36a1655d134fd01cfcbd368dc51ba50844681a964b7"

URI_aarch64_rust-crypto-bigint0.5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint0.5+default-devel-0.5.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint0.5+default-devel}"
SRC_URI[aarch64_rust-crypto-bigint0.5+default-devel.sha256sum] = "0a3822160ad14ed4396cd2af4a58cf56528440d5b5a71ef77c2f0db854af14d2"

URI_aarch64_rust-crypto-bigint0.5+der-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint0.5+der-devel-0.5.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint0.5+der-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint0.5+der-devel}"
SRC_URI[aarch64_rust-crypto-bigint0.5+der-devel.sha256sum] = "11d29094d426a6cbca67690ee6a4c18347edfc067a463dbca513e9993232fed3"

URI_aarch64_rust-crypto-bigint0.5+extra-sizes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint0.5+extra-sizes-devel-0.5.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint0.5+extra-sizes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint0.5+extra-sizes-devel}"
SRC_URI[aarch64_rust-crypto-bigint0.5+extra-sizes-devel.sha256sum] = "8e51abe4e8b461324db85ca9b9f40e619c9554f75a3d8bf77e971354ddf575a2"

URI_aarch64_rust-crypto-bigint0.5+generic-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint0.5+generic-array-devel-0.5.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint0.5+generic-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint0.5+generic-array-devel}"
SRC_URI[aarch64_rust-crypto-bigint0.5+generic-array-devel.sha256sum] = "c546bb5ea9030349d974bc91cdcb2d8dd9312eb7fc158ad772d1fd3acf896e08"

URI_aarch64_rust-crypto-bigint0.5+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint0.5+rand-devel-0.5.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint0.5+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint0.5+rand-devel}"
SRC_URI[aarch64_rust-crypto-bigint0.5+rand-devel.sha256sum] = "3d029e47e6bb4f1c8f889a7095c7279ba313f7b0a53320342f43928484eb581a"

URI_aarch64_rust-crypto-bigint0.5+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint0.5+rand_core-devel-0.5.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint0.5+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint0.5+rand_core-devel}"
SRC_URI[aarch64_rust-crypto-bigint0.5+rand_core-devel.sha256sum] = "c72e58d6303133b58167799996883ae950e2e4bdd1940b1f73ddb017ee170613"

URI_aarch64_rust-crypto-bigint0.5+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint0.5+serde-devel-0.5.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint0.5+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint0.5+serde-devel}"
SRC_URI[aarch64_rust-crypto-bigint0.5+serde-devel.sha256sum] = "dcc0252fd37a7cecef39692d795909d9062e024d3488ad9f8910393fcf9bd173"

URI_aarch64_rust-crypto-bigint0.5+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint0.5+zeroize-devel-0.5.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint0.5+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint0.5+zeroize-devel}"
SRC_URI[aarch64_rust-crypto-bigint0.5+zeroize-devel.sha256sum] = "51ae5b0dfe3b3a236ccf47d6945fb43a56b86d78761acfd25d4b6498a24e1a5c"

URI_aarch64_rust-crypto-bigint0.5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint0.5-devel-0.5.5-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-bigint0.5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint0.5-devel}"
SRC_URI[aarch64_rust-crypto-bigint0.5-devel.sha256sum] = "03aafafc36e862d76c695995a2102d3b79ad0ba2c8e20b72bc60d23f59bb4bb1"

RDEPENDS:rust-crypto-bigint0.5+alloc-devel = " \
 cargo \
 rust-crypto-bigint0.5-devel \
 rust-serdect0.2+alloc-devel \
 rust-serdect0.2-devel \
 "
RDEPENDS:rust-crypto-bigint0.5+default-devel = " \
 cargo \
 rust-crypto-bigint0.5+rand-devel \
 rust-crypto-bigint0.5-devel \
 "
RDEPENDS:rust-crypto-bigint0.5+der-devel = " \
 cargo \
 rust-crypto-bigint0.5-devel \
 rust-der0.7-devel \
 "
RDEPENDS:rust-crypto-bigint0.5+extra-sizes-devel = " \
 cargo \
 rust-crypto-bigint0.5-devel \
 "
RDEPENDS:rust-crypto-bigint0.5+generic-array-devel = " \
 cargo \
 rust-crypto-bigint0.5-devel \
 rust-generic-array+default-devel \
 "
RDEPENDS:rust-crypto-bigint0.5+rand-devel = " \
 cargo \
 rust-crypto-bigint0.5-devel \
 rust-rand_core0.6+default-devel \
 rust-rand_core0.6+std-devel \
 "
RDEPENDS:rust-crypto-bigint0.5+rand_core-devel = " \
 cargo \
 rust-crypto-bigint0.5-devel \
 rust-rand_core0.6+default-devel \
 "
RDEPENDS:rust-crypto-bigint0.5+serde-devel = " \
 cargo \
 rust-crypto-bigint0.5-devel \
 rust-serdect0.2-devel \
 "
RDEPENDS:rust-crypto-bigint0.5+zeroize-devel = " \
 cargo \
 rust-crypto-bigint0.5-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-crypto-bigint0.5-devel = " \
 cargo \
 rust \
 rust-subtle-devel \
 "
