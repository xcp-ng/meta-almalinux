# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qrca"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 qrca \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qrca-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e25fd5bbd4a5cae7b52515a06c312acc2ee2089cacabf74be1b130e4d6808726"

URI_x86_64_v2_qrca = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qrca-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qrca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qrca}"
SRC_URI[x86_64_v2_qrca.sha256sum] = "7d660c0226942a41e784142bc160b3ac3c24251513c6da335172a0364e5840be"

URI_aarch64_qrca = "${EPEL_MIRROR}/aarch64/Packages/q/qrca-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_qrca;unpack=0"
SRC_URI:append = " ${URI_aarch64_qrca}"
SRC_URI[aarch64_qrca.sha256sum] = "6b672128c8297e923533914ec25c65a62b5a31aa9877ed0e38bfa8040b6aa576"

RDEPENDS:qrca = " \
 glibc \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kservice \
 kf6-networkmanager-qt \
 kf6-prison \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xdg-utils \
 "
