# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-editables"
PV = "0.6"
PR = "1.el10_3"
PACKAGES = " \
 python3-editables \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-editables-0.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64c628c5b069d421f4bd87af2880a0419ca374683842f6301e45731fbff83cba"

URI_x86_64_v2_python3-editables = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-editables-0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-editables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-editables}"
SRC_URI[x86_64_v2_python3-editables.sha256sum] = "f9dd2c8d3908ff1c03ca913c7541f537751d6dea52038e82c67da80384e132c2"

URI_aarch64_python3-editables = "${EPEL_MIRROR}/aarch64/Packages/p/python3-editables-0.6-1.el10_3.noarch.rpm;name=aarch64_python3-editables;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-editables}"
SRC_URI[aarch64_python3-editables.sha256sum] = "b628969bf7304ae158359c6c45b084fab4bab1fd494d27c2b2a4680f72496d28"

RDEPENDS:python3-editables = " \
 python3 \
 "
