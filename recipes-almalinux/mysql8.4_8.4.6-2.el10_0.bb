# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mysql8.4"
PV = "8.4.6"
PR = "2.el10_0"
PACKAGES = " \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-devel \
 mysql8.4-errmsg \
 mysql8.4-libs \
 mysql8.4-server \
 mysql8.4-test \
 mysql8.4-test-data \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mysql8.4-8.4.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "991631a72f7a5c8389c30a451df8635af8af7aca4ead2b3ba4045cb36dba9c63"

URI_x86_64_v2_mysql8.4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-8.4.6-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_mysql8.4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4}"
SRC_URI[x86_64_v2_mysql8.4.sha256sum] = "337d8d0d51fa08a6d168d158bc92226e99df294ba626358f8cdf5ffaf3a3a994"

URI_x86_64_v2_mysql8.4-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-common-8.4.6-2.el10_0.noarch.rpm;name=x86_64_v2_mysql8.4-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-common}"
SRC_URI[x86_64_v2_mysql8.4-common.sha256sum] = "d28d82cce2fa0c207f0c5e8a92bdda59a52bdae3c24d31c72af961bdf43f604f"

URI_x86_64_v2_mysql8.4-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mysql8.4-devel-8.4.6-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-devel}"
SRC_URI[x86_64_v2_mysql8.4-devel.sha256sum] = "b2d8ca88dde364844a23b7fd69ac90ca3d2a0974b62446c1b814026723af79f6"

URI_x86_64_v2_mysql8.4-errmsg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-errmsg-8.4.6-2.el10_0.noarch.rpm;name=x86_64_v2_mysql8.4-errmsg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-errmsg}"
SRC_URI[x86_64_v2_mysql8.4-errmsg.sha256sum] = "bb9511e88f0708b0c62e3ab0bad8bb2046dd777dd884dc213c6a8fcd2826bb08"

URI_x86_64_v2_mysql8.4-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-libs-8.4.6-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-libs}"
SRC_URI[x86_64_v2_mysql8.4-libs.sha256sum] = "ab93c783c77e346db8c31566ea0cc712cd7fff2ac989b30e0be50abd812c9322"

URI_x86_64_v2_mysql8.4-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-server-8.4.6-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-server}"
SRC_URI[x86_64_v2_mysql8.4-server.sha256sum] = "292d9eb7b1f1e5e89d9d7e4cd41dbc4a89f3f2dc801e06c9476f47ea7bc18806"

URI_x86_64_v2_mysql8.4-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mysql8.4-test-8.4.6-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-test}"
SRC_URI[x86_64_v2_mysql8.4-test.sha256sum] = "b714bad3b666486049dd5cdbf0952b0c12be71f2a7154d78dcea75597c58ca53"

URI_x86_64_v2_mysql8.4-test-data = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mysql8.4-test-data-8.4.6-2.el10_0.noarch.rpm;name=x86_64_v2_mysql8.4-test-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-test-data}"
SRC_URI[x86_64_v2_mysql8.4-test-data.sha256sum] = "634743d5badee59910d831c52ccba8e9bac6ce085620109ebb3bfa7abdc106e6"

URI_aarch64_mysql8.4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-8.4.6-2.el10_0.aarch64.rpm;name=aarch64_mysql8.4;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4}"
SRC_URI[aarch64_mysql8.4.sha256sum] = "85bd6d46a57990edad6d4727759853c2c1db0f9ecae9e3b984a85a66904876e6"

URI_aarch64_mysql8.4-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-common-8.4.6-2.el10_0.noarch.rpm;name=aarch64_mysql8.4-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-common}"
SRC_URI[aarch64_mysql8.4-common.sha256sum] = "d28d82cce2fa0c207f0c5e8a92bdda59a52bdae3c24d31c72af961bdf43f604f"

URI_aarch64_mysql8.4-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mysql8.4-devel-8.4.6-2.el10_0.aarch64.rpm;name=aarch64_mysql8.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-devel}"
SRC_URI[aarch64_mysql8.4-devel.sha256sum] = "be35d5f9414d75d65137131aeaf103384f85430a6a912acff80d6081b6e44c5c"

URI_aarch64_mysql8.4-errmsg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-errmsg-8.4.6-2.el10_0.noarch.rpm;name=aarch64_mysql8.4-errmsg;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-errmsg}"
SRC_URI[aarch64_mysql8.4-errmsg.sha256sum] = "bb9511e88f0708b0c62e3ab0bad8bb2046dd777dd884dc213c6a8fcd2826bb08"

URI_aarch64_mysql8.4-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-libs-8.4.6-2.el10_0.aarch64.rpm;name=aarch64_mysql8.4-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-libs}"
SRC_URI[aarch64_mysql8.4-libs.sha256sum] = "b85bb56855e01548ba696bba5847c0033fcdd4e5fd17f76d9b45663da8fe1d90"

URI_aarch64_mysql8.4-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-server-8.4.6-2.el10_0.aarch64.rpm;name=aarch64_mysql8.4-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-server}"
SRC_URI[aarch64_mysql8.4-server.sha256sum] = "d88111c846b4b7876f48fb985c9b52e5cad90ae61bc82fe67a533ed8e07fee7f"

URI_aarch64_mysql8.4-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mysql8.4-test-8.4.6-2.el10_0.aarch64.rpm;name=aarch64_mysql8.4-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-test}"
SRC_URI[aarch64_mysql8.4-test.sha256sum] = "296cc9c4317354f23f6b944bebf958d5bacb8960bff67f8c1004475eb024fed3"

URI_aarch64_mysql8.4-test-data = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mysql8.4-test-data-8.4.6-2.el10_0.noarch.rpm;name=aarch64_mysql8.4-test-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-test-data}"
SRC_URI[aarch64_mysql8.4-test-data.sha256sum] = "634743d5badee59910d831c52ccba8e9bac6ce085620109ebb3bfa7abdc106e6"

RDEPENDS:mysql8.4 = " \
 bash \
 glibc \
 grep \
 libedit \
 libgcc \
 libstdc++ \
 libzstd \
 mysql8.4-common \
 openssl-libs \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:mysql8.4-common = " \
 mariadb-connector-c-config \
 "
RDEPENDS:mysql8.4-devel = " \
 bash \
 libzstd-devel \
 mysql8.4-libs \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:mysql8.4-errmsg = " \
 mysql8.4-common \
 "
RDEPENDS:mysql8.4-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 mysql8.4-common \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:mysql8.4-server:x86_64_v2 = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libicu \
 libstdc++ \
 libtirpc \
 libzstd \
 lz4-libs \
 mariadb-connector-c-config \
 mecab \
 mysql-selinux \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-errmsg \
 numactl-libs \
 openssl-libs \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 policycoreutils-python-utils \
 protobuf-lite \
 shadow-utils \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:mysql8.4-server:aarch64 = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libicu \
 libstdc++ \
 libtirpc \
 libzstd \
 lz4-libs \
 mariadb-connector-c-config \
 mecab \
 mysql-selinux \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-errmsg \
 openssl-libs \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 policycoreutils-python-utils \
 protobuf-lite \
 shadow-utils \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:mysql8.4-test = " \
 bash \
 glibc \
 gzip \
 libgcc \
 libstdc++ \
 libzstd \
 lz4 \
 lz4-libs \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-server \
 mysql8.4-test-data \
 openssl \
 openssl-libs \
 perl-Data-Dumper \
 perl-Digest \
 perl-Digest-MD5 \
 perl-Env \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Compare \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-JSON \
 perl-Memoize \
 perl-Socket \
 perl-Sys-Hostname \
 perl-Test-Simple \
 perl-Time-HiRes \
 perl-libwww-perl \
 protobuf \
 zlib-ng-compat \
 "
RDEPENDS:mysql8.4-test-data = " \
 bash \
 mysql8.4-test \
 perl-Carp \
 perl-Data-Dumper \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IO \
 perl-JSON \
 perl-Memoize \
 perl-POSIX \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Test-Simple \
 perl-Time \
 perl-Time-HiRes \
 perl-base \
 perl-constant \
 perl-if \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 perl-threads \
 perl-threads-shared \
 "
