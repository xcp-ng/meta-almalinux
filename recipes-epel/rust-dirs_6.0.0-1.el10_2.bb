# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dirs"
PV = "6.0.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-dirs+default-devel \
 rust-dirs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dirs-6.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17f2be4c65cb117485dd8d5cb517256ed09dd3ff9f2db98370f9cb2ac75c58bc"

URI_x86_64_v2_rust-dirs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dirs+default-devel-6.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dirs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dirs+default-devel}"
SRC_URI[x86_64_v2_rust-dirs+default-devel.sha256sum] = "f45cbdafd4ebe5bc0333fca2103ea114027cb35e680d8e19fcdf8eb8fc3e74cb"

URI_x86_64_v2_rust-dirs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dirs-devel-6.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dirs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dirs-devel}"
SRC_URI[x86_64_v2_rust-dirs-devel.sha256sum] = "b2c7d25d02f7a100a07d0d5c2639d93679fcbd7e12112b27ee5109b2557bb46f"

URI_aarch64_rust-dirs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dirs+default-devel-6.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-dirs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dirs+default-devel}"
SRC_URI[aarch64_rust-dirs+default-devel.sha256sum] = "6e3446ad83ee1270d77fced919c734e68178040de6b6080485517868e539d02b"

URI_aarch64_rust-dirs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dirs-devel-6.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-dirs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dirs-devel}"
SRC_URI[aarch64_rust-dirs-devel.sha256sum] = "5d7bdfc8ca3ee95a571a02aeeed9c0b6f910cf97be1ecb12541b4a2543514d28"

RDEPENDS:rust-dirs+default-devel = " \
 cargo \
 rust-dirs-devel \
 "
RDEPENDS:rust-dirs-devel = " \
 cargo \
 rust-dirs-sys+default-devel \
 "
