# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "desktop-file-utils"
PV = "0.26"
PR = "14.el10"
PACKAGES = " \
 desktop-file-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/desktop-file-utils-0.26-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "776309fa5d871a706ea6784d593607b73f832549a8e211a120f778154570200c"

URI_x86_64_v2_desktop-file-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/desktop-file-utils-0.26-14.el10.x86_64_v2.rpm;name=x86_64_v2_desktop-file-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-file-utils}"
SRC_URI[x86_64_v2_desktop-file-utils.sha256sum] = "d773682c41e812d363789a14e6194fa9718a39d2fc31c268bcaac8470e8b09d1"

URI_aarch64_desktop-file-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/desktop-file-utils-0.26-14.el10.aarch64.rpm;name=aarch64_desktop-file-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-file-utils}"
SRC_URI[aarch64_desktop-file-utils.sha256sum] = "c488b752492e08c070a5f9b0b2d0e6ca31941fa20ae24e6b2fec3cb700b2c895"

RDEPENDS:desktop-file-utils = " \
 bash \
 emacs-filesystem \
 glib2 \
 glibc \
 "
