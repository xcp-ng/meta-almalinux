# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openscap"
PE = "1"
PV = "1.4.3"
PR = "1.el10_1.alma.1"
PACKAGES = " \
 openscap \
 openscap-engine-sce \
 openscap-scanner \
 openscap-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openscap-1.4.3-1.el10_1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c4d1d96809f9bbfc051eff212b0c18b60258e2a432408d5e5b71b4f84253999"

URI_x86_64_v2_openscap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-1.4.3-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap}"
SRC_URI[x86_64_v2_openscap.sha256sum] = "d58a22b54989063c08cc1a39bbb09de455cb5fb46b1b7c7a8b17e474c8955a91"

URI_x86_64_v2_openscap-engine-sce = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-engine-sce-1.4.3-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap-engine-sce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap-engine-sce}"
SRC_URI[x86_64_v2_openscap-engine-sce.sha256sum] = "fdf7dd9eeb7d377eccadaadd9002ccaf68ce1f9054f094ebf0379c42e9266a3a"

URI_x86_64_v2_openscap-scanner = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-scanner-1.4.3-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap-scanner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap-scanner}"
SRC_URI[x86_64_v2_openscap-scanner.sha256sum] = "8063b6f3d1b9fee4a48862b2e0aa7ac876d7d74b3f52efe2d55d431c6a70c3c2"

URI_x86_64_v2_openscap-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-utils-1.4.3-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap-utils}"
SRC_URI[x86_64_v2_openscap-utils.sha256sum] = "d4fba796fd5f345aa7a7f535da320621d07973db99ddb9417fcd52bedcc0055e"

URI_aarch64_openscap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-1.4.3-1.el10_1.alma.1.aarch64.rpm;name=aarch64_openscap;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap}"
SRC_URI[aarch64_openscap.sha256sum] = "93147b6fbb00f599a6330339b2c84abb50817604460aae1103b990336e4e6d0e"

URI_aarch64_openscap-engine-sce = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-engine-sce-1.4.3-1.el10_1.alma.1.aarch64.rpm;name=aarch64_openscap-engine-sce;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap-engine-sce}"
SRC_URI[aarch64_openscap-engine-sce.sha256sum] = "f094e7daca1ffad09170c18656c8226c140184fd94805532755cda3b91e09281"

URI_aarch64_openscap-scanner = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-scanner-1.4.3-1.el10_1.alma.1.aarch64.rpm;name=aarch64_openscap-scanner;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap-scanner}"
SRC_URI[aarch64_openscap-scanner.sha256sum] = "140022c4ff20da4c160ab331391b3ff3aa1445e836a52564cccbb22392de4283"

URI_aarch64_openscap-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-utils-1.4.3-1.el10_1.alma.1.aarch64.rpm;name=aarch64_openscap-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap-utils}"
SRC_URI[aarch64_openscap-utils.sha256sum] = "e360b35be9a54ba295db354d6c1bc5baf503584aa58964de8771fea9109764c1"

RDEPENDS:openscap = " \
 bash \
 bzip2-libs \
 dbus \
 dbus-libs \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libcap \
 libgcc \
 libselinux \
 libxml2 \
 libxslt \
 libyaml \
 nss \
 openldap \
 pcre2 \
 popt \
 procps-ng \
 rpm-libs \
 virtual/libcurl.so.4___64bit_ \
 xmlsec1 \
 xmlsec1-openssl \
 "
RDEPENDS:openscap-engine-sce = " \
 glibc \
 openscap \
 "
RDEPENDS:openscap-scanner = " \
 bash \
 glibc \
 openscap \
 virtual/libcurl_ge_7.12.0 \
 "
RDEPENDS:openscap-utils = " \
 bash \
 openscap \
 openscap-scanner \
 python3 \
 rpm-build \
 rpmdevtools \
 "
