# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "luit"
PV = "2.0.20240910"
PR = "5.el10_1"
PACKAGES = " \
 luit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/luit-2.0.20240910-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cbdfbb87f0a7043c9cb63b5c9de4926c5a1703931088042895e6c7dca5d8490"

URI_x86_64_v2_luit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/luit-2.0.20240910-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_luit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_luit}"
SRC_URI[x86_64_v2_luit.sha256sum] = "399274f8274801a3120dd00f692391c30b302005931cdef7a15544acfb4a7edc"

URI_aarch64_luit = "${EPEL_MIRROR}/aarch64/Packages/l/luit-2.0.20240910-5.el10_1.aarch64.rpm;name=aarch64_luit;unpack=0"
SRC_URI:append = " ${URI_aarch64_luit}"
SRC_URI[aarch64_luit.sha256sum] = "e43b052dd9f3a465f6da1075c9f433cee71df0a427eb4c43efa8a30aefb67f36"

RDEPENDS:luit = " \
 glibc \
 zlib-ng-compat \
 "
