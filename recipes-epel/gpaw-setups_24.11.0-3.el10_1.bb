# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpaw-setups"
PV = "24.11.0"
PR = "3.el10_1"
PACKAGES = " \
 gpaw-setups \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gpaw-setups-24.11.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1bf1334543a9cf8afc3851c74cb2a82a4844a25eda7e6747a9e67eefee52092"

URI_x86_64_v2_gpaw-setups = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpaw-setups-24.11.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gpaw-setups;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpaw-setups}"
SRC_URI[x86_64_v2_gpaw-setups.sha256sum] = "27f7fe66dceb07507b3ab046a8226f8d191e9f3bf52ab31cac129fc84baa21fe"

URI_aarch64_gpaw-setups = "${EPEL_MIRROR}/aarch64/Packages/g/gpaw-setups-24.11.0-3.el10_1.noarch.rpm;name=aarch64_gpaw-setups;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpaw-setups}"
SRC_URI[aarch64_gpaw-setups.sha256sum] = "85051541512f8c4bdbdbdfb801d619690dc1af3244df3ce827382cc25e9d152d"

RDEPENDS:gpaw-setups = " \
 "
