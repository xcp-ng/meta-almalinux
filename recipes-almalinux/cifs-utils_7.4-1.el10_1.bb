# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cifs-utils"
PV = "7.4"
PR = "1.el10_1"
PACKAGES = " \
 cifs-utils \
 cifs-utils-devel \
 pam_cifscreds \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cifs-utils-7.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63c53071a2e869a251d9e5f48875af92ff729186e08219099dfcc9c7faf564d8"

URI_x86_64_v2_cifs-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cifs-utils-7.4-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_cifs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cifs-utils}"
SRC_URI[x86_64_v2_cifs-utils.sha256sum] = "b2a62cbff9d7b1fb45c87c131801de9647d534163a1b4575f7d2152a924c8455"

URI_x86_64_v2_cifs-utils-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cifs-utils-devel-7.4-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_cifs-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cifs-utils-devel}"
SRC_URI[x86_64_v2_cifs-utils-devel.sha256sum] = "dcb10143e0ca1496ee398d4eeaa6ec03bec08b1c9680bf772fa9d434be704ea9"

URI_x86_64_v2_pam_cifscreds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pam_cifscreds-7.4-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_pam_cifscreds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_cifscreds}"
SRC_URI[x86_64_v2_pam_cifscreds.sha256sum] = "4474e660d82c19fcfc75d49a6051b2040ec99857872c83b8063aabb79657e546"

URI_aarch64_cifs-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cifs-utils-7.4-1.el10_1.aarch64.rpm;name=aarch64_cifs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_cifs-utils}"
SRC_URI[aarch64_cifs-utils.sha256sum] = "ad2770ae3df122084f923dfdbf8cc60bb8f2a65042198f82e05ab41f7606b8cd"

URI_aarch64_cifs-utils-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cifs-utils-devel-7.4-1.el10_1.aarch64.rpm;name=aarch64_cifs-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cifs-utils-devel}"
SRC_URI[aarch64_cifs-utils-devel.sha256sum] = "ecd8b2c4330b43adf8891d430b661e4797f69c12544dca4e4cc5e5d30cd12f6b"

URI_aarch64_pam_cifscreds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pam_cifscreds-7.4-1.el10_1.aarch64.rpm;name=aarch64_pam_cifscreds;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_cifscreds}"
SRC_URI[aarch64_pam_cifscreds.sha256sum] = "7a71850c2f43f85367fd08ad4c033563b462b010b4662ccc6b249ced50b50ba2"

RDEPENDS:cifs-utils = " \
 alternatives \
 bash \
 glibc \
 keyutils \
 keyutils-libs \
 krb5-libs \
 libcap-ng \
 libtalloc \
 libwbclient \
 "
RDEPENDS:cifs-utils-devel = " \
 "
RDEPENDS:pam_cifscreds = " \
 glibc \
 keyutils-libs \
 libtalloc \
 pam-libs \
 "
