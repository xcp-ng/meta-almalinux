# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdk-pixbuf2-xlib"
PV = "2.40.2"
PR = "11.el10_0"
PACKAGES = " \
 gdk-pixbuf2-xlib \
 gdk-pixbuf2-xlib-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gdk-pixbuf2-xlib-2.40.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cf5e575f49b6df366dda29da703f10ac7df88ee7fae5feff90953b2f1e0bc75e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdk-pixbuf2-xlib-2.40.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdk-pixbuf2-xlib;unpack=0"
SRC_URI[x86_64_v2_gdk-pixbuf2-xlib.sha256sum] = "2ed3ee4b20406820df0026fe796f1b0db86c3e1dfdedc4d71bf05fa9a04b4734"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdk-pixbuf2-xlib-devel-2.40.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdk-pixbuf2-xlib-devel;unpack=0"
SRC_URI[x86_64_v2_gdk-pixbuf2-xlib-devel.sha256sum] = "dab64a0307a38b08f38d555eff44c6d1ae336bc34c20fbec81c07d642e96e113"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gdk-pixbuf2-xlib-2.40.2-11.el10_0.aarch64.rpm;name=aarch64_gdk-pixbuf2-xlib;unpack=0"
SRC_URI[aarch64_gdk-pixbuf2-xlib.sha256sum] = "1d15766b5871f1f2815e8a0e1806e9bac8cdf19fb8e06ac31e783a2bef4bfad8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gdk-pixbuf2-xlib-devel-2.40.2-11.el10_0.aarch64.rpm;name=aarch64_gdk-pixbuf2-xlib-devel;unpack=0"
SRC_URI[aarch64_gdk-pixbuf2-xlib-devel.sha256sum] = "72520349e62332113e72c2ba47212a9a29a814812f68bfbdd8aa485fe815d597"

RDEPENDS:gdk-pixbuf2-xlib = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libX11 \
 "
RDEPENDS:gdk-pixbuf2-xlib-devel = " \
 gdk-pixbuf2-devel \
 gdk-pixbuf2-xlib \
 libX11-devel \
 pkgconf-pkg-config \
 "
