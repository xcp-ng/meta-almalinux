# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmplot"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kmplot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmplot-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fae352218108fbd0acd29313b6e3685dacd903644521889732d773362c04034"

URI_x86_64_v2_kmplot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmplot-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmplot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmplot}"
SRC_URI[x86_64_v2_kmplot.sha256sum] = "ff847e5f235be586949deb8820eb1ca9a1d453bd3687730f515ff096fa757984"

URI_aarch64_kmplot = "${EPEL_MIRROR}/aarch64/Packages/k/kmplot-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmplot;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmplot}"
SRC_URI[aarch64_kmplot.sha256sum] = "08f47ac4cf43c49401952f0a94753ef3f47b4da291604408109b551b5300eea2"

RDEPENDS:kmplot = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
