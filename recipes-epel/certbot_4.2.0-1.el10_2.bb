# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "certbot"
PV = "4.2.0"
PR = "1.el10_2"
PACKAGES = " \
 certbot \
 python3-acme \
 python3-certbot \
 python3-certbot-apache \
 python3-certbot-dns-cloudflare \
 python3-certbot-dns-digitalocean \
 python3-certbot-dns-dnsimple \
 python3-certbot-dns-dnsmadeeasy \
 python3-certbot-dns-gehirn \
 python3-certbot-dns-linode \
 python3-certbot-dns-luadns \
 python3-certbot-dns-nsone \
 python3-certbot-dns-ovh \
 python3-certbot-dns-rfc2136 \
 python3-certbot-dns-route53 \
 python3-certbot-dns-sakuracloud \
 python3-certbot-nginx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/certbot-4.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bfb9939d9431fe3ea77d013df2a39736706bdf16029acd3c15bf4b2f2126bd5a"

URI_x86_64_v2_certbot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/certbot-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_certbot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_certbot}"
SRC_URI[x86_64_v2_certbot.sha256sum] = "381f286f1c51d14b83884f5d1c5399a8f6e595fd968e56eaf651dd0295cb8592"

URI_x86_64_v2_python3-acme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-acme-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-acme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-acme}"
SRC_URI[x86_64_v2_python3-acme.sha256sum] = "d3bae2e9751a5180027a1ac5db99f17a472d0647e9dd1c7696a3c028b1a8dd16"

URI_x86_64_v2_python3-certbot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot}"
SRC_URI[x86_64_v2_python3-certbot.sha256sum] = "b16a109dea57273a783fa6a4986f93e3b51a4c0674399709e552735ac90c2ad4"

URI_x86_64_v2_python3-certbot-apache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-apache-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-apache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-apache}"
SRC_URI[x86_64_v2_python3-certbot-apache.sha256sum] = "df7a4114f568e12939cd38251e1834bc28bc082ade5f1f36955381e0d365511b"

URI_x86_64_v2_python3-certbot-dns-cloudflare = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-cloudflare-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-cloudflare;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-cloudflare}"
SRC_URI[x86_64_v2_python3-certbot-dns-cloudflare.sha256sum] = "6f3ea2c62ee77f239f989180116ac6397f58fcfc8dbf225e0c4c6cbc116c6042"

URI_x86_64_v2_python3-certbot-dns-digitalocean = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-digitalocean-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-digitalocean;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-digitalocean}"
SRC_URI[x86_64_v2_python3-certbot-dns-digitalocean.sha256sum] = "eae2826332f3795933c7b8e05694e55fe28c31cc264ebe1ac62936c8b3badd2a"

URI_x86_64_v2_python3-certbot-dns-dnsimple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-dnsimple-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-dnsimple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-dnsimple}"
SRC_URI[x86_64_v2_python3-certbot-dns-dnsimple.sha256sum] = "ec7c6864dfa40bfda77e14993a97067461f701847db9435748c63db26ad4bc07"

URI_x86_64_v2_python3-certbot-dns-dnsmadeeasy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-dnsmadeeasy-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-dnsmadeeasy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-dnsmadeeasy}"
SRC_URI[x86_64_v2_python3-certbot-dns-dnsmadeeasy.sha256sum] = "3cf48a4a8a2195bfef5750559c51c1c9352861c2cb0ca7cdb330c74bc0ef2c7d"

URI_x86_64_v2_python3-certbot-dns-gehirn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-gehirn-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-gehirn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-gehirn}"
SRC_URI[x86_64_v2_python3-certbot-dns-gehirn.sha256sum] = "a777958e0361862617736bf2f6f69a6a2c710118f9f05ab3f90d401137f75901"

URI_x86_64_v2_python3-certbot-dns-linode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-linode-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-linode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-linode}"
SRC_URI[x86_64_v2_python3-certbot-dns-linode.sha256sum] = "e145d7b9d5c4ab3ee405517afd46395491af80461760c83c253a5e31f1b6cf7b"

URI_x86_64_v2_python3-certbot-dns-luadns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-luadns-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-luadns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-luadns}"
SRC_URI[x86_64_v2_python3-certbot-dns-luadns.sha256sum] = "993b9c08bc9965a318cb4952f70236f8f816f167b76fed2f250b2e0eb592127c"

URI_x86_64_v2_python3-certbot-dns-nsone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-nsone-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-nsone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-nsone}"
SRC_URI[x86_64_v2_python3-certbot-dns-nsone.sha256sum] = "3e7507121c00a223de95f67809e4bd768f1790ad3fe26f942df1efb7d2e575df"

URI_x86_64_v2_python3-certbot-dns-ovh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-ovh-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-ovh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-ovh}"
SRC_URI[x86_64_v2_python3-certbot-dns-ovh.sha256sum] = "56b67dd4de3614fb0c5c8cb1185d0ffd93b00f450e0e5979672a4ac1cb16269c"

URI_x86_64_v2_python3-certbot-dns-rfc2136 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-rfc2136-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-rfc2136;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-rfc2136}"
SRC_URI[x86_64_v2_python3-certbot-dns-rfc2136.sha256sum] = "3c13317413d5b9e1326bc7889eebf02cd7977292f1165299382ec2f4d873d2cd"

URI_x86_64_v2_python3-certbot-dns-route53 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-route53-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-route53;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-route53}"
SRC_URI[x86_64_v2_python3-certbot-dns-route53.sha256sum] = "abadb1426303e12a22fa059d1cece9c1f49300aac886da00ea0e30287f42a6e9"

URI_x86_64_v2_python3-certbot-dns-sakuracloud = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-sakuracloud-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-sakuracloud;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-sakuracloud}"
SRC_URI[x86_64_v2_python3-certbot-dns-sakuracloud.sha256sum] = "3f991202462af81f804bc6167006d1216f9dd4e117df9b8e50a220024d9751ea"

URI_x86_64_v2_python3-certbot-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-nginx-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-nginx}"
SRC_URI[x86_64_v2_python3-certbot-nginx.sha256sum] = "8f54d326d9fb7e5806d020df4b1570c1c74117b41716ad30c9d23a47ef449f42"

URI_aarch64_certbot = "${EPEL_MIRROR}/aarch64/Packages/c/certbot-4.2.0-1.el10_2.noarch.rpm;name=aarch64_certbot;unpack=0"
SRC_URI:append = " ${URI_aarch64_certbot}"
SRC_URI[aarch64_certbot.sha256sum] = "5d2554d6ffd1903ad9706e0e35139aaaaa0a49f7b8fa19b37da0e9663e76a1f7"

URI_aarch64_python3-acme = "${EPEL_MIRROR}/aarch64/Packages/p/python3-acme-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-acme;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-acme}"
SRC_URI[aarch64_python3-acme.sha256sum] = "3229170401a9b19497e9ec36d84174a9cda0cc079b8f60b85f18e89c750ea690"

URI_aarch64_python3-certbot = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-certbot;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot}"
SRC_URI[aarch64_python3-certbot.sha256sum] = "a6ed64e8d76c67ba9c69706d4851065c23722b720dd64706eb437f017d3844a8"

URI_aarch64_python3-certbot-apache = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-apache-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-certbot-apache;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-apache}"
SRC_URI[aarch64_python3-certbot-apache.sha256sum] = "da87abd57909ce3b17201ceff3eb176b2303b9c3ad1c864c79a04187a07db11a"

URI_aarch64_python3-certbot-dns-cloudflare = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-cloudflare-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-certbot-dns-cloudflare;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-cloudflare}"
SRC_URI[aarch64_python3-certbot-dns-cloudflare.sha256sum] = "e671d85c8b3fb77720ffcd5631e2dff6b1cbac597b4f948b2dc19d5a54476bf1"

URI_aarch64_python3-certbot-dns-digitalocean = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-digitalocean-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-certbot-dns-digitalocean;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-digitalocean}"
SRC_URI[aarch64_python3-certbot-dns-digitalocean.sha256sum] = "2a210f8c5110c3b3fd2d35a7b74cc7075b6557f2f5e00985caba352f6b5a240a"

URI_aarch64_python3-certbot-dns-dnsimple = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-dnsimple-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-certbot-dns-dnsimple;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-dnsimple}"
SRC_URI[aarch64_python3-certbot-dns-dnsimple.sha256sum] = "67d0721eb833f43036f9202e2161b8d0a13956635645ff473de2ecee9419a74a"

URI_aarch64_python3-certbot-dns-dnsmadeeasy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-dnsmadeeasy-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-certbot-dns-dnsmadeeasy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-dnsmadeeasy}"
SRC_URI[aarch64_python3-certbot-dns-dnsmadeeasy.sha256sum] = "45c1f0f3e316606b8062e7dd7d474097574d8f08af23dc6ccd1301dfca42fb61"

URI_aarch64_python3-certbot-dns-gehirn = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-gehirn-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-certbot-dns-gehirn;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-gehirn}"
SRC_URI[aarch64_python3-certbot-dns-gehirn.sha256sum] = "28e13df26c9cede81cf53841446f402a6740705797319300bdf772a4896070e9"

URI_aarch64_python3-certbot-dns-linode = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-linode-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-certbot-dns-linode;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-linode}"
SRC_URI[aarch64_python3-certbot-dns-linode.sha256sum] = "75b353cfefbe1e5b093ee103c502f91c8c95ee391345130573cea820ee4ebf4b"

URI_aarch64_python3-certbot-dns-luadns = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-luadns-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-certbot-dns-luadns;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-luadns}"
SRC_URI[aarch64_python3-certbot-dns-luadns.sha256sum] = "fb1773393981a52a681cfd74949242f42cdda9d15a3f49562691dbeaca62ebf2"

URI_aarch64_python3-certbot-dns-nsone = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-nsone-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-certbot-dns-nsone;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-nsone}"
SRC_URI[aarch64_python3-certbot-dns-nsone.sha256sum] = "904128fd2ef57a499cdfa2cd8c4164f351df17bbedbf8ce8925c863eebc0e307"

URI_aarch64_python3-certbot-dns-ovh = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-ovh-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-certbot-dns-ovh;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-ovh}"
SRC_URI[aarch64_python3-certbot-dns-ovh.sha256sum] = "c9695c7cbc409d198b971fc20f335bf36d2f633c162dd4ff40257725959a91a4"

URI_aarch64_python3-certbot-dns-rfc2136 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-rfc2136-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-certbot-dns-rfc2136;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-rfc2136}"
SRC_URI[aarch64_python3-certbot-dns-rfc2136.sha256sum] = "060099fce0882434f21493914fd9d3fb6628e777875345e0f301a91418057300"

URI_aarch64_python3-certbot-dns-route53 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-route53-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-certbot-dns-route53;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-route53}"
SRC_URI[aarch64_python3-certbot-dns-route53.sha256sum] = "b2dacbd92bb0482f1a5a47161254131ca76a76dcfe5f35307c93b39c920da416"

URI_aarch64_python3-certbot-dns-sakuracloud = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-sakuracloud-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-certbot-dns-sakuracloud;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-sakuracloud}"
SRC_URI[aarch64_python3-certbot-dns-sakuracloud.sha256sum] = "637c14f12b25c04890bab2adb29dfb6003f1c32c41225b42c5aee5cc61bc729a"

URI_aarch64_python3-certbot-nginx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-nginx-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-certbot-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-nginx}"
SRC_URI[aarch64_python3-certbot-nginx.sha256sum] = "82a764d41c81c19f629c8b419c8445b55bea13a5c8a56d82b2960a7aa6be50f1"

RDEPENDS:certbot = " \
 bash \
 fontawesome4-fonts \
 policycoreutils \
 python3-certbot \
 systemd \
 "
RDEPENDS:python3-acme = " \
 python3 \
 python3-cryptography \
 python3-josepy \
 python3-pyOpenSSL \
 python3-pyrfc3339 \
 python3-requests \
 "
RDEPENDS:python3-certbot = " \
 python3 \
 python3-acme \
 python3-configargparse \
 python3-configobj \
 python3-cryptography \
 python3-distro \
 python3-josepy \
 python3-parsedatetime \
 python3-pyrfc3339 \
 "
RDEPENDS:python3-certbot-apache = " \
 mod_ssl \
 python3 \
 python3-acme \
 python3-augeas \
 python3-certbot \
 "
RDEPENDS:python3-certbot-dns-cloudflare = " \
 python3 \
 python3-cloudflare \
 "
RDEPENDS:python3-certbot-dns-digitalocean = " \
 python3 \
 python3-digitalocean \
 "
RDEPENDS:python3-certbot-dns-dnsimple = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-dnsmadeeasy = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-gehirn = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-linode = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-luadns = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-nsone = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-ovh = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-rfc2136 = " \
 python3 \
 python3-dns \
 "
RDEPENDS:python3-certbot-dns-route53 = " \
 python3 \
 python3-boto3 \
 "
RDEPENDS:python3-certbot-dns-sakuracloud = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-nginx = " \
 python3 \
 python3-acme \
 python3-certbot \
 python3-pyOpenSSL \
 python3-pyparsing \
 "
