# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-CIDR-Lite"
PV = "0.24"
PR = "1.el10_1"
PACKAGES = " \
 perl-Net-CIDR-Lite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-CIDR-Lite-0.24-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76e183e1996e03d5683d1eb8c9bf71df3387cc6a04ce37e3fb2b95402bd1e06d"

URI_x86_64_v2_perl-Net-CIDR-Lite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-CIDR-Lite-0.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-CIDR-Lite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-CIDR-Lite}"
SRC_URI[x86_64_v2_perl-Net-CIDR-Lite.sha256sum] = "e893591fe6dac7a061dbe7129666b4a3a7351707a5e4770e6b642867b87b84f4"

URI_aarch64_perl-Net-CIDR-Lite = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-CIDR-Lite-0.24-1.el10_1.noarch.rpm;name=aarch64_perl-Net-CIDR-Lite;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-CIDR-Lite}"
SRC_URI[aarch64_perl-Net-CIDR-Lite.sha256sum] = "23f8da04a03676b485a6f9ecf275b3a4d836250cd7e9137f44f9ec625f387ddb"

RDEPENDS:perl-Net-CIDR-Lite = " \
 perl-Carp \
 perl-libs \
 perl-vars \
 "
