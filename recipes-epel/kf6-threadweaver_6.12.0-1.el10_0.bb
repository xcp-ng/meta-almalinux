# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-threadweaver"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-threadweaver \
 kf6-threadweaver-devel \
 kf6-threadweaver-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-threadweaver-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2af36f2982e3caddbe0359be0a092038961ea467c6157d382607415e327b4035"

URI_x86_64_v2_kf6-threadweaver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-threadweaver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-threadweaver}"
SRC_URI[x86_64_v2_kf6-threadweaver.sha256sum] = "0dd4fe2a269792aca13c39fc3fd6e25f9ed2647d58c6918515e25f1cf6bb94c3"

URI_x86_64_v2_kf6-threadweaver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-threadweaver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-threadweaver-devel}"
SRC_URI[x86_64_v2_kf6-threadweaver-devel.sha256sum] = "b52e392f617fa6285812231f7d9aaa61a23ae9174bf30145ce7b38f10587f24e"

URI_x86_64_v2_kf6-threadweaver-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-threadweaver-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-threadweaver-doc}"
SRC_URI[x86_64_v2_kf6-threadweaver-doc.sha256sum] = "624e1cab2ac2a64824b7b72db65f480dc9d1c7d468dbfc01d45a0776f54849bd"

URI_aarch64_kf6-threadweaver = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-threadweaver;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-threadweaver}"
SRC_URI[aarch64_kf6-threadweaver.sha256sum] = "422159c9daa493e213137228556e78a2706d407b93bd39772890a4c834b70c56"

URI_aarch64_kf6-threadweaver-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-threadweaver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-threadweaver-devel}"
SRC_URI[aarch64_kf6-threadweaver-devel.sha256sum] = "c311e5a2613ec9cb286dab0ffda12c216378e95d1934b2e883b214d169513cbe"

URI_aarch64_kf6-threadweaver-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-threadweaver-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-threadweaver-doc}"
SRC_URI[aarch64_kf6-threadweaver-doc.sha256sum] = "b48ce5ef8321d8df53196e956972fb908b46a25635a0fe47139dcd4de6db695e"

RDEPENDS:kf6-threadweaver = " \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-threadweaver-devel = " \
 cmake-filesystem \
 kf6-threadweaver \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-threadweaver-doc = " \
 "
