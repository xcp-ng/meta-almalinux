# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crash"
PV = "9.0.2"
PR = "1.el10.alma.1"
PACKAGES = " \
 crash \
 crash-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/crash-9.0.2-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5db61078c43e47a867fe6505f510b16543db745a582a953b10b820d4a5a9cb4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crash-9.0.2-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_crash;unpack=0"
SRC_URI[x86_64_v2_crash.sha256sum] = "b6df98f604efd713a577ddbf04a76788fe5fbdc6403e84e731a1751c39451d20"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/crash-devel-9.0.2-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_crash-devel;unpack=0"
SRC_URI[x86_64_v2_crash-devel.sha256sum] = "d1f4044245de95848bef211042d45a5428bd519f07cf0e70eb360f51189b44fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crash-9.0.2-1.el10.alma.1.aarch64.rpm;name=aarch64_crash;unpack=0"
SRC_URI[aarch64_crash.sha256sum] = "ca156563c2232112bcd8ef35b6f313b193176881c605ab9962b20844fbbba166"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/crash-devel-9.0.2-1.el10.alma.1.aarch64.rpm;name=aarch64_crash-devel;unpack=0"
SRC_URI[aarch64_crash-devel.sha256sum] = "3775f78a68dfba193f39d1031c4159d66c3d11353afbaf468b84e4b79b77711d"

RDEPENDS:crash = " \
 binutils \
 glibc \
 gmp \
 libgcc \
 libstdc++ \
 libzstd \
 lzo \
 mpfr \
 ncurses-libs \
 snappy \
 "
RDEPENDS:crash-devel = " \
 crash \
 zlib-ng-compat-devel \
 "
