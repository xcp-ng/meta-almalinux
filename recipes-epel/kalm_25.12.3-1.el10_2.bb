# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalm"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kalm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kalm-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "531bcc886e70d4b69b710436e85dfd43cb5ba3b2e37b42198d03a738a2e8d7f5"

URI_x86_64_v2_kalm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalm-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kalm}"
SRC_URI[x86_64_v2_kalm.sha256sum] = "4f8ee66e539f78bb4c5838164e404f6fd1c017601c83769616b5aaeb2585ecc2"

URI_aarch64_kalm = "${EPEL_MIRROR}/aarch64/Packages/k/kalm-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kalm;unpack=0"
SRC_URI:append = " ${URI_aarch64_kalm}"
SRC_URI[aarch64_kalm.sha256sum] = "5f56d6b7e2238710bffbfd2f2f9f2e35b163069be0f2bad0d3c5563c67503678"

RDEPENDS:kalm = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami-addons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
