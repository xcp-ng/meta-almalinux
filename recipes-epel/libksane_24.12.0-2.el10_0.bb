# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libksane"
PV = "24.12.0"
PR = "2.el10_0"
PACKAGES = " \
 libksane \
 libksane-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libksane-24.12.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "577f4f47cde62a2a7ea40e8c3479d8b08138cee8da700d79f5ccc9d458557994"

URI_x86_64_v2_libksane = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksane-24.12.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksane;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksane}"
SRC_URI[x86_64_v2_libksane.sha256sum] = "a366ed2545c7f89a3c7672a9e18bc59690cfeed26cfef4cda0173590b3379118"

URI_x86_64_v2_libksane-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksane-devel-24.12.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksane-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksane-devel}"
SRC_URI[x86_64_v2_libksane-devel.sha256sum] = "1dac6dd8f25112ba68b8bcfdfffbaaeb67e9140071eeef99815fdd13514b1044"

URI_aarch64_libksane = "${EPEL_MIRROR}/aarch64/Packages/l/libksane-24.12.0-2.el10_0.aarch64.rpm;name=aarch64_libksane;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksane}"
SRC_URI[aarch64_libksane.sha256sum] = "f35cacd859e0bbf363b046a57e008ac6f142426ca2353ab54fcc743675c2b64b"

URI_aarch64_libksane-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libksane-devel-24.12.0-2.el10_0.aarch64.rpm;name=aarch64_libksane-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksane-devel}"
SRC_URI[aarch64_libksane-devel.sha256sum] = "325cb37d88886abea2733386c9551bd3b3d492fdc2deb1a1aa77b337dff731e9"

RDEPENDS:libksane = " \
 glibc \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 ksanecore \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libksane-devel = " \
 cmake-filesystem \
 libksane \
 qt6-qtbase-devel \
 "
