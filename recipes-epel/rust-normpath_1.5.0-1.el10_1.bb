# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-normpath"
PV = "1.5.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-normpath+default-devel \
 rust-normpath+localization-devel \
 rust-normpath+serde-devel \
 rust-normpath-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-normpath-1.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e4eb8246ff05703f63c3ab76711a253d1f7186a84fb84846165b17f3c83d6067"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath+default-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-normpath+default-devel.sha256sum] = "fb3d3d421168dc5f3e8415a121358f25c5282cae5773e78d6a87324576b5b0a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath+localization-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath+localization-devel;unpack=0"
SRC_URI[x86_64_v2_rust-normpath+localization-devel.sha256sum] = "741304fe8b19d7fa46c9ae0c9c419f28c4f44e67cf4e944c1953949766bc9816"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath+serde-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-normpath+serde-devel.sha256sum] = "5c09ebb4f2cb34badec4864bfb98165a73a227bc898712e4ab83aa9bbfc6514c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath-devel;unpack=0"
SRC_URI[x86_64_v2_rust-normpath-devel.sha256sum] = "29d7091e9b4ec403a7df3f751ca8fdd93405e2000e9bca2fd8d3ced40c31bf1a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath+default-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-normpath+default-devel;unpack=0"
SRC_URI[aarch64_rust-normpath+default-devel.sha256sum] = "64686a7dcd323cccc5f1d2c4868391473f2b8f8ef23c0ab538c6116a63981694"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath+localization-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-normpath+localization-devel;unpack=0"
SRC_URI[aarch64_rust-normpath+localization-devel.sha256sum] = "eaf48662374d23b43914d4defd24efd41f41851591a3740f6ffb4bc9c0498693"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath+serde-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-normpath+serde-devel;unpack=0"
SRC_URI[aarch64_rust-normpath+serde-devel.sha256sum] = "62002d8574c0969a0660876d87ffa130404e09c78b5000b4d4fa7c929013507a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-normpath-devel;unpack=0"
SRC_URI[aarch64_rust-normpath-devel.sha256sum] = "3f7205007a579569a19e17c27f6673e3e2a3279c75842b51014eed48d5c5ce4c"

RDEPENDS:rust-normpath+default-devel = " \
 cargo \
 rust-normpath-devel \
 "
RDEPENDS:rust-normpath+localization-devel = " \
 cargo \
 rust-normpath-devel \
 "
RDEPENDS:rust-normpath+serde-devel = " \
 cargo \
 rust-normpath-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-normpath-devel = " \
 cargo \
 rust \
 "
