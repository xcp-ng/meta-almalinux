# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashlink"
PV = "0.11.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-hashlink+default-devel \
 rust-hashlink+serde-devel \
 rust-hashlink+serde_impl-devel \
 rust-hashlink-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hashlink-0.11.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de157b57581e94b7038cf593c44f1364869ce1a962dbd0a2cd87715b46f53ee0"

URI_x86_64_v2_rust-hashlink+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink+default-devel-0.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink+default-devel}"
SRC_URI[x86_64_v2_rust-hashlink+default-devel.sha256sum] = "84fc850125714c7218a7a48d6ae320b30279f3a53340c872c1c32f142957af70"

URI_x86_64_v2_rust-hashlink+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink+serde-devel-0.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink+serde-devel}"
SRC_URI[x86_64_v2_rust-hashlink+serde-devel.sha256sum] = "853342b0b0151e08bedcc61a575b72ad652c5dcbe6c0712d1acdea36e1be04bf"

URI_x86_64_v2_rust-hashlink+serde_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink+serde_impl-devel-0.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink+serde_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink+serde_impl-devel}"
SRC_URI[x86_64_v2_rust-hashlink+serde_impl-devel.sha256sum] = "63f8e207015cccbec1adee435554b32b36a236a5ae66033ab873b1bd879d379a"

URI_x86_64_v2_rust-hashlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink-devel-0.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink-devel}"
SRC_URI[x86_64_v2_rust-hashlink-devel.sha256sum] = "d150528d43ff523ff3bf31faded8ccf83551b82467e92a0dbceceea146a70c9e"

URI_aarch64_rust-hashlink+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink+default-devel-0.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-hashlink+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink+default-devel}"
SRC_URI[aarch64_rust-hashlink+default-devel.sha256sum] = "575889f68e884a43d92efbae8c38bd19b27f5924e1041079e3b2ec7593bb1b6c"

URI_aarch64_rust-hashlink+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink+serde-devel-0.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-hashlink+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink+serde-devel}"
SRC_URI[aarch64_rust-hashlink+serde-devel.sha256sum] = "f1778d95cc21ecbf068edfb0cca5d2aad4ce79a93d7e08ffd8f2dabd0205d6b0"

URI_aarch64_rust-hashlink+serde_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink+serde_impl-devel-0.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-hashlink+serde_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink+serde_impl-devel}"
SRC_URI[aarch64_rust-hashlink+serde_impl-devel.sha256sum] = "59fa59f426ebd52d531bd5a6339d95b02abe89c1da5f33c7fe4dac90818e2874"

URI_aarch64_rust-hashlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink-devel-0.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-hashlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink-devel}"
SRC_URI[aarch64_rust-hashlink-devel.sha256sum] = "ec18bacb6c693ff7daa3876ec3f9276966fe526dc5d38bdebe80b5a0815c4e5a"

RDEPENDS:rust-hashlink+default-devel = " \
 cargo \
 rust-hashlink-devel \
 "
RDEPENDS:rust-hashlink+serde-devel = " \
 cargo \
 rust-hashlink-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-hashlink+serde_impl-devel = " \
 cargo \
 rust-hashlink+serde-devel \
 rust-hashlink-devel \
 "
RDEPENDS:rust-hashlink-devel = " \
 cargo \
 rust \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown-devel \
 "
