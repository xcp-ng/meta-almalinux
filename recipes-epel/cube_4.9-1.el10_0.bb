# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cube"
PV = "4.9"
PR = "1.el10_0"
PACKAGES = " \
 cube \
 cube-doc \
 cube-guilib \
 cube-guilib-devel \
 cube-libs \
 cube-libs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cube-4.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a4375de6ab845e57abbbd403d9450fa44b599a99ea36fa0baba14184ef31b16"

URI_x86_64_v2_cube = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-4.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube}"
SRC_URI[x86_64_v2_cube.sha256sum] = "966da50449a51aaf70a5fa6a35e0fc2e563b6ff9135d0988b531a2f2604ee9fb"

URI_x86_64_v2_cube-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-doc-4.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_cube-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-doc}"
SRC_URI[x86_64_v2_cube-doc.sha256sum] = "9a5b876615191194009e3416635933458a47baa7b65402a8687ada9a4a8c4123"

URI_x86_64_v2_cube-guilib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-guilib-4.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-guilib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-guilib}"
SRC_URI[x86_64_v2_cube-guilib.sha256sum] = "3237d93d3543284afe9f1e3bc539e96079ff694e7160f3b9484abeed15d300af"

URI_x86_64_v2_cube-guilib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-guilib-devel-4.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-guilib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-guilib-devel}"
SRC_URI[x86_64_v2_cube-guilib-devel.sha256sum] = "3b7df92b1cac6a5b772e5175a9cc287c6733712fc9b6c88b26c517d74ec52975"

URI_x86_64_v2_cube-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-libs-4.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-libs}"
SRC_URI[x86_64_v2_cube-libs.sha256sum] = "81bfd4a5d59f4f79c649e8a40ec6dff3dcbaa66c05c4f78fb6e6c12f8dc90d26"

URI_x86_64_v2_cube-libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-libs-devel-4.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-libs-devel}"
SRC_URI[x86_64_v2_cube-libs-devel.sha256sum] = "9a65da30a5ef4686f7651d4f49bac84d38f380b258d9984911ea11503cce9a49"

URI_aarch64_cube = "${EPEL_MIRROR}/aarch64/Packages/c/cube-4.9-1.el10_0.aarch64.rpm;name=aarch64_cube;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube}"
SRC_URI[aarch64_cube.sha256sum] = "50798b5f889d265f03b55a662a950df50d527fc39c406f669d57dba48c8aee67"

URI_aarch64_cube-doc = "${EPEL_MIRROR}/aarch64/Packages/c/cube-doc-4.9-1.el10_0.noarch.rpm;name=aarch64_cube-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-doc}"
SRC_URI[aarch64_cube-doc.sha256sum] = "7fa56074f657994eaa42c761caf4b049fdafc4349486ece73f276833b18290c4"

URI_aarch64_cube-guilib = "${EPEL_MIRROR}/aarch64/Packages/c/cube-guilib-4.9-1.el10_0.aarch64.rpm;name=aarch64_cube-guilib;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-guilib}"
SRC_URI[aarch64_cube-guilib.sha256sum] = "a7de6feea970df7e0055397ab87c40e096bdc5ee5130f2cc6bfc2af0e292a3ab"

URI_aarch64_cube-guilib-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cube-guilib-devel-4.9-1.el10_0.aarch64.rpm;name=aarch64_cube-guilib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-guilib-devel}"
SRC_URI[aarch64_cube-guilib-devel.sha256sum] = "6b6fa307e091849d96b165ce1374990f60222ec3e46c0dcc36c0293506f321de"

URI_aarch64_cube-libs = "${EPEL_MIRROR}/aarch64/Packages/c/cube-libs-4.9-1.el10_0.aarch64.rpm;name=aarch64_cube-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-libs}"
SRC_URI[aarch64_cube-libs.sha256sum] = "3195e99ee7e3b52ea15bfdbb8aeb07d1a77d51dfdcf002ab21dd7a2ed50ba3f7"

URI_aarch64_cube-libs-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cube-libs-devel-4.9-1.el10_0.aarch64.rpm;name=aarch64_cube-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-libs-devel}"
SRC_URI[aarch64_cube-libs-devel.sha256sum] = "625bc3d172f9d6adc46989f0ef1bfa8727dbb8e9861ed72f2165cc8b688ff004"

RDEPENDS:cube = " \
 bash \
 cube-guilib \
 cube-libs \
 dbus-libs \
 glibc \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:cube-doc = " \
 "
RDEPENDS:cube-guilib = " \
 cube-libs \
 glibc \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:cube-guilib-devel = " \
 cmake-filesystem \
 cube-guilib \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:cube-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:cube-libs-devel = " \
 cmake-filesystem \
 cube-guilib \
 cube-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
