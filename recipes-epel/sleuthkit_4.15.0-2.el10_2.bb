# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sleuthkit"
PV = "4.15.0"
PR = "2.el10_2"
PACKAGES = " \
 sleuthkit \
 sleuthkit-devel \
 sleuthkit-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sleuthkit-4.15.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0404157978b4ae9679ca6fd5b4aed950922adc5f5a410c458664f7b46b57e447"

URI_x86_64_v2_sleuthkit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleuthkit-4.15.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleuthkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleuthkit}"
SRC_URI[x86_64_v2_sleuthkit.sha256sum] = "345846b056eb35f9dbde5603db9d9f70744327a50bd071167fe8df7a331f6052"

URI_x86_64_v2_sleuthkit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleuthkit-devel-4.15.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleuthkit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleuthkit-devel}"
SRC_URI[x86_64_v2_sleuthkit-devel.sha256sum] = "e538db3459ca0339d0a2316e5665ae9bc0fbb1f5d069015bd67cbaf297e2e7fc"

URI_x86_64_v2_sleuthkit-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleuthkit-libs-4.15.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleuthkit-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleuthkit-libs}"
SRC_URI[x86_64_v2_sleuthkit-libs.sha256sum] = "fe193cd14388cf14fe69045b68e3900ceb8a26b818b3d1db495b4fda570962e4"

URI_aarch64_sleuthkit = "${EPEL_MIRROR}/aarch64/Packages/s/sleuthkit-4.15.0-2.el10_2.aarch64.rpm;name=aarch64_sleuthkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleuthkit}"
SRC_URI[aarch64_sleuthkit.sha256sum] = "49e6e6d617f107cb158d20abea4fa828c39fa65be1a4615f0a7804a896664361"

URI_aarch64_sleuthkit-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sleuthkit-devel-4.15.0-2.el10_2.aarch64.rpm;name=aarch64_sleuthkit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleuthkit-devel}"
SRC_URI[aarch64_sleuthkit-devel.sha256sum] = "a7d2f0c4989ca20310b4162017c2f188888c506c9d0637f4f87dd7110bf1dfb9"

URI_aarch64_sleuthkit-libs = "${EPEL_MIRROR}/aarch64/Packages/s/sleuthkit-libs-4.15.0-2.el10_2.aarch64.rpm;name=aarch64_sleuthkit-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleuthkit-libs}"
SRC_URI[aarch64_sleuthkit-libs.sha256sum] = "8cf1c109de37506d4ab628809b6f95db98c3a877a50bc4d6973dd54abb9349d3"

RDEPENDS:sleuthkit = " \
 afflib \
 file \
 glibc \
 libewf \
 libgcc \
 libstdc++ \
 mac-robber \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 sleuthkit-libs \
 "
RDEPENDS:sleuthkit-devel = " \
 libewf-devel \
 pkgconf-pkg-config \
 sleuthkit-libs \
 sqlite-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:sleuthkit-libs = " \
 afflib \
 glibc \
 libewf \
 libgcc \
 libstdc++ \
 sqlite-libs \
 zlib-ng-compat \
 "
