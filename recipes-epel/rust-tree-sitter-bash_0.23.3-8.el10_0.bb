# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-bash"
PV = "0.23.3"
PR = "8.el10_0"
PACKAGES = " \
 rust-tree-sitter-bash+default-devel \
 rust-tree-sitter-bash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-bash-0.23.3-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee0a6bb4ff4992cdd0362d756d2f3418ece850ffdb04e041cb9413bac41aaeae"

URI_x86_64_v2_rust-tree-sitter-bash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-bash+default-devel-0.23.3-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-bash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-bash+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-bash+default-devel.sha256sum] = "53a7d03c554c6edd15ed5655c9e3755624624e21e742e60dcc653ccd9cc0d5bb"

URI_x86_64_v2_rust-tree-sitter-bash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-bash-devel-0.23.3-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-bash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-bash-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-bash-devel.sha256sum] = "d9c7b426cf4c1211468806a2979815c5c8b4aeb99b4bfe7f77958038ecdcd35c"

URI_aarch64_rust-tree-sitter-bash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-bash+default-devel-0.23.3-8.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-bash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-bash+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-bash+default-devel.sha256sum] = "cd259b20dc9c070ca9158b43a483ec0493461f01a787ce15482a0db0659cdceb"

URI_aarch64_rust-tree-sitter-bash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-bash-devel-0.23.3-8.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-bash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-bash-devel}"
SRC_URI[aarch64_rust-tree-sitter-bash-devel.sha256sum] = "78180b2d078b8192ff56b77b07959fc6374541134e6cd0e6b033f50e2f11fddd"

RDEPENDS:rust-tree-sitter-bash+default-devel = " \
 cargo \
 rust-tree-sitter-bash-devel \
 "
RDEPENDS:rust-tree-sitter-bash-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
