# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-pingcap-errors"
PV = "0.11.4"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-pingcap-errors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-pingcap-errors-0.11.4-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98e366dfd9370ea09f776020910cb4abcc5a06bfe3ac84f94607db727fa70013"

URI_x86_64_v2_golang-github-pingcap-errors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-pingcap-errors-devel-0.11.4-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-pingcap-errors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-pingcap-errors-devel}"
SRC_URI[x86_64_v2_golang-github-pingcap-errors-devel.sha256sum] = "01d009c70c8097befd236e6b5987c5d89238c594741564bafcf6f526552aee10"

URI_aarch64_golang-github-pingcap-errors-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-pingcap-errors-devel-0.11.4-13.el10_0.noarch.rpm;name=aarch64_golang-github-pingcap-errors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-pingcap-errors-devel}"
SRC_URI[aarch64_golang-github-pingcap-errors-devel.sha256sum] = "503dec6677c0f2a6df3bca76d2004682f111a3430786f0a074aed43b39d52938"

RDEPENDS:golang-github-pingcap-errors-devel = " \
 go-filesystem \
 "
