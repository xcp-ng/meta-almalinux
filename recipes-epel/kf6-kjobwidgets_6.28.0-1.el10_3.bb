# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kjobwidgets"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kjobwidgets \
 kf6-kjobwidgets-devel \
 kf6-kjobwidgets-doc \
 kf6-kjobwidgets-html \
 python3-kf6-kjobwidgets \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kjobwidgets-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "adfe691f5bc71cf47312814607c57010dce2c9f2deda0047725a2deaed4eb895"

URI_x86_64_v2_kf6-kjobwidgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kjobwidgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kjobwidgets}"
SRC_URI[x86_64_v2_kf6-kjobwidgets.sha256sum] = "0f6f753e157f551ee998b04d4c90f96c3485e80b91e4b238fb3f11f27a9fba50"

URI_x86_64_v2_kf6-kjobwidgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kjobwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kjobwidgets-devel}"
SRC_URI[x86_64_v2_kf6-kjobwidgets-devel.sha256sum] = "e6aa5148b36ab8c08467a77fe97ddbfdd16a350b8fa8d021268fa5b4b333abb4"

URI_x86_64_v2_kf6-kjobwidgets-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kjobwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kjobwidgets-doc}"
SRC_URI[x86_64_v2_kf6-kjobwidgets-doc.sha256sum] = "dc1d8e2de2430b2f1692e7b48fe68e018bc72d52c2494f76723fa142e9726894"

URI_x86_64_v2_kf6-kjobwidgets-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kjobwidgets-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kjobwidgets-html}"
SRC_URI[x86_64_v2_kf6-kjobwidgets-html.sha256sum] = "b9e47d63b073caa3a55b9f2db4e277cdfa2e44a92bd29b68d851b09972915b43"

URI_x86_64_v2_python3-kf6-kjobwidgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kjobwidgets-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kjobwidgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kjobwidgets}"
SRC_URI[x86_64_v2_python3-kf6-kjobwidgets.sha256sum] = "8f7428afdaf0f5bd9c410b79424169206fb1f8da41c4ec8d1139d85c90c0858c"

URI_aarch64_kf6-kjobwidgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kjobwidgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kjobwidgets}"
SRC_URI[aarch64_kf6-kjobwidgets.sha256sum] = "7dda321c43a58871b15a2c2a9f6e5e413661a41bc177d7a97b3a15a5a3765d4d"

URI_aarch64_kf6-kjobwidgets-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kjobwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kjobwidgets-devel}"
SRC_URI[aarch64_kf6-kjobwidgets-devel.sha256sum] = "c57684862a5dda8df5f878a161de9c56d53d3bcf9322bdd2863e960679d9e75d"

URI_aarch64_kf6-kjobwidgets-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kjobwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kjobwidgets-doc}"
SRC_URI[aarch64_kf6-kjobwidgets-doc.sha256sum] = "19fcc7793c3cdd151b3a088a2d32ec387f2fe1252cdf72fbf37731881a61e5f4"

URI_aarch64_kf6-kjobwidgets-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kjobwidgets-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kjobwidgets-html}"
SRC_URI[aarch64_kf6-kjobwidgets-html.sha256sum] = "2ae9353365878ffee1c5565cc7e798d17fb154922bdb9a5e0ad8ef6a1bef3cc0"

URI_aarch64_python3-kf6-kjobwidgets = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kjobwidgets-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kjobwidgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kjobwidgets}"
SRC_URI[aarch64_python3-kf6-kjobwidgets.sha256sum] = "05539c9ab8ea7c758825101b422f2401aecff68d930a0196e5a6d491619ec1ad"

RDEPENDS:kf6-kjobwidgets = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kjobwidgets-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kjobwidgets \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kjobwidgets-doc = " \
 "
RDEPENDS:kf6-kjobwidgets-html = " \
 "
RDEPENDS:python3-kf6-kjobwidgets = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kjobwidgets \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 "
