# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bisection"
PV = "0.1.0"
PR = "5.el10_0"
PACKAGES = " \
 rust-bisection+default-devel \
 rust-bisection-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bisection-0.1.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a536920291c25b6741ee86862496e8284b8149a8bb629963c5d5e8a3e1bce7cd"

URI_x86_64_v2_rust-bisection+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bisection+default-devel-0.1.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bisection+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bisection+default-devel}"
SRC_URI[x86_64_v2_rust-bisection+default-devel.sha256sum] = "5ca3b9b9c76bc3658cdb2fa311296e172604238b39ccc84296b54e8d2ee0fe2d"

URI_x86_64_v2_rust-bisection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bisection-devel-0.1.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bisection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bisection-devel}"
SRC_URI[x86_64_v2_rust-bisection-devel.sha256sum] = "0c5f52ad726a2842d331c4c7a3b463612c3c4ac8bfc39a06e9a4757bca115ed8"

URI_aarch64_rust-bisection+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bisection+default-devel-0.1.0-5.el10_0.noarch.rpm;name=aarch64_rust-bisection+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bisection+default-devel}"
SRC_URI[aarch64_rust-bisection+default-devel.sha256sum] = "fd7050a7e360eeebad812b4ae5ed89b0f3c0d2683bd79424a0e31e1a0acf319a"

URI_aarch64_rust-bisection-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bisection-devel-0.1.0-5.el10_0.noarch.rpm;name=aarch64_rust-bisection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bisection-devel}"
SRC_URI[aarch64_rust-bisection-devel.sha256sum] = "619a05498be9639f0a6fba3f0bbb474bf60e07c0e6bc6885ff2b86de6da61510"

RDEPENDS:rust-bisection+default-devel = " \
 cargo \
 rust-bisection-devel \
 "
RDEPENDS:rust-bisection-devel = " \
 cargo \
 "
