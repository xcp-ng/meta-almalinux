# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "barman"
PV = "3.20.0"
PR = "1.el10_3"
PACKAGES = " \
 barman \
 barman-cli \
 python3-barman \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/barman-3.20.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a3232be3c5227c1581c4785b2f8627a91bca6e80940714445103a0aeae7c9783"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/barman-3.20.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_barman;unpack=0"
SRC_URI[x86_64_v2_barman.sha256sum] = "0b80c4729a6cbaf37a572aa2e5de8862bb55867c0a6a2e94ccb2f2eb518fda90"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/barman-cli-3.20.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_barman-cli;unpack=0"
SRC_URI[x86_64_v2_barman-cli.sha256sum] = "74aa4b5239b91e3c5699184fcbbb2c34b842554a6f811896dcd3a0ca14d21dcc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-barman-3.20.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-barman;unpack=0"
SRC_URI[x86_64_v2_python3-barman.sha256sum] = "efdb8ac590664d6f272e5357fa41b1bff8c8395c28a79e3aac7d429e83b6ec65"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/barman-3.20.0-1.el10_3.noarch.rpm;name=aarch64_barman;unpack=0"
SRC_URI[aarch64_barman.sha256sum] = "520a07181bb94d0fb1134d3561f656fcdddf0b31ab4996775036e85dd03818d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/barman-cli-3.20.0-1.el10_3.noarch.rpm;name=aarch64_barman-cli;unpack=0"
SRC_URI[aarch64_barman-cli.sha256sum] = "66df027100aa4a795fc83e10abb576c843f66dd0050e7d6c5c2c8236e0c8dd5e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-barman-3.20.0-1.el10_3.noarch.rpm;name=aarch64_python3-barman;unpack=0"
SRC_URI[aarch64_python3-barman.sha256sum] = "0a3659359a5c2fe702bd75279c139e70f559d0d4f7895c7b5fefcc36e90a280d"

RDEPENDS:barman = " \
 cronie \
 logrotate \
 python3 \
 python3-argcomplete \
 python3-barman \
 rsync \
 "
RDEPENDS:barman-cli = " \
 python3 \
 python3-barman \
 "
RDEPENDS:python3-barman = " \
 python3 \
 python3-dateutil \
 python3-psycopg2 \
 "
