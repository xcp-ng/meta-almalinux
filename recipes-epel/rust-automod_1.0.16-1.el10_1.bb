# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-automod"
PV = "1.0.16"
PR = "1.el10_1"
PACKAGES = " \
 rust-automod+default-devel \
 rust-automod-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-automod-1.0.16-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f5743521d3296ca52255f417566b49aee9120864c04efcfbf4be436bf8a79cd"

URI_x86_64_v2_rust-automod+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-automod+default-devel-1.0.16-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-automod+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-automod+default-devel}"
SRC_URI[x86_64_v2_rust-automod+default-devel.sha256sum] = "9529a1ba9145334d22c01b3d83d7e1f922a6b02dee05b8b644aba49e07479636"

URI_x86_64_v2_rust-automod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-automod-devel-1.0.16-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-automod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-automod-devel}"
SRC_URI[x86_64_v2_rust-automod-devel.sha256sum] = "1d1ccd25cd201b5cb7a64e699d3a97a33d64c04e8eadc41c1e6493c4cf946a2e"

URI_aarch64_rust-automod+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-automod+default-devel-1.0.16-1.el10_1.noarch.rpm;name=aarch64_rust-automod+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-automod+default-devel}"
SRC_URI[aarch64_rust-automod+default-devel.sha256sum] = "5139b1dc0bd21980845e55f51365a4f2bf2be8c31c35621abb6491263d1d1d10"

URI_aarch64_rust-automod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-automod-devel-1.0.16-1.el10_1.noarch.rpm;name=aarch64_rust-automod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-automod-devel}"
SRC_URI[aarch64_rust-automod-devel.sha256sum] = "595dff8b5798503311f4942dc8d556aa0f4a7673ab4df8c03f03f5b2395e071c"

RDEPENDS:rust-automod+default-devel = " \
 cargo \
 rust-automod-devel \
 "
RDEPENDS:rust-automod-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
