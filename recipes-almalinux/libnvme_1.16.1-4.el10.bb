# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnvme"
PV = "1.16.1"
PR = "4.el10"
PACKAGES = " \
 libnvme \
 libnvme-devel \
 python3-libnvme \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libnvme-1.16.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ad3448b209bab64714c22b068ef8ec4ef792b503c9ec5ed18297f5370159fd6"

URI_x86_64_v2_libnvme = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnvme-1.16.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_libnvme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnvme}"
SRC_URI[x86_64_v2_libnvme.sha256sum] = "556984d10e2eb882e7b3f3dfdccce5093e2d6987f995b407e918b20a0b2fa5e5"

URI_x86_64_v2_libnvme-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnvme-devel-1.16.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_libnvme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnvme-devel}"
SRC_URI[x86_64_v2_libnvme-devel.sha256sum] = "0cd358397605745d9b865ee466c9211a0b0c2c6ebda639d1c2950697f4a5b45b"

URI_x86_64_v2_python3-libnvme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnvme-1.16.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libnvme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libnvme}"
SRC_URI[x86_64_v2_python3-libnvme.sha256sum] = "7e492c94989e2987061466d3a02c022b788c669f1447a7475dba57ee6f1c9249"

URI_aarch64_libnvme = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnvme-1.16.1-4.el10.aarch64.rpm;name=aarch64_libnvme;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnvme}"
SRC_URI[aarch64_libnvme.sha256sum] = "f4d19a80d8e859be0c45c5b21d4654287339d0909de767092a0e97c9b689f582"

URI_aarch64_libnvme-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnvme-devel-1.16.1-4.el10.aarch64.rpm;name=aarch64_libnvme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnvme-devel}"
SRC_URI[aarch64_libnvme-devel.sha256sum] = "68aec8e53d2c363dcf5fca03526fa6906fb06414ab015564141d07f7b7ff64cd"

URI_aarch64_python3-libnvme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnvme-1.16.1-4.el10.aarch64.rpm;name=aarch64_python3-libnvme;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libnvme}"
SRC_URI[aarch64_python3-libnvme.sha256sum] = "d05994efff8272332ea6b80e261a392f9ece65c27a7fea641eca1f4050452e30"

RDEPENDS:libnvme = " \
 dbus-libs \
 glibc \
 json-c \
 keyutils-libs \
 libgcc \
 openssl-libs \
 "
RDEPENDS:libnvme-devel = " \
 dbus-devel \
 json-c-devel \
 keyutils-libs-devel \
 libnvme \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libnvme = " \
 glibc \
 libnvme \
 python3 \
 "
