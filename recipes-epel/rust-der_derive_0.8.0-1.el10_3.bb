# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-der_derive"
PV = "0.8.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-der_derive+default-devel \
 rust-der_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-der_derive-0.8.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7814640fffd3d42ce575318241aabc1e63c20a4582bd0b6afd17f0affc49b786"

URI_x86_64_v2_rust-der_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der_derive+default-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der_derive+default-devel}"
SRC_URI[x86_64_v2_rust-der_derive+default-devel.sha256sum] = "93683b6144c6fadda027ea39d37e4ed0adb3ad028f5205854f8e85f40ee9d833"

URI_x86_64_v2_rust-der_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der_derive-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der_derive-devel}"
SRC_URI[x86_64_v2_rust-der_derive-devel.sha256sum] = "cab7b59baa78351cfbd6fd3398c3f77623e12f3093d0b818bad42336b0928d92"

URI_aarch64_rust-der_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der_derive+default-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der_derive+default-devel}"
SRC_URI[aarch64_rust-der_derive+default-devel.sha256sum] = "bb5d55c1b2927f011508abb69d8a31d2ad09120b894404c29d1a63585c2f28ca"

URI_aarch64_rust-der_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der_derive-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der_derive-devel}"
SRC_URI[aarch64_rust-der_derive-devel.sha256sum] = "92b5fb41d075bef9e5e0d976312e7ed05c4fa1670d6173c199f49bed554ce83a"

RDEPENDS:rust-der_derive+default-devel = " \
 cargo \
 rust-der_derive-devel \
 "
RDEPENDS:rust-der_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 "
