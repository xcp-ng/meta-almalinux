# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cdrkit"
PV = "1.1.11"
PR = "58.el10_1"
PACKAGES = " \
 dirsplit \
 genisoimage \
 icedax \
 libusal \
 libusal-devel \
 wodim \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cdrkit-1.1.11-58.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cdb3274a9204e2b36b6d34dd242fd7aec6a10c368d710588b6e208bd9ccc4540"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - wodim: libcap.so.2()(64bit)

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dirsplit-1.1.11-58.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dirsplit;unpack=0"
SRC_URI[x86_64_v2_dirsplit.sha256sum] = "8a7b81c5cf5aeffe588a91ba168385bf7658833e83a44f9b0f395d04c0023522"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genisoimage-1.1.11-58.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genisoimage;unpack=0"
SRC_URI[x86_64_v2_genisoimage.sha256sum] = "ef8b79b23a338fdbb28bc921135feab67195b545211892bf4bd6987e9c3629c1"
RPROVIDES:genisoimage:append:x86_64_v2 = " virtual//usr/bin/mkisofs"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icedax-1.1.11-58.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_icedax;unpack=0"
SRC_URI[x86_64_v2_icedax.sha256sum] = "67e87ffc7934629cbc69e74c9c896237a0d90c641ff2b3fd86a8e4b2a9de7665"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusal-1.1.11-58.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusal;unpack=0"
SRC_URI[x86_64_v2_libusal.sha256sum] = "88b161f9e15247696bc3d691f8efc9a01714487e9f1f7d8b4d6fb1da1621bf34"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusal-devel-1.1.11-58.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusal-devel;unpack=0"
SRC_URI[x86_64_v2_libusal-devel.sha256sum] = "346061fff03b5f5bd2b39d8c0ec18c8dd6fbfabee3dafcb8cd990351db7e1fa1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wodim-1.1.11-58.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wodim;unpack=0"
SRC_URI[x86_64_v2_wodim.sha256sum] = "e2285a597aa041d60d9ddf59f24227e9a6286a77eaabf7819d2696c5698b0351"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dirsplit-1.1.11-58.el10_1.aarch64.rpm;name=aarch64_dirsplit;unpack=0"
SRC_URI[aarch64_dirsplit.sha256sum] = "468ebc2b526aa495e1ece35ef7c23ce06cb37cddd682f7595f3675eeb8d3abb6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/genisoimage-1.1.11-58.el10_1.aarch64.rpm;name=aarch64_genisoimage;unpack=0"
SRC_URI[aarch64_genisoimage.sha256sum] = "5a2c29ecdb998d93a5f63a981c880afb48ad617646ced00a4b52eca968842b7c"
RPROVIDES:genisoimage:append:aarch64 = " virtual//usr/bin/mkisofs"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/icedax-1.1.11-58.el10_1.aarch64.rpm;name=aarch64_icedax;unpack=0"
SRC_URI[aarch64_icedax.sha256sum] = "eb80fedace3838350f1d4a3ea30d30bb823d2ac2e63e746320a4dac6d3e6ff56"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libusal-1.1.11-58.el10_1.aarch64.rpm;name=aarch64_libusal;unpack=0"
SRC_URI[aarch64_libusal.sha256sum] = "26c990ed8b6fb6ddde94678758f942c3ff7d9eeb37762acaa929ba7013d638b7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libusal-devel-1.1.11-58.el10_1.aarch64.rpm;name=aarch64_libusal-devel;unpack=0"
SRC_URI[aarch64_libusal-devel.sha256sum] = "7a0914ee4eb696d3060128e58baca3169ccf3cc73434059c51ba81b792b5d166"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wodim-1.1.11-58.el10_1.aarch64.rpm;name=aarch64_wodim;unpack=0"
SRC_URI[aarch64_wodim.sha256sum] = "da5d86adc43147169144ea663707fa865e401143fa21dcf069e37c32f6d642d0"

RDEPENDS:dirsplit = " \
 genisoimage \
 perl-File-Basename \
 perl-File-Path \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:genisoimage = " \
 alternatives \
 bash \
 bzip2-libs \
 file-libs \
 glibc \
 libusal \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:icedax = " \
 alternatives \
 bash \
 cdparanoia \
 cdparanoia-libs \
 glibc \
 libusal \
 virtual/coreutils \
 vorbis-tools \
 "
RDEPENDS:libusal = " \
 glibc \
 "
RDEPENDS:libusal-devel = " \
 libusal \
 "
RDEPENDS:wodim:x86_64_v2 = " \
 alternatives \
 bash \
 glibc \
 libcap \
 libusal \
 virtual/coreutils \
"
RDEPENDS:wodim:aarch64 = " \
 alternatives \
 bash \
 glibc \
 libusal \
 virtual/coreutils \
"
