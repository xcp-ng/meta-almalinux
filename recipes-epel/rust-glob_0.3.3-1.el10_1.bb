# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-glob"
PV = "0.3.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-glob+default-devel \
 rust-glob-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-glob-0.3.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2598740018c6fb367d015f77cca87b9ca4e36319b235f9dfc1f5444ae24cbb3"

URI_x86_64_v2_rust-glob+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-glob+default-devel-0.3.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-glob+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-glob+default-devel}"
SRC_URI[x86_64_v2_rust-glob+default-devel.sha256sum] = "f16e4d1d38590b12fc605a41188caa1f5161dbf05f05029eb425e9b7277b5358"

URI_x86_64_v2_rust-glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-glob-devel-0.3.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-glob-devel}"
SRC_URI[x86_64_v2_rust-glob-devel.sha256sum] = "acf3a1390206481409e7c036025ecf1e3f7b17d710c1b37a203e862fa1d1edc4"

URI_aarch64_rust-glob+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-glob+default-devel-0.3.3-1.el10_1.noarch.rpm;name=aarch64_rust-glob+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-glob+default-devel}"
SRC_URI[aarch64_rust-glob+default-devel.sha256sum] = "54c34d0502d23a2080913dd5c0875431aa87307c432dcb52090f3e49194c706c"

URI_aarch64_rust-glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-glob-devel-0.3.3-1.el10_1.noarch.rpm;name=aarch64_rust-glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-glob-devel}"
SRC_URI[aarch64_rust-glob-devel.sha256sum] = "4146c07676dc6cb5b0a9fbb804fda3f00372d56a692cff0feff36c16bffec521"

RDEPENDS:rust-glob+default-devel = " \
 cargo \
 rust-glob-devel \
 "
RDEPENDS:rust-glob-devel = " \
 cargo \
 rust \
 "
