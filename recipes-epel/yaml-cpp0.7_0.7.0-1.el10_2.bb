# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yaml-cpp0.7"
PV = "0.7.0"
PR = "1.el10_2"
PACKAGES = " \
 yaml-cpp0.7 \
 yaml-cpp0.7-devel \
 yaml-cpp0.7-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yaml-cpp0.7-0.7.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15cdf89786e351bc13118f958aee5201753abf2e3289d8bc4b017cdfb1cc2c64"

URI_x86_64_v2_yaml-cpp0.7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yaml-cpp0.7-0.7.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yaml-cpp0.7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yaml-cpp0.7}"
SRC_URI[x86_64_v2_yaml-cpp0.7.sha256sum] = "287a1847f680f8603044cec966a96b4643bac32f1db3e88702b82f5717366f64"

URI_x86_64_v2_yaml-cpp0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yaml-cpp0.7-devel-0.7.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yaml-cpp0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yaml-cpp0.7-devel}"
SRC_URI[x86_64_v2_yaml-cpp0.7-devel.sha256sum] = "c85f982e7de0b23b66e465ae1c170c4dbb29e2ab718ae13471ad8b94d1a5c200"
RPROVIDES:yaml-cpp0.7-devel:x86_64_v2 = "virtual/pkgconfig_yaml-cpp_"

URI_x86_64_v2_yaml-cpp0.7-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yaml-cpp0.7-static-0.7.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yaml-cpp0.7-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yaml-cpp0.7-static}"
SRC_URI[x86_64_v2_yaml-cpp0.7-static.sha256sum] = "9129c16142bb63e609b8a463fbb0d0b4a51d38c8c8d6317a64fa9e2f494a091a"

URI_aarch64_yaml-cpp0.7 = "${EPEL_MIRROR}/aarch64/Packages/y/yaml-cpp0.7-0.7.0-1.el10_2.aarch64.rpm;name=aarch64_yaml-cpp0.7;unpack=0"
SRC_URI:append = " ${URI_aarch64_yaml-cpp0.7}"
SRC_URI[aarch64_yaml-cpp0.7.sha256sum] = "d5b769678c10cf4960223a84583c780c7cd81896fcfe51bc9c2742df3fe9eb60"

URI_aarch64_yaml-cpp0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/y/yaml-cpp0.7-devel-0.7.0-1.el10_2.aarch64.rpm;name=aarch64_yaml-cpp0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yaml-cpp0.7-devel}"
SRC_URI[aarch64_yaml-cpp0.7-devel.sha256sum] = "26b2bcfe306511d5e3ac244d31167d7f06c30f85765354c9646f61cdfb55d57b"
RPROVIDES:yaml-cpp0.7-devel:aarch64 = "virtual/pkgconfig_yaml-cpp_"

URI_aarch64_yaml-cpp0.7-static = "${EPEL_MIRROR}/aarch64/Packages/y/yaml-cpp0.7-static-0.7.0-1.el10_2.aarch64.rpm;name=aarch64_yaml-cpp0.7-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_yaml-cpp0.7-static}"
SRC_URI[aarch64_yaml-cpp0.7-static.sha256sum] = "0967be25c5d70070c6dadecc2f7fb13b78da641ed2008dcde0826716912256c6"

RDEPENDS:yaml-cpp0.7 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:yaml-cpp0.7-devel = " \
 cmake-filesystem \
 libstdc++-devel \
 pkgconf-pkg-config \
 yaml-cpp0.7 \
 "
RDEPENDS:yaml-cpp0.7-static = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 yaml-cpp0.7-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/pkgconfig_yaml-cpp_"

PROVIDES:append:aarch64 = " rpm/virtual/pkgconfig_yaml-cpp_"
