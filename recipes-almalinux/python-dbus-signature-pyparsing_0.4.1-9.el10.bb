# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dbus-signature-pyparsing"
PV = "0.4.1"
PR = "9.el10"
PACKAGES = " \
 python3-dbus-signature-pyparsing \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-dbus-signature-pyparsing-0.4.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17de265b5af846cb7ac3dd6076b0df0fcef71909e404cd52aaad10ae318f7894"

URI_x86_64_v2_python3-dbus-signature-pyparsing = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dbus-signature-pyparsing-0.4.1-9.el10.noarch.rpm;name=x86_64_v2_python3-dbus-signature-pyparsing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dbus-signature-pyparsing}"
SRC_URI[x86_64_v2_python3-dbus-signature-pyparsing.sha256sum] = "4b6b51c02d4098c62851f2686d9736e14835003e14d7f4e684cf2ba0904eef49"

URI_aarch64_python3-dbus-signature-pyparsing = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dbus-signature-pyparsing-0.4.1-9.el10.noarch.rpm;name=aarch64_python3-dbus-signature-pyparsing;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dbus-signature-pyparsing}"
SRC_URI[aarch64_python3-dbus-signature-pyparsing.sha256sum] = "4b6b51c02d4098c62851f2686d9736e14835003e14d7f4e684cf2ba0904eef49"

RDEPENDS:python3-dbus-signature-pyparsing = " \
 python3 \
 python3-pyparsing \
 "
