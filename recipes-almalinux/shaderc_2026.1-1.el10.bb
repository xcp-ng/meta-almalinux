# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shaderc"
PV = "2026.1"
PR = "1.el10"
PACKAGES = " \
 glslc \
 libshaderc \
 libshaderc-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/shaderc-2026.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b41ed656084c81d1b1751870ee2951bbdea9207a6c66064c9de9c810245d2cc5"

URI_x86_64_v2_glslc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glslc-2026.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_glslc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glslc}"
SRC_URI[x86_64_v2_glslc.sha256sum] = "2107d19c8344f202f21732bd057465e61f646017bf9e544b6b33b351c14a9424"

URI_x86_64_v2_libshaderc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libshaderc-2026.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libshaderc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libshaderc}"
SRC_URI[x86_64_v2_libshaderc.sha256sum] = "9739fe9d52b0ddfc0b1a2e415771eb84057d17271c68a5acd938fcec9e4b1c87"

URI_x86_64_v2_libshaderc-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libshaderc-devel-2026.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libshaderc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libshaderc-devel}"
SRC_URI[x86_64_v2_libshaderc-devel.sha256sum] = "2847b90fca39b7dccbe99472c68cb58c17d3ca87af45a7eb2953a63b946c7ecf"

URI_aarch64_glslc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glslc-2026.1-1.el10.aarch64.rpm;name=aarch64_glslc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glslc}"
SRC_URI[aarch64_glslc.sha256sum] = "c865a01147dd5489d0a8cabafb0ed02f4d3f14688a8354b4200ffaa831b276a3"

URI_aarch64_libshaderc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libshaderc-2026.1-1.el10.aarch64.rpm;name=aarch64_libshaderc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libshaderc}"
SRC_URI[aarch64_libshaderc.sha256sum] = "513de2e944a17b35918a4dcc1d9df9e6920f67e3536888694ee16dfadd17aa61"

URI_aarch64_libshaderc-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libshaderc-devel-2026.1-1.el10.aarch64.rpm;name=aarch64_libshaderc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libshaderc-devel}"
SRC_URI[aarch64_libshaderc-devel.sha256sum] = "680795ce10179766fe470caba7f95a8b4400a8f50b6eed1cb2477131796596e9"

RDEPENDS:glslc = " \
 glibc \
 libgcc \
 libstdc++ \
 spirv-tools-libs \
 "
RDEPENDS:libshaderc = " \
 glibc \
 libgcc \
 libstdc++ \
 spirv-tools-libs \
 "
RDEPENDS:libshaderc-devel = " \
 libshaderc \
 pkgconf-pkg-config \
 "
