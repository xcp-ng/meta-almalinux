# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cryptopp"
PV = "8.8.0"
PR = "9.el10_0"
PACKAGES = " \
 cryptopp \
 cryptopp-devel \
 cryptopp-static \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cryptopp-8.8.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f61c3dc552ad692b8025fbd0feef292960ea43119c23acb186d4f247f16bac67"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cryptopp-8.8.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cryptopp;unpack=0"
SRC_URI[x86_64_v2_cryptopp.sha256sum] = "c487a6daea60ef603588df4955e2d9c14d08b4e93137ba7e43d20d5d6503305c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cryptopp-devel-8.8.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cryptopp-devel;unpack=0"
SRC_URI[x86_64_v2_cryptopp-devel.sha256sum] = "20b15ad603f0609e00e889eeb7bb4629c0905e47b5d970973fc671f6ce93f8f9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cryptopp-static-8.8.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cryptopp-static;unpack=0"
SRC_URI[x86_64_v2_cryptopp-static.sha256sum] = "f21688ce39cc3d9b1b8d2167d21c64a391f52f33bbca4d9976272808e97822c1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cryptopp-8.8.0-9.el10_0.aarch64.rpm;name=aarch64_cryptopp;unpack=0"
SRC_URI[aarch64_cryptopp.sha256sum] = "70fe79ba9a238c4300f7c46655760b5a54b7f741f1a09e706aca15ddb44e3104"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cryptopp-devel-8.8.0-9.el10_0.aarch64.rpm;name=aarch64_cryptopp-devel;unpack=0"
SRC_URI[aarch64_cryptopp-devel.sha256sum] = "36fcd9cc8662b9a5efb1af1a40123580ed82c1ad3009a173dae4ed4827727588"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cryptopp-static-8.8.0-9.el10_0.aarch64.rpm;name=aarch64_cryptopp-static;unpack=0"
SRC_URI[aarch64_cryptopp-static.sha256sum] = "4f711d5bdcd3e94c437e31dffde611e7b254639beaf4223cb41d4c1ef058cd91"

RDEPENDS:cryptopp = " \
 glibc \
 libgcc \
 "
RDEPENDS:cryptopp-devel = " \
 cryptopp \
 pkgconf-pkg-config \
 "
RDEPENDS:cryptopp-static = " \
 cryptopp-devel \
 "
