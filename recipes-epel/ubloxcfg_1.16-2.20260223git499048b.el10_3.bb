# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ubloxcfg"
PV = "1.16"
PR = "2.20260223git499048b.el10_3"
PACKAGES = " \
 ubloxcfg \
 ubloxcfg-devel \
 ubloxcfg-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/u/ubloxcfg-1.16-2.20260223git499048b.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d33a1971482b07fae20a129b201bdeb6be92ee088e473e56d3ef78470c9e080a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/ubloxcfg-1.16-2.20260223git499048b.el10_3.aarch64.rpm;name=aarch64_ubloxcfg;unpack=0"
SRC_URI[aarch64_ubloxcfg.sha256sum] = "dfc02fe4d2afdeaddd6023b7caa804fd45f8752467472161689e62a5bf008b57"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/ubloxcfg-devel-1.16-2.20260223git499048b.el10_3.aarch64.rpm;name=aarch64_ubloxcfg-devel;unpack=0"
SRC_URI[aarch64_ubloxcfg-devel.sha256sum] = "aa6e9981bc975f0cbb969eef49ac0b17bf4fbfd6feed7b26eb8f3c52856886fb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/ubloxcfg-doc-1.16-2.20260223git499048b.el10_3.noarch.rpm;name=aarch64_ubloxcfg-doc;unpack=0"
SRC_URI[aarch64_ubloxcfg-doc.sha256sum] = "e5fd500356710d1b4c6ae251167d3e93a3d8f42fca72cb236aae6f7845244cd9"

RDEPENDS:ubloxcfg = " \
 glibc \
 "
RDEPENDS:ubloxcfg-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 ubloxcfg \
 "
RDEPENDS:ubloxcfg-doc = " \
 ubloxcfg \
 "
