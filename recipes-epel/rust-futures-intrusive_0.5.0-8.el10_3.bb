# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-intrusive"
PV = "0.5.0"
PR = "8.el10_3"
PACKAGES = " \
 rust-futures-intrusive+alloc-devel \
 rust-futures-intrusive+default-devel \
 rust-futures-intrusive+parking_lot-devel \
 rust-futures-intrusive+std-devel \
 rust-futures-intrusive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-intrusive-0.5.0-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0aec7ff706e604839af4e559b8ecb66e3dd86b8f305d862c3eb66e0634d4bad6"

URI_x86_64_v2_rust-futures-intrusive+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-intrusive+alloc-devel-0.5.0-8.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-intrusive+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-intrusive+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-intrusive+alloc-devel.sha256sum] = "accadebd5531a7ede91171d76485fe66fe7d13070f7d490a29e191923333fb99"

URI_x86_64_v2_rust-futures-intrusive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-intrusive+default-devel-0.5.0-8.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-intrusive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-intrusive+default-devel}"
SRC_URI[x86_64_v2_rust-futures-intrusive+default-devel.sha256sum] = "5f839d8c5b60f3a1ced73bb4eb1ea819f560c68056b10457c433063066f0be29"

URI_x86_64_v2_rust-futures-intrusive+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-intrusive+parking_lot-devel-0.5.0-8.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-intrusive+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-intrusive+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-futures-intrusive+parking_lot-devel.sha256sum] = "0a8c97c1673eaba53d98effeedbcf98cc693a8253e90a7988ce1b2ea22f052ee"

URI_x86_64_v2_rust-futures-intrusive+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-intrusive+std-devel-0.5.0-8.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-intrusive+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-intrusive+std-devel}"
SRC_URI[x86_64_v2_rust-futures-intrusive+std-devel.sha256sum] = "67cfc1b50d88be2c6815390ed49a7df527037b89d9b5bc911388b47018b907ce"

URI_x86_64_v2_rust-futures-intrusive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-intrusive-devel-0.5.0-8.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-intrusive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-intrusive-devel}"
SRC_URI[x86_64_v2_rust-futures-intrusive-devel.sha256sum] = "48f80e67a0b3816c4bd41bc474ebb762d26c15495a11ace1b1c294a994fe277c"

URI_aarch64_rust-futures-intrusive+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-intrusive+alloc-devel-0.5.0-8.el10_3.noarch.rpm;name=aarch64_rust-futures-intrusive+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-intrusive+alloc-devel}"
SRC_URI[aarch64_rust-futures-intrusive+alloc-devel.sha256sum] = "95097ee9346546dfd763204bce6c9e046d3e86ecbedec74b696f00822397846f"

URI_aarch64_rust-futures-intrusive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-intrusive+default-devel-0.5.0-8.el10_3.noarch.rpm;name=aarch64_rust-futures-intrusive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-intrusive+default-devel}"
SRC_URI[aarch64_rust-futures-intrusive+default-devel.sha256sum] = "79b64e44b0b825d8c9da681c05c005c60939ce8ef99b4ba9d72f8cfaad76988d"

URI_aarch64_rust-futures-intrusive+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-intrusive+parking_lot-devel-0.5.0-8.el10_3.noarch.rpm;name=aarch64_rust-futures-intrusive+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-intrusive+parking_lot-devel}"
SRC_URI[aarch64_rust-futures-intrusive+parking_lot-devel.sha256sum] = "ab0ea04b22f8065f0f4b30dfc33d9d0ad905f7295821ef92cac4ed26895f5eb0"

URI_aarch64_rust-futures-intrusive+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-intrusive+std-devel-0.5.0-8.el10_3.noarch.rpm;name=aarch64_rust-futures-intrusive+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-intrusive+std-devel}"
SRC_URI[aarch64_rust-futures-intrusive+std-devel.sha256sum] = "906b55d3a234db08c1f18bb9adcaa089d3ac74d1c2574a948aca468f72eae369"

URI_aarch64_rust-futures-intrusive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-intrusive-devel-0.5.0-8.el10_3.noarch.rpm;name=aarch64_rust-futures-intrusive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-intrusive-devel}"
SRC_URI[aarch64_rust-futures-intrusive-devel.sha256sum] = "07295f0659fbf8a6eca85a70e9618f58f2eba44a89c4f72e75841364d1cfe459"

RDEPENDS:rust-futures-intrusive+alloc-devel = " \
 cargo \
 rust-futures-core+alloc-devel \
 rust-futures-intrusive-devel \
 "
RDEPENDS:rust-futures-intrusive+default-devel = " \
 cargo \
 rust-futures-intrusive+std-devel \
 rust-futures-intrusive-devel \
 "
RDEPENDS:rust-futures-intrusive+parking_lot-devel = " \
 cargo \
 rust-futures-intrusive-devel \
 rust-parking_lot+default-devel \
 "
RDEPENDS:rust-futures-intrusive+std-devel = " \
 cargo \
 rust-futures-intrusive+alloc-devel \
 rust-futures-intrusive+parking_lot-devel \
 rust-futures-intrusive-devel \
 "
RDEPENDS:rust-futures-intrusive-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-lock_api+default-devel \
 "
