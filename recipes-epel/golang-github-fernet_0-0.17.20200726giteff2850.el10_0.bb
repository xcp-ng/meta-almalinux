# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-fernet"
PV = "0"
PR = "0.17.20200726giteff2850.el10_0"
PACKAGES = " \
 golang-github-fernet \
 golang-github-fernet-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-fernet-0-0.17.20200726giteff2850.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9741ce7444b98270cba6f6031a3bae973cffe86c91d565aaceac74af480f453e"

URI_aarch64_golang-github-fernet = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-fernet-0-0.17.20200726giteff2850.el10_0.aarch64.rpm;name=aarch64_golang-github-fernet;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-fernet}"
SRC_URI[aarch64_golang-github-fernet.sha256sum] = "5cfee4250358bcc2d41c09acc9de3e267a2ef61c38cb06f4bb96396d5cd9b925"

URI_aarch64_golang-github-fernet-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-fernet-devel-0-0.17.20200726giteff2850.el10_0.noarch.rpm;name=aarch64_golang-github-fernet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-fernet-devel}"
SRC_URI[aarch64_golang-github-fernet-devel.sha256sum] = "666f8f93598336ae1a9307a2ce78071d059d1b2f4f74c5a262ac87bb99e58e19"

RDEPENDS:golang-github-fernet = " \
 glibc \
 "
RDEPENDS:golang-github-fernet-devel = " \
 go-filesystem \
 "
