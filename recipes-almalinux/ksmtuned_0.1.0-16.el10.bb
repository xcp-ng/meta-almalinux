# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksmtuned"
PV = "0.1.0"
PR = "16.el10"
PACKAGES = " \
 ksmtuned \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ksmtuned-0.1.0-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "759521b49c1cdd6347883df96b9c5a302c8510bcbe2ce29f2be52bb60427664e"

URI_x86_64_v2_ksmtuned = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ksmtuned-0.1.0-16.el10.x86_64_v2.rpm;name=x86_64_v2_ksmtuned;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksmtuned}"
SRC_URI[x86_64_v2_ksmtuned.sha256sum] = "d2bc51753c1f9f689abaf4516fd2ebd78e8a27069aa2d01bb73332e1900e2868"

URI_aarch64_ksmtuned = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ksmtuned-0.1.0-16.el10.aarch64.rpm;name=aarch64_ksmtuned;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksmtuned}"
SRC_URI[aarch64_ksmtuned.sha256sum] = "15692ca82ca39e4f550d48b3fe41a8314c12579a2f62ff7dd2e9bcf06971472b"

RDEPENDS:ksmtuned = " \
 bash \
 glibc \
 systemd \
 "
