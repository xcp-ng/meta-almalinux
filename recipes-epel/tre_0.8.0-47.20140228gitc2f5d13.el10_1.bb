# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tre"
PV = "0.8.0"
PR = "47.20140228gitc2f5d13.el10_1"
PACKAGES = " \
 agrep \
 python3-tre \
 tre \
 tre-common \
 tre-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tre-0.8.0-47.20140228gitc2f5d13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd46bdddf9d694c93aa01d212e71d77ff63cb6c6126876aede8ad4dd44776d7d"

URI_x86_64_v2_agrep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/agrep-0.8.0-47.20140228gitc2f5d13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_agrep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_agrep}"
SRC_URI[x86_64_v2_agrep.sha256sum] = "e0d1c170b68d6468f9a5ac7ea7768c9c07020fa16b5d101f687136ff838a55f4"

URI_x86_64_v2_python3-tre = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tre-0.8.0-47.20140228gitc2f5d13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-tre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tre}"
SRC_URI[x86_64_v2_python3-tre.sha256sum] = "aa9497e73fb5be37aae9fb3921235045e3867510a4e31cdb59611d89a7a63df3"

URI_x86_64_v2_tre = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tre-0.8.0-47.20140228gitc2f5d13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tre}"
SRC_URI[x86_64_v2_tre.sha256sum] = "1afed99de620204c4694daf290353546da7647d85ff790754bd82bbc7309f2fe"

URI_x86_64_v2_tre-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tre-common-0.8.0-47.20140228gitc2f5d13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tre-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tre-common}"
SRC_URI[x86_64_v2_tre-common.sha256sum] = "de8492f8a1e5a4edf22f321a961dddecd91a57fddd2ccc7dc0db39fa5c288bdc"

URI_x86_64_v2_tre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tre-devel-0.8.0-47.20140228gitc2f5d13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tre-devel}"
SRC_URI[x86_64_v2_tre-devel.sha256sum] = "88faa7f9a318b0ee970e6ee5afb6b4a35b4a072aeaeb47cbd3daa84ba88f1fd2"

URI_aarch64_agrep = "${EPEL_MIRROR}/aarch64/Packages/a/agrep-0.8.0-47.20140228gitc2f5d13.el10_1.aarch64.rpm;name=aarch64_agrep;unpack=0"
SRC_URI:append = " ${URI_aarch64_agrep}"
SRC_URI[aarch64_agrep.sha256sum] = "a5f5928c90a590855a0cd47a255b0a8acfb944d6c47dd88a15af356467386d6c"

URI_aarch64_python3-tre = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tre-0.8.0-47.20140228gitc2f5d13.el10_1.aarch64.rpm;name=aarch64_python3-tre;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tre}"
SRC_URI[aarch64_python3-tre.sha256sum] = "2073d2bae8805a861e793cd297930265fe2476ad89be4940beb883f5fe150683"

URI_aarch64_tre = "${EPEL_MIRROR}/aarch64/Packages/t/tre-0.8.0-47.20140228gitc2f5d13.el10_1.aarch64.rpm;name=aarch64_tre;unpack=0"
SRC_URI:append = " ${URI_aarch64_tre}"
SRC_URI[aarch64_tre.sha256sum] = "346103f1dbea4f60988868ae11ee92d4f16d4d2a1cd55eb691a787e83ab67363"

URI_aarch64_tre-common = "${EPEL_MIRROR}/aarch64/Packages/t/tre-common-0.8.0-47.20140228gitc2f5d13.el10_1.noarch.rpm;name=aarch64_tre-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_tre-common}"
SRC_URI[aarch64_tre-common.sha256sum] = "2a0aef132fe422b018965860b9e746be9accbc869d87f875154850d5dabdf425"

URI_aarch64_tre-devel = "${EPEL_MIRROR}/aarch64/Packages/t/tre-devel-0.8.0-47.20140228gitc2f5d13.el10_1.aarch64.rpm;name=aarch64_tre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tre-devel}"
SRC_URI[aarch64_tre-devel.sha256sum] = "c4b3515e73a8e23081c5fa1810c2736f5f7faf1641f298f946afc12d59b275a0"

RDEPENDS:agrep = " \
 glibc \
 tre \
 "
RDEPENDS:python3-tre = " \
 glibc \
 python3 \
 tre \
 "
RDEPENDS:tre = " \
 glibc \
 tre-common \
 "
RDEPENDS:tre-common = " \
 "
RDEPENDS:tre-devel = " \
 pkgconf-pkg-config \
 tre \
 "
