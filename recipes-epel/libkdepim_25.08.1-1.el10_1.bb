# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdepim"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 libkdepim \
 libkdepim-devel \
 libkdepim-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkdepim-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7d8e4477f73a5a62d7d61ce7d5b86827b629e8bd81b3d4f82a5e5c4d57c8fb5"

URI_x86_64_v2_libkdepim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdepim-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdepim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdepim}"
SRC_URI[x86_64_v2_libkdepim.sha256sum] = "7ea5837b28f06f5734d1ab1ea6cd83287f6f5866e2e35d97097d1e271168d14c"

URI_x86_64_v2_libkdepim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdepim-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdepim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdepim-devel}"
SRC_URI[x86_64_v2_libkdepim-devel.sha256sum] = "a840eda6b905426c509fdc14839c1a79887ca59ab770e7001d08c31b8af05f85"

URI_x86_64_v2_libkdepim-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdepim-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libkdepim-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdepim-doc}"
SRC_URI[x86_64_v2_libkdepim-doc.sha256sum] = "195d4c3260700e60329f1f4da53e1ed8a796a7f34996abbbfc81e128cbb5ce44"

URI_aarch64_libkdepim = "${EPEL_MIRROR}/aarch64/Packages/l/libkdepim-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkdepim;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdepim}"
SRC_URI[aarch64_libkdepim.sha256sum] = "c4bdd0f070029ea7766387767880ad4e555c8c458ba9b124cae5de6117abc43d"

URI_aarch64_libkdepim-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkdepim-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkdepim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdepim-devel}"
SRC_URI[aarch64_libkdepim-devel.sha256sum] = "9af99b555c58bf79ace3662efa060a187fc30e77cc5b7d5366699b09feedde1d"

URI_aarch64_libkdepim-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkdepim-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_libkdepim-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdepim-doc}"
SRC_URI[aarch64_libkdepim-doc.sha256sum] = "be78a603cb64082704957821d8686de80e4ff5511bf72a35ce39a8eb80587d0e"

RDEPENDS:libkdepim = " \
 glibc \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkdepim-devel = " \
 cmake-filesystem \
 glibc \
 libkdepim \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkdepim-doc = " \
 "
