# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nv-codec-headers"
PV = "13.0.19.1"
PR = "1.el10_3"
PACKAGES = " \
 nv-codec-headers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nv-codec-headers-13.0.19.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ecf55be90d6c6406d8d178680367ea51296a9f82d8ff74211ec2343e274d26b8"

URI_x86_64_v2_nv-codec-headers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nv-codec-headers-13.0.19.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nv-codec-headers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nv-codec-headers}"
SRC_URI[x86_64_v2_nv-codec-headers.sha256sum] = "69942adfbaa3bb3489bf5a07062ec94193a8fa13ff99fbfe75705bda2202fd54"

URI_aarch64_nv-codec-headers = "${EPEL_MIRROR}/aarch64/Packages/n/nv-codec-headers-13.0.19.1-1.el10_3.noarch.rpm;name=aarch64_nv-codec-headers;unpack=0"
SRC_URI:append = " ${URI_aarch64_nv-codec-headers}"
SRC_URI[aarch64_nv-codec-headers.sha256sum] = "5c8bd59c07d75e07ffc9f3526b86d3542855bdcae92e5b561bb1f6c39d57e7f3"

RDEPENDS:nv-codec-headers = " \
 pkgconf-pkg-config \
 "
