# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memmap2_0.5"
PV = "0.5.10"
PR = "5.el10_1"
PACKAGES = " \
 rust-memmap2_0.5+default-devel \
 rust-memmap2_0.5+stable_deref_trait-devel \
 rust-memmap2_0.5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memmap2_0.5-0.5.10-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90bd379d445cc7fb33cdcbd67607579773a4acdfc948bcd19b294599ccb85d71"

URI_x86_64_v2_rust-memmap2_0.5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2_0.5+default-devel-0.5.10-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2_0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2_0.5+default-devel}"
SRC_URI[x86_64_v2_rust-memmap2_0.5+default-devel.sha256sum] = "b6888f8327926d6bb7e5f21d97b70bec966c96245b81e09daa7fd8dfb88c56e0"

URI_x86_64_v2_rust-memmap2_0.5+stable_deref_trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2_0.5+stable_deref_trait-devel-0.5.10-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2_0.5+stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2_0.5+stable_deref_trait-devel}"
SRC_URI[x86_64_v2_rust-memmap2_0.5+stable_deref_trait-devel.sha256sum] = "0bb7d3807b6688b75ce57f29591ecdcdb1eab9e7c429e2a3736497b8b906a367"

URI_x86_64_v2_rust-memmap2_0.5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2_0.5-devel-0.5.10-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2_0.5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2_0.5-devel}"
SRC_URI[x86_64_v2_rust-memmap2_0.5-devel.sha256sum] = "1858398c2763e261a01a1bca81b86c8f858aad84eacba469cde38831d3abc3da"

URI_aarch64_rust-memmap2_0.5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2_0.5+default-devel-0.5.10-5.el10_1.noarch.rpm;name=aarch64_rust-memmap2_0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2_0.5+default-devel}"
SRC_URI[aarch64_rust-memmap2_0.5+default-devel.sha256sum] = "ec5cda4076f660b60a00256a20db8be8107716b8fd1473bca029025ac3674c3a"

URI_aarch64_rust-memmap2_0.5+stable_deref_trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2_0.5+stable_deref_trait-devel-0.5.10-5.el10_1.noarch.rpm;name=aarch64_rust-memmap2_0.5+stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2_0.5+stable_deref_trait-devel}"
SRC_URI[aarch64_rust-memmap2_0.5+stable_deref_trait-devel.sha256sum] = "18a36ac22b7bd72bb6e4d6f5ef029a9173dd935f187b9fbcbfa67b76504a74e8"

URI_aarch64_rust-memmap2_0.5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2_0.5-devel-0.5.10-5.el10_1.noarch.rpm;name=aarch64_rust-memmap2_0.5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2_0.5-devel}"
SRC_URI[aarch64_rust-memmap2_0.5-devel.sha256sum] = "978f1eb88dcdc68cd7a90f2ce94cb26d1c84be9317c2b2262d73cdfb561174d3"

RDEPENDS:rust-memmap2_0.5+default-devel = " \
 cargo \
 rust-memmap2_0.5-devel \
 "
RDEPENDS:rust-memmap2_0.5+stable_deref_trait-devel = " \
 cargo \
 rust-memmap2_0.5-devel \
 rust-stable_deref_trait+default-devel \
 "
RDEPENDS:rust-memmap2_0.5-devel = " \
 cargo \
 rust-libc+default-devel \
 "
