# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dns"
PV = "2.6.1"
PR = "1.el10"
PACKAGES = " \
 python3-dns \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-dns-2.6.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1be49a51c2a64a32466f29bd66629c835005eca1e909b27d00463b64df2248c0"

URI_x86_64_v2_python3-dns = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dns-2.6.1-1.el10.noarch.rpm;name=x86_64_v2_python3-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dns}"
SRC_URI[x86_64_v2_python3-dns.sha256sum] = "e96494427f1d0c812cb772605070b0ab680a4968b6700ce00a1f2f0850deed17"

URI_aarch64_python3-dns = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dns-2.6.1-1.el10.noarch.rpm;name=aarch64_python3-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dns}"
SRC_URI[aarch64_python3-dns.sha256sum] = "e96494427f1d0c812cb772605070b0ab680a4968b6700ce00a1f2f0850deed17"

RDEPENDS:python3-dns = " \
 python3 \
 "
