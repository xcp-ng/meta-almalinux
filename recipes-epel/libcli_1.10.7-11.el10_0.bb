# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcli"
PV = "1.10.7"
PR = "11.el10_0"
PACKAGES = " \
 libcli \
 libcli-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libcli-1.10.7-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "eb6760d0797276ed82976cb7a5aa8c2b0ffc5fc033059a4642183bc56ccd8a11"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcli-1.10.7-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcli;unpack=0"
SRC_URI[x86_64_v2_libcli.sha256sum] = "556f279e4db64483dae25f6774061686768e3904be29c3436dde951f6c8a168f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcli-devel-1.10.7-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcli-devel;unpack=0"
SRC_URI[x86_64_v2_libcli-devel.sha256sum] = "a2034fee7814a744bcf40585cd34d93e00b9c11b77a1c38cbae0144ed091fe7d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libcli-1.10.7-11.el10_0.aarch64.rpm;name=aarch64_libcli;unpack=0"
SRC_URI[aarch64_libcli.sha256sum] = "1f8f7afa279f97dbe3580000c1b31dc1a10385564ce463ec00a7906cfac8d7d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libcli-devel-1.10.7-11.el10_0.aarch64.rpm;name=aarch64_libcli-devel;unpack=0"
SRC_URI[aarch64_libcli-devel.sha256sum] = "4110bc4c038c53d158753d4b9750f2642f88bfbab94e4768242c17ca61123338"

RDEPENDS:libcli = " \
 glibc \
 libxcrypt \
 "
RDEPENDS:libcli-devel = " \
 libcli \
 "
