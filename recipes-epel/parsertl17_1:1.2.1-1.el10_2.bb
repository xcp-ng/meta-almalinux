# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "parsertl17"
PE = "1"
PV = "1.2.1"
PR = "1.el10_2"
PACKAGES = " \
 parsertl17-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/parsertl17-1.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15d026a0fae078e1ce7f55285c602613f4c72a1a8b77b4a9018eb8d8dcfdecc0"

URI_x86_64_v2_parsertl17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parsertl17-devel-1.2.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parsertl17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parsertl17-devel}"
SRC_URI[x86_64_v2_parsertl17-devel.sha256sum] = "118470952431f42d748b4f5f2ca95a258ad9b564647acb055451da5accdabab5"

URI_aarch64_parsertl17-devel = "${EPEL_MIRROR}/aarch64/Packages/p/parsertl17-devel-1.2.1-1.el10_2.aarch64.rpm;name=aarch64_parsertl17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_parsertl17-devel}"
SRC_URI[aarch64_parsertl17-devel.sha256sum] = "c6559a802fd4b83ad59b2e8aabade2720b99f3d77277cf922b6dc016806bd6ed"

RDEPENDS:parsertl17-devel = " \
 cmake-filesystem \
 lexertl17-devel \
 "
