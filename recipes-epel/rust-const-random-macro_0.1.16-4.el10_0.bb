# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-const-random-macro"
PV = "0.1.16"
PR = "4.el10_0"
PACKAGES = " \
 rust-const-random-macro+default-devel \
 rust-const-random-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-const-random-macro-0.1.16-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a87d82d0f2ff881cde738d00dc57fedcc855149a6625245618b18bc192fe12e2"

URI_x86_64_v2_rust-const-random-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-random-macro+default-devel-0.1.16-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-random-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-random-macro+default-devel}"
SRC_URI[x86_64_v2_rust-const-random-macro+default-devel.sha256sum] = "31da4ef15bb53cb8229b8ff81e4e3edfd71db08ef378ad67b93860c703575cda"

URI_x86_64_v2_rust-const-random-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-random-macro-devel-0.1.16-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-random-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-random-macro-devel}"
SRC_URI[x86_64_v2_rust-const-random-macro-devel.sha256sum] = "0501a0ddd657dc08bd32b16ef325ca633126f55971acd3bdc236cf6bb1c6dea2"

URI_aarch64_rust-const-random-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-random-macro+default-devel-0.1.16-4.el10_0.noarch.rpm;name=aarch64_rust-const-random-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-random-macro+default-devel}"
SRC_URI[aarch64_rust-const-random-macro+default-devel.sha256sum] = "b0d91ec5e3da356b0197b129ec8d00cb8abd191475e2735c37b4e62f4d669fd3"

URI_aarch64_rust-const-random-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-random-macro-devel-0.1.16-4.el10_0.noarch.rpm;name=aarch64_rust-const-random-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-random-macro-devel}"
SRC_URI[aarch64_rust-const-random-macro-devel.sha256sum] = "8905b006ca8175900d8e1e5a00cf6e692c5c661515c6d44730786a5c03618367"

RDEPENDS:rust-const-random-macro+default-devel = " \
 cargo \
 rust-const-random-macro-devel \
 "
RDEPENDS:rust-const-random-macro-devel = " \
 cargo \
 rust-getrandom0.2+default-devel \
 rust-once_cell+alloc-devel \
 rust-once_cell+race-devel \
 rust-once_cell-devel \
 rust-tiny-keccak+default-devel \
 rust-tiny-keccak+shake-devel \
 "
