# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sfnt2woff-zopfli"
PV = "1.3.1"
PR = "15.el10_1"
PACKAGES = " \
 sfnt2woff-zopfli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sfnt2woff-zopfli-1.3.1-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b4d229f3c96384841cba1b5df2ad9fe76bd1f366d84e8a60017b4842035af0f"

URI_x86_64_v2_sfnt2woff-zopfli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sfnt2woff-zopfli-1.3.1-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sfnt2woff-zopfli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sfnt2woff-zopfli}"
SRC_URI[x86_64_v2_sfnt2woff-zopfli.sha256sum] = "bf0346c347cbf89501f6a414afa8c7475bcfd9e8df064526fad07bfe51a8cb20"

URI_aarch64_sfnt2woff-zopfli = "${EPEL_MIRROR}/aarch64/Packages/s/sfnt2woff-zopfli-1.3.1-15.el10_1.aarch64.rpm;name=aarch64_sfnt2woff-zopfli;unpack=0"
SRC_URI:append = " ${URI_aarch64_sfnt2woff-zopfli}"
SRC_URI[aarch64_sfnt2woff-zopfli.sha256sum] = "8e3fbc04110556ba5ae1a1aff7921c1c8fba2901f6005586d72b0b26a58c4370"

RDEPENDS:sfnt2woff-zopfli = " \
 glibc \
 zlib-ng-compat \
 zopfli \
 "
