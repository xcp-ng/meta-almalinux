# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatbuffers"
PV = "24.3.25"
PR = "17.el10_0"
PACKAGES = " \
 flatbuffers \
 flatbuffers-compiler \
 flatbuffers-devel \
 flatbuffers-doc \
 mingw32-flatbuffers \
 mingw64-flatbuffers \
 python3-flatbuffers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/flatbuffers-24.3.25-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c0ab2e46f3792a46b7592d76dcedfc00c22d17dce586c888e0637e0bb724155"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - mingw32-flatbuffers: mingw32(libstdc++-6.dll)
# - mingw64-flatbuffers: mingw64(libstdc++-6.dll)

URI_x86_64_v2_flatbuffers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flatbuffers-24.3.25-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flatbuffers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatbuffers}"
SRC_URI[x86_64_v2_flatbuffers.sha256sum] = "c514e117ecbebdaef258d03197256574703a71e30bb8bc7db9e10dd23f3edf1a"

URI_x86_64_v2_flatbuffers-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flatbuffers-compiler-24.3.25-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flatbuffers-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatbuffers-compiler}"
SRC_URI[x86_64_v2_flatbuffers-compiler.sha256sum] = "770e8a7758fb294be027dc870f679f7957afbad6166edcb4d5d719bcabb631a1"

URI_x86_64_v2_flatbuffers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flatbuffers-devel-24.3.25-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flatbuffers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatbuffers-devel}"
SRC_URI[x86_64_v2_flatbuffers-devel.sha256sum] = "af589e82bc6d48bd5307642bb5d818da83ee4e474ddd99235951ea7331c92d39"

URI_x86_64_v2_flatbuffers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flatbuffers-doc-24.3.25-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_flatbuffers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatbuffers-doc}"
SRC_URI[x86_64_v2_flatbuffers-doc.sha256sum] = "faa091b29492d9aad03832f49b7fee509e306520513d57daf4740f0096fa8153"

URI_x86_64_v2_mingw32-flatbuffers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-flatbuffers-24.3.25-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-flatbuffers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-flatbuffers}"
SRC_URI[x86_64_v2_mingw32-flatbuffers.sha256sum] = "b296ca4f86226a8ce7e65bfa7404572fb7dc2dc39b37f746eb9ef64fed5ae17b"

URI_x86_64_v2_mingw64-flatbuffers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-flatbuffers-24.3.25-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-flatbuffers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-flatbuffers}"
SRC_URI[x86_64_v2_mingw64-flatbuffers.sha256sum] = "be28bb978dbf04ba71c85e8c762a0c672dbea8e18409f87186893acd091f17d2"

URI_x86_64_v2_python3-flatbuffers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flatbuffers-24.3.25-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flatbuffers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flatbuffers}"
SRC_URI[x86_64_v2_python3-flatbuffers.sha256sum] = "1cb01e203384e9740e21146d8e6087224416e156406dfdacede8f5d519f35d17"

URI_aarch64_flatbuffers = "${EPEL_MIRROR}/aarch64/Packages/f/flatbuffers-24.3.25-17.el10_0.aarch64.rpm;name=aarch64_flatbuffers;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatbuffers}"
SRC_URI[aarch64_flatbuffers.sha256sum] = "6ad3948774e8558a3d9885d77a3ab1e15ba0eb3e8c4d8ff4b665ae7c93dba3b4"

URI_aarch64_flatbuffers-compiler = "${EPEL_MIRROR}/aarch64/Packages/f/flatbuffers-compiler-24.3.25-17.el10_0.aarch64.rpm;name=aarch64_flatbuffers-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatbuffers-compiler}"
SRC_URI[aarch64_flatbuffers-compiler.sha256sum] = "14dd8af69652154bfad837469cee751ce64c79e598c7bb5775eb7463da62d62f"

URI_aarch64_flatbuffers-devel = "${EPEL_MIRROR}/aarch64/Packages/f/flatbuffers-devel-24.3.25-17.el10_0.aarch64.rpm;name=aarch64_flatbuffers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatbuffers-devel}"
SRC_URI[aarch64_flatbuffers-devel.sha256sum] = "9e6b3200092d0a8ef5978a1641197b6f011125bebce517e7f5f81ec07e772801"

URI_aarch64_flatbuffers-doc = "${EPEL_MIRROR}/aarch64/Packages/f/flatbuffers-doc-24.3.25-17.el10_0.noarch.rpm;name=aarch64_flatbuffers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatbuffers-doc}"
SRC_URI[aarch64_flatbuffers-doc.sha256sum] = "f8b80c00ee384438fad3137273cac4852c6b84b1e34c7911c344f3dd6b18a60e"

URI_aarch64_mingw32-flatbuffers = "${EPEL_MIRROR}/aarch64/Packages/m/mingw32-flatbuffers-24.3.25-17.el10_0.noarch.rpm;name=aarch64_mingw32-flatbuffers;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-flatbuffers}"
SRC_URI[aarch64_mingw32-flatbuffers.sha256sum] = "132839017175050c40b3b7a9922a6183a9172f0d171b594bef14b796a9d7347d"

URI_aarch64_mingw64-flatbuffers = "${EPEL_MIRROR}/aarch64/Packages/m/mingw64-flatbuffers-24.3.25-17.el10_0.noarch.rpm;name=aarch64_mingw64-flatbuffers;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-flatbuffers}"
SRC_URI[aarch64_mingw64-flatbuffers.sha256sum] = "b5f892df6b57e3e4f38d064cd3a9d137e5e098a26aa3b0939060dea96c527c9e"

URI_aarch64_python3-flatbuffers = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flatbuffers-24.3.25-17.el10_0.noarch.rpm;name=aarch64_python3-flatbuffers;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flatbuffers}"
SRC_URI[aarch64_python3-flatbuffers.sha256sum] = "657acb026b0daeb2738e2873f5d1310973e01c9090adfcaa959e5b272dc0fc4e"

RDEPENDS:flatbuffers = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:flatbuffers-compiler = " \
 flatbuffers \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:flatbuffers-devel = " \
 cmake-filesystem \
 flatbuffers \
 pkgconf-pkg-config \
 "
RDEPENDS:flatbuffers-doc = " \
 "
RDEPENDS:mingw32-flatbuffers:x86_64_v2 = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libgcc \
 mingw32-libstdc++ \
"
RDEPENDS:mingw32-flatbuffers:aarch64 = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libgcc \
"
RDEPENDS:mingw64-flatbuffers:x86_64_v2 = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-libgcc \
 mingw64-libstdc++ \
"
RDEPENDS:mingw64-flatbuffers:aarch64 = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-libgcc \
"
RDEPENDS:python3-flatbuffers = " \
 python3 \
 "
