# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-proxy-utils"
PV = "7.4"
PR = "1.el10_2"
PACKAGES = " \
 globus-proxy-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-proxy-utils-7.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16792d11268f3f89fd803b75b0f69dce955d97993b53663ab3495daa932d59d8"

URI_x86_64_v2_globus-proxy-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-proxy-utils-7.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-proxy-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-proxy-utils}"
SRC_URI[x86_64_v2_globus-proxy-utils.sha256sum] = "70b7f6081149ff7a96105c12f9088c65b8bf572e57840eebc38b5f616aad62bd"

URI_aarch64_globus-proxy-utils = "${EPEL_MIRROR}/aarch64/Packages/g/globus-proxy-utils-7.4-1.el10_2.aarch64.rpm;name=aarch64_globus-proxy-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-proxy-utils}"
SRC_URI[aarch64_globus-proxy-utils.sha256sum] = "f660d3a3b44156b741257878901cffd05eeb8c07652e04f58ab035f6135a7cba"

RDEPENDS:globus-proxy-utils = " \
 glibc \
 globus-common \
 globus-gsi-callback \
 globus-gsi-credential \
 globus-gsi-openssl-error \
 globus-gsi-proxy-core \
 globus-gsi-sysconfig \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-openssl-module \
 openssl-libs \
 "
