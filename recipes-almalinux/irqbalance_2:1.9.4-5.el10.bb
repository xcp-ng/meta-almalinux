# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "irqbalance"
PE = "2"
PV = "1.9.4"
PR = "5.el10"
PACKAGES = " \
 irqbalance \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/irqbalance-1.9.4-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "554b0788d0287b2f4365f12a581705b85b0ea68c75a5feb6343375d152ba836e"

URI_x86_64_v2_irqbalance = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/irqbalance-1.9.4-5.el10.x86_64_v2.rpm;name=x86_64_v2_irqbalance;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_irqbalance}"
SRC_URI[x86_64_v2_irqbalance.sha256sum] = "b33b3376e1b069346b418c9670da2625916847e019d3f370246bdd33d08dcb9f"

URI_aarch64_irqbalance = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/irqbalance-1.9.4-5.el10.aarch64.rpm;name=aarch64_irqbalance;unpack=0"
SRC_URI:append = " ${URI_aarch64_irqbalance}"
SRC_URI[aarch64_irqbalance.sha256sum] = "f4b1623c51898ad59b8e5f25630e32e5810ce5d5e493fc7b7ed0bdcde45c4bf1"

RDEPENDS:irqbalance = " \
 bash \
 glib2 \
 glibc \
 libcap-ng \
 ncurses-libs \
 numactl-libs \
 systemd-libs \
 "
