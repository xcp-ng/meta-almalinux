# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-build-api0"
PV = "0.0.7"
PR = "46.el10"
PACKAGES = " \
 plexus-build-api0 \
 plexus-build-api0-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/plexus-build-api0-0.0.7-46.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2afca703a075a64beaa8e0867ca597315c1104c73f9f5fdc683032edf25bc6a"

URI_x86_64_v2_plexus-build-api0 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-build-api0-0.0.7-46.el10.noarch.rpm;name=x86_64_v2_plexus-build-api0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-build-api0}"
SRC_URI[x86_64_v2_plexus-build-api0.sha256sum] = "63c07c3a68b8166454fc3334c1c8bd024d3a4b4abf00f061935e24b08565707f"

URI_x86_64_v2_plexus-build-api0-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-build-api0-javadoc-0.0.7-46.el10.noarch.rpm;name=x86_64_v2_plexus-build-api0-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-build-api0-javadoc}"
SRC_URI[x86_64_v2_plexus-build-api0-javadoc.sha256sum] = "ef0b43e7145e9f37d528af978f214fb6ef19981b1dff14cae79c354c9ae0e92b"

URI_aarch64_plexus-build-api0 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-build-api0-0.0.7-46.el10.noarch.rpm;name=aarch64_plexus-build-api0;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-build-api0}"
SRC_URI[aarch64_plexus-build-api0.sha256sum] = "63c07c3a68b8166454fc3334c1c8bd024d3a4b4abf00f061935e24b08565707f"

URI_aarch64_plexus-build-api0-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-build-api0-javadoc-0.0.7-46.el10.noarch.rpm;name=aarch64_plexus-build-api0-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-build-api0-javadoc}"
SRC_URI[aarch64_plexus-build-api0-javadoc.sha256sum] = "ef0b43e7145e9f37d528af978f214fb6ef19981b1dff14cae79c354c9ae0e92b"

RDEPENDS:plexus-build-api0 = " \
 javapackages-filesystem \
 plexus-utils \
 "
RDEPENDS:plexus-build-api0-javadoc = " \
 javapackages-filesystem \
 "
