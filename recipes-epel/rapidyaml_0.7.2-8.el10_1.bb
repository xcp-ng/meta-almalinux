# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rapidyaml"
PV = "0.7.2"
PR = "8.el10_1"
PACKAGES = " \
 python3-rapidyaml \
 rapidyaml \
 rapidyaml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rapidyaml-0.7.2-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc42acacf77da03ede90aa9cad8051059ce2b2432e8f7f23830e07eddf28fe92"

URI_x86_64_v2_python3-rapidyaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rapidyaml-0.7.2-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-rapidyaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rapidyaml}"
SRC_URI[x86_64_v2_python3-rapidyaml.sha256sum] = "a444b0f5ec26ab19022e573813ea3af692f05500a28a1a6fba60518ccb5a0a5a"

URI_x86_64_v2_rapidyaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rapidyaml-0.7.2-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rapidyaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rapidyaml}"
SRC_URI[x86_64_v2_rapidyaml.sha256sum] = "943773ab6170d733b0e4c498c8589113685f31bfce140b2adcf6c2f5a593a605"

URI_x86_64_v2_rapidyaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rapidyaml-devel-0.7.2-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rapidyaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rapidyaml-devel}"
SRC_URI[x86_64_v2_rapidyaml-devel.sha256sum] = "8502f8697005396db550262d4b132be349ee2fa400ba109d8a370fa507d8d0c6"

URI_aarch64_python3-rapidyaml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rapidyaml-0.7.2-8.el10_1.aarch64.rpm;name=aarch64_python3-rapidyaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rapidyaml}"
SRC_URI[aarch64_python3-rapidyaml.sha256sum] = "38bd127c3079e7520c4f616780bb6f4c7717050cb0436e44fb131341181808d9"

URI_aarch64_rapidyaml = "${EPEL_MIRROR}/aarch64/Packages/r/rapidyaml-0.7.2-8.el10_1.aarch64.rpm;name=aarch64_rapidyaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_rapidyaml}"
SRC_URI[aarch64_rapidyaml.sha256sum] = "3494a47df5f128a63ce35edb9d765f0c106b583daf348d08e97f453d89d684a4"

URI_aarch64_rapidyaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rapidyaml-devel-0.7.2-8.el10_1.aarch64.rpm;name=aarch64_rapidyaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rapidyaml-devel}"
SRC_URI[aarch64_rapidyaml-devel.sha256sum] = "250b395e90964f6a8a7789a0ca9caea8b752717790f2045e4652478a2279b06d"

RDEPENDS:python3-rapidyaml = " \
 c4core \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-deprecation \
 "
RDEPENDS:rapidyaml = " \
 c4core \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:rapidyaml-devel = " \
 c4core-devel \
 cmake-filesystem \
 rapidyaml \
 "
