# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mariadb10.11"
PE = "3"
PV = "10.11.18"
PR = "1.el10_2.alma.2"
PACKAGES = " \
 mariadb \
 mariadb-backup \
 mariadb-client-utils \
 mariadb-common \
 mariadb-devel \
 mariadb-embedded \
 mariadb-embedded-devel \
 mariadb-errmsg \
 mariadb-gssapi-server \
 mariadb-oqgraph-engine \
 mariadb-pam \
 mariadb-server \
 mariadb-server-galera \
 mariadb-server-utils \
 mariadb-test \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mariadb10.11-10.11.18-1.el10_2.alma.2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "678712a613d83408a44f2f55ad694f6ae95b140799348bd4a0dbccb00b0214b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-10.11.18-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb;unpack=0"
SRC_URI[x86_64_v2_mariadb.sha256sum] = "2e3b990fa8da79dc99a37124570564a4fc307c1c49bb6ae4bb7e99360f10b93d"
RPROVIDES:mariadb:append:x86_64_v2 = " virtual//usr/bin/mariadb-dump virtual//usr/bin/mysqldump"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-backup-10.11.18-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb-backup;unpack=0"
SRC_URI[x86_64_v2_mariadb-backup.sha256sum] = "ec9473fe0c53d57d92236bf22af6fb40daaa117e284a5e490b8ae4bb15426425"
RPROVIDES:mariadb-backup:append:x86_64_v2 = " virtual//usr/bin/mariabackup"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-client-utils-10.11.18-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb-client-utils;unpack=0"
SRC_URI[x86_64_v2_mariadb-client-utils.sha256sum] = "61e0b0fa09c5c3dca471024130e7856ec4dc0ca86fbaae0b48f187464be74aaf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-common-10.11.18-1.el10_2.alma.2.noarch.rpm;name=x86_64_v2_mariadb-common;unpack=0"
SRC_URI[x86_64_v2_mariadb-common.sha256sum] = "2c04ac38b4f80517ba3157c69c54236ce586cecaf9622fa48311b7e0a2629d30"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-devel-10.11.18-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb-devel;unpack=0"
SRC_URI[x86_64_v2_mariadb-devel.sha256sum] = "44f381a5502fb9d646e164f625e84452e874b7bd5e3d3c0aa24fd6e498192595"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-embedded-10.11.18-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb-embedded;unpack=0"
SRC_URI[x86_64_v2_mariadb-embedded.sha256sum] = "9b756eecddb86af8cf496ee8fad233b472cbfb98b7b7117bcdaed5758613ef58"
RPROVIDES:mariadb-embedded:append:x86_64_v2 = " virtual/libmariadbd.so.19___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-embedded-devel-10.11.18-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb-embedded-devel;unpack=0"
SRC_URI[x86_64_v2_mariadb-embedded-devel.sha256sum] = "da913b1a99b8c913e44b25ee3ec878d392b1047e2a71b84046d744e789d800d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-errmsg-10.11.18-1.el10_2.alma.2.noarch.rpm;name=x86_64_v2_mariadb-errmsg;unpack=0"
SRC_URI[x86_64_v2_mariadb-errmsg.sha256sum] = "95c7c9260cd837bdf83b405be114cf60f81ebdbdc9f8b94c76e6c7feddc4302a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-gssapi-server-10.11.18-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb-gssapi-server;unpack=0"
SRC_URI[x86_64_v2_mariadb-gssapi-server.sha256sum] = "ffc88fd8ba83ccfde3a0c266370c380dacacfb3d1befcf79c92746ed628d88ef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-oqgraph-engine-10.11.18-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb-oqgraph-engine;unpack=0"
SRC_URI[x86_64_v2_mariadb-oqgraph-engine.sha256sum] = "419d009ecfd06871ddc8339f3bed93b261074a020e9266c5c8962fe8f89b0ef5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-pam-10.11.18-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb-pam;unpack=0"
SRC_URI[x86_64_v2_mariadb-pam.sha256sum] = "fb96f358df82e69b410b77bc5b40a0e03d46f306a77c7933e186288d072d1ab8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-server-10.11.18-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb-server;unpack=0"
SRC_URI[x86_64_v2_mariadb-server.sha256sum] = "a8f8eb21383754c6bb158fc92456ae7c4b5ec6f499369c9346e55ccf5541f09e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-server-galera-10.11.18-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb-server-galera;unpack=0"
SRC_URI[x86_64_v2_mariadb-server-galera.sha256sum] = "3a22d87d8438079ee99c53999282c524d373c2e860e5e2ee2f606274f274d7a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-server-utils-10.11.18-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb-server-utils;unpack=0"
SRC_URI[x86_64_v2_mariadb-server-utils.sha256sum] = "d78c4c93aaccfcf6fe7e6a08d4da09715349baf0a46bc8eabbe2451566e00f5e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-test-10.11.18-1.el10_2.alma.2.x86_64_v2.rpm;name=x86_64_v2_mariadb-test;unpack=0"
SRC_URI[x86_64_v2_mariadb-test.sha256sum] = "b817abafa542d77d7be5baf257c104bf7b65460bb5225ecd4ba718e2d635cd9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-10.11.18-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb;unpack=0"
SRC_URI[aarch64_mariadb.sha256sum] = "f7008f3528a903282349a284d1791cd27b7d79df0bd6f5627564eb4ec06a36e3"
RPROVIDES:mariadb:append:aarch64 = " virtual//usr/bin/mariadb-dump virtual//usr/bin/mysqldump"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-backup-10.11.18-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb-backup;unpack=0"
SRC_URI[aarch64_mariadb-backup.sha256sum] = "6e2d7664a546355f72ed880dd2fd482025c215350960f07b975cc4ffee7c9bf9"
RPROVIDES:mariadb-backup:append:aarch64 = " virtual//usr/bin/mariabackup"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-client-utils-10.11.18-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb-client-utils;unpack=0"
SRC_URI[aarch64_mariadb-client-utils.sha256sum] = "78e42a0a6025c45ac95ca286e319186be7d689683a6f2b4d53273dc10d864f88"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-common-10.11.18-1.el10_2.alma.2.noarch.rpm;name=aarch64_mariadb-common;unpack=0"
SRC_URI[aarch64_mariadb-common.sha256sum] = "2c04ac38b4f80517ba3157c69c54236ce586cecaf9622fa48311b7e0a2629d30"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-devel-10.11.18-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb-devel;unpack=0"
SRC_URI[aarch64_mariadb-devel.sha256sum] = "b0c2ad0477506abaad9f7bc4559aece89229e862fd998a819798d16d5b0a30b9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-embedded-10.11.18-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb-embedded;unpack=0"
SRC_URI[aarch64_mariadb-embedded.sha256sum] = "1a7cb69646eac494fe50caaf6b8f07f3b41ade036d14512fb74468975e7ab53a"
RPROVIDES:mariadb-embedded:append:aarch64 = " virtual/libmariadbd.so.19___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-embedded-devel-10.11.18-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb-embedded-devel;unpack=0"
SRC_URI[aarch64_mariadb-embedded-devel.sha256sum] = "440600011b8991e56750dcce4ea11847280ca1e4785f8d73eef2d49ac830315d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-errmsg-10.11.18-1.el10_2.alma.2.noarch.rpm;name=aarch64_mariadb-errmsg;unpack=0"
SRC_URI[aarch64_mariadb-errmsg.sha256sum] = "95c7c9260cd837bdf83b405be114cf60f81ebdbdc9f8b94c76e6c7feddc4302a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-gssapi-server-10.11.18-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb-gssapi-server;unpack=0"
SRC_URI[aarch64_mariadb-gssapi-server.sha256sum] = "e1f2708cffa600536caca5f32f8a8ef93f3712716bb4d18ebbd467b570ed312a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-oqgraph-engine-10.11.18-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb-oqgraph-engine;unpack=0"
SRC_URI[aarch64_mariadb-oqgraph-engine.sha256sum] = "d6778b4e56da752563978c9cef5215ad0495cf6f5868a8f805b8b92315c89497"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-pam-10.11.18-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb-pam;unpack=0"
SRC_URI[aarch64_mariadb-pam.sha256sum] = "ffdc711c7100cb063e7d1e5cf669e9937a9dd480c2ce06507a5f6539a6b32809"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-server-10.11.18-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb-server;unpack=0"
SRC_URI[aarch64_mariadb-server.sha256sum] = "dae434e8b6d1965f6df3d152345649898622c247e78b88148bf97d2ab88754e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-server-galera-10.11.18-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb-server-galera;unpack=0"
SRC_URI[aarch64_mariadb-server-galera.sha256sum] = "0e2a1d7fab95b54e477d9c23ffecabd5d765590ca9cf366d0bff8485a66807af"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-server-utils-10.11.18-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb-server-utils;unpack=0"
SRC_URI[aarch64_mariadb-server-utils.sha256sum] = "1144a9c45d83556e89d686448d92f342b07a5f624d824b480462564fb08fe846"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-test-10.11.18-1.el10_2.alma.2.aarch64.rpm;name=aarch64_mariadb-test;unpack=0"
SRC_URI[aarch64_mariadb-test.sha256sum] = "771b0b9dde27b3c79cb1e0124b7dd2182a7701a58079901935e0aa624b88d6a5"

RDEPENDS:mariadb = " \
 bash \
 glibc \
 grep \
 libedit \
 libgcc \
 libstdc++ \
 mariadb-common \
 mariadb-connector-c \
 ncurses-libs \
 openssl-libs \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-backup = " \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb-server \
 openssl-libs \
 pcre2 \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-client-utils = " \
 mariadb \
 perl-DBI \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-Sys-Hostname \
 perl-interpreter \
 "
RDEPENDS:mariadb-common = " \
 mariadb-connector-c-config \
 "
RDEPENDS:mariadb-devel = " \
 mariadb-connector-c-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:mariadb-embedded = " \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb-common \
 mariadb-errmsg \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-embedded-devel = " \
 libaio-devel \
 mariadb-devel \
 mariadb-embedded \
 virtual/libmariadbd.so.19___64bit_ \
 "
RDEPENDS:mariadb-errmsg = " \
 mariadb-common \
 "
RDEPENDS:mariadb-gssapi-server = " \
 glibc \
 krb5-libs \
 mariadb-server \
 "
RDEPENDS:mariadb-oqgraph-engine = " \
 Judy \
 glibc \
 libgcc \
 libstdc++ \
 mariadb-server \
 "
RDEPENDS:mariadb-pam = " \
 glibc \
 mariadb-server \
 pam-libs \
 "
RDEPENDS:mariadb-server = " \
 bash \
 bzip2-libs \
 glibc \
 iproute \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 lz4-libs \
 lzo \
 mariadb \
 mariadb-common \
 mariadb-connector-c-config \
 mariadb-errmsg \
 mysql-selinux \
 openssl-libs \
 pam-libs \
 pcre2 \
 shadow-utils \
 snappy \
 systemd \
 systemd-libs \
 virtual/coreutils \
 which \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-server-galera = " \
 bash \
 galera \
 libselinux-utils \
 lsof \
 mariadb-common \
 mariadb-server \
 policycoreutils \
 policycoreutils-python-utils \
 rsync \
 "
RDEPENDS:mariadb-server-utils = " \
 glibc \
 mariadb-server \
 perl-DBD-MariaDB \
 perl-DBI \
 perl-Data-Dumper \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-POSIX \
 perl-Sys-Hostname \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:mariadb-test = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb \
 mariadb-common \
 mariadb-server \
 openssl-libs \
 patch \
 pcre2 \
 perl-Carp \
 perl-Data-Dumper \
 perl-English \
 perl-Env \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-Memoize \
 perl-POSIX \
 perl-PathTools \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Test-Simple \
 perl-Text-Tabs+Wrap \
 perl-Time \
 perl-Time-HiRes \
 perl-base \
 perl-constant \
 perl-if \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 perl-threads \
 perl-threads-shared \
 zlib-ng-compat \
 "
