# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MLDBM"
PV = "2.05"
PR = "34.el10_0"
PACKAGES = " \
 perl-MLDBM \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-MLDBM-2.05-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "86ba588d35c6c3d6047be45ee04d15c4ea707e0f68a83f6cd36f5d3f932637c6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MLDBM-2.05-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MLDBM;unpack=0"
SRC_URI[x86_64_v2_perl-MLDBM.sha256sum] = "d989a42e110247b0f0f805f94b65cccd32ace2d84888e15bcb125863bfacc735"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-MLDBM-2.05-34.el10_0.noarch.rpm;name=aarch64_perl-MLDBM;unpack=0"
SRC_URI[aarch64_perl-MLDBM.sha256sum] = "f195409d6df6564e0a63d89f6ee4b43cebdbd5e0067655a709d2847c60c9687a"

RDEPENDS:perl-MLDBM = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-FreezeThaw \
 perl-Storable \
 perl-libs \
 perl-vars \
 "
