# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-env"
PV = "1.1.3"
PR = "1.el10_2"
PACKAGES = " \
 python3-pytest-env \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-env-1.1.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "652b3368a5e1a190a4de04b7c55807cd659bae96f44f94b06d771d47eac16d50"

URI_x86_64_v2_python3-pytest-env = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-env-1.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-env;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-env}"
SRC_URI[x86_64_v2_python3-pytest-env.sha256sum] = "5c9904d0efdd2e3044825c33be815b86b24e5f91a79030bc6a54242a7b0a9196"

URI_aarch64_python3-pytest-env = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-env-1.1.3-1.el10_2.noarch.rpm;name=aarch64_python3-pytest-env;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-env}"
SRC_URI[aarch64_python3-pytest-env.sha256sum] = "1e11f80d2c01ed3388ec5ac8cc550ba7f4d711c4c86dfc633e89e74df3b6571a"

RDEPENDS:python3-pytest-env = " \
 python3 \
 python3-pytest \
 "
