# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ffmpegthumbnailer"
PV = "2.2.3"
PR = "2.el10_1"
PACKAGES = " \
 ffmpegthumbnailer \
 ffmpegthumbnailer-devel \
 ffmpegthumbnailer-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/ffmpegthumbnailer-2.2.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62432acda1e50adc2513ce5a151978aece6cf20affc6636545a322be261f844b"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - ffmpegthumbnailer-libs: libavcodec.so.61()(64bit)
# - ffmpegthumbnailer-libs: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - ffmpegthumbnailer-libs: libavfilter.so.10()(64bit)
# - ffmpegthumbnailer-libs: libavfilter.so.10(LIBAVFILTER_10)(64bit)
# - ffmpegthumbnailer-libs: libavformat.so.61()(64bit)
# - ffmpegthumbnailer-libs: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - ffmpegthumbnailer-libs: libavutil.so.59()(64bit)
# - ffmpegthumbnailer-libs: libavutil.so.59(LIBAVUTIL_59)(64bit)

URI_x86_64_v2_ffmpegthumbnailer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ffmpegthumbnailer-2.2.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ffmpegthumbnailer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ffmpegthumbnailer}"
SRC_URI[x86_64_v2_ffmpegthumbnailer.sha256sum] = "f3be0237fb34b6da2a8bc7e1760e25b8bec12bb604a8449c48aed7d69af52d5e"

URI_x86_64_v2_ffmpegthumbnailer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ffmpegthumbnailer-devel-2.2.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ffmpegthumbnailer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ffmpegthumbnailer-devel}"
SRC_URI[x86_64_v2_ffmpegthumbnailer-devel.sha256sum] = "0b3a6e91cf886bbfe0cf420d43bb0c7ac794a44249cc285cbfd954e2aea0ab51"

URI_x86_64_v2_ffmpegthumbnailer-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ffmpegthumbnailer-libs-2.2.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ffmpegthumbnailer-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ffmpegthumbnailer-libs}"
SRC_URI[x86_64_v2_ffmpegthumbnailer-libs.sha256sum] = "8126e429dfc9bfbba0a36e37e136d311c1fc57fa0077691a36c7d7c21a6640ae"

URI_aarch64_ffmpegthumbnailer = "${EPEL_MIRROR}/aarch64/Packages/f/ffmpegthumbnailer-2.2.3-2.el10_1.aarch64.rpm;name=aarch64_ffmpegthumbnailer;unpack=0"
SRC_URI:append = " ${URI_aarch64_ffmpegthumbnailer}"
SRC_URI[aarch64_ffmpegthumbnailer.sha256sum] = "692bc6f380d122fd4204514404c5930524c1a9e7823f8cc50ae7271586aed45f"

URI_aarch64_ffmpegthumbnailer-devel = "${EPEL_MIRROR}/aarch64/Packages/f/ffmpegthumbnailer-devel-2.2.3-2.el10_1.aarch64.rpm;name=aarch64_ffmpegthumbnailer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ffmpegthumbnailer-devel}"
SRC_URI[aarch64_ffmpegthumbnailer-devel.sha256sum] = "aa883cd20cd038f79fbdd51a8588690d46feae8c5db8e76859c8fad27c6650b4"

URI_aarch64_ffmpegthumbnailer-libs = "${EPEL_MIRROR}/aarch64/Packages/f/ffmpegthumbnailer-libs-2.2.3-2.el10_1.aarch64.rpm;name=aarch64_ffmpegthumbnailer-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ffmpegthumbnailer-libs}"
SRC_URI[aarch64_ffmpegthumbnailer-libs.sha256sum] = "f84a0f3ade11b478ccf0dba0cd53a951b12ca5427dc4b73a44c5e7da20c8c34e"

RDEPENDS:ffmpegthumbnailer = " \
 ffmpegthumbnailer-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:ffmpegthumbnailer-devel = " \
 ffmpegthumbnailer-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:ffmpegthumbnailer-libs:x86_64_v2 = " \
 glibc \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
"
RDEPENDS:ffmpegthumbnailer-libs:aarch64 = " \
 glibc \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
"
