# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "adobe-mappings-cmap"
PV = "20230622"
PR = "5.el10"
PACKAGES = " \
 adobe-mappings-cmap \
 adobe-mappings-cmap-deprecated \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/adobe-mappings-cmap-20230622-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e517979569c71e3305ec00d43c1376fa5015d5ce19f826579ffb02befdfbdfa6"

URI_x86_64_v2_adobe-mappings-cmap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/adobe-mappings-cmap-20230622-5.el10.noarch.rpm;name=x86_64_v2_adobe-mappings-cmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_adobe-mappings-cmap}"
SRC_URI[x86_64_v2_adobe-mappings-cmap.sha256sum] = "efb0594b06750f5e85693f8074f785671cf1c54689017d24b09bd1392f04201c"

URI_x86_64_v2_adobe-mappings-cmap-deprecated = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/adobe-mappings-cmap-deprecated-20230622-5.el10.noarch.rpm;name=x86_64_v2_adobe-mappings-cmap-deprecated;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_adobe-mappings-cmap-deprecated}"
SRC_URI[x86_64_v2_adobe-mappings-cmap-deprecated.sha256sum] = "079ac0cfa475b1a1269d19172d486847e50e517ea6f20882947d8be7164aac4d"

URI_aarch64_adobe-mappings-cmap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/adobe-mappings-cmap-20230622-5.el10.noarch.rpm;name=aarch64_adobe-mappings-cmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_adobe-mappings-cmap}"
SRC_URI[aarch64_adobe-mappings-cmap.sha256sum] = "efb0594b06750f5e85693f8074f785671cf1c54689017d24b09bd1392f04201c"

URI_aarch64_adobe-mappings-cmap-deprecated = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/adobe-mappings-cmap-deprecated-20230622-5.el10.noarch.rpm;name=aarch64_adobe-mappings-cmap-deprecated;unpack=0"
SRC_URI:append = " ${URI_aarch64_adobe-mappings-cmap-deprecated}"
SRC_URI[aarch64_adobe-mappings-cmap-deprecated.sha256sum] = "079ac0cfa475b1a1269d19172d486847e50e517ea6f20882947d8be7164aac4d"

RDEPENDS:adobe-mappings-cmap = " \
 "
RDEPENDS:adobe-mappings-cmap-deprecated = " \
 adobe-mappings-cmap \
 "
