# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lhapdf"
PV = "6.5.6"
PR = "3.el10_2"
PACKAGES = " \
 lhapdf \
 lhapdf-devel \
 lhapdf-doc \
 python3-lhapdf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lhapdf-6.5.6-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14e33deb5cf8e8f713803fc3605610aa7b0a4c73363fd8c72e791291613f6a63"

URI_x86_64_v2_lhapdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lhapdf-6.5.6-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lhapdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lhapdf}"
SRC_URI[x86_64_v2_lhapdf.sha256sum] = "8ca5a9a5c52d3286d3f3a15dde40a85e1bdb20eca265eb15f390d1d3a740d560"

URI_x86_64_v2_lhapdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lhapdf-devel-6.5.6-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lhapdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lhapdf-devel}"
SRC_URI[x86_64_v2_lhapdf-devel.sha256sum] = "0ac6a34792c02fd2efdc81bdc4c33b452e25925ead2beaf5c0a3d9ab7f563b97"

URI_x86_64_v2_lhapdf-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lhapdf-doc-6.5.6-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lhapdf-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lhapdf-doc}"
SRC_URI[x86_64_v2_lhapdf-doc.sha256sum] = "d1809afbc9e4e95dbbf33a505ea1c6989ec6663c845a59cca05c0bcbed7820b3"

URI_x86_64_v2_python3-lhapdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lhapdf-6.5.6-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lhapdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lhapdf}"
SRC_URI[x86_64_v2_python3-lhapdf.sha256sum] = "a163120dbee238c9d070777911c9702456197674ce3d354dee6521c0c4bc45b8"

URI_aarch64_lhapdf = "${EPEL_MIRROR}/aarch64/Packages/l/lhapdf-6.5.6-3.el10_2.aarch64.rpm;name=aarch64_lhapdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_lhapdf}"
SRC_URI[aarch64_lhapdf.sha256sum] = "f2cf8e6e9b49f352b19743c8281224f92f0c08f0ca3e7160c0c806d95d22dd4c"

URI_aarch64_lhapdf-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lhapdf-devel-6.5.6-3.el10_2.aarch64.rpm;name=aarch64_lhapdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lhapdf-devel}"
SRC_URI[aarch64_lhapdf-devel.sha256sum] = "5ce618a458f647a178da6dbdd3804243b031e0e978b719e3aeddcdf36d2f66f9"

URI_aarch64_lhapdf-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lhapdf-doc-6.5.6-3.el10_2.noarch.rpm;name=aarch64_lhapdf-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lhapdf-doc}"
SRC_URI[aarch64_lhapdf-doc.sha256sum] = "0df4debcebe93b46dce5513cdc05c6dcfbcff5ed20d8fda34db51512b09006d3"

URI_aarch64_python3-lhapdf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lhapdf-6.5.6-3.el10_2.aarch64.rpm;name=aarch64_python3-lhapdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lhapdf}"
SRC_URI[aarch64_python3-lhapdf.sha256sum] = "e73cae53c912cdee8de3b3677a09558838c4d6cfbee0e14cb8fb9b00de1630d2"

RDEPENDS:lhapdf = " \
 glibc \
 libgcc \
 libstdc++ \
 yaml-cpp \
 "
RDEPENDS:lhapdf-devel = " \
 bash \
 lhapdf \
 pkgconf-pkg-config \
 yaml-cpp-devel \
 "
RDEPENDS:lhapdf-doc = " \
 "
RDEPENDS:python3-lhapdf = " \
 glibc \
 lhapdf \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 "
