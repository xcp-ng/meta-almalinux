# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hlint"
PV = "3.6.1"
PR = "7.el10_0"
PACKAGES = " \
 ghc-deriving-aeson \
 ghc-deriving-aeson-devel \
 ghc-deriving-aeson-doc \
 ghc-deriving-aeson-prof \
 ghc-ghc-lib-parser-ex \
 ghc-ghc-lib-parser-ex-devel \
 ghc-ghc-lib-parser-ex-doc \
 ghc-ghc-lib-parser-ex-prof \
 ghc-hlint \
 ghc-hlint-devel \
 ghc-hlint-doc \
 ghc-hlint-prof \
 hlint \
 hlint-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hlint-3.6.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33784e99c4307dda59a631c34df33f2539c1aee7a00b4252fffe737da3cf6b72"

URI_x86_64_v2_ghc-deriving-aeson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deriving-aeson-0.2.9-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-deriving-aeson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deriving-aeson}"
SRC_URI[x86_64_v2_ghc-deriving-aeson.sha256sum] = "b62f3b27ef14b266bd033fc2eaccd1097b0e598567eeb86beffee640b63a355e"

URI_x86_64_v2_ghc-deriving-aeson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deriving-aeson-devel-0.2.9-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-deriving-aeson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deriving-aeson-devel}"
SRC_URI[x86_64_v2_ghc-deriving-aeson-devel.sha256sum] = "97b14ce0ad352695e6c8aaa1aa7b63aa571edc8900502b1dae565500ba5cb4e2"

URI_x86_64_v2_ghc-deriving-aeson-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deriving-aeson-doc-0.2.9-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-deriving-aeson-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deriving-aeson-doc}"
SRC_URI[x86_64_v2_ghc-deriving-aeson-doc.sha256sum] = "d86ef08f8b90b4180c351450006ae1eeed81be5c37a18d6c9f8115c3773a1d31"

URI_x86_64_v2_ghc-deriving-aeson-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deriving-aeson-prof-0.2.9-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-deriving-aeson-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deriving-aeson-prof}"
SRC_URI[x86_64_v2_ghc-deriving-aeson-prof.sha256sum] = "5fbfe971beacc2bf8926aef7f13ce63ab2c59605f8d392bcb44a1fb9719e7a06"

URI_x86_64_v2_ghc-ghc-lib-parser-ex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-lib-parser-ex-9.6.0.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-lib-parser-ex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-lib-parser-ex}"
SRC_URI[x86_64_v2_ghc-ghc-lib-parser-ex.sha256sum] = "313a137fa326e876ecb940e776cf54cf8f86862a088b798dc8be8de6b61ece28"

URI_x86_64_v2_ghc-ghc-lib-parser-ex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-lib-parser-ex-devel-9.6.0.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-lib-parser-ex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-lib-parser-ex-devel}"
SRC_URI[x86_64_v2_ghc-ghc-lib-parser-ex-devel.sha256sum] = "dac665c4bdee265927237989e8129e9693e3d8c3d72207e55ca941fe32a8c732"

URI_x86_64_v2_ghc-ghc-lib-parser-ex-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-lib-parser-ex-doc-9.6.0.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ghc-lib-parser-ex-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-lib-parser-ex-doc}"
SRC_URI[x86_64_v2_ghc-ghc-lib-parser-ex-doc.sha256sum] = "1b37ed8e3a76e86ab37eb3ca70a2b18d1371d3d15eb662ffb468420f6e58f04b"

URI_x86_64_v2_ghc-ghc-lib-parser-ex-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-lib-parser-ex-prof-9.6.0.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-lib-parser-ex-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-lib-parser-ex-prof}"
SRC_URI[x86_64_v2_ghc-ghc-lib-parser-ex-prof.sha256sum] = "de9fa493202317b7956d7bafbbeb825da455521bfcad916c898dc90a45d8a6f0"

URI_x86_64_v2_ghc-hlint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hlint-3.6.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hlint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hlint}"
SRC_URI[x86_64_v2_ghc-hlint.sha256sum] = "3e499c38858cf5e5edaa22a6f22c8dd28e134f53e271116261dd2fb27f5b842e"

URI_x86_64_v2_ghc-hlint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hlint-devel-3.6.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hlint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hlint-devel}"
SRC_URI[x86_64_v2_ghc-hlint-devel.sha256sum] = "e3c3a185bbf1fe811a759bfad673361a7848f10c1525a951fc9817d64c9a69e0"

URI_x86_64_v2_ghc-hlint-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hlint-doc-3.6.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hlint-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hlint-doc}"
SRC_URI[x86_64_v2_ghc-hlint-doc.sha256sum] = "fe48af8261d15b938531d57233d8cefcba297c35977acfe6eee104ed95bdc73f"

URI_x86_64_v2_ghc-hlint-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hlint-prof-3.6.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hlint-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hlint-prof}"
SRC_URI[x86_64_v2_ghc-hlint-prof.sha256sum] = "a660eb1f1323019310b9f4b17020a2fcf7f5307de0323e7ea92f2876fbe67c98"

URI_x86_64_v2_hlint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hlint-3.6.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hlint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hlint}"
SRC_URI[x86_64_v2_hlint.sha256sum] = "7095b199c409aeaeb48133c7c3200ce838f815ee0196347993060c633d4d8bf2"

URI_x86_64_v2_hlint-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hlint-common-3.6.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_hlint-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hlint-common}"
SRC_URI[x86_64_v2_hlint-common.sha256sum] = "bdb95930a307abc9ae2ebeae5baebaf58a0b28428ded529b89d36efbf344d476"

URI_aarch64_ghc-deriving-aeson = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deriving-aeson-0.2.9-7.el10_0.aarch64.rpm;name=aarch64_ghc-deriving-aeson;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deriving-aeson}"
SRC_URI[aarch64_ghc-deriving-aeson.sha256sum] = "14f4045e563a1401f0dfca97fee238f78be4a8ce1edb96cc9838f3f1cce5fcb5"

URI_aarch64_ghc-deriving-aeson-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deriving-aeson-devel-0.2.9-7.el10_0.aarch64.rpm;name=aarch64_ghc-deriving-aeson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deriving-aeson-devel}"
SRC_URI[aarch64_ghc-deriving-aeson-devel.sha256sum] = "c821c28e564254b24190562ef878eaaea29c70f1b2ef959cec34bd675f2b448b"

URI_aarch64_ghc-deriving-aeson-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deriving-aeson-doc-0.2.9-7.el10_0.noarch.rpm;name=aarch64_ghc-deriving-aeson-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deriving-aeson-doc}"
SRC_URI[aarch64_ghc-deriving-aeson-doc.sha256sum] = "8791ee849a304307871646d0d592f4ebb9a993005b14d67abdea0ca0ec3b0e51"

URI_aarch64_ghc-deriving-aeson-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deriving-aeson-prof-0.2.9-7.el10_0.aarch64.rpm;name=aarch64_ghc-deriving-aeson-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deriving-aeson-prof}"
SRC_URI[aarch64_ghc-deriving-aeson-prof.sha256sum] = "fbe936e7fc86cadeda1416de7fdecfbd29d920db1d217369e0bd96641e45a320"

URI_aarch64_ghc-ghc-lib-parser-ex = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-lib-parser-ex-9.6.0.2-7.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-lib-parser-ex;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-lib-parser-ex}"
SRC_URI[aarch64_ghc-ghc-lib-parser-ex.sha256sum] = "92be04d1dec231f0caa4eef59c0705c1c50b807101959493d28eb6eab6037306"

URI_aarch64_ghc-ghc-lib-parser-ex-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-lib-parser-ex-devel-9.6.0.2-7.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-lib-parser-ex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-lib-parser-ex-devel}"
SRC_URI[aarch64_ghc-ghc-lib-parser-ex-devel.sha256sum] = "02b33886f8636ea5aff280264e30cec99e978fa12c9c0b9f702f9b75e0d9adc8"

URI_aarch64_ghc-ghc-lib-parser-ex-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-lib-parser-ex-doc-9.6.0.2-7.el10_0.noarch.rpm;name=aarch64_ghc-ghc-lib-parser-ex-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-lib-parser-ex-doc}"
SRC_URI[aarch64_ghc-ghc-lib-parser-ex-doc.sha256sum] = "db4e960bbf6132b4fb503b774911a362c6d0f9febdad01c9347306b712f28467"

URI_aarch64_ghc-ghc-lib-parser-ex-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-lib-parser-ex-prof-9.6.0.2-7.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-lib-parser-ex-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-lib-parser-ex-prof}"
SRC_URI[aarch64_ghc-ghc-lib-parser-ex-prof.sha256sum] = "e11c51f30cdd6bf6d2e1031012040752619e93b2b026ada0608320d509d31c86"

URI_aarch64_ghc-hlint = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hlint-3.6.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-hlint;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hlint}"
SRC_URI[aarch64_ghc-hlint.sha256sum] = "5c506c5e2e9480537ecfb673fa5dd78fc5d496b72080edd7533ccb87b44f0574"

URI_aarch64_ghc-hlint-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hlint-devel-3.6.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-hlint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hlint-devel}"
SRC_URI[aarch64_ghc-hlint-devel.sha256sum] = "dff3e2304a56d164330b9f0b55c9e041b9f1f36091862bfb41ed207e9a294a81"

URI_aarch64_ghc-hlint-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hlint-doc-3.6.1-7.el10_0.noarch.rpm;name=aarch64_ghc-hlint-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hlint-doc}"
SRC_URI[aarch64_ghc-hlint-doc.sha256sum] = "82277b728669f469dcac735f69c77c1d7aa29e92b90e4cda246ae56a804d7fd1"

URI_aarch64_ghc-hlint-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hlint-prof-3.6.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-hlint-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hlint-prof}"
SRC_URI[aarch64_ghc-hlint-prof.sha256sum] = "34743dc7c7988c459d3985aec938f86a510fc0b8242c8018f0d52a3ab1791c33"

URI_aarch64_hlint = "${EPEL_MIRROR}/aarch64/Packages/h/hlint-3.6.1-7.el10_0.aarch64.rpm;name=aarch64_hlint;unpack=0"
SRC_URI:append = " ${URI_aarch64_hlint}"
SRC_URI[aarch64_hlint.sha256sum] = "b46ca443b42b8d9be3db9cc333fdf92ac006e5e7591d78935f281ee00da3b4e4"

URI_aarch64_hlint-common = "${EPEL_MIRROR}/aarch64/Packages/h/hlint-common-3.6.1-7.el10_0.noarch.rpm;name=aarch64_hlint-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_hlint-common}"
SRC_URI[aarch64_hlint-common.sha256sum] = "9b730c7c02cf171de5320276e8f0c141a7c3e251f25bd15b62d274ad625fdb8a"

RDEPENDS:ghc-deriving-aeson = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-deriving-aeson-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-deriving-aeson \
 "
RDEPENDS:ghc-deriving-aeson-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-deriving-aeson-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-deriving-aeson-devel \
 "
RDEPENDS:ghc-ghc-lib-parser-ex = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-ghc-lib-parser \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-syb \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-uniplate \
 ghc-unix \
 ghc-unordered-containers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ghc-lib-parser-ex-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-ghc-lib-parser-devel \
 ghc-ghc-lib-parser-ex \
 ghc-uniplate-devel \
 "
RDEPENDS:ghc-ghc-lib-parser-ex-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ghc-lib-parser-ex-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-ghc-lib-parser-ex-devel \
 ghc-ghc-lib-parser-prof \
 ghc-uniplate-prof \
 "
RDEPENDS:ghc-hlint = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-bytestring \
 ghc-clock \
 ghc-cmdargs \
 ghc-colour \
 ghc-comonad \
 ghc-conduit \
 ghc-containers \
 ghc-contravariant \
 ghc-cpphs \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-data-fix \
 ghc-deepseq \
 ghc-deriving-aeson \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-extra \
 ghc-file-embed \
 ghc-filepath \
 ghc-filepattern \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-ghc-lib-parser \
 ghc-ghc-lib-parser-ex \
 ghc-hashable \
 ghc-hscolour \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-libyaml \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-old-locale \
 ghc-os-string \
 ghc-parsec \
 ghc-polyparse \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-refact \
 ghc-resourcet \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-syb \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-uniplate \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-yaml \
 glibc \
 gmp \
 hlint-common \
 libyaml \
 "
RDEPENDS:ghc-hlint-devel = " \
 ghc-aeson-devel \
 ghc-ansi-terminal-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-cmdargs-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-cpphs-devel \
 ghc-data-default-devel \
 ghc-deriving-aeson-devel \
 ghc-directory-devel \
 ghc-extra-devel \
 ghc-file-embed-devel \
 ghc-filepath-devel \
 ghc-filepattern-devel \
 ghc-ghc-lib-parser-devel \
 ghc-ghc-lib-parser-ex-devel \
 ghc-hlint \
 ghc-hscolour-devel \
 ghc-process-devel \
 ghc-refact-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 ghc-uniplate-devel \
 ghc-unordered-containers-devel \
 ghc-utf8-string-devel \
 ghc-vector-devel \
 ghc-yaml-devel \
 "
RDEPENDS:ghc-hlint-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hlint-prof = " \
 ghc-aeson-prof \
 ghc-ansi-terminal-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cmdargs-prof \
 ghc-containers-prof \
 ghc-cpphs-prof \
 ghc-data-default-prof \
 ghc-deriving-aeson-prof \
 ghc-directory-prof \
 ghc-extra-prof \
 ghc-file-embed-prof \
 ghc-filepath-prof \
 ghc-filepattern-prof \
 ghc-ghc-lib-parser-ex-prof \
 ghc-ghc-lib-parser-prof \
 ghc-hlint-devel \
 ghc-hscolour-prof \
 ghc-process-prof \
 ghc-refact-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 ghc-uniplate-prof \
 ghc-unordered-containers-prof \
 ghc-utf8-string-prof \
 ghc-vector-prof \
 ghc-yaml-prof \
 "
RDEPENDS:hlint = " \
 glibc \
 gmp \
 hlint-common \
 libffi \
 libyaml \
 "
RDEPENDS:hlint-common = " \
 "
