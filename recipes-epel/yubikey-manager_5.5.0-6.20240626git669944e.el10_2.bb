# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yubikey-manager"
PV = "5.5.0"
PR = "6.20240626git669944e.el10_2"
PACKAGES = " \
 python3-yubikey-manager \
 yubikey-manager \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/y/yubikey-manager-5.5.0-6.20240626git669944e.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a0dc2c8b67ec0877e37f9d344e0b7e7000aa733d72247fe92094b4cae74828da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-yubikey-manager-5.5.0-6.20240626git669944e.el10_2.noarch.rpm;name=aarch64_python3-yubikey-manager;unpack=0"
SRC_URI[aarch64_python3-yubikey-manager.sha256sum] = "bf7cb9e2902a766d8b51f1d34f3ac988e96e8acf423cf0fb2068788148666809"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/y/yubikey-manager-5.5.0-6.20240626git669944e.el10_2.noarch.rpm;name=aarch64_yubikey-manager;unpack=0"
SRC_URI[aarch64_yubikey-manager.sha256sum] = "9918409e888e17a66aad497b8a99cffbb35b4d9d3ebd9cf39a65327692f30e13"

RDEPENDS:python3-yubikey-manager = " \
 pcsc-lite \
 python3 \
 python3-click \
 python3-cryptography \
 python3-fido2 \
 python3-keyring \
 python3-pyscard \
 ykpers \
 "
RDEPENDS:yubikey-manager = " \
 python3 \
 python3-yubikey-manager \
 systemd-udev \
 "
