# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "anaconda"
PV = "40.22.3.46"
PR = "1.el10_2.alma.1"
PACKAGES = " \
 anaconda \
 anaconda-core \
 anaconda-dracut \
 anaconda-gui \
 anaconda-install-env-deps \
 anaconda-install-img-deps \
 anaconda-tui \
 anaconda-widgets \
 anaconda-widgets-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/anaconda-40.22.3.46-1.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acca5c3ea18f90420303c3f578b645761b49cf41e960eddc67378e5e98fb8730"

URI_x86_64_v2_anaconda = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-40.22.3.46-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda}"
SRC_URI[x86_64_v2_anaconda.sha256sum] = "9690490d8f7a4ae848145c3176b005e1d8b75348b53b13ea7399af375d06ec57"

URI_x86_64_v2_anaconda-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-core-40.22.3.46-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-core}"
SRC_URI[x86_64_v2_anaconda-core.sha256sum] = "3040da669c92f6ea88f00f235e2a2a2e14795ea2f223c034ef7252e810dfd23c"

URI_x86_64_v2_anaconda-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-dracut-40.22.3.46-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-dracut}"
SRC_URI[x86_64_v2_anaconda-dracut.sha256sum] = "f5c71ce25458bd2d680cfb697a09b53e5b0be4462e9d49be6b595f70484d308e"

URI_x86_64_v2_anaconda-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-gui-40.22.3.46-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-gui}"
SRC_URI[x86_64_v2_anaconda-gui.sha256sum] = "8eb1e64ff5ddd1bbabb1d01336cbdab41ba24a2f7b05e62f1fe49324459e0054"

URI_x86_64_v2_anaconda-install-env-deps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-install-env-deps-40.22.3.46-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-install-env-deps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-install-env-deps}"
SRC_URI[x86_64_v2_anaconda-install-env-deps.sha256sum] = "671854e8e099b0b61d0eca4fec12d3369a0afeb735f2752305bfd596cfe1b924"

URI_x86_64_v2_anaconda-install-img-deps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-install-img-deps-40.22.3.46-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-install-img-deps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-install-img-deps}"
SRC_URI[x86_64_v2_anaconda-install-img-deps.sha256sum] = "f4e86c1a8f3af44ecb538bdd1ebed9e5403930eb4d2df41013a5ee5306189d4d"

URI_x86_64_v2_anaconda-tui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-tui-40.22.3.46-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-tui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-tui}"
SRC_URI[x86_64_v2_anaconda-tui.sha256sum] = "bc7bc4ab3382d2d16206713297351fac8dc390de4113097ffe740deb0fc2dfed"

URI_x86_64_v2_anaconda-widgets = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-widgets-40.22.3.46-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-widgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-widgets}"
SRC_URI[x86_64_v2_anaconda-widgets.sha256sum] = "36f16455112551a89fe58bc9e5a87c1824617e4635f40edf8c47b841971b0c28"

URI_x86_64_v2_anaconda-widgets-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/anaconda-widgets-devel-40.22.3.46-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-widgets-devel}"
SRC_URI[x86_64_v2_anaconda-widgets-devel.sha256sum] = "8a3f700de62f2d9a312ef58cb5724fdc4d30c66d9f477bff27ebdfbd4ce16249"

URI_aarch64_anaconda = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-40.22.3.46-1.el10_2.alma.1.aarch64.rpm;name=aarch64_anaconda;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda}"
SRC_URI[aarch64_anaconda.sha256sum] = "d6d0738ec4da4cfb8a105e362a241b9f80a00831ceb3e810752b39f82306a451"

URI_aarch64_anaconda-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-core-40.22.3.46-1.el10_2.alma.1.aarch64.rpm;name=aarch64_anaconda-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-core}"
SRC_URI[aarch64_anaconda-core.sha256sum] = "c1662da0acf976e45a0c7553d04fec18201f43f94258ef6ddb02f5437f0b22b7"

URI_aarch64_anaconda-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-dracut-40.22.3.46-1.el10_2.alma.1.aarch64.rpm;name=aarch64_anaconda-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-dracut}"
SRC_URI[aarch64_anaconda-dracut.sha256sum] = "ee5bf769e41aa3513d8bfa8f25ec2adb4b57e11925cd388c1ac25b6e9750cc26"

URI_aarch64_anaconda-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-gui-40.22.3.46-1.el10_2.alma.1.aarch64.rpm;name=aarch64_anaconda-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-gui}"
SRC_URI[aarch64_anaconda-gui.sha256sum] = "8257afc3f1df6e33694cef7bf11f578e6ff9a0cf08dac3949ebad2b810be3506"

URI_aarch64_anaconda-install-env-deps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-install-env-deps-40.22.3.46-1.el10_2.alma.1.aarch64.rpm;name=aarch64_anaconda-install-env-deps;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-install-env-deps}"
SRC_URI[aarch64_anaconda-install-env-deps.sha256sum] = "2443780a7f37e9e09c18c1895b37ee80943728fd2c7e247ecd27437cd5fcb3eb"

URI_aarch64_anaconda-install-img-deps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-install-img-deps-40.22.3.46-1.el10_2.alma.1.aarch64.rpm;name=aarch64_anaconda-install-img-deps;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-install-img-deps}"
SRC_URI[aarch64_anaconda-install-img-deps.sha256sum] = "c9087d4f47844d29d7c07a895f93284641b1b492640ad85b66c6e8b5b2eff22b"

URI_aarch64_anaconda-tui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-tui-40.22.3.46-1.el10_2.alma.1.aarch64.rpm;name=aarch64_anaconda-tui;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-tui}"
SRC_URI[aarch64_anaconda-tui.sha256sum] = "b600fdbb5f1de17f51b94adb55c6f190e711b67ad7fa1785c7eec8360de1a071"

URI_aarch64_anaconda-widgets = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-widgets-40.22.3.46-1.el10_2.alma.1.aarch64.rpm;name=aarch64_anaconda-widgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-widgets}"
SRC_URI[aarch64_anaconda-widgets.sha256sum] = "696da1221c2cdad5be624099e6f99ae9036a4dd79f95b32d5cc7d8556afb63af"

URI_aarch64_anaconda-widgets-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/anaconda-widgets-devel-40.22.3.46-1.el10_2.alma.1.aarch64.rpm;name=aarch64_anaconda-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-widgets-devel}"
SRC_URI[aarch64_anaconda-widgets-devel.sha256sum] = "f230f07417c0b9f03b6d32a3ab77bdb299f0bdbf70a22dbe9958c1ffd1aba63a"

RDEPENDS:anaconda = " \
 anaconda-gui \
 anaconda-tui \
 "
RDEPENDS:anaconda-core = " \
 NetworkManager \
 NetworkManager-libnm \
 anaconda-tui \
 bash \
 chrony \
 cracklib-dicts \
 crypto-policies \
 crypto-policies-scripts \
 dbus-daemon \
 flatpak \
 flatpak-libs \
 grub2-common \
 kbd \
 python3 \
 python3-blivet \
 python3-blockdev \
 python3-dasbus \
 python3-dnf \
 python3-gobject-base \
 python3-kickstart \
 python3-langtable \
 python3-libs \
 python3-libselinux \
 python3-meh \
 python3-pid \
 python3-productmd \
 python3-pwquality \
 python3-pyparted \
 python3-requests \
 python3-requests-file \
 python3-requests-ftp \
 python3-rpm \
 python3-systemd \
 systemd \
 util-linux \
 virtual//usr/bin/date \
 virtual/glibc-langpack-en_or_glibc-all-langpacks \
 "
RDEPENDS:anaconda-dracut = " \
 bash \
 dnsconfd \
 dnsconfd-dracut \
 dracut \
 dracut-live \
 dracut-network \
 glibc \
 iputils \
 libarchive \
 python3 \
 python3-kickstart \
 rpm-libs \
 xz \
 "
RDEPENDS:anaconda-gui = " \
 NetworkManager-wifi \
 adwaita-icon-theme \
 almalinux-logos \
 anaconda-core \
 anaconda-widgets \
 nm-connection-editor \
 python3 \
 python3-iso639 \
 python3-meh-gui \
 python3-xkbregistry \
 tecla \
 "
RDEPENDS:anaconda-install-env-deps = " \
 dosfstools \
 e2fsprogs \
 gdb \
 isomd5sum \
 kexec-tools \
 libblockdev-plugins-all \
 realmd \
 rsync \
 tmux \
 udisks2-iscsi \
 xfsprogs \
 "
RDEPENDS:anaconda-install-img-deps:x86_64_v2 = " \
 anaconda-install-env-deps \
 bootc \
 bootupd \
 brltty \
 createrepo_c \
 device-mapper-multipath \
 dnsconfd \
 dnsconfd-dracut \
 fcoe-utils \
 gnome-kiosk \
 gnome-remote-desktop \
 gsettings-desktop-schemas \
 kdump-anaconda-addon \
 librsvg2 \
 libselinux-utils \
 mesa-dri-drivers \
 nm-connection-editor \
 nvme-cli \
 openssl \
 ostree \
 policycoreutils \
 policycoreutils-python-utils \
 python3-pam \
 rpm-ostree \
 selinux-policy \
 selinux-policy-targeted \
 skopeo \
 zram-generator-defaults \
"
RDEPENDS:anaconda-install-img-deps:aarch64 = " \
 anaconda-install-env-deps \
 bootc \
 bootupd \
 brltty \
 createrepo_c \
 device-mapper-multipath \
 dnsconfd \
 dnsconfd-dracut \
 gnome-kiosk \
 gnome-remote-desktop \
 gsettings-desktop-schemas \
 kdump-anaconda-addon \
 librsvg2 \
 libselinux-utils \
 mesa-dri-drivers \
 nm-connection-editor \
 nvme-cli \
 openssl \
 ostree \
 policycoreutils \
 policycoreutils-python-utils \
 python3-pam \
 rpm-ostree \
 selinux-policy \
 selinux-policy-targeted \
 skopeo \
 zram-generator-defaults \
"
RDEPENDS:anaconda-tui = " \
 anaconda-core \
 python3 \
 python3-simpleline \
 "
RDEPENDS:anaconda-widgets = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libgcc \
 pango \
 python3 \
 "
RDEPENDS:anaconda-widgets-devel = " \
 anaconda-widgets \
 "
