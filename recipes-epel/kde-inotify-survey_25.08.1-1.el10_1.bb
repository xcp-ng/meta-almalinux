# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-inotify-survey"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kde-inotify-survey \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-inotify-survey-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "850a6260843a63c88dbae4007b03cfdc3a7f00b033092fbf39315f9c5efc2bed"

URI_x86_64_v2_kde-inotify-survey = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-inotify-survey-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-inotify-survey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-inotify-survey}"
SRC_URI[x86_64_v2_kde-inotify-survey.sha256sum] = "337cacfb8172ebee940b5127ee8245e6b115d2f074c5370158c2929d7a10754b"

URI_aarch64_kde-inotify-survey = "${EPEL_MIRROR}/aarch64/Packages/k/kde-inotify-survey-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kde-inotify-survey;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-inotify-survey}"
SRC_URI[aarch64_kde-inotify-survey.sha256sum] = "2fab3d2665eb90ca3447972e87e81f5491dc16cd9f8170ad06ffd5f2c51e0bbf"

RDEPENDS:kde-inotify-survey = " \
 dbus-common \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kded \
 kf6-ki18n \
 kf6-knotifications \
 libstdc++ \
 polkit \
 qt6-qtbase \
 "
