# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-console"
PV = "0.16.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-console+alloc-devel \
 rust-console+ansi-parsing-devel \
 rust-console+default-devel \
 rust-console+std-devel \
 rust-console+unicode-width-devel \
 rust-console-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-console-0.16.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45b01f23a08e00092ee41ef1b7e0e12ab89157667eb43cb6c1311a39156a9cef"

URI_x86_64_v2_rust-console+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+alloc-devel-0.16.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+alloc-devel}"
SRC_URI[x86_64_v2_rust-console+alloc-devel.sha256sum] = "1b478fea8549b5cdc1c16cec5eb074d2608b3107c283dac1e9d5272927c16866"

URI_x86_64_v2_rust-console+ansi-parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+ansi-parsing-devel-0.16.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+ansi-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+ansi-parsing-devel}"
SRC_URI[x86_64_v2_rust-console+ansi-parsing-devel.sha256sum] = "44468d23d2eada400f7e5c9f44325ba0f915666343c42b3cea562fe2e5f19ec0"

URI_x86_64_v2_rust-console+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+default-devel-0.16.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+default-devel}"
SRC_URI[x86_64_v2_rust-console+default-devel.sha256sum] = "070b471c22c52eb34c54ee64db08bb810e55094265182f8561ce3e13b7cf2de8"

URI_x86_64_v2_rust-console+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+std-devel-0.16.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+std-devel}"
SRC_URI[x86_64_v2_rust-console+std-devel.sha256sum] = "659a3fc959e996fb9abd0e76075f7ef502aaa936210512d65c962b58beda2a96"

URI_x86_64_v2_rust-console+unicode-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+unicode-width-devel-0.16.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+unicode-width-devel}"
SRC_URI[x86_64_v2_rust-console+unicode-width-devel.sha256sum] = "8c8253e702029c8336600ad37bc4174822d3476db1bdbb5be096963ef2065aae"

URI_x86_64_v2_rust-console-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console-devel-0.16.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console-devel}"
SRC_URI[x86_64_v2_rust-console-devel.sha256sum] = "670bd7cb039bbdc9b3d262baccc3f8aaad4ff48aa256c99410580b1b99bae594"

URI_aarch64_rust-console+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+alloc-devel-0.16.3-1.el10_1.noarch.rpm;name=aarch64_rust-console+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+alloc-devel}"
SRC_URI[aarch64_rust-console+alloc-devel.sha256sum] = "12608a5886d5c5883742d0353353fe49d59cdbb33d858b1f258f682a32894a2c"

URI_aarch64_rust-console+ansi-parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+ansi-parsing-devel-0.16.3-1.el10_1.noarch.rpm;name=aarch64_rust-console+ansi-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+ansi-parsing-devel}"
SRC_URI[aarch64_rust-console+ansi-parsing-devel.sha256sum] = "4be958443f38278d8c6bfc202b83c7edb468eacb2809b215e88becf746d88da3"

URI_aarch64_rust-console+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+default-devel-0.16.3-1.el10_1.noarch.rpm;name=aarch64_rust-console+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+default-devel}"
SRC_URI[aarch64_rust-console+default-devel.sha256sum] = "664d089824d7d1c6133986bba908a98f0366f543b8419b9d1dea8195266af52f"

URI_aarch64_rust-console+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+std-devel-0.16.3-1.el10_1.noarch.rpm;name=aarch64_rust-console+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+std-devel}"
SRC_URI[aarch64_rust-console+std-devel.sha256sum] = "c846bf4388ce91f2ed574364575d7fe664bc04be50a5a93889c1d290d488a111"

URI_aarch64_rust-console+unicode-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+unicode-width-devel-0.16.3-1.el10_1.noarch.rpm;name=aarch64_rust-console+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+unicode-width-devel}"
SRC_URI[aarch64_rust-console+unicode-width-devel.sha256sum] = "6c2921edcf41c816197d0dfa50e2de80616f3207566e8d301c7a354a342f3338"

URI_aarch64_rust-console-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console-devel-0.16.3-1.el10_1.noarch.rpm;name=aarch64_rust-console-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console-devel}"
SRC_URI[aarch64_rust-console-devel.sha256sum] = "6daefee6f03407bd8a1b7b1ca62ba7e83439d55f8717f840c7faabf6cde515c9"

RDEPENDS:rust-console+alloc-devel = " \
 cargo \
 rust-console-devel \
 "
RDEPENDS:rust-console+ansi-parsing-devel = " \
 cargo \
 rust-console-devel \
 "
RDEPENDS:rust-console+default-devel = " \
 cargo \
 rust-console+ansi-parsing-devel \
 rust-console+std-devel \
 rust-console+unicode-width-devel \
 rust-console-devel \
 "
RDEPENDS:rust-console+std-devel = " \
 cargo \
 rust-console+alloc-devel \
 rust-console-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-console+unicode-width-devel = " \
 cargo \
 rust-console-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-console-devel = " \
 cargo \
 rust \
 "
