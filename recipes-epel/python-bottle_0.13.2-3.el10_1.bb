# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-bottle"
PV = "0.13.2"
PR = "3.el10_1"
PACKAGES = " \
 python3-bottle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-bottle-0.13.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb52f0a83e1aac0cca778f7e564170eae63cb4eabfe9ecef6432376122474453"

URI_x86_64_v2_python3-bottle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bottle-0.13.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-bottle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bottle}"
SRC_URI[x86_64_v2_python3-bottle.sha256sum] = "52058ef625606d00b111cae18a7bc806bfdba2d575a050a18bd95fbd7bdb0e06"

URI_aarch64_python3-bottle = "${EPEL_MIRROR}/aarch64/Packages/p/python3-bottle-0.13.2-3.el10_1.noarch.rpm;name=aarch64_python3-bottle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bottle}"
SRC_URI[aarch64_python3-bottle.sha256sum] = "c80c95c03f4b03a050507fbbab14a81c2bb6de8638146867eb9cf5f1804d78ae"

RDEPENDS:python3-bottle = " \
 python3 \
 "
