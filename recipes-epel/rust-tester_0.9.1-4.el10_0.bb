# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tester"
PV = "0.9.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-tester+asm_black_box-devel \
 rust-tester+capture-devel \
 rust-tester+default-devel \
 rust-tester-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tester-0.9.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82288d486b7171ea6f4a5b161cf9aafd77a157b3b308a2b7869b253f1db55cd3"

URI_x86_64_v2_rust-tester+asm_black_box-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tester+asm_black_box-devel-0.9.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tester+asm_black_box-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tester+asm_black_box-devel}"
SRC_URI[x86_64_v2_rust-tester+asm_black_box-devel.sha256sum] = "a1dbcb6c52d4e19e2693ca6a220083d950f9fdd5c61a6a3e248570ef7e613a23"

URI_x86_64_v2_rust-tester+capture-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tester+capture-devel-0.9.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tester+capture-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tester+capture-devel}"
SRC_URI[x86_64_v2_rust-tester+capture-devel.sha256sum] = "2a5f575c2be7359d42caedb57ccbf2a469dfcd5379b28c4bef77802dfe120796"

URI_x86_64_v2_rust-tester+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tester+default-devel-0.9.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tester+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tester+default-devel}"
SRC_URI[x86_64_v2_rust-tester+default-devel.sha256sum] = "2ed30a305dbb85df49b75a36a023f955069a940ed1164e25460296d0119c0a32"

URI_x86_64_v2_rust-tester-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tester-devel-0.9.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tester-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tester-devel}"
SRC_URI[x86_64_v2_rust-tester-devel.sha256sum] = "bc32edb73c5118152ff4155242fc300324e08f77c29a5f3106c6bb6f8439f979"

URI_aarch64_rust-tester+asm_black_box-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tester+asm_black_box-devel-0.9.1-4.el10_0.noarch.rpm;name=aarch64_rust-tester+asm_black_box-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tester+asm_black_box-devel}"
SRC_URI[aarch64_rust-tester+asm_black_box-devel.sha256sum] = "855b97fd1ee5c4fc61f80cbb962aac1e0588c18d7cd1e15f85bf7e2732a4854e"

URI_aarch64_rust-tester+capture-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tester+capture-devel-0.9.1-4.el10_0.noarch.rpm;name=aarch64_rust-tester+capture-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tester+capture-devel}"
SRC_URI[aarch64_rust-tester+capture-devel.sha256sum] = "11ca6686ab4384984a1015ae2faedd8742239f2eef36e607165670f43a50bbee"

URI_aarch64_rust-tester+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tester+default-devel-0.9.1-4.el10_0.noarch.rpm;name=aarch64_rust-tester+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tester+default-devel}"
SRC_URI[aarch64_rust-tester+default-devel.sha256sum] = "4fc3a0bde9d7c7a2166ecb993f5c643dba24d36cf418d6c8bc20d52a40a21212"

URI_aarch64_rust-tester-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tester-devel-0.9.1-4.el10_0.noarch.rpm;name=aarch64_rust-tester-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tester-devel}"
SRC_URI[aarch64_rust-tester-devel.sha256sum] = "ad3a0331c4ccfc5ed94baf41ae593bafc95370ade4c093efa41af078dbe6e0b2"

RDEPENDS:rust-tester+asm_black_box-devel = " \
 cargo \
 rust-tester-devel \
 "
RDEPENDS:rust-tester+capture-devel = " \
 cargo \
 rust-tester-devel \
 "
RDEPENDS:rust-tester+default-devel = " \
 cargo \
 rust-tester-devel \
 "
RDEPENDS:rust-tester-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-getopts+default-devel \
 rust-libc-devel \
 rust-num_cpus+default-devel \
 rust-term0.7+default-devel \
 "
