# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-common"
PV = "18.15"
PR = "1.el10_2"
PACKAGES = " \
 globus-common \
 globus-common-devel \
 globus-common-doc \
 globus-common-progs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-common-18.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1db28ce4d3621924c7caeb56bf95b424e9f7f516cd7cf494dd50fb4f13e3b1dd"

URI_x86_64_v2_globus-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-common-18.15-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-common}"
SRC_URI[x86_64_v2_globus-common.sha256sum] = "34790f18dd8f48ed7bd5fa1ab5de2056709af0df43aa6a3eeeb5a967d15710e5"

URI_x86_64_v2_globus-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-common-devel-18.15-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-common-devel}"
SRC_URI[x86_64_v2_globus-common-devel.sha256sum] = "23d01efc04ca4bf9da5f2ed55a322f4755cb9bab4dc58ed7747bde4906b13161"

URI_x86_64_v2_globus-common-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-common-doc-18.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_globus-common-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-common-doc}"
SRC_URI[x86_64_v2_globus-common-doc.sha256sum] = "90aeb386154371d04cb8debb052ff91a6e2dbfe31886d5b17d5d75439033b6d3"

URI_x86_64_v2_globus-common-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-common-progs-18.15-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-common-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-common-progs}"
SRC_URI[x86_64_v2_globus-common-progs.sha256sum] = "84e5e9d12f0ed9f42d16cc0b35a5a530ea569c2cfab53d51c931ac0ee22952ce"

URI_aarch64_globus-common = "${EPEL_MIRROR}/aarch64/Packages/g/globus-common-18.15-1.el10_2.aarch64.rpm;name=aarch64_globus-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-common}"
SRC_URI[aarch64_globus-common.sha256sum] = "29c38bc2ad31987876ac0ecc7934cf5cc61db675067203f5283ebd8c2b39365e"

URI_aarch64_globus-common-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-common-devel-18.15-1.el10_2.aarch64.rpm;name=aarch64_globus-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-common-devel}"
SRC_URI[aarch64_globus-common-devel.sha256sum] = "fc8c89b96da5c1a6ba9bdd190329355d848af1bd8a55d9211fa33290c837542a"

URI_aarch64_globus-common-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-common-doc-18.15-1.el10_2.noarch.rpm;name=aarch64_globus-common-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-common-doc}"
SRC_URI[aarch64_globus-common-doc.sha256sum] = "a7f636c5affcf239a03fa2db86deaa4451dad5acaac58fa023c65f426d83e113"

URI_aarch64_globus-common-progs = "${EPEL_MIRROR}/aarch64/Packages/g/globus-common-progs-18.15-1.el10_2.aarch64.rpm;name=aarch64_globus-common-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-common-progs}"
SRC_URI[aarch64_globus-common-progs.sha256sum] = "02043aa3529e6f797ef168ea3e119c79144661574240dd485e217d8329618567"

RDEPENDS:globus-common = " \
 glibc \
 libtool-ltdl \
 perl-Exporter \
 perl-File-Basename \
 perl-libs \
 "
RDEPENDS:globus-common-devel = " \
 globus-common \
 libtool-ltdl-devel \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Usage \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-common-doc = " \
 "
RDEPENDS:globus-common-progs = " \
 bash \
 glibc \
 globus-common \
 libtool-ltdl \
 "
