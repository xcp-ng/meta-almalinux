# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3-rpm"
PV = "4.19.1.1"
PR = "25.1.el10_3"
PACKAGES = " \
 python3.13-rpm \
 python3.14-rpm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3-rpm-4.19.1.1-25.1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "949b2dd57e4bb84b0b603a55bb8314d086b3354f379f6778f73842a16c25668d"

URI_x86_64_v2_python3.13-rpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-rpm-4.19.1.1-25.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-rpm}"
SRC_URI[x86_64_v2_python3.13-rpm.sha256sum] = "80a08aa9a2437f9bdf6ce8db7ee8320834493f2677531c62df9e9910a5dd01ea"

URI_x86_64_v2_python3.14-rpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.14-rpm-4.19.1.1-25.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.14-rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-rpm}"
SRC_URI[x86_64_v2_python3.14-rpm.sha256sum] = "adfe900eeab9f44e4a7eb368a8599b2c4f62b1bdcd78f720a8843e9d4776edef"

URI_aarch64_python3.13-rpm = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-rpm-4.19.1.1-25.1.el10_3.aarch64.rpm;name=aarch64_python3.13-rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-rpm}"
SRC_URI[aarch64_python3.13-rpm.sha256sum] = "f248aa5d7e69d488b495058da59062f88dd85893c9d2e6c1ac7fbc7e3e9552e2"

URI_aarch64_python3.14-rpm = "${EPEL_MIRROR}/aarch64/Packages/p/python3.14-rpm-4.19.1.1-25.1.el10_3.aarch64.rpm;name=aarch64_python3.14-rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-rpm}"
SRC_URI[aarch64_python3.14-rpm.sha256sum] = "c008604c86e185bf71edbe25c574a2e7041cb06f45ef68c0f1b6fb5022ff8df2"

RDEPENDS:python3.13-rpm = " \
 glibc \
 python3.13 \
 rpm-build-libs \
 rpm-libs \
 rpm-sign-libs \
 "
RDEPENDS:python3.14-rpm = " \
 glibc \
 python3.14 \
 rpm-build-libs \
 rpm-libs \
 rpm-sign-libs \
 "
