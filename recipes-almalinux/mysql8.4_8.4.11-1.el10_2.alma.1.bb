# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mysql8.4"
PV = "8.4.11"
PR = "1.el10_2.alma.1"
PACKAGES = " \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-devel \
 mysql8.4-errmsg \
 mysql8.4-libs \
 mysql8.4-server \
 mysql8.4-test \
 mysql8.4-test-data \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mysql8.4-8.4.11-1.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ab51b6d9beef4fb80dab91f47b11c8c36689e6e1d52ae22e3f5d4ac8bd21360"

URI_x86_64_v2_mysql8.4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-8.4.11-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mysql8.4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4}"
SRC_URI[x86_64_v2_mysql8.4.sha256sum] = "cdf54bafe0a43d7d8ea37e04f149ce51f80cf843efeb9070517f345c32d27a03"
RPROVIDES:mysql8.4:x86_64_v2 = "virtual//usr/bin/mysqldump"

URI_x86_64_v2_mysql8.4-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-common-8.4.11-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_mysql8.4-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-common}"
SRC_URI[x86_64_v2_mysql8.4-common.sha256sum] = "c88645f04b3cebf77c1371c06af54dbc511288a9c7e60b32a1b8566680f797db"

URI_x86_64_v2_mysql8.4-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mysql8.4-devel-8.4.11-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-devel}"
SRC_URI[x86_64_v2_mysql8.4-devel.sha256sum] = "31d5a24418c0ac767fe2e2a32b1c2a4abd2b0810b0ab2af320a7505adba7c065"

URI_x86_64_v2_mysql8.4-errmsg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-errmsg-8.4.11-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_mysql8.4-errmsg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-errmsg}"
SRC_URI[x86_64_v2_mysql8.4-errmsg.sha256sum] = "363b90f121ea2698cc9695f9f3309d5ffa0b6afbaa96304878cd6e0f4729dc7e"

URI_x86_64_v2_mysql8.4-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-libs-8.4.11-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-libs}"
SRC_URI[x86_64_v2_mysql8.4-libs.sha256sum] = "dfdd83f8d1f19f0fb0bf01431b227a2591c22759461f9249f57f79e35ef5bc09"

URI_x86_64_v2_mysql8.4-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-server-8.4.11-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-server}"
SRC_URI[x86_64_v2_mysql8.4-server.sha256sum] = "246ad7f569e31f100344a7f9e285898a02a9cf7c0273d64327ded3a8e0cc0e2a"

URI_x86_64_v2_mysql8.4-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mysql8.4-test-8.4.11-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-test}"
SRC_URI[x86_64_v2_mysql8.4-test.sha256sum] = "fb0f6f262b7c29d286a5fea79f7a9eaf7476cc0926a0244e022a066b5beda622"

URI_x86_64_v2_mysql8.4-test-data = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mysql8.4-test-data-8.4.11-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_mysql8.4-test-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-test-data}"
SRC_URI[x86_64_v2_mysql8.4-test-data.sha256sum] = "d2cfc67fb9e6ffd91fcc37ace5d5f06a12107a569db323dd8f86bf7b1e2d5830"

URI_aarch64_mysql8.4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-8.4.11-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mysql8.4;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4}"
SRC_URI[aarch64_mysql8.4.sha256sum] = "ed85f9ca4d0d926c0054a52ba5ad0684d7b7fbc8e02037f2b55bc5e020aeb268"
RPROVIDES:mysql8.4:aarch64 = "virtual//usr/bin/mysqldump"

URI_aarch64_mysql8.4-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-common-8.4.11-1.el10_2.alma.1.noarch.rpm;name=aarch64_mysql8.4-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-common}"
SRC_URI[aarch64_mysql8.4-common.sha256sum] = "c88645f04b3cebf77c1371c06af54dbc511288a9c7e60b32a1b8566680f797db"

URI_aarch64_mysql8.4-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mysql8.4-devel-8.4.11-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mysql8.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-devel}"
SRC_URI[aarch64_mysql8.4-devel.sha256sum] = "17db52bdfab6ee2e2dbd4e8011882503c8d14ea5051aee3a01d91ec52ab104a5"

URI_aarch64_mysql8.4-errmsg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-errmsg-8.4.11-1.el10_2.alma.1.noarch.rpm;name=aarch64_mysql8.4-errmsg;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-errmsg}"
SRC_URI[aarch64_mysql8.4-errmsg.sha256sum] = "363b90f121ea2698cc9695f9f3309d5ffa0b6afbaa96304878cd6e0f4729dc7e"

URI_aarch64_mysql8.4-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-libs-8.4.11-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mysql8.4-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-libs}"
SRC_URI[aarch64_mysql8.4-libs.sha256sum] = "7a4cee3dbc2887388ce39ea2a3bce5a34ddc94529b959d83ae646ce3726faa1a"

URI_aarch64_mysql8.4-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-server-8.4.11-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mysql8.4-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-server}"
SRC_URI[aarch64_mysql8.4-server.sha256sum] = "1e155cf3ad05674412e2f993cf446984de91ecfb594c3fb6d2f07d0b7fbbb24e"

URI_aarch64_mysql8.4-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mysql8.4-test-8.4.11-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mysql8.4-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-test}"
SRC_URI[aarch64_mysql8.4-test.sha256sum] = "3b302f4f7fee9cab5f69247ee87690981470cc9a3778c70b37646e8cfb399406"

URI_aarch64_mysql8.4-test-data = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mysql8.4-test-data-8.4.11-1.el10_2.alma.1.noarch.rpm;name=aarch64_mysql8.4-test-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-test-data}"
SRC_URI[aarch64_mysql8.4-test-data.sha256sum] = "d2cfc67fb9e6ffd91fcc37ace5d5f06a12107a569db323dd8f86bf7b1e2d5830"

RDEPENDS:mysql8.4 = " \
 bash \
 glibc \
 grep \
 libedit \
 libgcc \
 libstdc++ \
 libzstd \
 mysql8.4-common \
 openssl-libs \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:mysql8.4-common = " \
 mariadb-connector-c-config \
 "
RDEPENDS:mysql8.4-devel = " \
 bash \
 libzstd-devel \
 mysql8.4-libs \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:mysql8.4-errmsg = " \
 mysql8.4-common \
 "
RDEPENDS:mysql8.4-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 mysql8.4-common \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:mysql8.4-server:x86_64_v2 = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libicu \
 libstdc++ \
 libtirpc \
 libzstd \
 lz4-libs \
 mariadb-connector-c-config \
 mecab \
 mysql-selinux \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-errmsg \
 numactl-libs \
 openssl-libs \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 policycoreutils-python-utils \
 protobuf-lite \
 shadow-utils \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:mysql8.4-server:aarch64 = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libicu \
 libstdc++ \
 libtirpc \
 libzstd \
 lz4-libs \
 mariadb-connector-c-config \
 mecab \
 mysql-selinux \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-errmsg \
 openssl-libs \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 policycoreutils-python-utils \
 protobuf-lite \
 shadow-utils \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:mysql8.4-test = " \
 bash \
 glibc \
 gzip \
 libgcc \
 libstdc++ \
 libzstd \
 lz4 \
 lz4-libs \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-server \
 mysql8.4-test-data \
 openssl \
 openssl-libs \
 perl-Data-Dumper \
 perl-Digest \
 perl-Digest-MD5 \
 perl-Env \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Compare \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-JSON \
 perl-Memoize \
 perl-Socket \
 perl-Sys-Hostname \
 perl-Test-Simple \
 perl-Time-HiRes \
 perl-libwww-perl \
 protobuf \
 zlib-ng-compat \
 "
RDEPENDS:mysql8.4-test-data = " \
 bash \
 mysql8.4-test \
 perl-Carp \
 perl-Data-Dumper \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IO \
 perl-JSON \
 perl-Memoize \
 perl-POSIX \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Test-Simple \
 perl-Time \
 perl-Time-HiRes \
 perl-base \
 perl-constant \
 perl-if \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 perl-threads \
 perl-threads-shared \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/mysqldump"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/mysqldump"
