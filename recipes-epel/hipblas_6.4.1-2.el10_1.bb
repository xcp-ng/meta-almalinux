# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipblas"
PV = "6.4.1"
PR = "2.el10_1"
PACKAGES:x86_64_v2 = " \
 hipblas \
 hipblas-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipblas-6.4.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0014306132de3e7d2a7f55eb110075ff9d5e6dc10a0864383f032e36fead5f83"

URI_x86_64_v2_hipblas = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipblas-6.4.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipblas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipblas}"
SRC_URI[x86_64_v2_hipblas.sha256sum] = "04d946b8f0ab897203799689c5e9255bba2c2b3bb1db00b16726c35ab0598ffe"

URI_x86_64_v2_hipblas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipblas-devel-6.4.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipblas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipblas-devel}"
SRC_URI[x86_64_v2_hipblas-devel.sha256sum] = "fac7c95f2a8fdb748083948f4d46d8d515f2a4290c878013fe87d615cf4c28b4"

RDEPENDS:hipblas = " \
 glibc \
 libgcc \
 libstdc++ \
 rocblas \
 rocsolver \
 "
RDEPENDS:hipblas-devel = " \
 cmake-filesystem \
 hipblas \
 hipblas-common-devel \
 "
