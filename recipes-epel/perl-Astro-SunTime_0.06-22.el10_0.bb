# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Astro-SunTime"
PV = "0.06"
PR = "22.el10_0"
PACKAGES = " \
 perl-Astro-SunTime \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Astro-SunTime-0.06-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9307901e925103e2feb7408ff411dedcc68e3720ef04beb206b478cd842042f4"

URI_x86_64_v2_perl-Astro-SunTime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Astro-SunTime-0.06-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Astro-SunTime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Astro-SunTime}"
SRC_URI[x86_64_v2_perl-Astro-SunTime.sha256sum] = "449d1fe797e44d3f15c66bb0c339f6088f1f0272f9dba6258dcfe1880c6dec80"

URI_aarch64_perl-Astro-SunTime = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Astro-SunTime-0.06-22.el10_0.noarch.rpm;name=aarch64_perl-Astro-SunTime;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Astro-SunTime}"
SRC_URI[aarch64_perl-Astro-SunTime.sha256sum] = "ecf393509956e9c75a979e53099efd60bdf7ffad22c38c9b486736776f931be5"

RDEPENDS:perl-Astro-SunTime = " \
 perl-POSIX \
 perl-Time-ParseDate \
 perl-libs \
 perl-vars \
 "
