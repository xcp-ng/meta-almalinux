# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnsmasq"
PV = "2.90"
PR = "7.el10_2"
PACKAGES = " \
 dnsmasq \
 dnsmasq-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dnsmasq-2.90-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a3699a8af5f4a9c4a4fe4dd8327e6c0a4357282b85b51567892ac1afd013d96"

URI_x86_64_v2_dnsmasq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsmasq-2.90-7.el10_2.x86_64_v2.rpm;name=x86_64_v2_dnsmasq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsmasq}"
SRC_URI[x86_64_v2_dnsmasq.sha256sum] = "956813393855e1b4e6dec4c9918a27556c20743ced8c07d5b3ca57d1082dfe5b"

URI_x86_64_v2_dnsmasq-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsmasq-utils-2.90-7.el10_2.x86_64_v2.rpm;name=x86_64_v2_dnsmasq-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsmasq-utils}"
SRC_URI[x86_64_v2_dnsmasq-utils.sha256sum] = "7ea1c08a8a2899546d9f7cfd932a93daaefc402f608973a58c4aaef733f0a656"

URI_aarch64_dnsmasq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsmasq-2.90-7.el10_2.aarch64.rpm;name=aarch64_dnsmasq;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsmasq}"
SRC_URI[aarch64_dnsmasq.sha256sum] = "db23d841b2c5eb195d7684db3a8eb3377cd41e84c009db9e0262bec419614afe"

URI_aarch64_dnsmasq-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsmasq-utils-2.90-7.el10_2.aarch64.rpm;name=aarch64_dnsmasq-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsmasq-utils}"
SRC_URI[aarch64_dnsmasq-utils.sha256sum] = "084dc08f58584e1aa8fb7bf0314bac6ea6d2875b2e4d5ea0ef92ae6467a3e954"

RDEPENDS:dnsmasq = " \
 bash \
 dbus-libs \
 glibc \
 gmp \
 libidn2 \
 libnetfilter_conntrack \
 nettle \
 "
RDEPENDS:dnsmasq-utils = " \
 glibc \
 "
