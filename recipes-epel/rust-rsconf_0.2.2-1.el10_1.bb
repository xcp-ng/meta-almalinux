# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rsconf"
PV = "0.2.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-rsconf+default-devel \
 rust-rsconf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rsconf-0.2.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30b301354f12c2a4815fd3ab35ebcd7809770facb563f154053f7b91e5f83cb7"

URI_x86_64_v2_rust-rsconf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsconf+default-devel-0.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsconf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsconf+default-devel}"
SRC_URI[x86_64_v2_rust-rsconf+default-devel.sha256sum] = "0c1c48472b94e8fffa9fdd7ab79ba72918af7be5984a514a39400ba115f3b211"

URI_x86_64_v2_rust-rsconf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsconf-devel-0.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsconf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsconf-devel}"
SRC_URI[x86_64_v2_rust-rsconf-devel.sha256sum] = "553a4e37158d464d686a1b2b4221e6a7b268dfa5d752bd1e1860f995cfde260a"

URI_aarch64_rust-rsconf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsconf+default-devel-0.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-rsconf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsconf+default-devel}"
SRC_URI[aarch64_rust-rsconf+default-devel.sha256sum] = "0819269ecce47add4babdcfacd2b3bce84a3eb149c9baa2f9f7bc6e637370903"

URI_aarch64_rust-rsconf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsconf-devel-0.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-rsconf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsconf-devel}"
SRC_URI[aarch64_rust-rsconf-devel.sha256sum] = "6f98bf9e5400bf522b3365ba8fab2a47db5926df8ab7dcc008a425e2a672cbf6"

RDEPENDS:rust-rsconf+default-devel = " \
 cargo \
 rust-rsconf-devel \
 "
RDEPENDS:rust-rsconf-devel = " \
 cargo \
 rust-cc+default-devel \
 "
