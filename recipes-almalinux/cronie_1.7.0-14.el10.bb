# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cronie"
PV = "1.7.0"
PR = "14.el10"
PACKAGES = " \
 cronie \
 cronie-anacron \
 cronie-noanacron \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cronie-1.7.0-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b74d8003e8f23ed25696c91dab6eb98c0682d40a11b9ee3cf413067cc8f4b875"

URI_x86_64_v2_cronie = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cronie-1.7.0-14.el10.x86_64_v2.rpm;name=x86_64_v2_cronie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cronie}"
SRC_URI[x86_64_v2_cronie.sha256sum] = "2c3b6690ba27f0f323d2c294d61e1d186877b34dd48c1e94e4bfd612f19d35bd"

URI_x86_64_v2_cronie-anacron = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cronie-anacron-1.7.0-14.el10.x86_64_v2.rpm;name=x86_64_v2_cronie-anacron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cronie-anacron}"
SRC_URI[x86_64_v2_cronie-anacron.sha256sum] = "3b40c1266f0213122cd11f9cd6e3b00b7c65aa73f3527b17a0dd3f67878bc403"
RPROVIDES:cronie-anacron:x86_64_v2 = "virtual/dailyjobs"

URI_x86_64_v2_cronie-noanacron = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cronie-noanacron-1.7.0-14.el10.x86_64_v2.rpm;name=x86_64_v2_cronie-noanacron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cronie-noanacron}"
SRC_URI[x86_64_v2_cronie-noanacron.sha256sum] = "23d1d227a099c8a209697b8827a008727f5eafa8a12ec6cd5947c8ee4934c5c5"
RPROVIDES:cronie-noanacron:x86_64_v2 = "virtual/dailyjobs"

URI_aarch64_cronie = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cronie-1.7.0-14.el10.aarch64.rpm;name=aarch64_cronie;unpack=0"
SRC_URI:append = " ${URI_aarch64_cronie}"
SRC_URI[aarch64_cronie.sha256sum] = "fe14591a498a482108c344e361c32e051b794cbfba12576afca1f57f55dd8820"

URI_aarch64_cronie-anacron = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cronie-anacron-1.7.0-14.el10.aarch64.rpm;name=aarch64_cronie-anacron;unpack=0"
SRC_URI:append = " ${URI_aarch64_cronie-anacron}"
SRC_URI[aarch64_cronie-anacron.sha256sum] = "76b4b249a8187d660d038101415a74cf0c710e3a924a56b8fe4d464f75f8cd1d"
RPROVIDES:cronie-anacron:aarch64 = "virtual/dailyjobs"

URI_aarch64_cronie-noanacron = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cronie-noanacron-1.7.0-14.el10.aarch64.rpm;name=aarch64_cronie-noanacron;unpack=0"
SRC_URI:append = " ${URI_aarch64_cronie-noanacron}"
SRC_URI[aarch64_cronie-noanacron.sha256sum] = "c89f9a8cbe4ecc63262125bb13c13ad0b30c841ec9b87bf723f4891d8118b69a"
RPROVIDES:cronie-noanacron:aarch64 = "virtual/dailyjobs"

RDEPENDS:cronie = " \
 audit-libs \
 bash \
 glibc \
 libselinux \
 pam \
 pam-libs \
 sed \
 virtual/coreutils \
 virtual/dailyjobs \
 "
RDEPENDS:cronie-anacron = " \
 bash \
 cronie \
 crontabs \
 glibc \
 virtual/coreutils \
 "
RDEPENDS:cronie-noanacron = " \
 cronie \
 crontabs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/dailyjobs"

PROVIDES:append:aarch64 = " rpm/virtual/dailyjobs"
