# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.13-flit-core"
PV = "3.12.0"
PR = "1.el10_1"
PACKAGES = " \
 python3.13-flit-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3.13-flit-core-3.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "869fa9facf73d7c41f086938eea8f30d944793d8df04ae9bd762bd1cf5fefd78"

URI_x86_64_v2_python3.13-flit-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-flit-core-3.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3.13-flit-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-flit-core}"
SRC_URI[x86_64_v2_python3.13-flit-core.sha256sum] = "5090e2435c9e141545dbc039b9a5a8f135daf9923b0bf3161508b2345b9ea2a3"

URI_aarch64_python3.13-flit-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-flit-core-3.12.0-1.el10_1.noarch.rpm;name=aarch64_python3.13-flit-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-flit-core}"
SRC_URI[aarch64_python3.13-flit-core.sha256sum] = "99498ff516c17d5ce393a0fb4c532bc521befc4d2123f55d5ffcdc0ea38bdade"

RDEPENDS:python3.13-flit-core = " \
 python3.13 \
 "
