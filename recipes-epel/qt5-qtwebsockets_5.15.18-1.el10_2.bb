# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtwebsockets"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtwebsockets \
 qt5-qtwebsockets-devel \
 qt5-qtwebsockets-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtwebsockets-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "812c2778c715b671ebf20134f1a402bee789bb421f047d95693a59ac8d586222"

URI_x86_64_v2_qt5-qtwebsockets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebsockets-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebsockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebsockets}"
SRC_URI[x86_64_v2_qt5-qtwebsockets.sha256sum] = "9f8bfaf2b3fd31899c2bf43f4fe78f2cd985c601096ef1ad7bafbb5f36fd78dc"

URI_x86_64_v2_qt5-qtwebsockets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebsockets-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebsockets-devel}"
SRC_URI[x86_64_v2_qt5-qtwebsockets-devel.sha256sum] = "8fcb918ef36cb58c7d7e58a724cea8f7cda168f91934a02e17c978055d41260c"

URI_x86_64_v2_qt5-qtwebsockets-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebsockets-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebsockets-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebsockets-examples}"
SRC_URI[x86_64_v2_qt5-qtwebsockets-examples.sha256sum] = "e43c5dc62d5706b3b9907fea8466d43373b1d143b04bc84d5717e45d387e665f"

URI_aarch64_qt5-qtwebsockets = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebsockets-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtwebsockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebsockets}"
SRC_URI[aarch64_qt5-qtwebsockets.sha256sum] = "0a62aa53e2a3840a74831ed4da7ef172834d0dff823a8c7c61264acfb8e56352"

URI_aarch64_qt5-qtwebsockets-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebsockets-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebsockets-devel}"
SRC_URI[aarch64_qt5-qtwebsockets-devel.sha256sum] = "11819db851099715d9ea0389bfbc0bbba8a663ba442ab4b43d72f623103e1525"

URI_aarch64_qt5-qtwebsockets-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebsockets-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtwebsockets-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebsockets-examples}"
SRC_URI[aarch64_qt5-qtwebsockets-examples.sha256sum] = "dff64fe9838fb6ddcb09ed196b8b5289fafdfa891de34915f0d9ee6a847ed1cd"

RDEPENDS:qt5-qtwebsockets = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtwebsockets-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtdeclarative \
 qt5-qtwebsockets \
 "
RDEPENDS:qt5-qtwebsockets-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtwebsockets \
 "
