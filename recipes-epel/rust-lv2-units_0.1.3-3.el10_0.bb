# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lv2-units"
PV = "0.1.3"
PR = "3.el10_0"
PACKAGES = " \
 rust-lv2-units+default-devel \
 rust-lv2-units-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lv2-units-0.1.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce415842707ced2ba7cafba888040a5fcc42f53819829e047372da0d620b8abc"

URI_x86_64_v2_rust-lv2-units+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-units+default-devel-0.1.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-units+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-units+default-devel}"
SRC_URI[x86_64_v2_rust-lv2-units+default-devel.sha256sum] = "ff6277a0c4dba5253140632014ecd8978d757bf4fc7e8f4ce3f9e8a953712406"

URI_x86_64_v2_rust-lv2-units-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-units-devel-0.1.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-units-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-units-devel}"
SRC_URI[x86_64_v2_rust-lv2-units-devel.sha256sum] = "b1013a02c440dd7451461abf8df5bb5378397e2beb45ddca42074cd2a92115e5"

URI_aarch64_rust-lv2-units+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-units+default-devel-0.1.3-3.el10_0.noarch.rpm;name=aarch64_rust-lv2-units+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-units+default-devel}"
SRC_URI[aarch64_rust-lv2-units+default-devel.sha256sum] = "835416e74cc6fe7032875a439107cf7a0a6d0387b1a2b1e08cfc6f92f9995290"

URI_aarch64_rust-lv2-units-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-units-devel-0.1.3-3.el10_0.noarch.rpm;name=aarch64_rust-lv2-units-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-units-devel}"
SRC_URI[aarch64_rust-lv2-units-devel.sha256sum] = "c0e48f5b4a73221b100a4db1dadfaed883f11723e2a5a75d13d0d0eb84335b0d"

RDEPENDS:rust-lv2-units+default-devel = " \
 cargo \
 rust-lv2-units-devel \
 "
RDEPENDS:rust-lv2-units-devel = " \
 cargo \
 rust-lv2-sys+default-devel \
 rust-urid+default-devel \
 "
