# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snafu-derive"
PV = "0.8.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-snafu-derive+default-devel \
 rust-snafu-derive+rust_1_61-devel \
 rust-snafu-derive+unstable-provider-api-devel \
 rust-snafu-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snafu-derive-0.8.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d4e692c0b19ea615d52b5cf627efef92e50bf1dd4bc1b5874f5544da9a3baff"

URI_x86_64_v2_rust-snafu-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu-derive+default-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu-derive+default-devel}"
SRC_URI[x86_64_v2_rust-snafu-derive+default-devel.sha256sum] = "3f5bdd70abd2501796e58f51ba16de3a1d9e8214952c94ad430b1bfd40ac3350"

URI_x86_64_v2_rust-snafu-derive+rust_1_61-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu-derive+rust_1_61-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu-derive+rust_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu-derive+rust_1_61-devel}"
SRC_URI[x86_64_v2_rust-snafu-derive+rust_1_61-devel.sha256sum] = "ec97f0d309126b9af9bb6671e276660d3d179747c52c5c8ddefa033266437383"

URI_x86_64_v2_rust-snafu-derive+unstable-provider-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu-derive+unstable-provider-api-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu-derive+unstable-provider-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu-derive+unstable-provider-api-devel}"
SRC_URI[x86_64_v2_rust-snafu-derive+unstable-provider-api-devel.sha256sum] = "1d78b387d7c32dd217a453bd1b4ca08e4829ffbf95314c9f5d5a7c9b73778824"

URI_x86_64_v2_rust-snafu-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu-derive-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu-derive-devel}"
SRC_URI[x86_64_v2_rust-snafu-derive-devel.sha256sum] = "332ac043f79e686c59ec27b4327aab324bd74992612cdd7a89ddc3edbe7b3f4c"

URI_aarch64_rust-snafu-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu-derive+default-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu-derive+default-devel}"
SRC_URI[aarch64_rust-snafu-derive+default-devel.sha256sum] = "e6ed0414178d4894375508e5f8441e3c99d87d35ed3940a32b8a80ed973ef42b"

URI_aarch64_rust-snafu-derive+rust_1_61-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu-derive+rust_1_61-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu-derive+rust_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu-derive+rust_1_61-devel}"
SRC_URI[aarch64_rust-snafu-derive+rust_1_61-devel.sha256sum] = "e631fee9d940c2e03a77a514d9d8231ecb717010c2b63bf0012959fb5f812ac2"

URI_aarch64_rust-snafu-derive+unstable-provider-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu-derive+unstable-provider-api-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu-derive+unstable-provider-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu-derive+unstable-provider-api-devel}"
SRC_URI[aarch64_rust-snafu-derive+unstable-provider-api-devel.sha256sum] = "73815096b56c1fa10396b5ad79829d83a252202384d17ef3e0a583a7815a523c"

URI_aarch64_rust-snafu-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu-derive-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu-derive-devel}"
SRC_URI[aarch64_rust-snafu-derive-devel.sha256sum] = "0e532f2b18c2792a4ced66a84c50ed43e9b9bd50539f3d9d5acb939e4b2dd28c"

RDEPENDS:rust-snafu-derive+default-devel = " \
 cargo \
 rust-snafu-derive-devel \
 "
RDEPENDS:rust-snafu-derive+rust_1_61-devel = " \
 cargo \
 rust-snafu-derive-devel \
 "
RDEPENDS:rust-snafu-derive+unstable-provider-api-devel = " \
 cargo \
 rust-snafu-derive-devel \
 "
RDEPENDS:rust-snafu-derive-devel = " \
 cargo \
 rust \
 rust-heck-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
