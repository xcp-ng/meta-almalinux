# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "PackageKit-Qt"
PV = "1.1.4"
PR = "2.el10_2"
PACKAGES = " \
 PackageKit-Qt6 \
 PackageKit-Qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/PackageKit-Qt-1.1.4-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2c3d1918efa419b51d77da3d4d2f4df1def15aabd3221af84a4aafaa090a968"

URI_x86_64_v2_PackageKit-Qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/PackageKit-Qt6-1.1.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_PackageKit-Qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-Qt6}"
SRC_URI[x86_64_v2_PackageKit-Qt6.sha256sum] = "eb2de13c2269c6c6151eb17fcde8a06f38977ead615b694988a6fc891045e6a7"

URI_x86_64_v2_PackageKit-Qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/PackageKit-Qt6-devel-1.1.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_PackageKit-Qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-Qt6-devel}"
SRC_URI[x86_64_v2_PackageKit-Qt6-devel.sha256sum] = "642f1ab1d855f6cbf4527b90fb15d6c001a2ae7c54e99a30c119064a929fd5a1"

URI_aarch64_PackageKit-Qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/PackageKit-Qt6-1.1.4-2.el10_2.aarch64.rpm;name=aarch64_PackageKit-Qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-Qt6}"
SRC_URI[aarch64_PackageKit-Qt6.sha256sum] = "7a7281d688f08f33c9016d204bc56c745ef6fcb545e9275d216a5a4af3bd4995"

URI_aarch64_PackageKit-Qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/PackageKit-Qt6-devel-1.1.4-2.el10_2.aarch64.rpm;name=aarch64_PackageKit-Qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-Qt6-devel}"
SRC_URI[aarch64_PackageKit-Qt6-devel.sha256sum] = "4b2a1a1862f951eaa2699c83f2544e01acff0a821aac980b9d6bb7c2cee80797"

RDEPENDS:PackageKit-Qt6 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:PackageKit-Qt6-devel = " \
 PackageKit-Qt6 \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
