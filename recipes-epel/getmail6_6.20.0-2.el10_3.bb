# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "getmail6"
PV = "6.20.0"
PR = "2.el10_3"
PACKAGES = " \
 getmail6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/getmail6-6.20.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e3918adc01961c80b54b081d087e1b9d50a8bc561d154ce044cadb24f663383"

URI_x86_64_v2_getmail6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/getmail6-6.20.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_getmail6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_getmail6}"
SRC_URI[x86_64_v2_getmail6.sha256sum] = "c1f082770ee890dcbe252bdee9c01be9dc9bf856074f9e1c2379e15e3a1d36c3"

URI_aarch64_getmail6 = "${EPEL_MIRROR}/aarch64/Packages/g/getmail6-6.20.0-2.el10_3.noarch.rpm;name=aarch64_getmail6;unpack=0"
SRC_URI:append = " ${URI_aarch64_getmail6}"
SRC_URI[aarch64_getmail6.sha256sum] = "c964527535389f3de562afdaaea5b511aa0c9c0d55b909288404aab443d23c7b"

RDEPENDS:getmail6 = " \
 bash \
 python3 \
 "
