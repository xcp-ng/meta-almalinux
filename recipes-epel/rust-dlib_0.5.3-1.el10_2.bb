# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dlib"
PV = "0.5.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-dlib+default-devel \
 rust-dlib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dlib-0.5.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "375913cced6ae8fbcdab91b27b7553a93e95f91494963ff5ab52498914690b66"

URI_x86_64_v2_rust-dlib+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dlib+default-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dlib+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dlib+default-devel}"
SRC_URI[x86_64_v2_rust-dlib+default-devel.sha256sum] = "f63628884f4e586da715b773d9c8b29704843f2b0425ed223af46c5ed6e4115c"

URI_x86_64_v2_rust-dlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dlib-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dlib-devel}"
SRC_URI[x86_64_v2_rust-dlib-devel.sha256sum] = "415ee4d78f83c7a4ad42bc6796387a9c797112300b5382640ae182269d9ca20d"

URI_aarch64_rust-dlib+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dlib+default-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-dlib+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dlib+default-devel}"
SRC_URI[aarch64_rust-dlib+default-devel.sha256sum] = "430a78d2843911579dbb5709c964c31746bbdfb72d29b937cb845b65508ba1e5"

URI_aarch64_rust-dlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dlib-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-dlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dlib-devel}"
SRC_URI[aarch64_rust-dlib-devel.sha256sum] = "75777a703451592b0fe0a9692a4b0dedd8b49ab9e3b36c74a9d92972bac37d1a"

RDEPENDS:rust-dlib+default-devel = " \
 cargo \
 rust-dlib-devel \
 "
RDEPENDS:rust-dlib-devel = " \
 cargo \
 rust \
 virtual/crate_libloading/default__ge_0.7.0_with_crate_libloading/default__lt_0.9.0~ \
 "
