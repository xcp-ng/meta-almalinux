# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kiconthemes"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kiconthemes \
 kf6-kiconthemes-devel \
 kf6-kiconthemes-doc \
 kf6-kiconthemes-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kiconthemes-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06b0f2d1664f6897a3a7362d4d0d6691b3fd28a2944d4a6db538198560888560"

URI_x86_64_v2_kf6-kiconthemes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kiconthemes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kiconthemes}"
SRC_URI[x86_64_v2_kf6-kiconthemes.sha256sum] = "20c245a3e9f5e3f5496d260bd6e6ff2b4466d311b5fd639d66a0aa7dccfbc703"

URI_x86_64_v2_kf6-kiconthemes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kiconthemes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kiconthemes-devel}"
SRC_URI[x86_64_v2_kf6-kiconthemes-devel.sha256sum] = "01c492435e3c641a95db2a13291be2a957add5342fc73692efe0849829c42490"

URI_x86_64_v2_kf6-kiconthemes-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kiconthemes-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kiconthemes-doc}"
SRC_URI[x86_64_v2_kf6-kiconthemes-doc.sha256sum] = "4194799c52c18201ebb830c9765d3040a9e5110b597672826099ab6f130549e9"

URI_x86_64_v2_kf6-kiconthemes-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kiconthemes-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kiconthemes-html}"
SRC_URI[x86_64_v2_kf6-kiconthemes-html.sha256sum] = "af43a531467a2176af82c9041fbd0670a6a06294e9ece0334293f0bd96b73525"

URI_aarch64_kf6-kiconthemes = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kiconthemes;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kiconthemes}"
SRC_URI[aarch64_kf6-kiconthemes.sha256sum] = "16cf9376ac1c5d12c37a6ab7e27cad4b60f63de0168e835dbfebf371e7a8ebf1"

URI_aarch64_kf6-kiconthemes-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kiconthemes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kiconthemes-devel}"
SRC_URI[aarch64_kf6-kiconthemes-devel.sha256sum] = "15ca6c9aa6e029df3da5f04967cedd79dc3ac5021f15761ff49e4be59f21d4e2"

URI_aarch64_kf6-kiconthemes-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kiconthemes-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kiconthemes-doc}"
SRC_URI[aarch64_kf6-kiconthemes-doc.sha256sum] = "aa97ac4cfa57b5bdd797269d8bb529a2f1a1b118082c5e855075d88047e23dad"

URI_aarch64_kf6-kiconthemes-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kiconthemes-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kiconthemes-html}"
SRC_URI[aarch64_kf6-kiconthemes-html.sha256sum] = "f92e2e34baf1ae47cc3ef308d9ef9ea11fd0aa1db3a2f7b19fc8222aac0c1d1f"

RDEPENDS:kf6-kiconthemes = " \
 glibc \
 hicolor-icon-theme \
 kf6-breeze-icons \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kiconthemes-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kiconthemes \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kiconthemes-doc = " \
 "
RDEPENDS:kf6-kiconthemes-html = " \
 "
