# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-url-normalize"
PV = "1.4.3"
PR = "5.el10_0"
PACKAGES = " \
 python3-url-normalize \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-url-normalize-1.4.3-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2d93f98356204d13cfd220b1c4b8827fded5ddcddfee67f248edbb8152c41122"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-url-normalize-1.4.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-url-normalize;unpack=0"
SRC_URI[x86_64_v2_python3-url-normalize.sha256sum] = "411a46eb6a8ce7a65303270e72bdd5f3af975cd867d332f1e06e3cdcd1b3e675"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-url-normalize-1.4.3-5.el10_0.noarch.rpm;name=aarch64_python3-url-normalize;unpack=0"
SRC_URI[aarch64_python3-url-normalize.sha256sum] = "f93d33f728f6447ec5f4f8a6b73801fc30d8f933386bb54a01a507b4484b7d7f"

RDEPENDS:python3-url-normalize = " \
 python3 \
 python3-six \
 "
