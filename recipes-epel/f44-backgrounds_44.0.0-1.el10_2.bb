# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "f44-backgrounds"
PV = "44.0.0"
PR = "1.el10_2"
PACKAGES = " \
 f44-backgrounds \
 f44-backgrounds-base \
 f44-backgrounds-budgie \
 f44-backgrounds-gnome \
 f44-backgrounds-kde \
 f44-backgrounds-mate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/f44-backgrounds-44.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc9ca3d394ecc9764b25411ddcf2497dd827b0b81a9501434f625dc6c4e5c5c8"

URI_x86_64_v2_f44-backgrounds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f44-backgrounds-44.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_f44-backgrounds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f44-backgrounds}"
SRC_URI[x86_64_v2_f44-backgrounds.sha256sum] = "84ed6f1922f17f770f13029aa02bb0a3672a6e8c2a8dc04a5bf3f5c8b192a02c"

URI_x86_64_v2_f44-backgrounds-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f44-backgrounds-base-44.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_f44-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f44-backgrounds-base}"
SRC_URI[x86_64_v2_f44-backgrounds-base.sha256sum] = "433aea19290484ca59351a8ba19ed552814f6591b8e3b29dec59f05e46e50edd"

URI_x86_64_v2_f44-backgrounds-budgie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f44-backgrounds-budgie-44.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_f44-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f44-backgrounds-budgie}"
SRC_URI[x86_64_v2_f44-backgrounds-budgie.sha256sum] = "a322382a27d0c99bff7e05e2e0111fe2a24e7578d7b10581bf027bbef6616cfa"

URI_x86_64_v2_f44-backgrounds-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f44-backgrounds-gnome-44.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_f44-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f44-backgrounds-gnome}"
SRC_URI[x86_64_v2_f44-backgrounds-gnome.sha256sum] = "a7bf12dbff0a1bfd3ca98b83c77c6d1f837b19e16e1d45deaf3d9e34b085b421"

URI_x86_64_v2_f44-backgrounds-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f44-backgrounds-kde-44.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_f44-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f44-backgrounds-kde}"
SRC_URI[x86_64_v2_f44-backgrounds-kde.sha256sum] = "f3bd6d146018f6c8e8dc477287487aea59a730127fec3ad199cbc749803e333b"

URI_x86_64_v2_f44-backgrounds-mate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f44-backgrounds-mate-44.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_f44-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f44-backgrounds-mate}"
SRC_URI[x86_64_v2_f44-backgrounds-mate.sha256sum] = "78dde7b43155f4a594f3bee6db0536d896bfae04f6cc2698015c2dbbf4efa171"

URI_aarch64_f44-backgrounds = "${EPEL_MIRROR}/aarch64/Packages/f/f44-backgrounds-44.0.0-1.el10_2.noarch.rpm;name=aarch64_f44-backgrounds;unpack=0"
SRC_URI:append = " ${URI_aarch64_f44-backgrounds}"
SRC_URI[aarch64_f44-backgrounds.sha256sum] = "d25b8fdd3734edf4999f4413f7895e65ce42eadcce073483e30ec52355e6fd36"

URI_aarch64_f44-backgrounds-base = "${EPEL_MIRROR}/aarch64/Packages/f/f44-backgrounds-base-44.0.0-1.el10_2.noarch.rpm;name=aarch64_f44-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_f44-backgrounds-base}"
SRC_URI[aarch64_f44-backgrounds-base.sha256sum] = "9383a6d91e0afeaf8fa2eb87fc65248908f3ea383b3d6ed36c43cb9a8f000752"

URI_aarch64_f44-backgrounds-budgie = "${EPEL_MIRROR}/aarch64/Packages/f/f44-backgrounds-budgie-44.0.0-1.el10_2.noarch.rpm;name=aarch64_f44-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_aarch64_f44-backgrounds-budgie}"
SRC_URI[aarch64_f44-backgrounds-budgie.sha256sum] = "7081ce3e51597846d29cda37bd4e33bd8f0ca26a8a0032f72561e53a47dcee65"

URI_aarch64_f44-backgrounds-gnome = "${EPEL_MIRROR}/aarch64/Packages/f/f44-backgrounds-gnome-44.0.0-1.el10_2.noarch.rpm;name=aarch64_f44-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_f44-backgrounds-gnome}"
SRC_URI[aarch64_f44-backgrounds-gnome.sha256sum] = "bb5bba5e9a481e93ec7e1ea2a5db5bc65cca0e3b4e199f37f4d79832fd639aea"

URI_aarch64_f44-backgrounds-kde = "${EPEL_MIRROR}/aarch64/Packages/f/f44-backgrounds-kde-44.0.0-1.el10_2.noarch.rpm;name=aarch64_f44-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_f44-backgrounds-kde}"
SRC_URI[aarch64_f44-backgrounds-kde.sha256sum] = "e89050c50d4c66aaa6f3ff00a87c6c3928e7b466d47498f23615f5380524e7fb"

URI_aarch64_f44-backgrounds-mate = "${EPEL_MIRROR}/aarch64/Packages/f/f44-backgrounds-mate-44.0.0-1.el10_2.noarch.rpm;name=aarch64_f44-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_aarch64_f44-backgrounds-mate}"
SRC_URI[aarch64_f44-backgrounds-mate.sha256sum] = "3f649a889f751f275e3bfd1c9d9f9397d85e3af698605e36761a86eec033d3ac"

RDEPENDS:f44-backgrounds = " \
 f44-backgrounds-budgie \
 f44-backgrounds-gnome \
 f44-backgrounds-kde \
 f44-backgrounds-mate \
 "
RDEPENDS:f44-backgrounds-base = " \
 jxl-pixbuf-loader \
 kf6-kimageformats \
 "
RDEPENDS:f44-backgrounds-budgie = " \
 f44-backgrounds-base \
 "
RDEPENDS:f44-backgrounds-gnome = " \
 f44-backgrounds-base \
 "
RDEPENDS:f44-backgrounds-kde = " \
 f44-backgrounds-base \
 kde-filesystem \
 "
RDEPENDS:f44-backgrounds-mate = " \
 f44-backgrounds-base \
 "
