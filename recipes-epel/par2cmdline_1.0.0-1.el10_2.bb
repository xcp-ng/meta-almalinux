# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "par2cmdline"
PV = "1.0.0"
PR = "1.el10_2"
PACKAGES = " \
 par2cmdline \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/par2cmdline-1.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf912b1fe86058a7986c8a8a041dcfe166037cb676a520bfefb8f67a8fe6a231"

URI_x86_64_v2_par2cmdline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/par2cmdline-1.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_par2cmdline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_par2cmdline}"
SRC_URI[x86_64_v2_par2cmdline.sha256sum] = "40e88d5d416c0bb6b59e1306377ca7686f5b91e036cbd1d493f8291936f9b50e"

URI_aarch64_par2cmdline = "${EPEL_MIRROR}/aarch64/Packages/p/par2cmdline-1.0.0-1.el10_2.aarch64.rpm;name=aarch64_par2cmdline;unpack=0"
SRC_URI:append = " ${URI_aarch64_par2cmdline}"
SRC_URI[aarch64_par2cmdline.sha256sum] = "ef9af173626b30118aa5caef0a821c82d3d1f53f513f107cde9b3930feef205a"

RDEPENDS:par2cmdline = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 "
