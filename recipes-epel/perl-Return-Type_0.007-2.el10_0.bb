# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Return-Type"
PV = "0.007"
PR = "2.el10_0"
PACKAGES = " \
 perl-Return-Type \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Return-Type-0.007-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11cc4ef6ccce537f16e6289c640685cc67c501b784cf2e4ed3d39d423a821367"

URI_x86_64_v2_perl-Return-Type = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Return-Type-0.007-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Return-Type;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Return-Type}"
SRC_URI[x86_64_v2_perl-Return-Type.sha256sum] = "4f614937ab66a32e033ac976177f984e3a860f6ab3c5901d19abf16cef3cfef1"

URI_aarch64_perl-Return-Type = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Return-Type-0.007-2.el10_0.noarch.rpm;name=aarch64_perl-Return-Type;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Return-Type}"
SRC_URI[aarch64_perl-Return-Type.sha256sum] = "d5214e25fe86af44790fc9505eb5893d93e512ee47b8fd620186c9e35e518180"

RDEPENDS:perl-Return-Type = " \
 perl-Attribute-Handlers \
 perl-Scalar-List-Utils \
 perl-Type-Tiny \
 perl-libs \
 "
