# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-wayland-protocols"
PV = "1.16.0"
PR = "1.el10_0"
PACKAGES = " \
 plasma-wayland-protocols \
 plasma-wayland-protocols-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-wayland-protocols-1.16.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4230c3eeec651010739ff24b56a8562a95921db2aa6bd78eaa090943091f86e9"

URI_x86_64_v2_plasma-wayland-protocols = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-wayland-protocols-1.16.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-wayland-protocols;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-wayland-protocols}"
SRC_URI[x86_64_v2_plasma-wayland-protocols.sha256sum] = "4801010327cbe3ec8b7a32b75f2b349ffff9837107774fa1949d86f945859cbf"

URI_x86_64_v2_plasma-wayland-protocols-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-wayland-protocols-devel-1.16.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-wayland-protocols-devel}"
SRC_URI[x86_64_v2_plasma-wayland-protocols-devel.sha256sum] = "07774db3b62eb3a1527da28ea5ad8abf83bd7ff8e8115258458c31071dae81da"

URI_aarch64_plasma-wayland-protocols = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-wayland-protocols-1.16.0-1.el10_0.aarch64.rpm;name=aarch64_plasma-wayland-protocols;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-wayland-protocols}"
SRC_URI[aarch64_plasma-wayland-protocols.sha256sum] = "de94c1a45a4f887f227b4e9fce00dd6ce5fdb85fda9939c1ed91ecf7de679806"

URI_aarch64_plasma-wayland-protocols-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-wayland-protocols-devel-1.16.0-1.el10_0.aarch64.rpm;name=aarch64_plasma-wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-wayland-protocols-devel}"
SRC_URI[aarch64_plasma-wayland-protocols-devel.sha256sum] = "cfba689eee02b5e09bb8f15a7ee40af8da6743ab4ecbfa349872c758460bec5f"

RDEPENDS:plasma-wayland-protocols = " \
 "
RDEPENDS:plasma-wayland-protocols-devel = " \
 cmake-filesystem \
 plasma-wayland-protocols \
 "
