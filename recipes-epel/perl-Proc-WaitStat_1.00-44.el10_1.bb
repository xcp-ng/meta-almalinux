# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Proc-WaitStat"
PV = "1.00"
PR = "44.el10_1"
PACKAGES = " \
 perl-Proc-WaitStat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Proc-WaitStat-1.00-44.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ccfb32c314c2d9a4c6d90c52554b728ffd4bf1ec15d3645b52f94d5931b8be8"

URI_x86_64_v2_perl-Proc-WaitStat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Proc-WaitStat-1.00-44.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Proc-WaitStat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Proc-WaitStat}"
SRC_URI[x86_64_v2_perl-Proc-WaitStat.sha256sum] = "feafa8d99fa59e992a31ef3133da949bb2b0edf1508baeaa682c57815132ba8a"

URI_aarch64_perl-Proc-WaitStat = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Proc-WaitStat-1.00-44.el10_1.noarch.rpm;name=aarch64_perl-Proc-WaitStat;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Proc-WaitStat}"
SRC_URI[aarch64_perl-Proc-WaitStat.sha256sum] = "73ac71a3e4f4f372e6dbac8578094f76148bc813993676af4bde11c0cfaf6242"

RDEPENDS:perl-Proc-WaitStat = " \
 perl-Carp \
 perl-Exporter \
 perl-IPC-Signal \
 perl-POSIX \
 perl-libs \
 perl-vars \
 "
