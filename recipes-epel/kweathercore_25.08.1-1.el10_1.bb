# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kweathercore"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kweathercore \
 kweathercore-devel \
 kweathercore-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kweathercore-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "325ad1b0797db1e284aea7bd5baf6485e599cc64c7711f9603e45d61ccd16f36"

URI_x86_64_v2_kweathercore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweathercore-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweathercore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweathercore}"
SRC_URI[x86_64_v2_kweathercore.sha256sum] = "1edf7eec172890dc7a2b882f5e0c86d1bbccf889c023e507b934984e815f7c94"

URI_x86_64_v2_kweathercore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweathercore-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweathercore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweathercore-devel}"
SRC_URI[x86_64_v2_kweathercore-devel.sha256sum] = "e346d5074ca8ba4d144f81b59e9f95e5ca277c725df516ee6bdcdc02d8309489"

URI_x86_64_v2_kweathercore-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweathercore-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kweathercore-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweathercore-doc}"
SRC_URI[x86_64_v2_kweathercore-doc.sha256sum] = "4b608a6124fca48b9f1ecf899e8d6510cbb87896e58351a32c43511a587d19e4"

URI_aarch64_kweathercore = "${EPEL_MIRROR}/aarch64/Packages/k/kweathercore-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kweathercore;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweathercore}"
SRC_URI[aarch64_kweathercore.sha256sum] = "3f05992a5e6fab6b8db168ee91589818e9a5e422afb917f66c5ebad11f7037c2"

URI_aarch64_kweathercore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kweathercore-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kweathercore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweathercore-devel}"
SRC_URI[aarch64_kweathercore-devel.sha256sum] = "1aab13b584f58552765deddbd914e69efeee051594eec37189c01b89b458c4ac"

URI_aarch64_kweathercore-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kweathercore-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_kweathercore-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweathercore-doc}"
SRC_URI[aarch64_kweathercore-doc.sha256sum] = "6dc160e3cb02c2195f5b9a32042fea40bbc3cbbbdc8fb8274165a227e5a4f833"

RDEPENDS:kweathercore = " \
 glibc \
 kf6-kholidays \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 "
RDEPENDS:kweathercore-devel = " \
 cmake-filesystem \
 kweathercore \
 "
RDEPENDS:kweathercore-doc = " \
 "
