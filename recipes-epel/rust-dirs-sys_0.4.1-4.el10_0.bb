# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dirs-sys"
PV = "0.4.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-dirs-sys+default-devel \
 rust-dirs-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dirs-sys-0.4.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3ca426d1103d11c18785a54cdd9bc668a087934f4060631c83d7b7835349f3a"

URI_x86_64_v2_rust-dirs-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dirs-sys+default-devel-0.4.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dirs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dirs-sys+default-devel}"
SRC_URI[x86_64_v2_rust-dirs-sys+default-devel.sha256sum] = "ec010307eb6cc71ce426ce303dcf60d21617b3ccc5e81ea07a23b81d50a171ef"

URI_x86_64_v2_rust-dirs-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dirs-sys-devel-0.4.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dirs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dirs-sys-devel}"
SRC_URI[x86_64_v2_rust-dirs-sys-devel.sha256sum] = "794a49caa60b71a9fde68a43c03b52c39961bd6004b93746376f544ba3e23892"

URI_aarch64_rust-dirs-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dirs-sys+default-devel-0.4.1-4.el10_0.noarch.rpm;name=aarch64_rust-dirs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dirs-sys+default-devel}"
SRC_URI[aarch64_rust-dirs-sys+default-devel.sha256sum] = "d89f915f8a2a6b82edeb2b8b099b8c9ba8250efb85d53a58cb086a65a5cf5364"

URI_aarch64_rust-dirs-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dirs-sys-devel-0.4.1-4.el10_0.noarch.rpm;name=aarch64_rust-dirs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dirs-sys-devel}"
SRC_URI[aarch64_rust-dirs-sys-devel.sha256sum] = "92ea5662f0da253e703d3bcd38f75596dd6ac26649fc3efb5cc45c354ec5c94c"

RDEPENDS:rust-dirs-sys+default-devel = " \
 cargo \
 rust-dirs-sys-devel \
 "
RDEPENDS:rust-dirs-sys-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-option-ext+default-devel \
 "
