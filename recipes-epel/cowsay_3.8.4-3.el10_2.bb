# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cowsay"
PV = "3.8.4"
PR = "3.el10_2"
PACKAGES = " \
 cowsay \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cowsay-3.8.4-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ff5e01e4eb2baa2af615f2878c5f1fddc62244d3f571efa89e357594be7944c"

URI_x86_64_v2_cowsay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cowsay-3.8.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_cowsay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cowsay}"
SRC_URI[x86_64_v2_cowsay.sha256sum] = "53295db92f99eb570a02c1aaa971d0191d64c7a5908787fbf3f02ac078ed5d8e"

URI_aarch64_cowsay = "${EPEL_MIRROR}/aarch64/Packages/c/cowsay-3.8.4-3.el10_2.noarch.rpm;name=aarch64_cowsay;unpack=0"
SRC_URI:append = " ${URI_aarch64_cowsay}"
SRC_URI[aarch64_cowsay.sha256sum] = "65d0294c55ac3fd6d9139a9ef6d38462e82578c06f38a63e57b528e28800519f"

RDEPENDS:cowsay = " \
 bash \
 filesystem \
 perl-Encode \
 perl-File-Basename \
 perl-File-Find \
 perl-Getopt-Std \
 perl-PathTools \
 perl-Text-Tabs+Wrap \
 perl-interpreter \
 "
