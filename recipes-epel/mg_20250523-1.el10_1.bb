# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mg"
PV = "20250523"
PR = "1.el10_1"
PACKAGES = " \
 mg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mg-20250523-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fd19dedfa76d54ef3646cf812237a72200b538a0f65f9ade500958d9220f170"

URI_x86_64_v2_mg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mg-20250523-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mg}"
SRC_URI[x86_64_v2_mg.sha256sum] = "2ab7c138feee1ec68575e92ba29c3f727576b626ce21d81dd0f56a318edca139"

URI_aarch64_mg = "${EPEL_MIRROR}/aarch64/Packages/m/mg-20250523-1.el10_1.aarch64.rpm;name=aarch64_mg;unpack=0"
SRC_URI:append = " ${URI_aarch64_mg}"
SRC_URI[aarch64_mg.sha256sum] = "aaabc3fac083fcb6564b0ef33910cce769afffb0bf66c22ce8549a79768e4bab"

RDEPENDS:mg = " \
 glibc \
 libbsd \
 ncurses-libs \
 "
