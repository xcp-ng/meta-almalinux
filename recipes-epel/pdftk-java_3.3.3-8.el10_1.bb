# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pdftk-java"
PV = "3.3.3"
PR = "8.el10_1"
PACKAGES = " \
 pdftk-java \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pdftk-java-3.3.3-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f62d7f400f91ec043d39887d649cc8b6d90ee9a72d883adbb588281d9cf18913"

URI_x86_64_v2_pdftk-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdftk-java-3.3.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pdftk-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdftk-java}"
SRC_URI[x86_64_v2_pdftk-java.sha256sum] = "e2e3da8658ba21015d35e7bb205302dd8b42b9f6c5d162ff49b7ff124be08609"

URI_aarch64_pdftk-java = "${EPEL_MIRROR}/aarch64/Packages/p/pdftk-java-3.3.3-8.el10_1.noarch.rpm;name=aarch64_pdftk-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdftk-java}"
SRC_URI[aarch64_pdftk-java.sha256sum] = "eb60d86684fec02dbfc0c1ae6f0c89bb4c9f84dcc55258d3e0f152047eb9587d"

RDEPENDS:pdftk-java = " \
 apache-commons-lang3 \
 bash \
 bouncycastle \
 java-21-openjdk-headless \
 javapackages-tools \
 "
