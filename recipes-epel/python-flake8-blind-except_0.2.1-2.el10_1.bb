# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flake8-blind-except"
PV = "0.2.1"
PR = "2.el10_1"
PACKAGES = " \
 python3-flake8-blind-except \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-flake8-blind-except-0.2.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3cf99e5ce440c9267e6798533947a4be25404bc2fdb4e522763b621f2d0c607"

URI_x86_64_v2_python3-flake8-blind-except = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flake8-blind-except-0.2.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flake8-blind-except;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flake8-blind-except}"
SRC_URI[x86_64_v2_python3-flake8-blind-except.sha256sum] = "2da5a2f8eed82f591ff4a653537e58b034e09cab2a6d3b364b14667cfcd80e5d"

URI_aarch64_python3-flake8-blind-except = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flake8-blind-except-0.2.1-2.el10_1.noarch.rpm;name=aarch64_python3-flake8-blind-except;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flake8-blind-except}"
SRC_URI[aarch64_python3-flake8-blind-except.sha256sum] = "514b97eb71e4815071155418ad0b75bde860b16acd8b437cae2843d397d1fe04"

RDEPENDS:python3-flake8-blind-except = " \
 python3 \
 python3-flake8 \
 python3-pycodestyle \
 "
