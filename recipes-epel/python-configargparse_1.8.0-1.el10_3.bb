# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-configargparse"
PV = "1.8.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-configargparse \
 python3-configargparse+yaml \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-configargparse-1.8.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5ae3b0443f000f46377b397b910dd35331476c68c9f2a2e5d4cb26ef1ca77fcd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-configargparse-1.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-configargparse;unpack=0"
SRC_URI[x86_64_v2_python3-configargparse.sha256sum] = "615e79a9bf60b0cc22588874d4c73d9af10b48e3a47dafe127ddbf2e3d970d61"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-configargparse+yaml-1.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-configargparse+yaml;unpack=0"
SRC_URI[x86_64_v2_python3-configargparse+yaml.sha256sum] = "d5ab76e799b67dd7e1d56b5b3c7bad3f644a9529e402f27a33383446708d2fb3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-configargparse-1.8.0-1.el10_3.noarch.rpm;name=aarch64_python3-configargparse;unpack=0"
SRC_URI[aarch64_python3-configargparse.sha256sum] = "99051f7036e89247ea1057d89279b11c0052456d12ae87c5afc709c48c037ec3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-configargparse+yaml-1.8.0-1.el10_3.noarch.rpm;name=aarch64_python3-configargparse+yaml;unpack=0"
SRC_URI[aarch64_python3-configargparse+yaml.sha256sum] = "b523e115574639e6f355cddaacbe518ff428e7dba0dad1bdbf9d031bd88f77fd"

RDEPENDS:python3-configargparse = " \
 python3 \
 "
RDEPENDS:python3-configargparse+yaml = " \
 python3 \
 python3-configargparse \
 python3-pyyaml \
 "
