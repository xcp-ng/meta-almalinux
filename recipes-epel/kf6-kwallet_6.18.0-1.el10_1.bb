# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kwallet"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kwallet \
 kf6-kwallet-devel \
 kf6-kwallet-doc \
 kf6-kwallet-html \
 kf6-kwallet-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kwallet-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "071ff62c2a353db9db90307e5226b7e922fd0a63332dce8d798f44b56e025f05"

URI_x86_64_v2_kf6-kwallet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwallet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet}"
SRC_URI[x86_64_v2_kf6-kwallet.sha256sum] = "ca3262bf1bddeeb0482eb0edad720cfa466bb1a6b1abd6ebc70c4cdcb898201c"

URI_x86_64_v2_kf6-kwallet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwallet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet-devel}"
SRC_URI[x86_64_v2_kf6-kwallet-devel.sha256sum] = "970b565f58a52d1cbfb0155f9a1bf66e64cb62c2b873592642893f72b06658a9"

URI_x86_64_v2_kf6-kwallet-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwallet-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet-doc}"
SRC_URI[x86_64_v2_kf6-kwallet-doc.sha256sum] = "219ab670d085034d07c5fdea23b5962ad5829cbb64761bfc50e9ef5656104c38"

URI_x86_64_v2_kf6-kwallet-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwallet-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet-html}"
SRC_URI[x86_64_v2_kf6-kwallet-html.sha256sum] = "5650092acb71fb975649e26e87d2b6eb81b74b7b5bbdb6fceab7433b4aa5d3c8"

URI_x86_64_v2_kf6-kwallet-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-libs-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwallet-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet-libs}"
SRC_URI[x86_64_v2_kf6-kwallet-libs.sha256sum] = "38928300a5918dc60e6ca65f554d12b488ed99faa3113e560a95e9c15b0cd5ea"

URI_aarch64_kf6-kwallet = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kwallet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet}"
SRC_URI[aarch64_kf6-kwallet.sha256sum] = "a7a3bae9fdd0576e5d9aabb1b01a1a54b946a3aec1ce4b2d1f53b197436cc23e"

URI_aarch64_kf6-kwallet-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kwallet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet-devel}"
SRC_URI[aarch64_kf6-kwallet-devel.sha256sum] = "cf8447abe629cb9cdafe66ac17a32c6582bd17df69b291cda58e3da0fd892a80"

URI_aarch64_kf6-kwallet-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kwallet-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet-doc}"
SRC_URI[aarch64_kf6-kwallet-doc.sha256sum] = "dd320bcbf9471d50bf93f172ba170dd04b1c7c79d35b4c9d626bee9bc345c019"

URI_aarch64_kf6-kwallet-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kwallet-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet-html}"
SRC_URI[aarch64_kf6-kwallet-html.sha256sum] = "3298e01c10a2b908639907c1d38faebccfdc08a7bf29aefd19319a8342a7c026"

URI_aarch64_kf6-kwallet-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-libs-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kwallet-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet-libs}"
SRC_URI[aarch64_kf6-kwallet-libs.sha256sum] = "f320580cf130567e853056e2b0da3e8f12b5ced16d5b53b0b0b65db62d4dd893"

RDEPENDS:kf6-kwallet = " \
 glib2 \
 glibc \
 gpgmepp \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libgcc \
 libsecret \
 libstdc++ \
 pinentry-gnome3 \
 qca-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kwallet-devel = " \
 cmake-filesystem \
 kf6-kwallet-libs \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kwallet-doc = " \
 "
RDEPENDS:kf6-kwallet-html = " \
 "
RDEPENDS:kf6-kwallet-libs = " \
 glibc \
 gpgmepp \
 kf6-kconfig \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kwallet \
 kf6-kwidgetsaddons \
 libgcrypt \
 libstdc++ \
 qca-qt6-ossl \
 qt6-qtbase \
 "
