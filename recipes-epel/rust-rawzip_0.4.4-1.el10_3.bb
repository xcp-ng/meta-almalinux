# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rawzip"
PV = "0.4.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-rawzip+default-devel \
 rust-rawzip-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rawzip-0.4.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad4e55c21002a09bf73b59191812dd63e7a7e251933c312c07c221c75849dbcf"

URI_x86_64_v2_rust-rawzip+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rawzip+default-devel-0.4.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rawzip+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rawzip+default-devel}"
SRC_URI[x86_64_v2_rust-rawzip+default-devel.sha256sum] = "c5a5883cce13a89ce1531236f7fbfc3b8c181a55192a18e22b88e074c41ce18a"

URI_x86_64_v2_rust-rawzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rawzip-devel-0.4.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rawzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rawzip-devel}"
SRC_URI[x86_64_v2_rust-rawzip-devel.sha256sum] = "d84a1161495d75c38f8c1cf26c13e58b12f39bdf36f4a70f2b15cda25f27b466"

URI_aarch64_rust-rawzip+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rawzip+default-devel-0.4.4-1.el10_3.noarch.rpm;name=aarch64_rust-rawzip+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rawzip+default-devel}"
SRC_URI[aarch64_rust-rawzip+default-devel.sha256sum] = "5f64f263d953fe81b9dc81f57f8d5e98b72d6b1584bc4f2155b40c948639cb74"

URI_aarch64_rust-rawzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rawzip-devel-0.4.4-1.el10_3.noarch.rpm;name=aarch64_rust-rawzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rawzip-devel}"
SRC_URI[aarch64_rust-rawzip-devel.sha256sum] = "a5d0efeb2198289438d060017ab59c7b10b01cd79b235ff430996ce47b4c9463"

RDEPENDS:rust-rawzip+default-devel = " \
 cargo \
 rust-rawzip-devel \
 "
RDEPENDS:rust-rawzip-devel = " \
 cargo \
 rust \
 "
