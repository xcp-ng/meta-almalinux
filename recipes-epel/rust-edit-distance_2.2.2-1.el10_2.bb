# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-edit-distance"
PV = "2.2.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-edit-distance+default-devel \
 rust-edit-distance-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-edit-distance-2.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8a84417dcf052252f730dd22d90bf2fccba6acd39f0aadd71890109781fa156"

URI_x86_64_v2_rust-edit-distance+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-edit-distance+default-devel-2.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-edit-distance+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-edit-distance+default-devel}"
SRC_URI[x86_64_v2_rust-edit-distance+default-devel.sha256sum] = "b8969a7614ca576f4c3b5b81aa89b1c23e1599cabee27b7af76581a79ad4db0b"

URI_x86_64_v2_rust-edit-distance-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-edit-distance-devel-2.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-edit-distance-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-edit-distance-devel}"
SRC_URI[x86_64_v2_rust-edit-distance-devel.sha256sum] = "e2c061eecee3a0eb0c59075e66d5a4d8cacf8bcd06ee84c76f85b0372933ac56"

URI_aarch64_rust-edit-distance+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-edit-distance+default-devel-2.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-edit-distance+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-edit-distance+default-devel}"
SRC_URI[aarch64_rust-edit-distance+default-devel.sha256sum] = "16c01abfdcf41b7cd961d856afcae624b3895c81a3539da2808e6b7016fbc1c7"

URI_aarch64_rust-edit-distance-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-edit-distance-devel-2.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-edit-distance-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-edit-distance-devel}"
SRC_URI[aarch64_rust-edit-distance-devel.sha256sum] = "7f1bfa371ca602dce23f3b4e22752b82c01174769c634e3d862b390980804383"

RDEPENDS:rust-edit-distance+default-devel = " \
 cargo \
 rust-edit-distance-devel \
 "
RDEPENDS:rust-edit-distance-devel = " \
 cargo \
 rust \
 "
