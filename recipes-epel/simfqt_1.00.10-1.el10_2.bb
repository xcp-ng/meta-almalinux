# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "simfqt"
PV = "1.00.10"
PR = "1.el10_2"
PACKAGES = " \
 simfqt \
 simfqt-devel \
 simfqt-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/simfqt-1.00.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3318f7c8d8d4cf2b88435d574ff029eb0701a5335a8dd981c17061e9b9631b1d"

URI_x86_64_v2_simfqt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simfqt-1.00.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_simfqt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_simfqt}"
SRC_URI[x86_64_v2_simfqt.sha256sum] = "340b139a9bf05ee956bdf5d2cfd3a96ba83a2e4ada33cfbc6562ad8e03d599f1"

URI_x86_64_v2_simfqt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simfqt-devel-1.00.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_simfqt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_simfqt-devel}"
SRC_URI[x86_64_v2_simfqt-devel.sha256sum] = "0c81a3e3f89cb804e5421b3fb4732fba8357ddc588378e2e01cc904a220a9ba6"

URI_x86_64_v2_simfqt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simfqt-doc-1.00.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_simfqt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_simfqt-doc}"
SRC_URI[x86_64_v2_simfqt-doc.sha256sum] = "6dbd3687bffb6c556c3403d6233572d04fc165696409af1728cbad4f7af4f1f8"

URI_aarch64_simfqt = "${EPEL_MIRROR}/aarch64/Packages/s/simfqt-1.00.10-1.el10_2.aarch64.rpm;name=aarch64_simfqt;unpack=0"
SRC_URI:append = " ${URI_aarch64_simfqt}"
SRC_URI[aarch64_simfqt.sha256sum] = "e7e4482100af2df2524443b3342aebd636edd4abcd3d1e67cfdd6b5a80ed4bcf"

URI_aarch64_simfqt-devel = "${EPEL_MIRROR}/aarch64/Packages/s/simfqt-devel-1.00.10-1.el10_2.aarch64.rpm;name=aarch64_simfqt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_simfqt-devel}"
SRC_URI[aarch64_simfqt-devel.sha256sum] = "c5756db8ac54858c2ed4e8653d7a1740f49167102b233f4b8fc274ff9d17d692"

URI_aarch64_simfqt-doc = "${EPEL_MIRROR}/aarch64/Packages/s/simfqt-doc-1.00.10-1.el10_2.noarch.rpm;name=aarch64_simfqt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_simfqt-doc}"
SRC_URI[aarch64_simfqt-doc.sha256sum] = "77bcad345f7c0c0149634fd5c426648a7890152d9895919b079ba0e21e0fd26d"

RDEPENDS:simfqt = " \
 boost-program-options \
 glibc \
 libgcc \
 libstdc++ \
 readline \
 stdair \
 "
RDEPENDS:simfqt-devel = " \
 bash \
 cmake-filesystem \
 pkgconf-pkg-config \
 simfqt \
 "
RDEPENDS:simfqt-doc = " \
 "
