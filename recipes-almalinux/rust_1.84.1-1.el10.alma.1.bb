# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust"
PV = "1.84.1"
PR = "1.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 cargo \
 clippy \
 rust \
 rust-analyzer \
 rust-debugger-common \
 rust-doc \
 rust-gdb \
 rust-lldb \
 rust-src \
 rust-std-static \
 rust-std-static-wasm32-unknown-unknown \
 rust-std-static-wasm32-wasip1 \
 rust-std-static-x86_64-unknown-none \
 rust-toolset \
 rust-toolset-srpm-macros \
 rustfmt \
"
PACKAGES:aarch64 = " \
 cargo \
 clippy \
 rust \
 rust-analyzer \
 rust-debugger-common \
 rust-doc \
 rust-gdb \
 rust-lldb \
 rust-src \
 rust-std-static \
 rust-std-static-aarch64-unknown-none-softfloat \
 rust-std-static-wasm32-unknown-unknown \
 rust-std-static-wasm32-wasip1 \
 rust-toolset \
 rust-toolset-srpm-macros \
 rustfmt \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-1.84.1-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf745025ec1a69ac5b37ea47ce397bbeacb2076958af550fd75dde17010f8430"

URI_x86_64_v2_cargo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cargo-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_cargo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo}"
SRC_URI[x86_64_v2_cargo.sha256sum] = "c3df202dd25a271c8ca38b5bfba5ba260b69c976db39aa7ea0e8848893507f3a"

URI_x86_64_v2_clippy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clippy-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clippy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clippy}"
SRC_URI[x86_64_v2_clippy.sha256sum] = "bb3684fb5b40445f3c98e49602487db27fc7aafa6c2bc5a399781410ab65c5db"

URI_x86_64_v2_rust = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust}"
SRC_URI[x86_64_v2_rust.sha256sum] = "bc7256adb2a65ec375175e637ab48e1e15a73c47e5517dd29942189dea7a29b7"

URI_x86_64_v2_rust-analyzer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-analyzer-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-analyzer}"
SRC_URI[x86_64_v2_rust-analyzer.sha256sum] = "ea56437fa2723236c05cf7cca76ddc798c02dcfe40b9b9b6c7c3f2babdf575b4"

URI_x86_64_v2_rust-debugger-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-debugger-common-1.84.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-debugger-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-debugger-common}"
SRC_URI[x86_64_v2_rust-debugger-common.sha256sum] = "22a9279a7f43b518000e35310a11f18180f1c352bbb1af51fc930d4345b434b0"

URI_x86_64_v2_rust-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-doc-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc}"
SRC_URI[x86_64_v2_rust-doc.sha256sum] = "e02ce4f93efcfc5545f076cf93a7649df8289676a95e2745ea2f162a9d5f9004"

URI_x86_64_v2_rust-gdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-gdb-1.84.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-gdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gdb}"
SRC_URI[x86_64_v2_rust-gdb.sha256sum] = "f284758e9c96a8df555632a726f82c9d603f97513ed8fd1f09de26c6ed09529d"

URI_x86_64_v2_rust-lldb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-lldb-1.84.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-lldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lldb}"
SRC_URI[x86_64_v2_rust-lldb.sha256sum] = "dca121858c27f7c20d73e9d98b3ead55d16054c6092fd525631239f0dd54c1ec"

URI_x86_64_v2_rust-src = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-src-1.84.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-src}"
SRC_URI[x86_64_v2_rust-src.sha256sum] = "5a019d19671ad02bf6eae025554e36b59c551d7f3cf2dc0ed6cd66977262bde0"

URI_x86_64_v2_rust-std-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-std-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static}"
SRC_URI[x86_64_v2_rust-std-static.sha256sum] = "3caf91f6303d28731a1cb7c85006db1fa310ef65df57a1d0a0393119a64411d4"

URI_x86_64_v2_rust-std-static-wasm32-unknown-unknown = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-wasm32-unknown-unknown-1.84.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-std-static-wasm32-unknown-unknown;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static-wasm32-unknown-unknown}"
SRC_URI[x86_64_v2_rust-std-static-wasm32-unknown-unknown.sha256sum] = "4713be8b3848700eec03791f3ceb3fdbc1046d2b52d2670f25db226908266a13"

URI_x86_64_v2_rust-std-static-wasm32-wasip1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-wasm32-wasip1-1.84.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-std-static-wasm32-wasip1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static-wasm32-wasip1}"
SRC_URI[x86_64_v2_rust-std-static-wasm32-wasip1.sha256sum] = "9f0102246f20338a2e595fed8ce5c025e2a4c5502addef8b2e73c8f157062361"

URI_x86_64_v2_rust-std-static-x86_64-unknown-none = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rust-std-static-x86_64-unknown-none-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-std-static-x86_64-unknown-none;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static-x86_64-unknown-none}"
SRC_URI[x86_64_v2_rust-std-static-x86_64-unknown-none.sha256sum] = "8480bb2d7ea04143acad8d0cdf883f5c544fa1b0d1535432c1d2ffb6513b771d"

URI_x86_64_v2_rust-toolset = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-toolset-1.84.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-toolset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toolset}"
SRC_URI[x86_64_v2_rust-toolset.sha256sum] = "d3dff9e6d77c083a30172899c00e41dff695fd84148e422cdda5c74b6e87d0ec"

URI_x86_64_v2_rust-toolset-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-toolset-srpm-macros-1.84.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-toolset-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toolset-srpm-macros}"
SRC_URI[x86_64_v2_rust-toolset-srpm-macros.sha256sum] = "5e979d839e63bf29b9b9e16ecf38a308e01ce223cf6261c6eb9102f97bf04955"

URI_x86_64_v2_rustfmt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rustfmt-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rustfmt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rustfmt}"
SRC_URI[x86_64_v2_rustfmt.sha256sum] = "68403b3ab1740e61ed99a3876d6ecefe77a24ba900d2ebcc0cfa278755b05057"

URI_aarch64_cargo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cargo-1.84.1-1.el10.alma.1.aarch64.rpm;name=aarch64_cargo;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo}"
SRC_URI[aarch64_cargo.sha256sum] = "3ff5eaf50767fe0d88d352c591e8bdbc38f7314bff9c6c092a880c889df6a3d5"

URI_aarch64_clippy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clippy-1.84.1-1.el10.alma.1.aarch64.rpm;name=aarch64_clippy;unpack=0"
SRC_URI:append = " ${URI_aarch64_clippy}"
SRC_URI[aarch64_clippy.sha256sum] = "d4ab1569a95b9bcda3aabe03f84f30d125c51403469fa14b16ddf9dd238e7be6"

URI_aarch64_rust = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-1.84.1-1.el10.alma.1.aarch64.rpm;name=aarch64_rust;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust}"
SRC_URI[aarch64_rust.sha256sum] = "512acc7984336329260b6aa4e023599ccae6ffb99db4aec650b857beeee0dd7a"

URI_aarch64_rust-analyzer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-analyzer-1.84.1-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-analyzer}"
SRC_URI[aarch64_rust-analyzer.sha256sum] = "23880ee4ea57c0faeb8fc98ca22b6353668c55e58caac28725a54d0399df38c2"

URI_aarch64_rust-debugger-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-debugger-common-1.84.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-debugger-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-debugger-common}"
SRC_URI[aarch64_rust-debugger-common.sha256sum] = "22a9279a7f43b518000e35310a11f18180f1c352bbb1af51fc930d4345b434b0"

URI_aarch64_rust-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-doc-1.84.1-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc}"
SRC_URI[aarch64_rust-doc.sha256sum] = "499688fa57d120316f874aeb094e95ff11d762913f7aa2b81840a42c6c0023f7"

URI_aarch64_rust-gdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-gdb-1.84.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-gdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gdb}"
SRC_URI[aarch64_rust-gdb.sha256sum] = "f284758e9c96a8df555632a726f82c9d603f97513ed8fd1f09de26c6ed09529d"

URI_aarch64_rust-lldb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-lldb-1.84.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-lldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lldb}"
SRC_URI[aarch64_rust-lldb.sha256sum] = "dca121858c27f7c20d73e9d98b3ead55d16054c6092fd525631239f0dd54c1ec"

URI_aarch64_rust-src = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-src-1.84.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-src}"
SRC_URI[aarch64_rust-src.sha256sum] = "5a019d19671ad02bf6eae025554e36b59c551d7f3cf2dc0ed6cd66977262bde0"

URI_aarch64_rust-std-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-1.84.1-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-std-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static}"
SRC_URI[aarch64_rust-std-static.sha256sum] = "3ef83e53361efbee0c325b572505a5e7f95a0dd0c9d3ac3e3980857c9b3b2c7c"

URI_aarch64_rust-std-static-aarch64-unknown-none-softfloat = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rust-std-static-aarch64-unknown-none-softfloat-1.84.1-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-std-static-aarch64-unknown-none-softfloat;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static-aarch64-unknown-none-softfloat}"
SRC_URI[aarch64_rust-std-static-aarch64-unknown-none-softfloat.sha256sum] = "f64f88935c132bcb599937150e1194290b03a9c6f54b06546981e8386fc4bb66"

URI_aarch64_rust-std-static-wasm32-unknown-unknown = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-wasm32-unknown-unknown-1.84.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-std-static-wasm32-unknown-unknown;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static-wasm32-unknown-unknown}"
SRC_URI[aarch64_rust-std-static-wasm32-unknown-unknown.sha256sum] = "4713be8b3848700eec03791f3ceb3fdbc1046d2b52d2670f25db226908266a13"

URI_aarch64_rust-std-static-wasm32-wasip1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-wasm32-wasip1-1.84.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-std-static-wasm32-wasip1;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static-wasm32-wasip1}"
SRC_URI[aarch64_rust-std-static-wasm32-wasip1.sha256sum] = "9f0102246f20338a2e595fed8ce5c025e2a4c5502addef8b2e73c8f157062361"

URI_aarch64_rust-toolset = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-toolset-1.84.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-toolset;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toolset}"
SRC_URI[aarch64_rust-toolset.sha256sum] = "d3dff9e6d77c083a30172899c00e41dff695fd84148e422cdda5c74b6e87d0ec"

URI_aarch64_rust-toolset-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-toolset-srpm-macros-1.84.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-toolset-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toolset-srpm-macros}"
SRC_URI[aarch64_rust-toolset-srpm-macros.sha256sum] = "5e979d839e63bf29b9b9e16ecf38a308e01ce223cf6261c6eb9102f97bf04955"

URI_aarch64_rustfmt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rustfmt-1.84.1-1.el10.alma.1.aarch64.rpm;name=aarch64_rustfmt;unpack=0"
SRC_URI:append = " ${URI_aarch64_rustfmt}"
SRC_URI[aarch64_rustfmt.sha256sum] = "d8809b3576977c5b27843f4bf210055cb9da0cb92b7b2777a1b7e89085f73648"

RDEPENDS:cargo = " \
 glibc \
 libgcc \
 openssl-libs \
 rust \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clippy = " \
 cargo \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust = " \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 rust-std-static \
 "
RDEPENDS:rust-analyzer = " \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust-debugger-common = " \
 "
RDEPENDS:rust-doc = " \
 "
RDEPENDS:rust-gdb = " \
 bash \
 gdb \
 rust-debugger-common \
 "
RDEPENDS:rust-lldb = " \
 bash \
 lldb \
 python3-lldb \
 rust-debugger-common \
 "
RDEPENDS:rust-src = " \
 "
RDEPENDS:rust-std-static = " \
 glibc \
 glibc-devel \
 libgcc \
 rust \
 "
RDEPENDS:rust-std-static-wasm32-unknown-unknown = " \
 lld \
 rust \
 "
RDEPENDS:rust-std-static-wasm32-wasip1 = " \
 lld \
 rust \
 "
RDEPENDS:rust-std-static-x86_64-unknown-none = " \
 lld \
 rust \
 "
RDEPENDS:rust-toolset = " \
 cargo \
 python3 \
 rust \
 rust-toolset-srpm-macros \
 "
RDEPENDS:rust-toolset-srpm-macros = " \
 "
RDEPENDS:rustfmt = " \
 cargo \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust-std-static-aarch64-unknown-none-softfloat = " \
 lld \
 rust \
 "
