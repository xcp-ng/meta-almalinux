# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtscript"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtscript \
 qt5-qtscript-devel \
 qt5-qtscript-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtscript-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e6bdec6f9baeb66d6a8b96d00571db0be9f9996b405a15da170a054461f6461"

URI_x86_64_v2_qt5-qtscript = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscript-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtscript;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscript}"
SRC_URI[x86_64_v2_qt5-qtscript.sha256sum] = "c73262178e505e3895250d1d52f64b37e07e70947d2c3c1b2fa2c1a4f0f1992e"

URI_x86_64_v2_qt5-qtscript-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscript-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtscript-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscript-devel}"
SRC_URI[x86_64_v2_qt5-qtscript-devel.sha256sum] = "9f98b0cfc12ee69a55b2282217bf4792c160cc1ab9210898c17707eef08f47c6"

URI_x86_64_v2_qt5-qtscript-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscript-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtscript-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscript-examples}"
SRC_URI[x86_64_v2_qt5-qtscript-examples.sha256sum] = "b9e111d5142ef5cc593ba4cb5422f6e384669617f6b480a61e9fd3e8dcac879c"

URI_aarch64_qt5-qtscript = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscript-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtscript;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscript}"
SRC_URI[aarch64_qt5-qtscript.sha256sum] = "66658d523ffaa4f63ba6c238aa74c9f1aed3fd9216da04007250e12f59583a2b"

URI_aarch64_qt5-qtscript-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscript-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtscript-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscript-devel}"
SRC_URI[aarch64_qt5-qtscript-devel.sha256sum] = "361bb2bcc6929b8d3178900332ad576d94436dcb9e408d8eb400d40cfc244d13"

URI_aarch64_qt5-qtscript-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscript-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtscript-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscript-examples}"
SRC_URI[aarch64_qt5-qtscript-examples.sha256sum] = "b18906902d0eae88525ea9314648858cc9c7971cbe1be2a7a6cd3e105b036fd2"

RDEPENDS:qt5-qtscript:x86_64_v2 = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
"
RDEPENDS:qt5-qtscript:aarch64 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
"
RDEPENDS:qt5-qtscript-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtscript \
 "
RDEPENDS:qt5-qtscript-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtscript \
 "
