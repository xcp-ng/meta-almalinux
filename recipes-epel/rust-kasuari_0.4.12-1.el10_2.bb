# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-kasuari"
PV = "0.4.12"
PR = "1.el10_2"
PACKAGES = " \
 rust-kasuari+default-devel \
 rust-kasuari+document-features-devel \
 rust-kasuari+portable-atomic-devel \
 rust-kasuari+std-devel \
 rust-kasuari-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-kasuari-0.4.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59f406def300fe01b2d8cb9bea2891701d61cba33be443db339d684689476766"

URI_x86_64_v2_rust-kasuari+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kasuari+default-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kasuari+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kasuari+default-devel}"
SRC_URI[x86_64_v2_rust-kasuari+default-devel.sha256sum] = "f93b08e9dba5109c62519caff266039797aa3717b221787ded6a8c61406a1650"

URI_x86_64_v2_rust-kasuari+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kasuari+document-features-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kasuari+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kasuari+document-features-devel}"
SRC_URI[x86_64_v2_rust-kasuari+document-features-devel.sha256sum] = "8f167310a8b587069f1d7874cb7f095931d778f687da18464061a78b2c33abb0"

URI_x86_64_v2_rust-kasuari+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kasuari+portable-atomic-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kasuari+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kasuari+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-kasuari+portable-atomic-devel.sha256sum] = "34c0ac9ca04ebe79407c1c8d2dbca6588e36b7f56865a4b3adae31f19f675592"

URI_x86_64_v2_rust-kasuari+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kasuari+std-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kasuari+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kasuari+std-devel}"
SRC_URI[x86_64_v2_rust-kasuari+std-devel.sha256sum] = "a547e89c8f17cf48725f82f07d4018574e23618738c23f5b72a5f1fb8a55343b"

URI_x86_64_v2_rust-kasuari-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kasuari-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kasuari-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kasuari-devel}"
SRC_URI[x86_64_v2_rust-kasuari-devel.sha256sum] = "857acc26e6c7f4a6d2e907acfea1c17960480caf3657ce1155567bc492edca3d"

URI_aarch64_rust-kasuari+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kasuari+default-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-kasuari+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kasuari+default-devel}"
SRC_URI[aarch64_rust-kasuari+default-devel.sha256sum] = "39ab69bdb91e8a354a82071aa19886e1b6b2bd69bd6d04c42b3824dbccb3f98a"

URI_aarch64_rust-kasuari+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kasuari+document-features-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-kasuari+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kasuari+document-features-devel}"
SRC_URI[aarch64_rust-kasuari+document-features-devel.sha256sum] = "f41d1917f022899d864ec6a779d9308eabe020d2107f0df94c94de86b07b706e"

URI_aarch64_rust-kasuari+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kasuari+portable-atomic-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-kasuari+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kasuari+portable-atomic-devel}"
SRC_URI[aarch64_rust-kasuari+portable-atomic-devel.sha256sum] = "01337182c9757a70aac155890529eb910ccdce8c473ff68bf347ce0083665dee"

URI_aarch64_rust-kasuari+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kasuari+std-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-kasuari+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kasuari+std-devel}"
SRC_URI[aarch64_rust-kasuari+std-devel.sha256sum] = "367d5f66424208207469d6ddc11e2664c2f6c3ea787d186b71d9e5e8dde33c49"

URI_aarch64_rust-kasuari-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kasuari-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-kasuari-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kasuari-devel}"
SRC_URI[aarch64_rust-kasuari-devel.sha256sum] = "d5f6f69194baed1327511a01d1c57cc53e1ba66f708b51aa67b7f97b9c2f03d3"

RDEPENDS:rust-kasuari+default-devel = " \
 cargo \
 rust-kasuari+std-devel \
 rust-kasuari-devel \
 "
RDEPENDS:rust-kasuari+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-kasuari-devel \
 "
RDEPENDS:rust-kasuari+portable-atomic-devel = " \
 cargo \
 rust-kasuari-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util+default-devel \
 "
RDEPENDS:rust-kasuari+std-devel = " \
 cargo \
 rust-kasuari-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic+std-devel \
 rust-portable-atomic-devel \
 rust-thiserror+std-devel \
 "
RDEPENDS:rust-kasuari-devel = " \
 cargo \
 rust \
 rust-hashbrown+default-devel \
 rust-thiserror-devel \
 "
