# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yarnpkg"
PV = "1.22.22"
PR = "18.el10_3"
PACKAGES = " \
 yarnpkg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yarnpkg-1.22.22-18.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "355e02a98599cacd97975a606e4e39fb790ceb730e049dc3a97f488688692fb0"

URI_x86_64_v2_yarnpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yarnpkg-1.22.22-18.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yarnpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yarnpkg}"
SRC_URI[x86_64_v2_yarnpkg.sha256sum] = "d59d77f1c73a4ee04520a5a94612d6d032080399a1b74c175e04fb546ca43796"

URI_aarch64_yarnpkg = "${EPEL_MIRROR}/aarch64/Packages/y/yarnpkg-1.22.22-18.el10_3.aarch64.rpm;name=aarch64_yarnpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_yarnpkg}"
SRC_URI[aarch64_yarnpkg.sha256sum] = "747ad44473e8451fa92c2ce4f5340273de12eeb3e3a18333db2adb2cd1f28b59"

RDEPENDS:yarnpkg = " \
 bash \
 nodejs \
 "
