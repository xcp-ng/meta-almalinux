# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyproject-toml"
PV = "0.13.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-pyproject-toml+default-devel \
 rust-pyproject-toml+glob-devel \
 rust-pyproject-toml+pep639-glob-devel \
 rust-pyproject-toml+tracing-devel \
 rust-pyproject-toml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyproject-toml-0.13.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7beac840ddf388c59b46f4cb1301014b50810741b5ece971953f8a3b33f1111b"

URI_x86_64_v2_rust-pyproject-toml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyproject-toml+default-devel-0.13.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyproject-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyproject-toml+default-devel}"
SRC_URI[x86_64_v2_rust-pyproject-toml+default-devel.sha256sum] = "f326c2c5b59bdc23750b06a46ffeeacbe422fe60efe2af3055706487bc27e383"

URI_x86_64_v2_rust-pyproject-toml+glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyproject-toml+glob-devel-0.13.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyproject-toml+glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyproject-toml+glob-devel}"
SRC_URI[x86_64_v2_rust-pyproject-toml+glob-devel.sha256sum] = "d777c7aca89d5d55e3b38438e32f330134dffb68abd6c5c3ddbabb19e0d69ac3"

URI_x86_64_v2_rust-pyproject-toml+pep639-glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyproject-toml+pep639-glob-devel-0.13.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyproject-toml+pep639-glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyproject-toml+pep639-glob-devel}"
SRC_URI[x86_64_v2_rust-pyproject-toml+pep639-glob-devel.sha256sum] = "35c5229fa478981a9f85b7715c16c688b1cd456d26d4431c25e182c53edd11d4"

URI_x86_64_v2_rust-pyproject-toml+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyproject-toml+tracing-devel-0.13.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyproject-toml+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyproject-toml+tracing-devel}"
SRC_URI[x86_64_v2_rust-pyproject-toml+tracing-devel.sha256sum] = "23d4d3c08b96f3ea14e497cf6495238919f72ec7f6090c6ab13043040f5ab0fa"

URI_x86_64_v2_rust-pyproject-toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyproject-toml-devel-0.13.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyproject-toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyproject-toml-devel}"
SRC_URI[x86_64_v2_rust-pyproject-toml-devel.sha256sum] = "1008ce7235830f376502aa348ff644babd2790b68b97f52b7409940380df6e05"

URI_aarch64_rust-pyproject-toml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyproject-toml+default-devel-0.13.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyproject-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyproject-toml+default-devel}"
SRC_URI[aarch64_rust-pyproject-toml+default-devel.sha256sum] = "edeac4f16a978fd713f491741c818db98958b3048a659bc71ee539c59f9e272c"

URI_aarch64_rust-pyproject-toml+glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyproject-toml+glob-devel-0.13.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyproject-toml+glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyproject-toml+glob-devel}"
SRC_URI[aarch64_rust-pyproject-toml+glob-devel.sha256sum] = "68f73137eca4f5969f4bc1dab0758b58a52cfbcfb02b702fca3acbea73873cf4"

URI_aarch64_rust-pyproject-toml+pep639-glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyproject-toml+pep639-glob-devel-0.13.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyproject-toml+pep639-glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyproject-toml+pep639-glob-devel}"
SRC_URI[aarch64_rust-pyproject-toml+pep639-glob-devel.sha256sum] = "b27d51e87c61d7fce6b3dc29d438ca4c577b66afb3d20c926861a38cc78a972c"

URI_aarch64_rust-pyproject-toml+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyproject-toml+tracing-devel-0.13.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyproject-toml+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyproject-toml+tracing-devel}"
SRC_URI[aarch64_rust-pyproject-toml+tracing-devel.sha256sum] = "ef812827c6e685d4e982ab8b3eb5dc264e952318565b1b086b8914a59406f5de"

URI_aarch64_rust-pyproject-toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyproject-toml-devel-0.13.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyproject-toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyproject-toml-devel}"
SRC_URI[aarch64_rust-pyproject-toml-devel.sha256sum] = "e54b792cde52fb2c0835269df86cde925603c9c783384a8a4701ed4373a8c203"

RDEPENDS:rust-pyproject-toml+default-devel = " \
 cargo \
 rust-pyproject-toml-devel \
 "
RDEPENDS:rust-pyproject-toml+glob-devel = " \
 cargo \
 rust-glob+default-devel \
 rust-pyproject-toml-devel \
 "
RDEPENDS:rust-pyproject-toml+pep639-glob-devel = " \
 cargo \
 rust-pyproject-toml+glob-devel \
 rust-pyproject-toml-devel \
 "
RDEPENDS:rust-pyproject-toml+tracing-devel = " \
 cargo \
 rust-pep440_rs+tracing-devel \
 rust-pep508_rs+tracing-devel \
 rust-pyproject-toml-devel \
 "
RDEPENDS:rust-pyproject-toml-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-indexmap+serde-devel \
 rust-pep440_rs+default-devel \
 rust-pep508_rs+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-thiserror+default-devel \
 rust-toml+parse-devel \
 rust-toml-devel \
 "
