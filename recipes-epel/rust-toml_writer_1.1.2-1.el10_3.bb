# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_writer"
PV = "1.1.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-toml_writer+alloc-devel \
 rust-toml_writer+default-devel \
 rust-toml_writer+std-devel \
 rust-toml_writer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_writer-1.1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c091fbabe7c2ba8b89fc537f5493c7db36ba13b0e6ffc00391512ee420acab69"

URI_x86_64_v2_rust-toml_writer+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_writer+alloc-devel-1.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_writer+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_writer+alloc-devel}"
SRC_URI[x86_64_v2_rust-toml_writer+alloc-devel.sha256sum] = "bdb3abfaeca6f0e862120d8149ab09fedbfaedfbe27b8e31ca17eb4dd6298b21"

URI_x86_64_v2_rust-toml_writer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_writer+default-devel-1.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_writer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_writer+default-devel}"
SRC_URI[x86_64_v2_rust-toml_writer+default-devel.sha256sum] = "1e54627cc81170abd44be8ec8e4bacac31b92805480a873339eb8b8246955e3f"

URI_x86_64_v2_rust-toml_writer+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_writer+std-devel-1.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_writer+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_writer+std-devel}"
SRC_URI[x86_64_v2_rust-toml_writer+std-devel.sha256sum] = "cf33c37aef8c5388bab0e4c03d2548cdf64be7852acfb6eace203ddf90ee6497"

URI_x86_64_v2_rust-toml_writer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_writer-devel-1.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_writer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_writer-devel}"
SRC_URI[x86_64_v2_rust-toml_writer-devel.sha256sum] = "55ba9ed257609e8a9314ea7523fa17647af6e514427851a55ed422f8a74fa0db"

URI_aarch64_rust-toml_writer+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_writer+alloc-devel-1.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-toml_writer+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_writer+alloc-devel}"
SRC_URI[aarch64_rust-toml_writer+alloc-devel.sha256sum] = "4ce237c1d2cec9211a8f722ad2714fbcf12bf4a99057db13835fc66e7b885474"

URI_aarch64_rust-toml_writer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_writer+default-devel-1.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-toml_writer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_writer+default-devel}"
SRC_URI[aarch64_rust-toml_writer+default-devel.sha256sum] = "cc54a4a0ef40b040725455ff449a70baf95f95c7574f7057330fc2dafaf70271"

URI_aarch64_rust-toml_writer+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_writer+std-devel-1.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-toml_writer+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_writer+std-devel}"
SRC_URI[aarch64_rust-toml_writer+std-devel.sha256sum] = "40ea2611dd3b18748ad98830e378b93e6c466c5f026e884420cb4084beeb23ad"

URI_aarch64_rust-toml_writer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_writer-devel-1.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-toml_writer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_writer-devel}"
SRC_URI[aarch64_rust-toml_writer-devel.sha256sum] = "edffdff75f08c329b9638e02367931751de471a67813a3acec3577d49e953855"

RDEPENDS:rust-toml_writer+alloc-devel = " \
 cargo \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml_writer+default-devel = " \
 cargo \
 rust-toml_writer+std-devel \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml_writer+std-devel = " \
 cargo \
 rust-toml_writer+alloc-devel \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml_writer-devel = " \
 cargo \
 rust \
 "
