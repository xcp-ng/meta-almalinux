# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-http-send-reqwest"
PV = "4.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-http-send-reqwest+default-devel \
 rust-reqsign-http-send-reqwest-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-http-send-reqwest-4.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "272352dc43b6369079d357ac0eb373fbea278f4bbd22a29b624561b55f991d88"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-http-send-reqwest+default-devel-4.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-http-send-reqwest+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-http-send-reqwest+default-devel.sha256sum] = "9e807a6f4fa7617b7e00e568a929ca314ef9ae9d40877d8bf7ec6e2e51d49f76"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-http-send-reqwest-devel-4.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-http-send-reqwest-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-http-send-reqwest-devel.sha256sum] = "8c2005be36009f980d24d3baccba5cdcb3a7539a126912684d12c0c2b7d4d8d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-http-send-reqwest+default-devel-4.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-http-send-reqwest+default-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-http-send-reqwest+default-devel.sha256sum] = "450173d4472ce32f6ba943e69815a7004cfafa13a9dc576fcd86bea2d94d7dea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-http-send-reqwest-devel-4.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-http-send-reqwest-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-http-send-reqwest-devel.sha256sum] = "9032f91aca5da05ca8fd595a147777251173ddba702d72d098febbbd73278e43"

RDEPENDS:rust-reqsign-http-send-reqwest+default-devel = " \
 cargo \
 rust-reqsign-http-send-reqwest-devel \
 "
RDEPENDS:rust-reqsign-http-send-reqwest-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-http-body-util+default-devel \
 rust-reqsign-core+default-devel \
 rust-reqwest-devel \
 "
