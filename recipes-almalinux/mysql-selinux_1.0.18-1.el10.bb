# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mysql-selinux"
PV = "1.0.18"
PR = "1.el10"
PACKAGES = " \
 mysql-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mysql-selinux-1.0.18-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "16a7ce3f389d688542735871349e541b02ed005b55b9f80109f3407f549e1945"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql-selinux-1.0.18-1.el10.noarch.rpm;name=x86_64_v2_mysql-selinux;unpack=0"
SRC_URI[x86_64_v2_mysql-selinux.sha256sum] = "7103f1e9776a36dc2a6c07f9cd391749ab342dd612d9ec243d27a3747fa1309f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql-selinux-1.0.18-1.el10.noarch.rpm;name=aarch64_mysql-selinux;unpack=0"
SRC_URI[aarch64_mysql-selinux.sha256sum] = "7103f1e9776a36dc2a6c07f9cd391749ab342dd612d9ec243d27a3747fa1309f"

RDEPENDS:mysql-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
