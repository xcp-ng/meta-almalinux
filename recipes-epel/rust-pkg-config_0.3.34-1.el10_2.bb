# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pkg-config"
PV = "0.3.34"
PR = "1.el10_2"
PACKAGES = " \
 rust-pkg-config+default-devel \
 rust-pkg-config-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-pkg-config-0.3.34-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "37d935e755f8a9bb392bbf2fa0acb15d0a1d53448239f8701155b68b76c2709f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkg-config+default-devel-0.3.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkg-config+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pkg-config+default-devel.sha256sum] = "103bc2e8e4649832977641e8df8355011614fc743ad6546c5ccc4e7ffb93597b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkg-config-devel-0.3.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkg-config-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pkg-config-devel.sha256sum] = "fcb1347aea7a540f2091e3a0b4ab25f89fb0456579a6a639a0209dad108e3f02"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pkg-config+default-devel-0.3.34-1.el10_2.noarch.rpm;name=aarch64_rust-pkg-config+default-devel;unpack=0"
SRC_URI[aarch64_rust-pkg-config+default-devel.sha256sum] = "42cc105e81a1a4a8a05e5d6833852296bf3ab876065eb7982af1ca0ba0f98d73"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pkg-config-devel-0.3.34-1.el10_2.noarch.rpm;name=aarch64_rust-pkg-config-devel;unpack=0"
SRC_URI[aarch64_rust-pkg-config-devel.sha256sum] = "df42a49010b273ac1cd21a9f777b8edf0c7da874d14fbc04ccde817d0d838d2b"

RDEPENDS:rust-pkg-config+default-devel = " \
 cargo \
 rust-pkg-config-devel \
 "
RDEPENDS:rust-pkg-config-devel = " \
 cargo \
 pkgconf-pkg-config \
 rust \
 "
