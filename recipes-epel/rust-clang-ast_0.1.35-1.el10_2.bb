# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clang-ast"
PV = "0.1.35"
PR = "1.el10_2"
PACKAGES = " \
 rust-clang-ast+default-devel \
 rust-clang-ast+serde-devel \
 rust-clang-ast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clang-ast-0.1.35-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "168cccea6405102411f8f576239a5d9ccc006ab2c70078f30f890ad18cf9f6db"

URI_x86_64_v2_rust-clang-ast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-ast+default-devel-0.1.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-ast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-ast+default-devel}"
SRC_URI[x86_64_v2_rust-clang-ast+default-devel.sha256sum] = "0f3815db30d8ec28e88ef9b85a3dacfd2d6535a134a68be201076caacd2bcaf3"

URI_x86_64_v2_rust-clang-ast+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-ast+serde-devel-0.1.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-ast+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-ast+serde-devel}"
SRC_URI[x86_64_v2_rust-clang-ast+serde-devel.sha256sum] = "558ccb102950d018d46c04eb105902a54bf354b410be864f213c265a82299cb3"

URI_x86_64_v2_rust-clang-ast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-ast-devel-0.1.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-ast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-ast-devel}"
SRC_URI[x86_64_v2_rust-clang-ast-devel.sha256sum] = "116d552f1ba5abfb15c1b77878d3ea8c6bbf7402a8859a8d0f7f50b6ee0ce4d2"

URI_aarch64_rust-clang-ast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-ast+default-devel-0.1.35-1.el10_2.noarch.rpm;name=aarch64_rust-clang-ast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-ast+default-devel}"
SRC_URI[aarch64_rust-clang-ast+default-devel.sha256sum] = "6d79a39186c86c4b4abfe7aec570e66831f143ec79d2534056f1364993d32795"

URI_aarch64_rust-clang-ast+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-ast+serde-devel-0.1.35-1.el10_2.noarch.rpm;name=aarch64_rust-clang-ast+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-ast+serde-devel}"
SRC_URI[aarch64_rust-clang-ast+serde-devel.sha256sum] = "6c3f387b1cb8359904153476545557b1864a8665eb312c5a8e8f7511f0514197"

URI_aarch64_rust-clang-ast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-ast-devel-0.1.35-1.el10_2.noarch.rpm;name=aarch64_rust-clang-ast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-ast-devel}"
SRC_URI[aarch64_rust-clang-ast-devel.sha256sum] = "c2e665bb26c9d68675624ab9f8dcce6a4a95f66ccf61f58b8c6eaffad1d2c265"

RDEPENDS:rust-clang-ast+default-devel = " \
 cargo \
 rust-clang-ast-devel \
 "
RDEPENDS:rust-clang-ast+serde-devel = " \
 cargo \
 rust-clang-ast-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-clang-ast-devel = " \
 cargo \
 rust-foldhash+default-devel \
 rust-serde_core+default-devel \
 "
