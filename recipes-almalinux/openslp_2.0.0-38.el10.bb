# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openslp"
PV = "2.0.0"
PR = "38.el10"
PACKAGES = " \
 openslp \
 openslp-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openslp-2.0.0-38.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "07368c609e29b862a96bc66251bf602671b8b35e3fa223144c17ceb6d1613a7d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openslp-2.0.0-38.el10.x86_64_v2.rpm;name=x86_64_v2_openslp;unpack=0"
SRC_URI[x86_64_v2_openslp.sha256sum] = "618f4666f7a9622bf1414e707de965dff7a2d3a3a9be305c59137aae2acb45ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openslp-devel-2.0.0-38.el10.x86_64_v2.rpm;name=x86_64_v2_openslp-devel;unpack=0"
SRC_URI[x86_64_v2_openslp-devel.sha256sum] = "c8af425911501fa7f2f178ff8d15866ed780827284757e2335d6f530ac0522b6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openslp-2.0.0-38.el10.aarch64.rpm;name=aarch64_openslp;unpack=0"
SRC_URI[aarch64_openslp.sha256sum] = "3ae7b709c865223472388d501010817592569512c4def9ecc4837ab69cbe4a2e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openslp-devel-2.0.0-38.el10.aarch64.rpm;name=aarch64_openslp-devel;unpack=0"
SRC_URI[aarch64_openslp-devel.sha256sum] = "94c700d905d230553f40ac1347c0d68faec731a67d5ff45404e8dccf493ecf27"

RDEPENDS:openslp = " \
 glibc \
 "
RDEPENDS:openslp-devel = " \
 openslp \
 "
