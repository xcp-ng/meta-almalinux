# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typed-path"
PV = "0.12.3"
PR = "2.el10_2"
PACKAGES = " \
 rust-typed-path+default-devel \
 rust-typed-path+std-devel \
 rust-typed-path-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typed-path-0.12.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b32e7aac9fc568e77a8badfdba2ec49bf8ee9c74e939c7e8233dcc9c48012c1b"

URI_x86_64_v2_rust-typed-path+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-path+default-devel-0.12.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-path+default-devel}"
SRC_URI[x86_64_v2_rust-typed-path+default-devel.sha256sum] = "6743661e7468ab851d95ecc49f0cb53c075aa6df1706475460f341e81cd135a9"

URI_x86_64_v2_rust-typed-path+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-path+std-devel-0.12.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-path+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-path+std-devel}"
SRC_URI[x86_64_v2_rust-typed-path+std-devel.sha256sum] = "952e68a4e603e478d547a7473bc8b006d4cd37261cfcbb116a2c1f3c05982308"

URI_x86_64_v2_rust-typed-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-path-devel-0.12.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-path-devel}"
SRC_URI[x86_64_v2_rust-typed-path-devel.sha256sum] = "555f379773c657bb20d0b1f8140c6c3b25bcc79e1c2f501cc5383df7df541445"

URI_aarch64_rust-typed-path+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-path+default-devel-0.12.3-2.el10_2.noarch.rpm;name=aarch64_rust-typed-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-path+default-devel}"
SRC_URI[aarch64_rust-typed-path+default-devel.sha256sum] = "0fc8079efe33ac2cf67dbc16cd4c7a1de0e1aaea3cba7de4d28ed15f1e532e70"

URI_aarch64_rust-typed-path+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-path+std-devel-0.12.3-2.el10_2.noarch.rpm;name=aarch64_rust-typed-path+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-path+std-devel}"
SRC_URI[aarch64_rust-typed-path+std-devel.sha256sum] = "7a41c20fd458d82dc137807a5be929f066babe034408b57f4a1e18d971f3c032"

URI_aarch64_rust-typed-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-path-devel-0.12.3-2.el10_2.noarch.rpm;name=aarch64_rust-typed-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-path-devel}"
SRC_URI[aarch64_rust-typed-path-devel.sha256sum] = "66a4694ed0f37615855473d46011a54bee255a2ca6957c1b6ff8d61aa10144cd"

RDEPENDS:rust-typed-path+default-devel = " \
 cargo \
 rust-typed-path+std-devel \
 rust-typed-path-devel \
 "
RDEPENDS:rust-typed-path+std-devel = " \
 cargo \
 rust-typed-path-devel \
 "
RDEPENDS:rust-typed-path-devel = " \
 cargo \
 rust \
 "
