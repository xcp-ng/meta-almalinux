# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gaupol"
PV = "1.15"
PR = "19.el10_0"
PACKAGES = " \
 gaupol \
 python3-aeidon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gaupol-1.15-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0343891216f13c0fc68a7eea23d7b224eb1a823dcaed90572cff00c0170e3dfb"

URI_x86_64_v2_gaupol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gaupol-1.15-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gaupol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gaupol}"
SRC_URI[x86_64_v2_gaupol.sha256sum] = "7a41da47cbcc7a16289e78ca2c227ae6dfc2a6c7177346f2453a710fd2a17f05"

URI_x86_64_v2_python3-aeidon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aeidon-1.15-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aeidon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aeidon}"
SRC_URI[x86_64_v2_python3-aeidon.sha256sum] = "3ae07a3fd6420132b96cc0e49bdf325dcc3981095ecbc33077d3e28879b4b9d1"

URI_aarch64_gaupol = "${EPEL_MIRROR}/aarch64/Packages/g/gaupol-1.15-19.el10_0.noarch.rpm;name=aarch64_gaupol;unpack=0"
SRC_URI:append = " ${URI_aarch64_gaupol}"
SRC_URI[aarch64_gaupol.sha256sum] = "71c698ab2b5ddb8701f75c9c64d8f40d8deaa122e96717d46d9337ecc09025c5"

URI_aarch64_python3-aeidon = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aeidon-1.15-19.el10_0.noarch.rpm;name=aarch64_python3-aeidon;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aeidon}"
SRC_URI[aarch64_python3-aeidon.sha256sum] = "c882889bdd1d67b41151d2a1befc0ee747881a81f8cab7e2283b196f2591f24b"

RDEPENDS:gaupol = " \
 gspell \
 gstreamer1 \
 gstreamer1-plugins-base \
 gstreamer1-plugins-good \
 gstreamer1-plugins-good-gtk \
 gtk3 \
 hicolor-icon-theme \
 iso-codes \
 python3 \
 python3-aeidon \
 python3-gobject-base \
 "
RDEPENDS:python3-aeidon = " \
 gspell \
 iso-codes \
 python3 \
 python3-charset-normalizer \
 python3-gobject-base \
 "
