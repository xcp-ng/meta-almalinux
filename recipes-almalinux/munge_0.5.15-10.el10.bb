# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "munge"
PV = "0.5.15"
PR = "10.el10"
PACKAGES = " \
 munge \
 munge-devel \
 munge-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/munge-0.5.15-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c4a57de4903c71d9b6986e5b4a47e1da52e3e3cef83b98b75bd492aea17a7c6"

URI_x86_64_v2_munge = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/munge-0.5.15-10.el10.x86_64_v2.rpm;name=x86_64_v2_munge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_munge}"
SRC_URI[x86_64_v2_munge.sha256sum] = "3a30adfb3ff23a734df2b5bc42e9f6a6e7e3c5ff810bc357cabf9da57dda47a3"

URI_x86_64_v2_munge-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/munge-devel-0.5.15-10.el10.x86_64_v2.rpm;name=x86_64_v2_munge-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_munge-devel}"
SRC_URI[x86_64_v2_munge-devel.sha256sum] = "e79ca9e97df97824b5d5f34dfc8cb559ffbe2cb07027ccd33bb7e87807e036d7"

URI_x86_64_v2_munge-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/munge-libs-0.5.15-10.el10.x86_64_v2.rpm;name=x86_64_v2_munge-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_munge-libs}"
SRC_URI[x86_64_v2_munge-libs.sha256sum] = "6edddcdbede341035cd52a604b2ef910afe02ac139f166a4d90dd7516b2bcb1d"

URI_aarch64_munge = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/munge-0.5.15-10.el10.aarch64.rpm;name=aarch64_munge;unpack=0"
SRC_URI:append = " ${URI_aarch64_munge}"
SRC_URI[aarch64_munge.sha256sum] = "d59a64a8ccef60bdb9060d647a9d3634c6228561cc9724f4d112774f35b50007"

URI_aarch64_munge-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/munge-devel-0.5.15-10.el10.aarch64.rpm;name=aarch64_munge-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_munge-devel}"
SRC_URI[aarch64_munge-devel.sha256sum] = "4c2ce967189e9bff6e8b78c02a6b7047127a183958162db471081a40373a6bd1"

URI_aarch64_munge-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/munge-libs-0.5.15-10.el10.aarch64.rpm;name=aarch64_munge-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_munge-libs}"
SRC_URI[aarch64_munge-libs.sha256sum] = "5308ddb7de873924c9d9c37b5df193665bb3b049d3ceca346078aad265f136e1"

RDEPENDS:munge = " \
 bash \
 bzip2-libs \
 glibc \
 libgcc \
 logrotate \
 munge-libs \
 openssl-libs \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
RDEPENDS:munge-devel = " \
 munge-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:munge-libs = " \
 glibc \
 "
