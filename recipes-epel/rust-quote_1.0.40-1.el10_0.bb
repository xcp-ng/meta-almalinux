# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quote"
PV = "1.0.40"
PR = "1.el10_0"
PACKAGES = " \
 rust-quote+default-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quote-1.0.40-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9834877ac01e5584dcff3ce039add5d87b5ad96409936f41cfaf8cc5deec939c"

URI_x86_64_v2_rust-quote+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quote+default-devel-1.0.40-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quote+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quote+default-devel}"
SRC_URI[x86_64_v2_rust-quote+default-devel.sha256sum] = "2f7d25511d54fd4fc85d6dbab0a5e54a21531b79e92cb644f934061c4fb05996"

URI_x86_64_v2_rust-quote+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quote+proc-macro-devel-1.0.40-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quote+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quote+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-quote+proc-macro-devel.sha256sum] = "716bf6f4d5f8ffef72018211637bda42c5a653d81936a09f0b1fd3013331386d"

URI_x86_64_v2_rust-quote-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quote-devel-1.0.40-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quote-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quote-devel}"
SRC_URI[x86_64_v2_rust-quote-devel.sha256sum] = "c5bd83f45d6d0efcb9e1161f586c17fbb924736877fb45082964039e3c092052"

URI_aarch64_rust-quote+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quote+default-devel-1.0.40-1.el10_0.noarch.rpm;name=aarch64_rust-quote+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quote+default-devel}"
SRC_URI[aarch64_rust-quote+default-devel.sha256sum] = "a2b251433eb2a36a6000c2b1fc38f0e9d74a2807353eaf8c7f5423f526b9d813"

URI_aarch64_rust-quote+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quote+proc-macro-devel-1.0.40-1.el10_0.noarch.rpm;name=aarch64_rust-quote+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quote+proc-macro-devel}"
SRC_URI[aarch64_rust-quote+proc-macro-devel.sha256sum] = "d7c730b5c1f51791738b3c0d00421548353ad763df34167eeee82c65d5d859d7"

URI_aarch64_rust-quote-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quote-devel-1.0.40-1.el10_0.noarch.rpm;name=aarch64_rust-quote-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quote-devel}"
SRC_URI[aarch64_rust-quote-devel.sha256sum] = "b39cabc72a9eeb57148138886e29723d3b69aee926f6cb581e316ab4a98ffea0"

RDEPENDS:rust-quote+default-devel = " \
 cargo \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 "
RDEPENDS:rust-quote+proc-macro-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-quote-devel \
 "
RDEPENDS:rust-quote-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 "
