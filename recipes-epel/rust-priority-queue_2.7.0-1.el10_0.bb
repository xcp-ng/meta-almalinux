# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-priority-queue"
PV = "2.7.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-priority-queue+benchmarks-devel \
 rust-priority-queue+default-devel \
 rust-priority-queue+serde-devel \
 rust-priority-queue+std-devel \
 rust-priority-queue-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-priority-queue-2.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e01b485055bc8383af58a472e07551d8693b9ea10cd59e0d8eac21155525e8f9"

URI_x86_64_v2_rust-priority-queue+benchmarks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-priority-queue+benchmarks-devel-2.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-priority-queue+benchmarks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-priority-queue+benchmarks-devel}"
SRC_URI[x86_64_v2_rust-priority-queue+benchmarks-devel.sha256sum] = "36218ec489d6e5b068f00f8b8ce83b79bd545c31d9150c856dcfc1d1909956ed"

URI_x86_64_v2_rust-priority-queue+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-priority-queue+default-devel-2.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-priority-queue+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-priority-queue+default-devel}"
SRC_URI[x86_64_v2_rust-priority-queue+default-devel.sha256sum] = "c4bfb648d8f828ec62eee17d42039570e97eb81b7fcc6dad90f0061efd6c08af"

URI_x86_64_v2_rust-priority-queue+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-priority-queue+serde-devel-2.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-priority-queue+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-priority-queue+serde-devel}"
SRC_URI[x86_64_v2_rust-priority-queue+serde-devel.sha256sum] = "9d5868c11cdd85e734780bf4d3ad41e9ba1cac8d502f124f500b76849201c05a"

URI_x86_64_v2_rust-priority-queue+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-priority-queue+std-devel-2.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-priority-queue+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-priority-queue+std-devel}"
SRC_URI[x86_64_v2_rust-priority-queue+std-devel.sha256sum] = "4ec1ae57134442bba59d133c49643faef1c1741195e808971743935d67a2e302"

URI_x86_64_v2_rust-priority-queue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-priority-queue-devel-2.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-priority-queue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-priority-queue-devel}"
SRC_URI[x86_64_v2_rust-priority-queue-devel.sha256sum] = "611e2cbc10ff4c5e972ece9b65cf2bf8d2fe25ec433c44e2438f890740629902"

URI_aarch64_rust-priority-queue+benchmarks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-priority-queue+benchmarks-devel-2.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-priority-queue+benchmarks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-priority-queue+benchmarks-devel}"
SRC_URI[aarch64_rust-priority-queue+benchmarks-devel.sha256sum] = "1ebb97020e135e03685c4b489499278d9fcddc5c89f308f21478774e6c218217"

URI_aarch64_rust-priority-queue+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-priority-queue+default-devel-2.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-priority-queue+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-priority-queue+default-devel}"
SRC_URI[aarch64_rust-priority-queue+default-devel.sha256sum] = "dabf9b599dd269d1706f767c4020f4b174916e37c8b3b7ff456740f3f0891761"

URI_aarch64_rust-priority-queue+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-priority-queue+serde-devel-2.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-priority-queue+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-priority-queue+serde-devel}"
SRC_URI[aarch64_rust-priority-queue+serde-devel.sha256sum] = "c4c054124b6b330eb919a5313b9708aef9f72e9fd199561dc3e76a606e6a22be"

URI_aarch64_rust-priority-queue+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-priority-queue+std-devel-2.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-priority-queue+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-priority-queue+std-devel}"
SRC_URI[aarch64_rust-priority-queue+std-devel.sha256sum] = "fb761cefee3070ddbdcca00f6ab8896b710d8697f731c6871601000bd53b749d"

URI_aarch64_rust-priority-queue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-priority-queue-devel-2.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-priority-queue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-priority-queue-devel}"
SRC_URI[aarch64_rust-priority-queue-devel.sha256sum] = "f3fce085b75962eb60ea789a33bab0958c4e66915f0f64d82fcb280c4f003258"

RDEPENDS:rust-priority-queue+benchmarks-devel = " \
 cargo \
 rust-priority-queue-devel \
 "
RDEPENDS:rust-priority-queue+default-devel = " \
 cargo \
 rust-priority-queue+std-devel \
 rust-priority-queue-devel \
 "
RDEPENDS:rust-priority-queue+serde-devel = " \
 cargo \
 rust-priority-queue-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-priority-queue+std-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-priority-queue-devel \
 rust-serde+alloc-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-priority-queue-devel = " \
 cargo \
 rust \
 rust-equivalent+default-devel \
 rust-indexmap-devel \
 "
