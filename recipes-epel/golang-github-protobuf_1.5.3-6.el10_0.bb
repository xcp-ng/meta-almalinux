# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-protobuf"
PV = "1.5.3"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-protobuf-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-protobuf-1.5.3-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1a564ea46fb830643be28cb708185765d00e8b54b745046209af057dff20c7b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-protobuf-devel-1.5.3-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-protobuf-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-protobuf-devel.sha256sum] = "f3a98bba40ade31185c5f5d98f8accd73a0c66fc1ba1ee49b6e73449c78596d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-protobuf-devel-1.5.3-6.el10_0.noarch.rpm;name=aarch64_golang-github-protobuf-devel;unpack=0"
SRC_URI[aarch64_golang-github-protobuf-devel.sha256sum] = "e605baa1813a42e35fdeddefbf8381a4bdec54e3fc5386e7ccc5634b793b7517"

RDEPENDS:golang-github-protobuf-devel = " \
 go-filesystem \
 golang-google-protobuf-devel \
 "
