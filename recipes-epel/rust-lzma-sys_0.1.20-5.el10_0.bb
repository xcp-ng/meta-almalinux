# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lzma-sys"
PV = "0.1.20"
PR = "5.el10_0"
PACKAGES = " \
 rust-lzma-sys+default-devel \
 rust-lzma-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lzma-sys-0.1.20-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae58de606de74bcad52298159e6121cf7bf083b467b44f0e8ab4287d77162486"

URI_x86_64_v2_rust-lzma-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-sys+default-devel-0.1.20-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-sys+default-devel}"
SRC_URI[x86_64_v2_rust-lzma-sys+default-devel.sha256sum] = "56eaff1e795f053e2fe2774acd727246fc5bb23ba5f1f21c7679dd7607197ef8"

URI_x86_64_v2_rust-lzma-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-sys-devel-0.1.20-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lzma-sys-devel}"
SRC_URI[x86_64_v2_rust-lzma-sys-devel.sha256sum] = "77459f1a434192ca6ec7fecfccd2ab8ff1e382618a5e722072c4363509c8c942"

URI_aarch64_rust-lzma-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-sys+default-devel-0.1.20-5.el10_0.noarch.rpm;name=aarch64_rust-lzma-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-sys+default-devel}"
SRC_URI[aarch64_rust-lzma-sys+default-devel.sha256sum] = "e21bb8d38d488fdc6f25486c6a28e0254afbc27f3e7960dfe846a3bf7d387a5e"

URI_aarch64_rust-lzma-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-sys-devel-0.1.20-5.el10_0.noarch.rpm;name=aarch64_rust-lzma-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lzma-sys-devel}"
SRC_URI[aarch64_rust-lzma-sys-devel.sha256sum] = "16e16fcf083d16186af239d0a6fd620e77258f76e8bb9fd7522d5cf8c8a796bb"

RDEPENDS:rust-lzma-sys+default-devel = " \
 cargo \
 rust-lzma-sys-devel \
 "
RDEPENDS:rust-lzma-sys-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 xz-devel \
 "
