# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-version-sync"
PV = "0.9.5"
PR = "4.el10_0"
PACKAGES = " \
 rust-version-sync+contains_regex-devel \
 rust-version-sync+default-devel \
 rust-version-sync+html_root_url_updated-devel \
 rust-version-sync+markdown_deps_updated-devel \
 rust-version-sync+proc-macro2-devel \
 rust-version-sync+pulldown-cmark-devel \
 rust-version-sync+regex-devel \
 rust-version-sync+semver-devel \
 rust-version-sync+syn-devel \
 rust-version-sync+toml-devel \
 rust-version-sync+url-devel \
 rust-version-sync-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-version-sync-0.9.5-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d5bcd2eae58216359ff6a245c28c565e85f35470c08897f2f06f9a7fdb8fa65"

URI_x86_64_v2_rust-version-sync+contains_regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-sync+contains_regex-devel-0.9.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-sync+contains_regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-sync+contains_regex-devel}"
SRC_URI[x86_64_v2_rust-version-sync+contains_regex-devel.sha256sum] = "e9749b040909e2dd5878ec1ae7ed8716b1bddfb98efe3921fa240df8700b40dc"

URI_x86_64_v2_rust-version-sync+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-sync+default-devel-0.9.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-sync+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-sync+default-devel}"
SRC_URI[x86_64_v2_rust-version-sync+default-devel.sha256sum] = "48cd189339a22fea71c3d5f5305e8cb03bf73c592ff0f4afd4d337d7687d93ad"

URI_x86_64_v2_rust-version-sync+html_root_url_updated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-sync+html_root_url_updated-devel-0.9.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-sync+html_root_url_updated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-sync+html_root_url_updated-devel}"
SRC_URI[x86_64_v2_rust-version-sync+html_root_url_updated-devel.sha256sum] = "80a98ed0672578b400fb25d050a04af3ecb502379604dede63425061597923e9"

URI_x86_64_v2_rust-version-sync+markdown_deps_updated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-sync+markdown_deps_updated-devel-0.9.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-sync+markdown_deps_updated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-sync+markdown_deps_updated-devel}"
SRC_URI[x86_64_v2_rust-version-sync+markdown_deps_updated-devel.sha256sum] = "3a4aedc59e7f7d7cb98d9a5baf65ca87de85b383fb1cb263bae256928b0ffac3"

URI_x86_64_v2_rust-version-sync+proc-macro2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-sync+proc-macro2-devel-0.9.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-sync+proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-sync+proc-macro2-devel}"
SRC_URI[x86_64_v2_rust-version-sync+proc-macro2-devel.sha256sum] = "edd43718323d5baf9dece5f0b06d03b302edd5c31bedbfb9572320f54ad3fa00"

URI_x86_64_v2_rust-version-sync+pulldown-cmark-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-sync+pulldown-cmark-devel-0.9.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-sync+pulldown-cmark-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-sync+pulldown-cmark-devel}"
SRC_URI[x86_64_v2_rust-version-sync+pulldown-cmark-devel.sha256sum] = "61feef1f38880b23e723a0e073758c17a3e8f90ccdb142444f0c1d50b66d1c74"

URI_x86_64_v2_rust-version-sync+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-sync+regex-devel-0.9.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-sync+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-sync+regex-devel}"
SRC_URI[x86_64_v2_rust-version-sync+regex-devel.sha256sum] = "820d9ae968a8798bbed7ce32439895e6b65941929f8c0a8967cba0d063b58582"

URI_x86_64_v2_rust-version-sync+semver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-sync+semver-devel-0.9.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-sync+semver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-sync+semver-devel}"
SRC_URI[x86_64_v2_rust-version-sync+semver-devel.sha256sum] = "a4a893baab21ecef15d499327b0296eb7d6bfc972ac7277f9f8b60925b47b999"

URI_x86_64_v2_rust-version-sync+syn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-sync+syn-devel-0.9.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-sync+syn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-sync+syn-devel}"
SRC_URI[x86_64_v2_rust-version-sync+syn-devel.sha256sum] = "57818056d331dad98a7ee643676bcc8d3ce01aa71c89bdcd7a066b05bc4d06e3"

URI_x86_64_v2_rust-version-sync+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-sync+toml-devel-0.9.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-sync+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-sync+toml-devel}"
SRC_URI[x86_64_v2_rust-version-sync+toml-devel.sha256sum] = "5ed3ba4e227a105e3a2082548ee96fcdb9dd799b676837ac86bf3529a54913c3"

URI_x86_64_v2_rust-version-sync+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-sync+url-devel-0.9.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-sync+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-sync+url-devel}"
SRC_URI[x86_64_v2_rust-version-sync+url-devel.sha256sum] = "c1eb3026fb263343ab7e7c8e60feb39f807b78c0bd4c5ea269fcb4b4c9b980e4"

URI_x86_64_v2_rust-version-sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-sync-devel-0.9.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-sync-devel}"
SRC_URI[x86_64_v2_rust-version-sync-devel.sha256sum] = "3a4a32773e4684f00a31adbd3b3bee4612c505418bc5b3ec070c55a25756fca6"

URI_aarch64_rust-version-sync+contains_regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-sync+contains_regex-devel-0.9.5-4.el10_0.noarch.rpm;name=aarch64_rust-version-sync+contains_regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-sync+contains_regex-devel}"
SRC_URI[aarch64_rust-version-sync+contains_regex-devel.sha256sum] = "027ca968dbc6c81b2aa5d7faaa75b8d7d185f12e936876c29bb81028075ba673"

URI_aarch64_rust-version-sync+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-sync+default-devel-0.9.5-4.el10_0.noarch.rpm;name=aarch64_rust-version-sync+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-sync+default-devel}"
SRC_URI[aarch64_rust-version-sync+default-devel.sha256sum] = "35effc99a9b22d87f76e5356a9b8085ded266bf7d8866674aa51848c2b0cc567"

URI_aarch64_rust-version-sync+html_root_url_updated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-sync+html_root_url_updated-devel-0.9.5-4.el10_0.noarch.rpm;name=aarch64_rust-version-sync+html_root_url_updated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-sync+html_root_url_updated-devel}"
SRC_URI[aarch64_rust-version-sync+html_root_url_updated-devel.sha256sum] = "5d00858c751e4e43a7ed8f5c58bc6c5b4fcf91f94b65e0b0eed57d4eadd46cda"

URI_aarch64_rust-version-sync+markdown_deps_updated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-sync+markdown_deps_updated-devel-0.9.5-4.el10_0.noarch.rpm;name=aarch64_rust-version-sync+markdown_deps_updated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-sync+markdown_deps_updated-devel}"
SRC_URI[aarch64_rust-version-sync+markdown_deps_updated-devel.sha256sum] = "cc7acb82d730455979e96b26ae5ab4e950dc69b4580ada5f4f93e6523829af29"

URI_aarch64_rust-version-sync+proc-macro2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-sync+proc-macro2-devel-0.9.5-4.el10_0.noarch.rpm;name=aarch64_rust-version-sync+proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-sync+proc-macro2-devel}"
SRC_URI[aarch64_rust-version-sync+proc-macro2-devel.sha256sum] = "37b24e3e670f3a3e4bfaad52f706a2056fab9b76c39db9a1c98e592a3f19ec2a"

URI_aarch64_rust-version-sync+pulldown-cmark-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-sync+pulldown-cmark-devel-0.9.5-4.el10_0.noarch.rpm;name=aarch64_rust-version-sync+pulldown-cmark-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-sync+pulldown-cmark-devel}"
SRC_URI[aarch64_rust-version-sync+pulldown-cmark-devel.sha256sum] = "6184aa09bc8ae23da3970e3676661d2d82775a77b75e526a4bd7c0530c56f984"

URI_aarch64_rust-version-sync+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-sync+regex-devel-0.9.5-4.el10_0.noarch.rpm;name=aarch64_rust-version-sync+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-sync+regex-devel}"
SRC_URI[aarch64_rust-version-sync+regex-devel.sha256sum] = "89ec2a084cee78b2378790668426d44e28825bd9c513977d2721b7c39c68cc43"

URI_aarch64_rust-version-sync+semver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-sync+semver-devel-0.9.5-4.el10_0.noarch.rpm;name=aarch64_rust-version-sync+semver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-sync+semver-devel}"
SRC_URI[aarch64_rust-version-sync+semver-devel.sha256sum] = "9603624ab06f558bab38bdabdfb76905e1c93df1148fff7a0e95a4208acfc10d"

URI_aarch64_rust-version-sync+syn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-sync+syn-devel-0.9.5-4.el10_0.noarch.rpm;name=aarch64_rust-version-sync+syn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-sync+syn-devel}"
SRC_URI[aarch64_rust-version-sync+syn-devel.sha256sum] = "9c08f9e7f52abaa230d3f899a31ecd8599cf78ef249b1dfbc82df13529266b85"

URI_aarch64_rust-version-sync+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-sync+toml-devel-0.9.5-4.el10_0.noarch.rpm;name=aarch64_rust-version-sync+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-sync+toml-devel}"
SRC_URI[aarch64_rust-version-sync+toml-devel.sha256sum] = "a0739837f7cc41fa397483fff6be426b11cfb7111ae92d1ed0e652e718f5f65d"

URI_aarch64_rust-version-sync+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-sync+url-devel-0.9.5-4.el10_0.noarch.rpm;name=aarch64_rust-version-sync+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-sync+url-devel}"
SRC_URI[aarch64_rust-version-sync+url-devel.sha256sum] = "d4853606c8775182629545f42626a70b0bf5e98663231993f818766a456b867e"

URI_aarch64_rust-version-sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-sync-devel-0.9.5-4.el10_0.noarch.rpm;name=aarch64_rust-version-sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-sync-devel}"
SRC_URI[aarch64_rust-version-sync-devel.sha256sum] = "697dbbc3f04380214add635ae1cececf6ae54f4a201af74d947ec9e69d296dc7"

RDEPENDS:rust-version-sync+contains_regex-devel = " \
 cargo \
 rust-version-sync+regex-devel \
 rust-version-sync+semver-devel \
 rust-version-sync-devel \
 "
RDEPENDS:rust-version-sync+default-devel = " \
 cargo \
 rust-version-sync+contains_regex-devel \
 rust-version-sync+html_root_url_updated-devel \
 rust-version-sync+markdown_deps_updated-devel \
 rust-version-sync-devel \
 "
RDEPENDS:rust-version-sync+html_root_url_updated-devel = " \
 cargo \
 rust-version-sync+proc-macro2-devel \
 rust-version-sync+semver-devel \
 rust-version-sync+syn-devel \
 rust-version-sync+url-devel \
 rust-version-sync-devel \
 "
RDEPENDS:rust-version-sync+markdown_deps_updated-devel = " \
 cargo \
 rust-version-sync+pulldown-cmark-devel \
 rust-version-sync+semver-devel \
 rust-version-sync+toml-devel \
 rust-version-sync-devel \
 "
RDEPENDS:rust-version-sync+proc-macro2-devel = " \
 cargo \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 rust-version-sync-devel \
 "
RDEPENDS:rust-version-sync+pulldown-cmark-devel = " \
 cargo \
 rust-pulldown-cmark0.11-devel \
 rust-version-sync-devel \
 "
RDEPENDS:rust-version-sync+regex-devel = " \
 cargo \
 rust-regex+std-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 rust-version-sync-devel \
 "
RDEPENDS:rust-version-sync+semver-devel = " \
 cargo \
 rust-semver+default-devel \
 rust-version-sync-devel \
 "
RDEPENDS:rust-version-sync+syn-devel = " \
 cargo \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 rust-version-sync-devel \
 "
RDEPENDS:rust-version-sync+toml-devel = " \
 cargo \
 rust-toml0.8+default-devel \
 rust-version-sync-devel \
 "
RDEPENDS:rust-version-sync+url-devel = " \
 cargo \
 rust-url+default-devel \
 rust-version-sync-devel \
 "
RDEPENDS:rust-version-sync-devel = " \
 cargo \
 "
