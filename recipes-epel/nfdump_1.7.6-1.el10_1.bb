# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nfdump"
PV = "1.7.6"
PR = "1.el10_1"
PACKAGES = " \
 nfdump \
 nfdump-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nfdump-1.7.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "381ccadeb5ec4a9012770b71eb8791ce54cd0060db46d9b19704ed936ceec0fb"

URI_x86_64_v2_nfdump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nfdump-1.7.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nfdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfdump}"
SRC_URI[x86_64_v2_nfdump.sha256sum] = "a2565d87de30d05734ced8443f26ebf905ed7926e7f402afdeb5847f20ac3bd8"

URI_x86_64_v2_nfdump-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nfdump-libs-1.7.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nfdump-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfdump-libs}"
SRC_URI[x86_64_v2_nfdump-libs.sha256sum] = "9f71e61224870147ec85facf91d57c1498902354c548045342f1e55215f64814"

URI_aarch64_nfdump = "${EPEL_MIRROR}/aarch64/Packages/n/nfdump-1.7.6-1.el10_1.aarch64.rpm;name=aarch64_nfdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfdump}"
SRC_URI[aarch64_nfdump.sha256sum] = "4afc1058a5284a2593d67cde376d1a89e104013c53c936defd85fd072b57919a"

URI_aarch64_nfdump-libs = "${EPEL_MIRROR}/aarch64/Packages/n/nfdump-libs-1.7.6-1.el10_1.aarch64.rpm;name=aarch64_nfdump-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfdump-libs}"
SRC_URI[aarch64_nfdump-libs.sha256sum] = "19a1456e81e922ef39dd42c210732b0212e98b89a87d1a2838cd012e5708862b"

RDEPENDS:nfdump = " \
 glibc \
 libpcap \
 nfdump-libs \
 rrdtool \
 "
RDEPENDS:nfdump-libs:x86_64_v2 = " \
 bzip2-libs \
 glibc \
 libzstd \
 rrdtool \
"
RDEPENDS:nfdump-libs:aarch64 = " \
 bzip2-libs \
 glibc \
 libatomic \
 libzstd \
 rrdtool \
"
