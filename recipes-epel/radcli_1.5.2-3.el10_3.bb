# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radcli"
PV = "1.5.2"
PR = "3.el10_3"
PACKAGES = " \
 radcli \
 radcli-compat-devel \
 radcli-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/radcli-1.5.2-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aa349b2203330794e6a8256c1874e0a1fc8a9d4f19501c7cb62431f5298d025c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radcli-1.5.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_radcli;unpack=0"
SRC_URI[x86_64_v2_radcli.sha256sum] = "184f74ef2caf0c06db9eb8521d66a52c1db51d269cb52778de8e86794c969767"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radcli-compat-devel-1.5.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_radcli-compat-devel;unpack=0"
SRC_URI[x86_64_v2_radcli-compat-devel.sha256sum] = "07dde49d72fe63dc6c4a5e5e63ba480eda123d906fa0b9702377ec7c9d9a6d00"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radcli-devel-1.5.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_radcli-devel;unpack=0"
SRC_URI[x86_64_v2_radcli-devel.sha256sum] = "2cd63dadbe97ed2ffaa68e22f420cf19b7798b0aaf3925826a0a82bef7bc86c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/radcli-1.5.2-3.el10_3.aarch64.rpm;name=aarch64_radcli;unpack=0"
SRC_URI[aarch64_radcli.sha256sum] = "1c111d0bc1a80cc0d7bef1a077c722f772916451a1c0c881b3167dae08bd7882"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/radcli-compat-devel-1.5.2-3.el10_3.aarch64.rpm;name=aarch64_radcli-compat-devel;unpack=0"
SRC_URI[aarch64_radcli-compat-devel.sha256sum] = "83bbec28864b0ff9fd5d5d1211517cf6ea526b670124fc48fc828fa0abee159a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/radcli-devel-1.5.2-3.el10_3.aarch64.rpm;name=aarch64_radcli-devel;unpack=0"
SRC_URI[aarch64_radcli-devel.sha256sum] = "3601ff868a40f26911bbcb6a309843a514f84ad40fc4013016b5ede4009140a4"

RDEPENDS:radcli = " \
 glibc \
 gnutls \
 nettle \
 "
RDEPENDS:radcli-compat-devel = " \
 radcli-devel \
 "
RDEPENDS:radcli-devel = " \
 gnutls-devel \
 nettle-devel \
 pkgconf-pkg-config \
 radcli \
 "
