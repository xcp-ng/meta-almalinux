# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "extra-cmake-modules"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 extra-cmake-modules \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/extra-cmake-modules-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0422eb4c82ffa5246e15529716a94aa21361013f32ab743c018fa72a7b354c15"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/extra-cmake-modules-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_extra-cmake-modules;unpack=0"
SRC_URI[x86_64_v2_extra-cmake-modules.sha256sum] = "3d8f391340f1295cb802b821d82931d490e0d29756b6edf3e911d2af0f86bb54"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/extra-cmake-modules-6.30.0-1.el10_3.noarch.rpm;name=aarch64_extra-cmake-modules;unpack=0"
SRC_URI[aarch64_extra-cmake-modules.sha256sum] = "adebb412e00d2319329f1d528699af4698b9aa93b6d0dedbc53be49c67470f4c"

RDEPENDS:extra-cmake-modules = " \
 bash \
 kf6-rpm-macros \
 python3 \
 "
