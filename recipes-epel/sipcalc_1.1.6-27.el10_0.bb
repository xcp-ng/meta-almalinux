# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sipcalc"
PV = "1.1.6"
PR = "27.el10_0"
PACKAGES = " \
 sipcalc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sipcalc-1.1.6-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5e0472c5c70bdf1e65286581caf97b0fad5adfcdb5ccdfd12a6fb786a0a24902"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sipcalc-1.1.6-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sipcalc;unpack=0"
SRC_URI[x86_64_v2_sipcalc.sha256sum] = "62cc3c5c34a5f60560bc41cf4f09983b3651cf80073c4ea9e99dd75aa558c255"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sipcalc-1.1.6-27.el10_0.aarch64.rpm;name=aarch64_sipcalc;unpack=0"
SRC_URI[aarch64_sipcalc.sha256sum] = "2bb93241ef3eca2b8d36009c78d97a2ce1a0c70db433e08aa6cd773fe8039f06"

RDEPENDS:sipcalc = " \
 glibc \
 "
