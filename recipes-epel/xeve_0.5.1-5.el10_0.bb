# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xeve"
PV = "0.5.1"
PR = "5.el10_0"
PACKAGES = " \
 xeve \
 xeve-devel \
 xeve-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xeve-0.5.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb66ec63841aec7ea1a86fa48a1c230ba3883afbd7d7bc1e9d62c51e57670507"

URI_x86_64_v2_xeve = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xeve-0.5.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xeve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xeve}"
SRC_URI[x86_64_v2_xeve.sha256sum] = "b7588605ef4823cc9be663788ec4442f3c4bfe593f13fdbe721996f1187339ff"

URI_x86_64_v2_xeve-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xeve-devel-0.5.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xeve-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xeve-devel}"
SRC_URI[x86_64_v2_xeve-devel.sha256sum] = "745b68773ba828855b5d0c73cc92b34d17604be836dc9e99fac2378f57839940"

URI_x86_64_v2_xeve-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xeve-libs-0.5.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xeve-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xeve-libs}"
SRC_URI[x86_64_v2_xeve-libs.sha256sum] = "ec00ffcd4739faf46bb51dfdee07aef977aa602aaccdc8e87ce8e2fb667b4425"

URI_aarch64_xeve = "${EPEL_MIRROR}/aarch64/Packages/x/xeve-0.5.1-5.el10_0.aarch64.rpm;name=aarch64_xeve;unpack=0"
SRC_URI:append = " ${URI_aarch64_xeve}"
SRC_URI[aarch64_xeve.sha256sum] = "d5ff967565d1b15a5fbbe97c47e279450aad0edb3c6f8f09183af2ad01d759b3"

URI_aarch64_xeve-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xeve-devel-0.5.1-5.el10_0.aarch64.rpm;name=aarch64_xeve-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xeve-devel}"
SRC_URI[aarch64_xeve-devel.sha256sum] = "2f50ac2147d757b2e2584b3e0d5f70f69d926b525edf5e7b2a48d667354a91f2"

URI_aarch64_xeve-libs = "${EPEL_MIRROR}/aarch64/Packages/x/xeve-libs-0.5.1-5.el10_0.aarch64.rpm;name=aarch64_xeve-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xeve-libs}"
SRC_URI[aarch64_xeve-libs.sha256sum] = "bd120d8846b936facb01a6f19869434cc1ba52e50d75064dc94301290b36ef44"

RDEPENDS:xeve = " \
 glibc \
 xeve-libs \
 "
RDEPENDS:xeve-devel = " \
 pkgconf-pkg-config \
 xeve-libs \
 "
RDEPENDS:xeve-libs = " \
 glibc \
 "
