# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust-embed-utils"
PV = "8.7.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-rust-embed-utils+debug-embed-devel \
 rust-rust-embed-utils+default-devel \
 rust-rust-embed-utils+globset-devel \
 rust-rust-embed-utils+include-exclude-devel \
 rust-rust-embed-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust-embed-utils-8.7.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df32f9a1f8ddf27bbe36740a91a6460c05038307cc25eca9ee22b35429398675"

URI_x86_64_v2_rust-rust-embed-utils+debug-embed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-utils+debug-embed-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-utils+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-utils+debug-embed-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-utils+debug-embed-devel.sha256sum] = "d323a2a7be873884166a07da6a926eb150a5c3211d2db77e32f24b04aef473a6"

URI_x86_64_v2_rust-rust-embed-utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-utils+default-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-utils+default-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-utils+default-devel.sha256sum] = "ac7f14ff1e5148c1237771610346f460b70710e98c165aae8c4c73025973d4e3"

URI_x86_64_v2_rust-rust-embed-utils+globset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-utils+globset-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-utils+globset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-utils+globset-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-utils+globset-devel.sha256sum] = "49d728a848cc4bb061c5da5bb0c1fc1dc8a4a6d59914e2238758a56c4fe504ea"

URI_x86_64_v2_rust-rust-embed-utils+include-exclude-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-utils+include-exclude-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-utils+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-utils+include-exclude-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-utils+include-exclude-devel.sha256sum] = "8004dc998d7e5252c02e33f274f26a20553f45e10400088d72d67b73c0bc2098"

URI_x86_64_v2_rust-rust-embed-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-utils-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-utils-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-utils-devel.sha256sum] = "d9739938581584dd139d0bdc4962d182eda1567866c31ae93695a19f4bf0e646"

URI_aarch64_rust-rust-embed-utils+debug-embed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-utils+debug-embed-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed-utils+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-utils+debug-embed-devel}"
SRC_URI[aarch64_rust-rust-embed-utils+debug-embed-devel.sha256sum] = "19a96903e9c82c312f3cf0e65ba286ea741ae0274028e07af2eaeac3f9b3978d"

URI_aarch64_rust-rust-embed-utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-utils+default-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-utils+default-devel}"
SRC_URI[aarch64_rust-rust-embed-utils+default-devel.sha256sum] = "a2cf3c8f3e07d08b287ff3967ca7f6884945cfc8735b021e3f7d200fc3158038"

URI_aarch64_rust-rust-embed-utils+globset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-utils+globset-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed-utils+globset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-utils+globset-devel}"
SRC_URI[aarch64_rust-rust-embed-utils+globset-devel.sha256sum] = "edf4a6f6b996070977861335ab2692a9db0359c821d8ae0d7f5d0fd841c20ad9"

URI_aarch64_rust-rust-embed-utils+include-exclude-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-utils+include-exclude-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed-utils+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-utils+include-exclude-devel}"
SRC_URI[aarch64_rust-rust-embed-utils+include-exclude-devel.sha256sum] = "50db8e778abce16e36b063df473cbf78d1dd6ad37e022b7b3b37521b4eaff317"

URI_aarch64_rust-rust-embed-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-utils-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-utils-devel}"
SRC_URI[aarch64_rust-rust-embed-utils-devel.sha256sum] = "c7ae59c7947decd1e23713e07ff2ccb797f24795a635b2df116fd8e0b5dd73ec"

RDEPENDS:rust-rust-embed-utils+debug-embed-devel = " \
 cargo \
 rust-rust-embed-utils-devel \
 "
RDEPENDS:rust-rust-embed-utils+default-devel = " \
 cargo \
 rust-rust-embed-utils-devel \
 "
RDEPENDS:rust-rust-embed-utils+globset-devel = " \
 cargo \
 rust-globset+default-devel \
 rust-rust-embed-utils-devel \
 "
RDEPENDS:rust-rust-embed-utils+include-exclude-devel = " \
 cargo \
 rust-rust-embed-utils+globset-devel \
 rust-rust-embed-utils-devel \
 "
RDEPENDS:rust-rust-embed-utils-devel = " \
 cargo \
 rust-sha2+default-devel \
 rust-walkdir+default-devel \
 "
