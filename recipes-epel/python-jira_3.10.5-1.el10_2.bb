# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jira"
PV = "3.10.5"
PR = "1.el10_2"
PACKAGES = " \
 jirashell \
 python3-jira \
 python3-jira+async \
 python3-jira+cli \
 python3-jira+docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jira-3.10.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6aed0f4142d46a1e7643cddebd1021dd8bf66ae3de7620f35afd534cf73948a"

URI_x86_64_v2_jirashell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jirashell-3.10.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_jirashell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jirashell}"
SRC_URI[x86_64_v2_jirashell.sha256sum] = "de5d7b85f57b9330ed39c7c46e98cc97e4925a5105a9624410c6560affb57083"

URI_x86_64_v2_python3-jira = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jira-3.10.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jira;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jira}"
SRC_URI[x86_64_v2_python3-jira.sha256sum] = "95180e3185b3b13fe5ec7c4fd311222f0aa72784be67c3aa94c8a71ac0e3f6d4"

URI_x86_64_v2_python3-jira+async = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jira+async-3.10.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jira+async;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jira+async}"
SRC_URI[x86_64_v2_python3-jira+async.sha256sum] = "f86c9337f2517b06a2b9c3cc6ed5f7701f0f83ef4b8e0cbe1adeed5a8efbfebc"

URI_x86_64_v2_python3-jira+cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jira+cli-3.10.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jira+cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jira+cli}"
SRC_URI[x86_64_v2_python3-jira+cli.sha256sum] = "909d0986af2ac3a2a5fac42bc572c10512f978644d52795f39a6da668be9ff66"

URI_x86_64_v2_python3-jira+docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jira+docs-3.10.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jira+docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jira+docs}"
SRC_URI[x86_64_v2_python3-jira+docs.sha256sum] = "44bc5a71c9686c3f906e14b55fa88eed081c82e74e3cc52b588a2b6c2fdc9a09"

URI_aarch64_jirashell = "${EPEL_MIRROR}/aarch64/Packages/j/jirashell-3.10.5-1.el10_2.noarch.rpm;name=aarch64_jirashell;unpack=0"
SRC_URI:append = " ${URI_aarch64_jirashell}"
SRC_URI[aarch64_jirashell.sha256sum] = "39c8c0cb8850eec6e54a1c86d416f931d45bf9bf9bfa28c46715023e0a16a069"

URI_aarch64_python3-jira = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jira-3.10.5-1.el10_2.noarch.rpm;name=aarch64_python3-jira;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jira}"
SRC_URI[aarch64_python3-jira.sha256sum] = "c2c1afa6a547ecb971f7fb59a2673b45aeeb86db5e0417a054853b2570c54ce2"

URI_aarch64_python3-jira+async = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jira+async-3.10.5-1.el10_2.noarch.rpm;name=aarch64_python3-jira+async;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jira+async}"
SRC_URI[aarch64_python3-jira+async.sha256sum] = "970a949370605d83e7ff021a6f96e24343b2fe29624b81f1f87249afdbc5954e"

URI_aarch64_python3-jira+cli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jira+cli-3.10.5-1.el10_2.noarch.rpm;name=aarch64_python3-jira+cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jira+cli}"
SRC_URI[aarch64_python3-jira+cli.sha256sum] = "1398ffca65a0d0037eb0365fa2f17e732ea7b28718202143a6f2f1762d108894"

URI_aarch64_python3-jira+docs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jira+docs-3.10.5-1.el10_2.noarch.rpm;name=aarch64_python3-jira+docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jira+docs}"
SRC_URI[aarch64_python3-jira+docs.sha256sum] = "d3bae575e836589e99f4873304349f1fef3fa82d0e60c395383b48f2e0bddca1"

RDEPENDS:jirashell = " \
 python3 \
 python3-ipython \
 python3-jira \
 python3-keyring \
 "
RDEPENDS:python3-jira = " \
 python3 \
 python3-defusedxml \
 python3-packaging \
 python3-requests \
 python3-requests-oauthlib \
 python3-requests-toolbelt \
 python3-typing-extensions \
 "
RDEPENDS:python3-jira+async = " \
 python3 \
 python3-jira \
 python3-requests-futures \
 "
RDEPENDS:python3-jira+cli = " \
 python3 \
 python3-ipython \
 python3-jira \
 python3-keyring \
 "
RDEPENDS:python3-jira+docs = " \
 python3 \
 python3-furo \
 python3-jira \
 python3-sphinx \
 python3-sphinx-copybutton \
 "
