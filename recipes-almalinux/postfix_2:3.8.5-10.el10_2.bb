# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postfix"
PE = "2"
PV = "3.8.5"
PR = "10.el10_2"
PACKAGES = " \
 postfix \
 postfix-cdb \
 postfix-ldap \
 postfix-lmdb \
 postfix-mysql \
 postfix-pcre \
 postfix-perl-scripts \
 postfix-pgsql \
 postfix-sqlite \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postfix-3.8.5-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a62415209f86d2d033e40ee8c90f98e8372ff1b9df96ebe5635d3d2b4299182d"

URI_x86_64_v2_postfix = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-3.8.5-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_postfix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix}"
SRC_URI[x86_64_v2_postfix.sha256sum] = "140fc51d32189a003ee919f901d7d2601ace8c37c9ee08162e3e9dc058db8c5e"
RPROVIDES:postfix:x86_64_v2 = "virtual//usr/bin/mailq virtual//usr/sbin/sendmail virtual/smtpdaemon"

URI_x86_64_v2_postfix-cdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-cdb-3.8.5-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_postfix-cdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-cdb}"
SRC_URI[x86_64_v2_postfix-cdb.sha256sum] = "21efadc6f1b9da65bff6c51474be2fe87c4b6f532e13d4622ddb519511a74987"

URI_x86_64_v2_postfix-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-ldap-3.8.5-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_postfix-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-ldap}"
SRC_URI[x86_64_v2_postfix-ldap.sha256sum] = "a5688e90c6e0fb08b6ade2e5558e325729d4a7b0d867f48bac71ff209f7061a9"

URI_x86_64_v2_postfix-lmdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-lmdb-3.8.5-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_postfix-lmdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-lmdb}"
SRC_URI[x86_64_v2_postfix-lmdb.sha256sum] = "2503908238192a2a36ddfe3902427b1a4efa7e5c5eb0e3dbe4a7ce8c125124fb"

URI_x86_64_v2_postfix-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-mysql-3.8.5-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_postfix-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-mysql}"
SRC_URI[x86_64_v2_postfix-mysql.sha256sum] = "b5221aba9850c298b89530c072f8361cf9f8413fe54c76f014636ce0309a62e6"

URI_x86_64_v2_postfix-pcre = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-pcre-3.8.5-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_postfix-pcre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-pcre}"
SRC_URI[x86_64_v2_postfix-pcre.sha256sum] = "ab6c2f5868c62eb19109c1004a88c5d5ac831a83101ed9314d8ccd0dc8350178"

URI_x86_64_v2_postfix-perl-scripts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-perl-scripts-3.8.5-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_postfix-perl-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-perl-scripts}"
SRC_URI[x86_64_v2_postfix-perl-scripts.sha256sum] = "974c3218bde0323f099914ea73de7f09a1c9424375c31b799abc92fb7715bca1"

URI_x86_64_v2_postfix-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-pgsql-3.8.5-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_postfix-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-pgsql}"
SRC_URI[x86_64_v2_postfix-pgsql.sha256sum] = "6c21b2395db85876eff9b1cb53735c693a7ef634a888d0d3c1ba0ed5ac6274ae"

URI_x86_64_v2_postfix-sqlite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-sqlite-3.8.5-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_postfix-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-sqlite}"
SRC_URI[x86_64_v2_postfix-sqlite.sha256sum] = "6c7f55a30eaf66530887e3ae8fc3f44e44899dceeda40ddeeaa536bc9ef0bfbb"

URI_aarch64_postfix = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-3.8.5-10.el10_2.aarch64.rpm;name=aarch64_postfix;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix}"
SRC_URI[aarch64_postfix.sha256sum] = "9a85eb84e6cc0c07655f06f95510b8ecc413e1facb10d3b65e38ca5a441a1cd2"
RPROVIDES:postfix:aarch64 = "virtual//usr/bin/mailq virtual//usr/sbin/sendmail virtual/smtpdaemon"

URI_aarch64_postfix-cdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-cdb-3.8.5-10.el10_2.aarch64.rpm;name=aarch64_postfix-cdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-cdb}"
SRC_URI[aarch64_postfix-cdb.sha256sum] = "291cfa30e369b785e715c6161a80474da27c4d20b186bc5bc0f150ff43deb99c"

URI_aarch64_postfix-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-ldap-3.8.5-10.el10_2.aarch64.rpm;name=aarch64_postfix-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-ldap}"
SRC_URI[aarch64_postfix-ldap.sha256sum] = "801d485c45585aab0cd6c4319e25c9fe37aaffc10b582dd9b285f63f7f16b0d6"

URI_aarch64_postfix-lmdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-lmdb-3.8.5-10.el10_2.aarch64.rpm;name=aarch64_postfix-lmdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-lmdb}"
SRC_URI[aarch64_postfix-lmdb.sha256sum] = "9d29901080e7bbed967dd3cf36958d80114774a1e5fdc2b69446ed34714a1454"

URI_aarch64_postfix-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-mysql-3.8.5-10.el10_2.aarch64.rpm;name=aarch64_postfix-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-mysql}"
SRC_URI[aarch64_postfix-mysql.sha256sum] = "ccdcdae0e1f879fab6c4fd5cabefc7d2754dda1278e273c17994b49a0a192c06"

URI_aarch64_postfix-pcre = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-pcre-3.8.5-10.el10_2.aarch64.rpm;name=aarch64_postfix-pcre;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-pcre}"
SRC_URI[aarch64_postfix-pcre.sha256sum] = "e001106e395eb19bfb6e16c96c64236d88343f6b8d8b1b73149ed2a5fad33690"

URI_aarch64_postfix-perl-scripts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-perl-scripts-3.8.5-10.el10_2.aarch64.rpm;name=aarch64_postfix-perl-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-perl-scripts}"
SRC_URI[aarch64_postfix-perl-scripts.sha256sum] = "4f1d986d093e12137f7e34b16d48f254464b7cebf08a340bbdbbaee5f65bc659"

URI_aarch64_postfix-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-pgsql-3.8.5-10.el10_2.aarch64.rpm;name=aarch64_postfix-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-pgsql}"
SRC_URI[aarch64_postfix-pgsql.sha256sum] = "413703f81ddfa9f7507a8d74a90bbb4b24ce00e1f32c5d016ec3fdbdefe7a45f"

URI_aarch64_postfix-sqlite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-sqlite-3.8.5-10.el10_2.aarch64.rpm;name=aarch64_postfix-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-sqlite}"
SRC_URI[aarch64_postfix-sqlite.sha256sum] = "53713fcd00d1c27c3478ddbe1665c1cfbfe75d3b96d8957004774a6000d5de6f"

RDEPENDS:postfix = " \
 alternatives \
 bash \
 cyrus-sasl-lib \
 diffutils \
 findutils \
 glibc \
 hostname \
 libicu \
 openssl \
 openssl-libs \
 policycoreutils \
 postfix-lmdb \
 systemd \
 "
RDEPENDS:postfix-cdb = " \
 glibc \
 postfix \
 tinycdb \
 "
RDEPENDS:postfix-ldap = " \
 glibc \
 openldap \
 postfix \
 "
RDEPENDS:postfix-lmdb = " \
 glibc \
 lmdb-libs \
 postfix \
 "
RDEPENDS:postfix-mysql = " \
 glibc \
 mariadb-connector-c \
 postfix \
 "
RDEPENDS:postfix-pcre = " \
 glibc \
 pcre2 \
 postfix \
 "
RDEPENDS:postfix-perl-scripts = " \
 perl-Date-Calc \
 perl-File-Find \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-interpreter \
 perl-libs \
 perl-locale \
 perl-vars \
 postfix \
 "
RDEPENDS:postfix-pgsql = " \
 glibc \
 libpq \
 postfix \
 "
RDEPENDS:postfix-sqlite = " \
 glibc \
 postfix \
 sqlite-libs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/mailq rpm/virtual//usr/sbin/sendmail rpm/virtual/smtpdaemon"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/mailq rpm/virtual//usr/sbin/sendmail rpm/virtual/smtpdaemon"
