# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest0.12"
PV = "0.12.28"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqwest0.12+__rustls-devel \
 rust-reqwest0.12+__rustls-ring-devel \
 rust-reqwest0.12+__tls-devel \
 rust-reqwest0.12+blocking-devel \
 rust-reqwest0.12+brotli-devel \
 rust-reqwest0.12+charset-devel \
 rust-reqwest0.12+cookies-devel \
 rust-reqwest0.12+default-devel \
 rust-reqwest0.12+default-tls-devel \
 rust-reqwest0.12+deflate-devel \
 rust-reqwest0.12+gzip-devel \
 rust-reqwest0.12+h2-devel \
 rust-reqwest0.12+hickory-dns-devel \
 rust-reqwest0.12+http2-devel \
 rust-reqwest0.12+json-devel \
 rust-reqwest0.12+multipart-devel \
 rust-reqwest0.12+native-tls-alpn-devel \
 rust-reqwest0.12+native-tls-devel \
 rust-reqwest0.12+rustls-tls-devel \
 rust-reqwest0.12+rustls-tls-manual-roots-devel \
 rust-reqwest0.12+rustls-tls-manual-roots-no-provider-devel \
 rust-reqwest0.12+rustls-tls-native-roots-devel \
 rust-reqwest0.12+rustls-tls-native-roots-no-provider-devel \
 rust-reqwest0.12+rustls-tls-no-provider-devel \
 rust-reqwest0.12+rustls-tls-webpki-roots-devel \
 rust-reqwest0.12+rustls-tls-webpki-roots-no-provider-devel \
 rust-reqwest0.12+socks-devel \
 rust-reqwest0.12+stream-devel \
 rust-reqwest0.12+system-proxy-devel \
 rust-reqwest0.12+trust-dns-devel \
 rust-reqwest0.12+zstd-devel \
 rust-reqwest0.12-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest0.12-0.12.28-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6373e316fe3a7120610f133c3257b088b8710ec42ac2292362bf79519fbaddca"

URI_x86_64_v2_rust-reqwest0.12+__rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+__rustls-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+__rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+__rustls-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+__rustls-devel.sha256sum] = "846fa56f01b123ff48eb2a211f86540fbc323c16b9a3848f9e69ea1826a95be2"

URI_x86_64_v2_rust-reqwest0.12+__rustls-ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+__rustls-ring-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+__rustls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+__rustls-ring-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+__rustls-ring-devel.sha256sum] = "c73fb611592c101e879d5f9555e3c279cefa30c3fccba88b180cd45e22e3f0f3"

URI_x86_64_v2_rust-reqwest0.12+__tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+__tls-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+__tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+__tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+__tls-devel.sha256sum] = "9c69e34d7e5ab1720997cda8e2e4fc58ea2428708c613274b4121bc861144380"

URI_x86_64_v2_rust-reqwest0.12+blocking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+blocking-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+blocking-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+blocking-devel.sha256sum] = "3abb72431cc9f3a4aeaec4c241337b8d986898dd4eaf9084086e3263bbc56113"

URI_x86_64_v2_rust-reqwest0.12+brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+brotli-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+brotli-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+brotli-devel.sha256sum] = "5054f618708358a946ef0286bb68c8f049c9b42d7b632e330abbd254346dca8f"

URI_x86_64_v2_rust-reqwest0.12+charset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+charset-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+charset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+charset-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+charset-devel.sha256sum] = "82569f591a7aa8242d34e20546f176e0782ae39a384100dc2e115077f7eac962"

URI_x86_64_v2_rust-reqwest0.12+cookies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+cookies-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+cookies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+cookies-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+cookies-devel.sha256sum] = "171cda74d3d1d931e1ecc4d33249bb610492c37f66a77a1aec6982e9ddca14bd"

URI_x86_64_v2_rust-reqwest0.12+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+default-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+default-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+default-devel.sha256sum] = "4945c769a7015bfa7c8c98980438487a58e1dd54480f9b4c1e9b268a834738b6"

URI_x86_64_v2_rust-reqwest0.12+default-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+default-tls-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+default-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+default-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+default-tls-devel.sha256sum] = "92c149af8994d07db160b06b177db8b6825b7c770972ab3de59f957770dd11ed"

URI_x86_64_v2_rust-reqwest0.12+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+deflate-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+deflate-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+deflate-devel.sha256sum] = "25ed8aafb9fd0d64545ffd35084080e2a7da8c85b720edf576442f0d7be920a4"

URI_x86_64_v2_rust-reqwest0.12+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+gzip-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+gzip-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+gzip-devel.sha256sum] = "d683b351a2df4c90fb1c219da1ff6f0e6a41ed8164b9676b694a33781fdc3cd5"

URI_x86_64_v2_rust-reqwest0.12+h2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+h2-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+h2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+h2-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+h2-devel.sha256sum] = "afeb6b3bda0a66d55d1672f4f3b08feb9d24b9e50f0a8419fe2f7e09efb0d13a"

URI_x86_64_v2_rust-reqwest0.12+hickory-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+hickory-dns-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+hickory-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+hickory-dns-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+hickory-dns-devel.sha256sum] = "6daa49eb06a577419783b5a6f13e7e3e6f1f61fdc6cfebac50a2d386e5c624fc"

URI_x86_64_v2_rust-reqwest0.12+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+http2-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+http2-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+http2-devel.sha256sum] = "66d443dac34c3991c232850485faabf0ae367a7dc2a849c9a8ebbd79d7d050d8"

URI_x86_64_v2_rust-reqwest0.12+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+json-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+json-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+json-devel.sha256sum] = "1a8ad84c42a4da02206315ea8edbde9cc25bb71e5eb211ea9e501329c36f58d4"

URI_x86_64_v2_rust-reqwest0.12+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+multipart-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+multipart-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+multipart-devel.sha256sum] = "ed32003431911306756fa0ea1ab096796fc91cd8c9cacd54f3a280032c324196"

URI_x86_64_v2_rust-reqwest0.12+native-tls-alpn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+native-tls-alpn-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+native-tls-alpn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+native-tls-alpn-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+native-tls-alpn-devel.sha256sum] = "65b55df7e40d3eca11bd625f5a6a6d37c104c77d3fc3809ddc00d93b39c51fe7"

URI_x86_64_v2_rust-reqwest0.12+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+native-tls-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+native-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+native-tls-devel.sha256sum] = "3a2490fb778074f21f71cdb30c08d62064a9f7547fac0ca3d954dbdfba39185e"

URI_x86_64_v2_rust-reqwest0.12+rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+rustls-tls-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+rustls-tls-devel.sha256sum] = "d562738a382c5c99e6a93ed70693009014ad4d6c441044a8d596b424d8dfbeb3"

URI_x86_64_v2_rust-reqwest0.12+rustls-tls-manual-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+rustls-tls-manual-roots-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+rustls-tls-manual-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+rustls-tls-manual-roots-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+rustls-tls-manual-roots-devel.sha256sum] = "91ba046017751a96726a301de63e8d2a501ed397e7cee1e3728c061402b907c7"

URI_x86_64_v2_rust-reqwest0.12+rustls-tls-manual-roots-no-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+rustls-tls-manual-roots-no-provider-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+rustls-tls-manual-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+rustls-tls-manual-roots-no-provider-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+rustls-tls-manual-roots-no-provider-devel.sha256sum] = "b5e1e59ab11249e51c7a59c4f510c4b11a1b6ed6f3349e142a8348be0dd5c89f"

URI_x86_64_v2_rust-reqwest0.12+rustls-tls-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+rustls-tls-native-roots-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+rustls-tls-native-roots-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+rustls-tls-native-roots-devel.sha256sum] = "005ac157bfb4b5cf0751bc33dc064efc7b61db799d3a6ce19cbcbc03e03589e0"

URI_x86_64_v2_rust-reqwest0.12+rustls-tls-native-roots-no-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+rustls-tls-native-roots-no-provider-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+rustls-tls-native-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+rustls-tls-native-roots-no-provider-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+rustls-tls-native-roots-no-provider-devel.sha256sum] = "ac8d6357b300bb6c23e85e95d8155183c43732e933f700a92ba9a8093f1d8290"

URI_x86_64_v2_rust-reqwest0.12+rustls-tls-no-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+rustls-tls-no-provider-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+rustls-tls-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+rustls-tls-no-provider-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+rustls-tls-no-provider-devel.sha256sum] = "20d25317a674fa5e38fbd40f52887e02dea718c62e04b13e5f86d0577652c670"

URI_x86_64_v2_rust-reqwest0.12+rustls-tls-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+rustls-tls-webpki-roots-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+rustls-tls-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+rustls-tls-webpki-roots-devel.sha256sum] = "d4e99c1921d77a48a12a19eecd19bcd784a1e795566fc85d2c1c606bc96ba214"

URI_x86_64_v2_rust-reqwest0.12+rustls-tls-webpki-roots-no-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+rustls-tls-webpki-roots-no-provider-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+rustls-tls-webpki-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+rustls-tls-webpki-roots-no-provider-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+rustls-tls-webpki-roots-no-provider-devel.sha256sum] = "a4477d8052a4c3affa2bb08d90dfd8e419e423b9878c835e84b5c28cb0834e69"

URI_x86_64_v2_rust-reqwest0.12+socks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+socks-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+socks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+socks-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+socks-devel.sha256sum] = "281f7639408b6b3d89edf3080fa1017003d83cbbf9da0303c9d381e8ffcbabbf"

URI_x86_64_v2_rust-reqwest0.12+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+stream-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+stream-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+stream-devel.sha256sum] = "da14a41f7db143757750a3044430f2ff88bfc179768290ac67874b88ee43552f"

URI_x86_64_v2_rust-reqwest0.12+system-proxy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+system-proxy-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+system-proxy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+system-proxy-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+system-proxy-devel.sha256sum] = "53abd51d0383bc4cd432a85c588a3e9936b8e409a4aa45aaca17374e4c42c8dd"

URI_x86_64_v2_rust-reqwest0.12+trust-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+trust-dns-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+trust-dns-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+trust-dns-devel.sha256sum] = "f3eae61ad5342722e9710670637bf7dde7cb0fb039a0c53986db96864c2977ad"

URI_x86_64_v2_rust-reqwest0.12+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12+zstd-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12+zstd-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12+zstd-devel.sha256sum] = "72b4c98f4637eb60c6957cedb32bf66742cd54fbbb14cbd00e5fb8771de40bf0"

URI_x86_64_v2_rust-reqwest0.12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest0.12-devel-0.12.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest0.12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest0.12-devel}"
SRC_URI[x86_64_v2_rust-reqwest0.12-devel.sha256sum] = "579e5e802c90ecb22bba4fbf4ca4309432cb59c25857d00b4e73fcd6a8305f5e"

URI_aarch64_rust-reqwest0.12+__rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+__rustls-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+__rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+__rustls-devel}"
SRC_URI[aarch64_rust-reqwest0.12+__rustls-devel.sha256sum] = "c08a1fefc9d039e7b90d66810c9fb5850f454522f4d9c86e5fd41af7c6cee346"

URI_aarch64_rust-reqwest0.12+__rustls-ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+__rustls-ring-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+__rustls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+__rustls-ring-devel}"
SRC_URI[aarch64_rust-reqwest0.12+__rustls-ring-devel.sha256sum] = "d328cd9e33874375a5d34f4084c94d237907f3dae0a22d99624b17ffedd6f613"

URI_aarch64_rust-reqwest0.12+__tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+__tls-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+__tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+__tls-devel}"
SRC_URI[aarch64_rust-reqwest0.12+__tls-devel.sha256sum] = "4f5758a8c7020fd79a6fa9424928ee0bef8aa6181e69bc596c3b9cb9b170a6e4"

URI_aarch64_rust-reqwest0.12+blocking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+blocking-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+blocking-devel}"
SRC_URI[aarch64_rust-reqwest0.12+blocking-devel.sha256sum] = "61237d08857c402c5d0a92fcd799480e8a1872d6e12ebfde1ed3729482e1e0de"

URI_aarch64_rust-reqwest0.12+brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+brotli-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+brotli-devel}"
SRC_URI[aarch64_rust-reqwest0.12+brotli-devel.sha256sum] = "eba1d8526ecc0572ce4cf5ced8fcc4fdaa3894b387ef94ea6cfc06a1a7e03756"

URI_aarch64_rust-reqwest0.12+charset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+charset-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+charset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+charset-devel}"
SRC_URI[aarch64_rust-reqwest0.12+charset-devel.sha256sum] = "c17b232cd6e74c49b9702b51368a90f1d3bc4f322ef3afa5126207d33eceebc1"

URI_aarch64_rust-reqwest0.12+cookies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+cookies-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+cookies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+cookies-devel}"
SRC_URI[aarch64_rust-reqwest0.12+cookies-devel.sha256sum] = "87aefb91f2c1390d55b43e5ae34c7365a871b10f6193f2c5c4b6c42c9febafab"

URI_aarch64_rust-reqwest0.12+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+default-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+default-devel}"
SRC_URI[aarch64_rust-reqwest0.12+default-devel.sha256sum] = "2dead78949ff7a5f839269efa0cdea70e2b1f591d6c3458ebc1bf0b04dca8682"

URI_aarch64_rust-reqwest0.12+default-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+default-tls-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+default-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+default-tls-devel}"
SRC_URI[aarch64_rust-reqwest0.12+default-tls-devel.sha256sum] = "01541e4de2e38191b19f92984ef5acdcb29cba0c32c22992bea54272cfd55880"

URI_aarch64_rust-reqwest0.12+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+deflate-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+deflate-devel}"
SRC_URI[aarch64_rust-reqwest0.12+deflate-devel.sha256sum] = "d076bb9841d1801e43d79436f5d8a528d481728a0d42c380dc76192f350931fa"

URI_aarch64_rust-reqwest0.12+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+gzip-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+gzip-devel}"
SRC_URI[aarch64_rust-reqwest0.12+gzip-devel.sha256sum] = "a453e9be83dfb40b627ec04b248f5a61d41cc5131002edd737c21c2bf0201f1f"

URI_aarch64_rust-reqwest0.12+h2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+h2-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+h2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+h2-devel}"
SRC_URI[aarch64_rust-reqwest0.12+h2-devel.sha256sum] = "1723132599440b7e1b688d24552a2c7f313fbde22bf3d3a6f45a7a671e073d2c"

URI_aarch64_rust-reqwest0.12+hickory-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+hickory-dns-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+hickory-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+hickory-dns-devel}"
SRC_URI[aarch64_rust-reqwest0.12+hickory-dns-devel.sha256sum] = "07df03e60eebd7065b5b5b00701adc151ad0ccbe447be101459c99d967511faa"

URI_aarch64_rust-reqwest0.12+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+http2-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+http2-devel}"
SRC_URI[aarch64_rust-reqwest0.12+http2-devel.sha256sum] = "1a0689c074ca892c69e6df4109327e501cc2ff097ac2bc6009d3ad1f6df2d006"

URI_aarch64_rust-reqwest0.12+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+json-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+json-devel}"
SRC_URI[aarch64_rust-reqwest0.12+json-devel.sha256sum] = "5148a45a2f3cd75e69e40d0e87eca1b189ea659144dfe1099138069fd55a7825"

URI_aarch64_rust-reqwest0.12+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+multipart-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+multipart-devel}"
SRC_URI[aarch64_rust-reqwest0.12+multipart-devel.sha256sum] = "1f6bcd849068e8b8aa257412befbcc1c3614782715a1ab20232489f34de6275b"

URI_aarch64_rust-reqwest0.12+native-tls-alpn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+native-tls-alpn-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+native-tls-alpn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+native-tls-alpn-devel}"
SRC_URI[aarch64_rust-reqwest0.12+native-tls-alpn-devel.sha256sum] = "77c102563f3f892304d47b79fd841582f6693c7cfa9649eac7860d3243db27f2"

URI_aarch64_rust-reqwest0.12+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+native-tls-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+native-tls-devel}"
SRC_URI[aarch64_rust-reqwest0.12+native-tls-devel.sha256sum] = "b7eb6552fd05c7248220bb863a55d7f8dd04434a3415abcabd1c9c4b869426d1"

URI_aarch64_rust-reqwest0.12+rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+rustls-tls-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+rustls-tls-devel}"
SRC_URI[aarch64_rust-reqwest0.12+rustls-tls-devel.sha256sum] = "997cd75267ae04c37a4b18df2c78141a76de4f357b4382b072699ae497d37af2"

URI_aarch64_rust-reqwest0.12+rustls-tls-manual-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+rustls-tls-manual-roots-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+rustls-tls-manual-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+rustls-tls-manual-roots-devel}"
SRC_URI[aarch64_rust-reqwest0.12+rustls-tls-manual-roots-devel.sha256sum] = "5b6a2ecdf5f2a00b2ca9f0851672effd7eee2b5ef53cdc10947d76310f9e4d4e"

URI_aarch64_rust-reqwest0.12+rustls-tls-manual-roots-no-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+rustls-tls-manual-roots-no-provider-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+rustls-tls-manual-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+rustls-tls-manual-roots-no-provider-devel}"
SRC_URI[aarch64_rust-reqwest0.12+rustls-tls-manual-roots-no-provider-devel.sha256sum] = "abc7502227e27d21d01d807a885a3311e84ee321bb8205f5c003bd27544e1121"

URI_aarch64_rust-reqwest0.12+rustls-tls-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+rustls-tls-native-roots-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+rustls-tls-native-roots-devel}"
SRC_URI[aarch64_rust-reqwest0.12+rustls-tls-native-roots-devel.sha256sum] = "4619c5b577c1a1a6a9d032ff510d5c9b8854826b362b8aaabebc74517722206d"

URI_aarch64_rust-reqwest0.12+rustls-tls-native-roots-no-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+rustls-tls-native-roots-no-provider-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+rustls-tls-native-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+rustls-tls-native-roots-no-provider-devel}"
SRC_URI[aarch64_rust-reqwest0.12+rustls-tls-native-roots-no-provider-devel.sha256sum] = "5bc10ef881c7c2e635f189e082036306107f53a10fd325dbee2f1a403330d2e7"

URI_aarch64_rust-reqwest0.12+rustls-tls-no-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+rustls-tls-no-provider-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+rustls-tls-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+rustls-tls-no-provider-devel}"
SRC_URI[aarch64_rust-reqwest0.12+rustls-tls-no-provider-devel.sha256sum] = "6e1c2d12e14fc30bc550291eb6bd9c382ccde4f999efd6c7aa907238663ddf8f"

URI_aarch64_rust-reqwest0.12+rustls-tls-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+rustls-tls-webpki-roots-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+rustls-tls-webpki-roots-devel}"
SRC_URI[aarch64_rust-reqwest0.12+rustls-tls-webpki-roots-devel.sha256sum] = "f68ace1619f46e55419d3c32e9412e9beedf9411c8b86bee42b56c03a12c4f57"

URI_aarch64_rust-reqwest0.12+rustls-tls-webpki-roots-no-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+rustls-tls-webpki-roots-no-provider-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+rustls-tls-webpki-roots-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+rustls-tls-webpki-roots-no-provider-devel}"
SRC_URI[aarch64_rust-reqwest0.12+rustls-tls-webpki-roots-no-provider-devel.sha256sum] = "5dc72e41489e7d0f8396b4ad2015e1f17ba741ff4c8e7b276b32df6d8255feab"

URI_aarch64_rust-reqwest0.12+socks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+socks-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+socks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+socks-devel}"
SRC_URI[aarch64_rust-reqwest0.12+socks-devel.sha256sum] = "b6f7f12d8cd0e19620d0e2739ee99b06cf1207eb3825f04325e9172982c8aa45"

URI_aarch64_rust-reqwest0.12+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+stream-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+stream-devel}"
SRC_URI[aarch64_rust-reqwest0.12+stream-devel.sha256sum] = "0c2735b5b979d1b6f14b06c47dcae3721f0608c9f12f3b0d497d95b889e88128"

URI_aarch64_rust-reqwest0.12+system-proxy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+system-proxy-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+system-proxy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+system-proxy-devel}"
SRC_URI[aarch64_rust-reqwest0.12+system-proxy-devel.sha256sum] = "0da3e7fd7a1c64d5e685a68fc20100b0794b7d13a4f89500952de21e0a7a05d1"

URI_aarch64_rust-reqwest0.12+trust-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+trust-dns-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+trust-dns-devel}"
SRC_URI[aarch64_rust-reqwest0.12+trust-dns-devel.sha256sum] = "b9338ef22280364ae6beb597f5c92e4aecebe9af63344d77fbc909f83cbc45c3"

URI_aarch64_rust-reqwest0.12+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12+zstd-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12+zstd-devel}"
SRC_URI[aarch64_rust-reqwest0.12+zstd-devel.sha256sum] = "ce4d1a58878b104afb6b555bb5d80b469faebcec4923ac08392853131b50cf78"

URI_aarch64_rust-reqwest0.12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest0.12-devel-0.12.28-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest0.12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest0.12-devel}"
SRC_URI[aarch64_rust-reqwest0.12-devel.sha256sum] = "ad2bde4121c0e3405f57f2642279ee4221417e680307cff2c98652b2546f378e"

RDEPENDS:rust-reqwest0.12+__rustls-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-reqwest0.12+__tls-devel \
 rust-reqwest0.12-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-reqwest0.12+__rustls-ring-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+ring-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-reqwest0.12-devel \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-reqwest0.12+__tls-devel = " \
 cargo \
 rust-reqwest0.12-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-pki-types+std-devel \
 rust-tokio+io-util-devel \
 "
RDEPENDS:rust-reqwest0.12+blocking-devel = " \
 cargo \
 rust-futures-channel+default-devel \
 rust-futures-channel+sink-devel \
 rust-futures-util+io-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 rust-reqwest0.12-devel \
 rust-tokio+sync-devel \
 "
RDEPENDS:rust-reqwest0.12+brotli-devel = " \
 cargo \
 rust-reqwest0.12-devel \
 rust-tower-http+decompression-br-devel \
 "
RDEPENDS:rust-reqwest0.12+charset-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-mime+default-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+cookies-devel = " \
 cargo \
 rust-cookie+default-devel \
 rust-cookie_store+default-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+default-devel = " \
 cargo \
 rust-reqwest0.12+charset-devel \
 rust-reqwest0.12+default-tls-devel \
 rust-reqwest0.12+http2-devel \
 rust-reqwest0.12+system-proxy-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+default-tls-devel = " \
 cargo \
 rust-hyper-tls+default-devel \
 rust-native-tls+default-devel \
 rust-reqwest0.12+__tls-devel \
 rust-reqwest0.12-devel \
 rust-tokio-native-tls+default-devel \
 "
RDEPENDS:rust-reqwest0.12+deflate-devel = " \
 cargo \
 rust-reqwest0.12-devel \
 rust-tower-http+decompression-deflate-devel \
 "
RDEPENDS:rust-reqwest0.12+gzip-devel = " \
 cargo \
 rust-reqwest0.12-devel \
 rust-tower-http+decompression-gzip-devel \
 "
RDEPENDS:rust-reqwest0.12+h2-devel = " \
 cargo \
 rust-h2+default-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+hickory-dns-devel = " \
 cargo \
 rust-hickory-resolver+default-devel \
 rust-hickory-resolver+tokio-devel \
 rust-once_cell+default-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+http2-devel = " \
 cargo \
 rust-hyper+http2-devel \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+http2-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-hyper-util+http2-devel \
 rust-reqwest0.12+h2-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+json-devel = " \
 cargo \
 rust-reqwest0.12-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-reqwest0.12+multipart-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-mime_guess-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+native-tls-alpn-devel = " \
 cargo \
 rust-hyper-tls+alpn-devel \
 rust-hyper-tls+default-devel \
 rust-native-tls+alpn-devel \
 rust-native-tls+default-devel \
 rust-reqwest0.12+native-tls-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+native-tls-devel = " \
 cargo \
 rust-reqwest0.12+default-tls-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+rustls-tls-devel = " \
 cargo \
 rust-reqwest0.12+rustls-tls-webpki-roots-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+rustls-tls-manual-roots-devel = " \
 cargo \
 rust-reqwest0.12+__rustls-ring-devel \
 rust-reqwest0.12+rustls-tls-manual-roots-no-provider-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+rustls-tls-manual-roots-no-provider-devel = " \
 cargo \
 rust-reqwest0.12+__rustls-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+rustls-tls-native-roots-devel = " \
 cargo \
 rust-reqwest0.12+__rustls-ring-devel \
 rust-reqwest0.12+rustls-tls-native-roots-no-provider-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+rustls-tls-native-roots-no-provider-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+native-tokio-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-reqwest0.12+__rustls-devel \
 rust-reqwest0.12-devel \
 rust-rustls-native-certs+default-devel \
 "
RDEPENDS:rust-reqwest0.12+rustls-tls-no-provider-devel = " \
 cargo \
 rust-reqwest0.12+rustls-tls-manual-roots-no-provider-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+rustls-tls-webpki-roots-devel = " \
 cargo \
 rust-reqwest0.12+__rustls-ring-devel \
 rust-reqwest0.12+rustls-tls-webpki-roots-no-provider-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+rustls-tls-webpki-roots-no-provider-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls+webpki-tokio-devel \
 rust-hyper-rustls-devel \
 rust-reqwest0.12+__rustls-devel \
 rust-reqwest0.12-devel \
 rust-webpki-roots+default-devel \
 "
RDEPENDS:rust-reqwest0.12+socks-devel = " \
 cargo \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+stream-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-reqwest0.12-devel \
 rust-tokio+fs-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-reqwest0.12+system-proxy-devel = " \
 cargo \
 rust-hyper-util+client-proxy-system-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+trust-dns-devel = " \
 cargo \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-reqwest0.12+zstd-devel = " \
 cargo \
 rust-reqwest0.12-devel \
 rust-tower-http+decompression-zstd-devel \
 "
RDEPENDS:rust-reqwest0.12-devel = " \
 cargo \
 rust \
 rust-base64+default-devel \
 rust-bytes+default-devel \
 rust-futures-core-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-hyper+client-devel \
 rust-hyper+default-devel \
 rust-hyper+http1-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+client-proxy-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+tokio-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-pin-project-lite+default-devel \
 rust-serde+default-devel \
 rust-serde_urlencoded+default-devel \
 rust-sync_wrapper+default-devel \
 rust-sync_wrapper+futures-devel \
 rust-tokio+net-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tower+retry-devel \
 rust-tower+timeout-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http-devel \
 rust-tower-service+default-devel \
 rust-url+default-devel \
 "
