# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-json-logger"
PV = "3.3.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-json-logger \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-json-logger-3.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "703114b77136218bab7b78d335da2dac95d3d80d57e10fe7f788031c2978fdb2"

URI_x86_64_v2_python3-json-logger = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-json-logger-3.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-json-logger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-json-logger}"
SRC_URI[x86_64_v2_python3-json-logger.sha256sum] = "f4f56c8c65de2d68726ba6529997f3409b7c9dc9722720fd42d653273b11ee3f"

URI_aarch64_python3-json-logger = "${EPEL_MIRROR}/aarch64/Packages/p/python3-json-logger-3.3.0-1.el10_1.noarch.rpm;name=aarch64_python3-json-logger;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-json-logger}"
SRC_URI[aarch64_python3-json-logger.sha256sum] = "20edf9d0070343d70f3790c58abff4731c964776fd9c69a133ec12ad79a7777d"

RDEPENDS:python3-json-logger = " \
 python3 \
 "
