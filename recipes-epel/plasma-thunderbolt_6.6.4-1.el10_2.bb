# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-thunderbolt"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-thunderbolt \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-thunderbolt-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2c3491b9777fe26bfe7833b8c01cb43213b4d28587e70161fa5e64bbbf5d8325"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-thunderbolt-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-thunderbolt;unpack=0"
SRC_URI[x86_64_v2_plasma-thunderbolt.sha256sum] = "ed5b9ba0a154d8377b87cb647adc89427eefb7781e5ced8f4ad1e9a307499b0e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-thunderbolt-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-thunderbolt;unpack=0"
SRC_URI[aarch64_plasma-thunderbolt.sha256sum] = "ddecea219bd1da62da13b4a2f6bb910552fbaba0ed66f994daf3168c95bae691"

RDEPENDS:plasma-thunderbolt = " \
 bolt \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knotifications \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
