# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stoken"
PV = "0.93"
PR = "2.el10_3"
PACKAGES = " \
 stoken-cli \
 stoken-devel \
 stoken-gui \
 stoken-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/stoken-0.93-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b887c1c61cec993f90880e761ad4553e752e1690a8232f792dd336b9588d85db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-cli-0.93-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-cli;unpack=0"
SRC_URI[x86_64_v2_stoken-cli.sha256sum] = "b654f7be43f17f78751b3d59758f482152c454c9d529e7678d92358a3fd1c150"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-devel-0.93-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-devel;unpack=0"
SRC_URI[x86_64_v2_stoken-devel.sha256sum] = "3bd58063eecb6b728a8ba0cdd31c79484308d7c8cc5518fecc015e50e359cccd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-gui-0.93-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-gui;unpack=0"
SRC_URI[x86_64_v2_stoken-gui.sha256sum] = "eb7544c706975b05b1ef76832a8688c8215e0ffe716fe9eca5f8f6963c2e0fcb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-libs-0.93-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-libs;unpack=0"
SRC_URI[x86_64_v2_stoken-libs.sha256sum] = "14e0b497f6e872bd76f657be51af6fb8335c12ca67b47479fabc0987074feec6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stoken-cli-0.93-2.el10_3.aarch64.rpm;name=aarch64_stoken-cli;unpack=0"
SRC_URI[aarch64_stoken-cli.sha256sum] = "81bf6598baa69edc9aa6b37166c1cba7891dd5482349b0b4b7392679cc00295d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stoken-devel-0.93-2.el10_3.aarch64.rpm;name=aarch64_stoken-devel;unpack=0"
SRC_URI[aarch64_stoken-devel.sha256sum] = "73e1b959ef0b4374dea8a9d3c9a959d40acc7709ed941332c4508f2dc854007e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stoken-gui-0.93-2.el10_3.aarch64.rpm;name=aarch64_stoken-gui;unpack=0"
SRC_URI[aarch64_stoken-gui.sha256sum] = "a4c6622fed5c8a4e9443a1521db2fcf627874e824a5602f0daedc95be5d4c46f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stoken-libs-0.93-2.el10_3.aarch64.rpm;name=aarch64_stoken-libs;unpack=0"
SRC_URI[aarch64_stoken-libs.sha256sum] = "6dd7401b195a5c408d0fd1d9f9d625a1f135d7ff3a78d005ddd5d2ff0074749e"

RDEPENDS:stoken-cli = " \
 glibc \
 stoken-libs \
 "
RDEPENDS:stoken-devel = " \
 gmp-devel \
 libxml2-devel \
 nettle-devel \
 pkgconf-pkg-config \
 stoken-libs \
 "
RDEPENDS:stoken-gui = " \
 cairo \
 glib2 \
 glibc \
 gtk3 \
 stoken-libs \
 "
RDEPENDS:stoken-libs = " \
 glibc \
 gmp \
 libxml2 \
 nettle \
 "
