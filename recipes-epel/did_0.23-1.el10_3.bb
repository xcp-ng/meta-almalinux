# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "did"
PV = "0.23"
PR = "1.el10_3"
PACKAGES = " \
 did \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/did-0.23-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afaedf18749107648fcdbf807e934fd9ab55e00069b099b09d4f86d089c58784"

URI_x86_64_v2_did = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/did-0.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_did;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_did}"
SRC_URI[x86_64_v2_did.sha256sum] = "0009c2892a58a115e2e6670d3e7d6ec8c971bd3e03b69cd9c05be85f9f0d7ab4"

URI_aarch64_did = "${EPEL_MIRROR}/aarch64/Packages/d/did-0.23-1.el10_3.noarch.rpm;name=aarch64_did;unpack=0"
SRC_URI:append = " ${URI_aarch64_did}"
SRC_URI[aarch64_did.sha256sum] = "9582d8e755f64c573c93642269bb68c334981276ec2b11410fa9b860cd59ee1f"

RDEPENDS:did = " \
 python3 \
 python3-bugzilla \
 python3-dateutil \
 python3-feedparser \
 python3-httplib2 \
 python3-nitrate \
 python3-requests \
 python3-requests-gssapi \
 python3-tenacity \
 python3-urllib3 \
 "
