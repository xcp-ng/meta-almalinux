# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro2"
PV = "1.0.103"
PR = "1.el10_0"
PACKAGES = " \
 rust-proc-macro2+default-devel \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro2-1.0.103-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a806df055184a9cbc8e39a0ed70af87951cec63a53fdf46f436dbf59d477eda"

URI_x86_64_v2_rust-proc-macro2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+default-devel-1.0.103-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2+default-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2+default-devel.sha256sum] = "bd3f1b01403c84c1cef6a18822224e88264177332c57d1f33d936ddaa0a2ced9"

URI_x86_64_v2_rust-proc-macro2+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+proc-macro-devel-1.0.103-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2+proc-macro-devel.sha256sum] = "59e3dc9dc7fc889c92980a6bcf869a217aac330eb77159cd78c636efc36a1d84"

URI_x86_64_v2_rust-proc-macro2+span-locations-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+span-locations-devel-1.0.103-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+span-locations-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2+span-locations-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2+span-locations-devel.sha256sum] = "f59a8c2dd5c91dbb982a9b7a0196d721523bf96c43b33000119cff32bd7fe9ee"

URI_x86_64_v2_rust-proc-macro2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2-devel-1.0.103-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2-devel.sha256sum] = "ac1c658c519daabd73733f568b81c21400af91e39f04044479f97407296ae6aa"

URI_aarch64_rust-proc-macro2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+default-devel-1.0.103-1.el10_0.noarch.rpm;name=aarch64_rust-proc-macro2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2+default-devel}"
SRC_URI[aarch64_rust-proc-macro2+default-devel.sha256sum] = "47df3f88eea166f32400926e2cc30617b8dff7134e6f4ec8895a8d90515ba35e"

URI_aarch64_rust-proc-macro2+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+proc-macro-devel-1.0.103-1.el10_0.noarch.rpm;name=aarch64_rust-proc-macro2+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2+proc-macro-devel}"
SRC_URI[aarch64_rust-proc-macro2+proc-macro-devel.sha256sum] = "4a69514599b70c1e3331dfa61d61abca915fb16fabd33e661d43d13c91155f6d"

URI_aarch64_rust-proc-macro2+span-locations-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+span-locations-devel-1.0.103-1.el10_0.noarch.rpm;name=aarch64_rust-proc-macro2+span-locations-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2+span-locations-devel}"
SRC_URI[aarch64_rust-proc-macro2+span-locations-devel.sha256sum] = "cf30b4144538d001f4e4c1f204aa88fef05e1d3f596aff8bee2d1b14125fb44f"

URI_aarch64_rust-proc-macro2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2-devel-1.0.103-1.el10_0.noarch.rpm;name=aarch64_rust-proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2-devel}"
SRC_URI[aarch64_rust-proc-macro2-devel.sha256sum] = "a8dd6c566c4b9bd4860b3bb03a6b4530305b39f3140347f8d3003a5ef7a892b3"

RDEPENDS:rust-proc-macro2+default-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2+proc-macro-devel = " \
 cargo \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2+span-locations-devel = " \
 cargo \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2-devel = " \
 cargo \
 rust \
 rust-unicode-ident+default-devel \
 "
