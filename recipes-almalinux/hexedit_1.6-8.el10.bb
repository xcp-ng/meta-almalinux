# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hexedit"
PV = "1.6"
PR = "8.el10"
PACKAGES = " \
 hexedit \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hexedit-1.6-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "edfcd81b0c8c85953c55fa48c26a96ea294a781a33196636f250e0cde01bb6d6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hexedit-1.6-8.el10.x86_64_v2.rpm;name=x86_64_v2_hexedit;unpack=0"
SRC_URI[x86_64_v2_hexedit.sha256sum] = "37d72cee740cb7f92cbed605bea5f0010b3d1f3d3d74e6057b48d99e15e789e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hexedit-1.6-8.el10.aarch64.rpm;name=aarch64_hexedit;unpack=0"
SRC_URI[aarch64_hexedit.sha256sum] = "a59280cad58527d03ece0d87cc00c22178153f00999500c745df472c30071baf"

RDEPENDS:hexedit = " \
 glibc \
 ncurses-libs \
 "
