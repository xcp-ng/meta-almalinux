# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-SQL-Abstract"
PV = "2.000001"
PR = "21.el10_3"
PACKAGES = " \
 perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough \
 perl-SQL-Abstract \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-SQL-Abstract-2.000001-21.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dee89de1a9a2aa9b67ae3aeb30aa1ca0d2b34a96c1665a980b0f021c8eb02941"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough-2.000001-21.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough;unpack=0"
SRC_URI[x86_64_v2_perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough.sha256sum] = "549e4046e39b24f27a71829492c8b22ee8bf005e064b0a4ecad622ab9901fa77"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SQL-Abstract-2.000001-21.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SQL-Abstract;unpack=0"
SRC_URI[x86_64_v2_perl-SQL-Abstract.sha256sum] = "3078b9d29bc1a272881125e9a897f03be40fbd745fc90aa2d277fde0435f0106"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough-2.000001-21.el10_3.noarch.rpm;name=aarch64_perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough;unpack=0"
SRC_URI[aarch64_perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough.sha256sum] = "87956be94b92051f967ce71dd26fb18d6324f901e4e17d7dc5f6197780f24b10"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-SQL-Abstract-2.000001-21.el10_3.noarch.rpm;name=aarch64_perl-SQL-Abstract;unpack=0"
SRC_URI[aarch64_perl-SQL-Abstract.sha256sum] = "57812b960a4c611e2fcd92c35aadeac11c5332741fba29f72c45b476bddb6e22"

RDEPENDS:perl-DBIx-Class-SQLMaker-Role-SQLA2Passthrough = " \
 perl-Role-Tiny \
 perl-libs \
 "
RDEPENDS:perl-SQL-Abstract = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-Hash-Merge \
 perl-Module-Runtime \
 perl-Moo \
 perl-Scalar-List-Utils \
 perl-Sub-Quote \
 perl-Test-Deep \
 perl-Test-Simple \
 perl-Text-Balanced \
 perl-base \
 perl-constant \
 perl-libs \
 perl-mro \
 perl-overload \
 "
