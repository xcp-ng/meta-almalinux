# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-Facebook-Oauth2"
PV = "0.12"
PR = "15.el10_0"
PACKAGES = " \
 perl-Net-Facebook-Oauth2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-Facebook-Oauth2-0.12-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a18afd62be58bc2fd9960bcc067c48a00b208c85cb25d756e4ccd91f7af8cb9b"

URI_x86_64_v2_perl-Net-Facebook-Oauth2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-Facebook-Oauth2-0.12-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-Facebook-Oauth2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-Facebook-Oauth2}"
SRC_URI[x86_64_v2_perl-Net-Facebook-Oauth2.sha256sum] = "25f8fccf469c9978a4b8e3dbb9f1b20d0ab24810880132a939f62e12ece249dc"

URI_aarch64_perl-Net-Facebook-Oauth2 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-Facebook-Oauth2-0.12-15.el10_0.noarch.rpm;name=aarch64_perl-Net-Facebook-Oauth2;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-Facebook-Oauth2}"
SRC_URI[aarch64_perl-Net-Facebook-Oauth2.sha256sum] = "72bc045ab6d288ce1e7e843ef381f945a2ee19724ce898cf8dae5ac191a00ab2"

RDEPENDS:perl-Net-Facebook-Oauth2 = " \
 perl-Carp \
 perl-JSON-MaybeXS \
 perl-LWP-Protocol-https \
 perl-URI \
 perl-libs \
 perl-libwww-perl \
 "
