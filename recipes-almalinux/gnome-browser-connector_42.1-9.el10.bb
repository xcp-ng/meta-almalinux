# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-browser-connector"
PV = "42.1"
PR = "9.el10"
PACKAGES = " \
 gnome-browser-connector \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-browser-connector-42.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b4afbb2b4a93b45b50f0d879c153db2802489af67cbb19aa815b22aafd9127c"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - gnome-browser-connector: gnome-shell

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - gnome-browser-connector: gnome-shell

URI_x86_64_v2_gnome-browser-connector = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-browser-connector-42.1-9.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-browser-connector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-browser-connector}"
SRC_URI[x86_64_v2_gnome-browser-connector.sha256sum] = "0d64fdfaad05bac97b8347100a6deac5c73f136f31afccbe9dbe6810a2baf973"

URI_aarch64_gnome-browser-connector = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-browser-connector-42.1-9.el10.aarch64.rpm;name=aarch64_gnome-browser-connector;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-browser-connector}"
SRC_URI[aarch64_gnome-browser-connector.sha256sum] = "eef7e7efaab73302bfd4eebb8d8dc9d41ae418722335d61a7b90c4da0ad545be"

RDEPENDS:gnome-browser-connector = " \
 dbus \
 hicolor-icon-theme \
 mozilla-filesystem \
 python3 \
 python3-gobject-base \
 "
