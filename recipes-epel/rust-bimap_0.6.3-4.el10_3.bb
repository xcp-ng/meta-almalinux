# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bimap"
PV = "0.6.3"
PR = "4.el10_3"
PACKAGES = " \
 rust-bimap+default-devel \
 rust-bimap+serde-devel \
 rust-bimap+std-devel \
 rust-bimap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bimap-0.6.3-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfd590a21d349c0948b90d3bbd9fb0633d7dbe961c38838300bc5bbefbe45917"

URI_x86_64_v2_rust-bimap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bimap+default-devel-0.6.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bimap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bimap+default-devel}"
SRC_URI[x86_64_v2_rust-bimap+default-devel.sha256sum] = "f43c8a8aa42d8b9e8095d330e3bc2d9de8c0632bbec9d6e13215e2858209d181"

URI_x86_64_v2_rust-bimap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bimap+serde-devel-0.6.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bimap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bimap+serde-devel}"
SRC_URI[x86_64_v2_rust-bimap+serde-devel.sha256sum] = "eda8a08efc59ca8423cf506677686b5c77607efdc60849933bb6429c8a2c4339"

URI_x86_64_v2_rust-bimap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bimap+std-devel-0.6.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bimap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bimap+std-devel}"
SRC_URI[x86_64_v2_rust-bimap+std-devel.sha256sum] = "7c6b31f212ee353872b3659ec44bb7b4da4d2f08d9ce2e3b88268b364bfc0db9"

URI_x86_64_v2_rust-bimap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bimap-devel-0.6.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bimap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bimap-devel}"
SRC_URI[x86_64_v2_rust-bimap-devel.sha256sum] = "71caaff34c22d594b6149b97fc59f54340e8637eb1ce2085a2a7162954a086de"

URI_aarch64_rust-bimap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bimap+default-devel-0.6.3-4.el10_3.noarch.rpm;name=aarch64_rust-bimap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bimap+default-devel}"
SRC_URI[aarch64_rust-bimap+default-devel.sha256sum] = "32e78ca383956a89761c1b9b6991aabcd9c2b67535a8d3ba1a1e558d3bb14407"

URI_aarch64_rust-bimap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bimap+serde-devel-0.6.3-4.el10_3.noarch.rpm;name=aarch64_rust-bimap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bimap+serde-devel}"
SRC_URI[aarch64_rust-bimap+serde-devel.sha256sum] = "6af23c10981c35f26fe6f8d0cac6f778d441f1dc1308219e40ef9cdee38ad629"

URI_aarch64_rust-bimap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bimap+std-devel-0.6.3-4.el10_3.noarch.rpm;name=aarch64_rust-bimap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bimap+std-devel}"
SRC_URI[aarch64_rust-bimap+std-devel.sha256sum] = "8b21af141f09603f6d7d3ad46ad1288c3f370c7769a399136e90d1f2dadc6c5c"

URI_aarch64_rust-bimap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bimap-devel-0.6.3-4.el10_3.noarch.rpm;name=aarch64_rust-bimap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bimap-devel}"
SRC_URI[aarch64_rust-bimap-devel.sha256sum] = "3535bb9be9ae6867da14d91d22adf1af3b477c6d0285a4f32e544f846049799e"

RDEPENDS:rust-bimap+default-devel = " \
 cargo \
 rust-bimap+std-devel \
 rust-bimap-devel \
 "
RDEPENDS:rust-bimap+serde-devel = " \
 cargo \
 rust-bimap-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-bimap+std-devel = " \
 cargo \
 rust-bimap-devel \
 "
RDEPENDS:rust-bimap-devel = " \
 cargo \
 "
