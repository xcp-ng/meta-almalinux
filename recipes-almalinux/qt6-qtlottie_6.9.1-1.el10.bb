# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtlottie"
PV = "6.9.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtlottie \
 qt6-qtlottie-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtlottie-6.9.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b05e0b77ad32c70f1cc6462dbf23dc7c20173200c6d00ddee226a7becb420565"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtlottie-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlottie;unpack=0"
SRC_URI[x86_64_v2_qt6-qtlottie.sha256sum] = "c214a06ba95008cf7eb5a58e47478f99aaa0939d67729c91e1654ab74edaf3cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtlottie-devel-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlottie-devel;unpack=0"
SRC_URI[x86_64_v2_qt6-qtlottie-devel.sha256sum] = "4afa4424acea350e67622a4b94d252d09739264c389cb5ac724ac55d7c6b880f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtlottie-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtlottie;unpack=0"
SRC_URI[aarch64_qt6-qtlottie.sha256sum] = "31490baf7ee082446600da6fc53c8c3001a1854f905bf47b0a8e9e53673d9fa9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtlottie-devel-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtlottie-devel;unpack=0"
SRC_URI[aarch64_qt6-qtlottie-devel.sha256sum] = "3191dd894d4b010bf49eed8dab94a3144708df7042104e13798813742b7a986e"

RDEPENDS:qt6-qtlottie = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtlottie-devel = " \
 cmake-filesystem \
 qt6-qtbase-devel \
 qt6-qtlottie \
 "
