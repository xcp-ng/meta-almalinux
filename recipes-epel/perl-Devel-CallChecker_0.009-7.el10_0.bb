# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-CallChecker"
PV = "0.009"
PR = "7.el10_0"
PACKAGES = " \
 perl-Devel-CallChecker \
 perl-Devel-CallChecker-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-CallChecker-0.009-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad819f2dba37860922cb21e16e4e7a41b73d0fccd627892978df43974e30efd5"

URI_x86_64_v2_perl-Devel-CallChecker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-CallChecker-0.009-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Devel-CallChecker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-CallChecker}"
SRC_URI[x86_64_v2_perl-Devel-CallChecker.sha256sum] = "8d2ba18f18e82c3dba466e1f8f94d97b827ae559696e15aba601c9174cc1d73b"

URI_x86_64_v2_perl-Devel-CallChecker-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-CallChecker-tests-0.009-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Devel-CallChecker-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-CallChecker-tests}"
SRC_URI[x86_64_v2_perl-Devel-CallChecker-tests.sha256sum] = "8b519764f979d6a30b4365b1f242cdf4b3087287d8a88e04d6583be9b1203951"

URI_aarch64_perl-Devel-CallChecker = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-CallChecker-0.009-7.el10_0.aarch64.rpm;name=aarch64_perl-Devel-CallChecker;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-CallChecker}"
SRC_URI[aarch64_perl-Devel-CallChecker.sha256sum] = "ada1e23607c385d478148d40536475f083436b35755d1083e20b82726f3176e8"

URI_aarch64_perl-Devel-CallChecker-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-CallChecker-tests-0.009-7.el10_0.noarch.rpm;name=aarch64_perl-Devel-CallChecker-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-CallChecker-tests}"
SRC_URI[aarch64_perl-Devel-CallChecker-tests.sha256sum] = "a9a167bd0862ea9f586c2c9488254c20408e0063cad74b2aab1128a01d653761"

RDEPENDS:perl-Devel-CallChecker = " \
 glibc \
 perl-DynaLoader \
 perl-DynaLoader-Functions \
 perl-Exporter \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-Devel-CallChecker-tests = " \
 bash \
 perl-Devel-CallChecker \
 perl-DynaLoader \
 perl-ExtUtils-CBuilder \
 perl-ExtUtils-ParseXS \
 perl-IO \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Thread-Semaphore \
 perl-interpreter \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 virtual/coreutils \
 "
