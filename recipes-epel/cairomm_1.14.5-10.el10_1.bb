# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cairomm"
PV = "1.14.5"
PR = "10.el10_1"
PACKAGES = " \
 cairomm \
 cairomm-devel \
 cairomm-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cairomm-1.14.5-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ca69ed735517dfd9fb5e7148d34edb40ceb2e78ab8391d0f77fadb3169e30693"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cairomm-1.14.5-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cairomm;unpack=0"
SRC_URI[x86_64_v2_cairomm.sha256sum] = "41a657abb103b513545f7ef889e7659d5c7cb60522bbfbb459a8856c5c326853"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cairomm-devel-1.14.5-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cairomm-devel;unpack=0"
SRC_URI[x86_64_v2_cairomm-devel.sha256sum] = "c2803c444865c860a1773f2067168432fb653846232c7d5c9b3f3f08e8a569e8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cairomm-doc-1.14.5-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_cairomm-doc;unpack=0"
SRC_URI[x86_64_v2_cairomm-doc.sha256sum] = "b1309c15249cc6525db8201749e1952c7562a424f24f528abdd56e502f2e8624"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cairomm-1.14.5-10.el10_1.aarch64.rpm;name=aarch64_cairomm;unpack=0"
SRC_URI[aarch64_cairomm.sha256sum] = "411886cf92d382dc659884e849e8777b0c5411626be5ed5a4160d3fab954689a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cairomm-devel-1.14.5-10.el10_1.aarch64.rpm;name=aarch64_cairomm-devel;unpack=0"
SRC_URI[aarch64_cairomm-devel.sha256sum] = "bc68eaed9ac9b57598080e6366a0af1fdecf7dc213b7c1fbee33015bd7838290"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cairomm-doc-1.14.5-10.el10_1.noarch.rpm;name=aarch64_cairomm-doc;unpack=0"
SRC_URI[aarch64_cairomm-doc.sha256sum] = "929056b720c53946902ecbb52584c00752c6e81565bb5ff8837f19d4dcb01aa6"

RDEPENDS:cairomm = " \
 cairo \
 glibc \
 libgcc \
 libsigc++20 \
 libstdc++ \
 "
RDEPENDS:cairomm-devel = " \
 cairo-devel \
 cairomm \
 cairomm-devel \
 libsigc++20-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:cairomm-doc = " \
 "
