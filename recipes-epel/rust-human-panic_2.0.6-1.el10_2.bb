# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-human-panic"
PV = "2.0.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-human-panic+color-devel \
 rust-human-panic+default-devel \
 rust-human-panic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-human-panic-2.0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab9e728aca40f7de97ff84a3c2b70e055cb1d4cb5d2c3e142d00d12864b1166e"

URI_x86_64_v2_rust-human-panic+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-panic+color-devel-2.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-panic+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-panic+color-devel}"
SRC_URI[x86_64_v2_rust-human-panic+color-devel.sha256sum] = "702c487d7c33bda6fd1ba84bd2decbe306814677e138dc1038a0dc81d40e5070"

URI_x86_64_v2_rust-human-panic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-panic+default-devel-2.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-panic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-panic+default-devel}"
SRC_URI[x86_64_v2_rust-human-panic+default-devel.sha256sum] = "39f43ed22c676b411c46c31616132d5596d6307de988b978d18e3d2910094b64"

URI_x86_64_v2_rust-human-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-panic-devel-2.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-panic-devel}"
SRC_URI[x86_64_v2_rust-human-panic-devel.sha256sum] = "254e690e83ba70d83268121fd3096811d583cacfb6f774c34f0400c0e4d3bed4"

URI_aarch64_rust-human-panic+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-panic+color-devel-2.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-human-panic+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-panic+color-devel}"
SRC_URI[aarch64_rust-human-panic+color-devel.sha256sum] = "eb2a05524470e166171af76817a5323025b8faf10962a142de21799c574d4253"

URI_aarch64_rust-human-panic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-panic+default-devel-2.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-human-panic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-panic+default-devel}"
SRC_URI[aarch64_rust-human-panic+default-devel.sha256sum] = "71165a1d6cbc346a64a7e3e6c4686a98a17cacf0161f5a856eb7998764863a25"

URI_aarch64_rust-human-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-panic-devel-2.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-human-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-panic-devel}"
SRC_URI[aarch64_rust-human-panic-devel.sha256sum] = "561fb6d74d603ee1aade53c48eac260d875467b7800edf6026c67b4cace7b1d8"

RDEPENDS:rust-human-panic+color-devel = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-anstyle+default-devel \
 rust-human-panic-devel \
 "
RDEPENDS:rust-human-panic+default-devel = " \
 cargo \
 rust-human-panic+color-devel \
 rust-human-panic-devel \
 "
RDEPENDS:rust-human-panic-devel = " \
 cargo \
 rust \
 rust-backtrace+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-sysinfo+system-devel \
 rust-sysinfo-devel \
 rust-toml0.9+display-devel \
 rust-toml0.9+serde-devel \
 rust-toml0.9-devel \
 rust-uuid+v4-devel \
 rust-uuid-devel \
 "
