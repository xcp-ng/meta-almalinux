# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkolabxml"
PV = "1.2.0"
PR = "22.el10_0"
PACKAGES = " \
 java-kolabformat \
 libkolabxml \
 libkolabxml-devel \
 php-kolabformat \
 python3-kolabformat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkolabxml-1.2.0-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "279df904ba692d45ba985dbcb8c39596a6f801ab5015487466cdcf5169c9efd1"

URI_x86_64_v2_java-kolabformat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-kolabformat-1.2.0-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-kolabformat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-kolabformat}"
SRC_URI[x86_64_v2_java-kolabformat.sha256sum] = "be727987656c7350194ae823ecc3c30259aed8174f74365b752596a788d80f17"

URI_x86_64_v2_libkolabxml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkolabxml-1.2.0-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkolabxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkolabxml}"
SRC_URI[x86_64_v2_libkolabxml.sha256sum] = "90950a888b330323ebb74a523f46908ca5959a3d3b12c40e9923bdadda9f2ed1"

URI_x86_64_v2_libkolabxml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkolabxml-devel-1.2.0-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkolabxml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkolabxml-devel}"
SRC_URI[x86_64_v2_libkolabxml-devel.sha256sum] = "3e0e629f797f1267506dcb384b345c5a14f8447d993ab9d256fb8e8899e82a6e"

URI_x86_64_v2_php-kolabformat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-kolabformat-1.2.0-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-kolabformat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-kolabformat}"
SRC_URI[x86_64_v2_php-kolabformat.sha256sum] = "44e575580bcb84dd7f1412a05b350ad847a829390cd00bec58a2ba14dc616c37"

URI_x86_64_v2_python3-kolabformat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kolabformat-1.2.0-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kolabformat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kolabformat}"
SRC_URI[x86_64_v2_python3-kolabformat.sha256sum] = "f2d72572fdd0ead775b453a5f4925c33c0e98374284972d67a56f905697cf522"

URI_aarch64_java-kolabformat = "${EPEL_MIRROR}/aarch64/Packages/j/java-kolabformat-1.2.0-22.el10_0.aarch64.rpm;name=aarch64_java-kolabformat;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-kolabformat}"
SRC_URI[aarch64_java-kolabformat.sha256sum] = "3ca958373fccd9870d4ea94dc9a98ad75fef52e0c143086b89cf77df942212c7"

URI_aarch64_libkolabxml = "${EPEL_MIRROR}/aarch64/Packages/l/libkolabxml-1.2.0-22.el10_0.aarch64.rpm;name=aarch64_libkolabxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkolabxml}"
SRC_URI[aarch64_libkolabxml.sha256sum] = "303f8ca4ac225389f4bdbc967eace3a6e8ff88573a21ee06e22dc5da16e4e04e"

URI_aarch64_libkolabxml-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkolabxml-devel-1.2.0-22.el10_0.aarch64.rpm;name=aarch64_libkolabxml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkolabxml-devel}"
SRC_URI[aarch64_libkolabxml-devel.sha256sum] = "3743bcf2703110bfe59e33ba6fa002aa5342ae45bfd2b0b6f33fa9a37c2c1e58"

URI_aarch64_php-kolabformat = "${EPEL_MIRROR}/aarch64/Packages/p/php-kolabformat-1.2.0-22.el10_0.aarch64.rpm;name=aarch64_php-kolabformat;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-kolabformat}"
SRC_URI[aarch64_php-kolabformat.sha256sum] = "986b3a33671f4dda6362adacb7e1c1a2440f77aae606f8af551fa34f92960063"

URI_aarch64_python3-kolabformat = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kolabformat-1.2.0-22.el10_0.aarch64.rpm;name=aarch64_python3-kolabformat;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kolabformat}"
SRC_URI[aarch64_python3-kolabformat.sha256sum] = "08e88b540465685ad1cd4dd1775c003fcfb7fe7c639f3a666b2ac5352f6eae01"

RDEPENDS:java-kolabformat = " \
 libkolabxml \
 "
RDEPENDS:libkolabxml = " \
 boost-thread \
 glibc \
 libgcc \
 libstdc++ \
 virtual/libcurl.so.4___64bit_ \
 xerces-c \
 "
RDEPENDS:libkolabxml-devel = " \
 boost-devel \
 cmake \
 cmake-filesystem \
 libcurl-devel \
 libkolabxml \
 xerces-c-devel \
 "
RDEPENDS:php-kolabformat = " \
 glibc \
 libgcc \
 libkolabxml \
 libstdc++ \
 php-common \
 "
RDEPENDS:python3-kolabformat = " \
 glibc \
 libgcc \
 libkolabxml \
 libstdc++ \
 python3 \
 python3-libs \
 "
