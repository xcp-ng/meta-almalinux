# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-thunderbolt"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-thunderbolt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-thunderbolt-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1aaaa1d610c4f4acf3d6948ad7540035549392c933435db9ab98904e7e8737d"

URI_x86_64_v2_plasma-thunderbolt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-thunderbolt-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-thunderbolt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-thunderbolt}"
SRC_URI[x86_64_v2_plasma-thunderbolt.sha256sum] = "95a549c349b346bd271a1de0603eb3ae484d8ca1955dda35bffa81a6b4142855"

URI_aarch64_plasma-thunderbolt = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-thunderbolt-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-thunderbolt;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-thunderbolt}"
SRC_URI[aarch64_plasma-thunderbolt.sha256sum] = "430e6a4b28a420e7cbd189bdfe6d99b5a468b5b580a65cb8347344fdea6f28e2"

RDEPENDS:plasma-thunderbolt = " \
 bolt \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knotifications \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
