# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mlnx-tools"
PV = "23.07"
PR = "5.el10_0"
PACKAGES = " \
 mlnx-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mlnx-tools-23.07-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94df48b0b8bc111390afc3d1d384daeb52b41108e18eb3cc31141a39a9f2e1ed"

URI_x86_64_v2_mlnx-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mlnx-tools-23.07-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mlnx-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mlnx-tools}"
SRC_URI[x86_64_v2_mlnx-tools.sha256sum] = "0c91ed5b9e2604a157631157d1b0553c5b9b9c803e2f3cc60b5cc3f9f4f3b7cd"

URI_aarch64_mlnx-tools = "${EPEL_MIRROR}/aarch64/Packages/m/mlnx-tools-23.07-5.el10_0.noarch.rpm;name=aarch64_mlnx-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_mlnx-tools}"
SRC_URI[aarch64_mlnx-tools.sha256sum] = "577ceb1ad3534ac49a75c131301e63fc1a1df5be8e61b748fca1d177ac0e6e0f"

RDEPENDS:mlnx-tools = " \
 bash \
 ethtool \
 iproute \
 pciutils \
 python3 \
 systemd-udev \
 "
