# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pngcheck"
PV = "4.0.0"
PR = "1.el10_1"
PACKAGES = " \
 pngcheck \
 pngcheck-extras \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pngcheck-4.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18d8cd0c2dc1fa21ec78d8ba618154b3b1bc94e74dbf1e501107a8ff325f01d4"

URI_x86_64_v2_pngcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pngcheck-4.0.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pngcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pngcheck}"
SRC_URI[x86_64_v2_pngcheck.sha256sum] = "296fa6ed74fadb6edad271405f6a07ad563dedf0c3f1a8f9f95b6169d759c1cf"

URI_x86_64_v2_pngcheck-extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pngcheck-extras-4.0.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pngcheck-extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pngcheck-extras}"
SRC_URI[x86_64_v2_pngcheck-extras.sha256sum] = "42e05d1ab7a5ccb19724b9e839401474085976fd9d6b5926473ab85a6d56653b"

URI_aarch64_pngcheck = "${EPEL_MIRROR}/aarch64/Packages/p/pngcheck-4.0.0-1.el10_1.aarch64.rpm;name=aarch64_pngcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_pngcheck}"
SRC_URI[aarch64_pngcheck.sha256sum] = "d14427ec9d0849b2b84b23d234d158bb07d174fdff20b965b5cffed7224328a0"

URI_aarch64_pngcheck-extras = "${EPEL_MIRROR}/aarch64/Packages/p/pngcheck-extras-4.0.0-1.el10_1.aarch64.rpm;name=aarch64_pngcheck-extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_pngcheck-extras}"
SRC_URI[aarch64_pngcheck-extras.sha256sum] = "088a02436a4b0fc233be7b48bcaf3c0020bd42e7b73ec26f330c937cababa214"

RDEPENDS:pngcheck = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:pngcheck-extras = " \
 glibc \
 zlib-ng-compat \
 "
