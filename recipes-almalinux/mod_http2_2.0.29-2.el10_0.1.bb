# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_http2"
PV = "2.0.29"
PR = "2.el10_0.1"
PACKAGES = " \
 mod_http2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_http2-2.0.29-2.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af6262f988b5a6c5abdfc12773b16a4903a79d4eb3944e5ff694f9a14251dee0"

URI_x86_64_v2_mod_http2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_http2-2.0.29-2.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_mod_http2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_http2}"
SRC_URI[x86_64_v2_mod_http2.sha256sum] = "5a4b4ee456b79b41494aa40ed2984eb75211245ee1b46012d1504b1872c3b5bd"

URI_aarch64_mod_http2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_http2-2.0.29-2.el10_0.1.aarch64.rpm;name=aarch64_mod_http2;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_http2}"
SRC_URI[aarch64_mod_http2.sha256sum] = "d8b50559ac8151723dcc63ca4893619c316095d871923957a03c88f084aa3f63"

RDEPENDS:mod_http2 = " \
 glibc \
 httpd-core \
 libnghttp2 \
 openssl-libs \
 "
