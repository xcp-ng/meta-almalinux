# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-C3-Componentised"
PV = "1.001002"
PR = "25.el10_3"
PACKAGES = " \
 perl-Class-C3-Componentised \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-C3-Componentised-1.001002-25.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "646b2a832d86de3b592c6c37ab475c282cd4a80108970c74481a3ac5c2d7dcae"

URI_x86_64_v2_perl-Class-C3-Componentised = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-C3-Componentised-1.001002-25.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-C3-Componentised;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-C3-Componentised}"
SRC_URI[x86_64_v2_perl-Class-C3-Componentised.sha256sum] = "53da789f093021e49e13f27eba5b5bf4c728c6de78759ac0733d79f049b3e314"

URI_aarch64_perl-Class-C3-Componentised = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-C3-Componentised-1.001002-25.el10_3.noarch.rpm;name=aarch64_perl-Class-C3-Componentised;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-C3-Componentised}"
SRC_URI[aarch64_perl-Class-C3-Componentised.sha256sum] = "da189d3967270084bcfb1b32b22b5f64fd456d9442f633c9b9328cd48222ee32"

RDEPENDS:perl-Class-C3-Componentised = " \
 perl-Carp \
 perl-Class-C3 \
 perl-Class-Inspector \
 perl-MRO-Compat \
 perl-Scalar-List-Utils \
 perl-libs \
 "
