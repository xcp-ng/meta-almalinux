# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "buildah"
PE = "2"
PV = "1.43.1"
PR = "4.el10_2"
PACKAGES = " \
 buildah \
 buildah-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/buildah-1.43.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0732f454e0e44bbcc31f27d57fe496aec26af36ad98fbc3beb34df64aa95ef4"

URI_x86_64_v2_buildah = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/buildah-1.43.1-4.el10_2.x86_64_v2.rpm;name=x86_64_v2_buildah;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_buildah}"
SRC_URI[x86_64_v2_buildah.sha256sum] = "a82021e09dd848ca54e4c32414c4a2142c4e4684e514e137aa3beb8ae7a1d5dc"

URI_x86_64_v2_buildah-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/buildah-tests-1.43.1-4.el10_2.x86_64_v2.rpm;name=x86_64_v2_buildah-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_buildah-tests}"
SRC_URI[x86_64_v2_buildah-tests.sha256sum] = "ba5e03c3835b02f0509453038342ef23f509e04ad3f14245a972fc6119cee782"

URI_aarch64_buildah = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/buildah-1.43.1-4.el10_2.aarch64.rpm;name=aarch64_buildah;unpack=0"
SRC_URI:append = " ${URI_aarch64_buildah}"
SRC_URI[aarch64_buildah.sha256sum] = "7f31e1e7102ea0b6acb82d294994199b9adf219c27a5583e996466e22a26d1cd"

URI_aarch64_buildah-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/buildah-tests-1.43.1-4.el10_2.aarch64.rpm;name=aarch64_buildah-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_buildah-tests}"
SRC_URI[aarch64_buildah-tests.sha256sum] = "4a453ad6255eddf5c3b820689b015f590a71e8c4f7d5da64f87645d749c4cf8e"

RDEPENDS:buildah = " \
 containers-common-extra \
 glibc \
 gpgme \
 libseccomp \
 podman-sequoia \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:buildah-tests = " \
 bash \
 buildah \
 bzip2 \
 git-daemon \
 glibc \
 golang \
 gpgme \
 httpd-tools \
 jq \
 libseccomp \
 nmap-ncat \
 openssl \
 podman \
 shadow-utils-subid \
 sqlite-libs \
 "
