# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pydantic-settings"
PV = "2.8.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-pydantic-settings \
 python3-pydantic-settings+toml \
 python3-pydantic-settings+yaml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pydantic-settings-2.8.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf0d85ba8f4efed94918bf598fad71385998501306250d06c2a5c8340f95b4ac"

URI_x86_64_v2_python3-pydantic-settings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-settings-2.8.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic-settings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic-settings}"
SRC_URI[x86_64_v2_python3-pydantic-settings.sha256sum] = "c9af33877d528032784e03bf809e427071eb6dc1ac215b39cd590aa3851f22da"

URI_x86_64_v2_python3-pydantic-settings+toml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-settings+toml-2.8.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic-settings+toml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic-settings+toml}"
SRC_URI[x86_64_v2_python3-pydantic-settings+toml.sha256sum] = "6afb6801554a70ad743c09bc7944df98003490fa77214beb7cbf11e827e89053"

URI_x86_64_v2_python3-pydantic-settings+yaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-settings+yaml-2.8.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic-settings+yaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic-settings+yaml}"
SRC_URI[x86_64_v2_python3-pydantic-settings+yaml.sha256sum] = "12c751fb5323ade1697baa8281c73a26732dcb7cc27abb9c982a2c47b602d97b"

URI_aarch64_python3-pydantic-settings = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-settings-2.8.1-1.el10_0.noarch.rpm;name=aarch64_python3-pydantic-settings;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic-settings}"
SRC_URI[aarch64_python3-pydantic-settings.sha256sum] = "f69850c03a7573a285c2ff33a58bde41f71b6cee4fbcefa144e23f05dd402629"

URI_aarch64_python3-pydantic-settings+toml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-settings+toml-2.8.1-1.el10_0.noarch.rpm;name=aarch64_python3-pydantic-settings+toml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic-settings+toml}"
SRC_URI[aarch64_python3-pydantic-settings+toml.sha256sum] = "88d40a26916ceab0d2e62cd5962c374db8b9143bf8b84456933794502123df47"

URI_aarch64_python3-pydantic-settings+yaml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-settings+yaml-2.8.1-1.el10_0.noarch.rpm;name=aarch64_python3-pydantic-settings+yaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic-settings+yaml}"
SRC_URI[aarch64_python3-pydantic-settings+yaml.sha256sum] = "1b6af17474cf1a804e9db18eadda8c0cdafb9ffb7c36cc84953f858530da3a69"

RDEPENDS:python3-pydantic-settings = " \
 python3 \
 python3-dotenv \
 python3-pydantic \
 "
RDEPENDS:python3-pydantic-settings+toml = " \
 python3 \
 python3-pydantic-settings \
 python3-tomli \
 "
RDEPENDS:python3-pydantic-settings+yaml = " \
 python3 \
 python3-pydantic-settings \
 python3-pyyaml \
 "
