# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ephemeral-port-reserve"
PV = "1.1.4"
PR = "12.el10_1"
PACKAGES = " \
 ephemeral-port-reserve \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/ephemeral-port-reserve-1.1.4-12.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "616347862196ab6ed876cc5480c6fe246870a77041a8380e6b51d480e5f42584"

URI_x86_64_v2_ephemeral-port-reserve = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ephemeral-port-reserve-1.1.4-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ephemeral-port-reserve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ephemeral-port-reserve}"
SRC_URI[x86_64_v2_ephemeral-port-reserve.sha256sum] = "55d9063f5fbdf4068d8622cab6135bd1248b6f4829413fac58ae676b0bc1f032"

URI_aarch64_ephemeral-port-reserve = "${EPEL_MIRROR}/aarch64/Packages/e/ephemeral-port-reserve-1.1.4-12.el10_1.noarch.rpm;name=aarch64_ephemeral-port-reserve;unpack=0"
SRC_URI:append = " ${URI_aarch64_ephemeral-port-reserve}"
SRC_URI[aarch64_ephemeral-port-reserve.sha256sum] = "c80ab37f3529fc06212a13f735ad3bff8247926d8dfa1bfcd7f427b3bf9ff23e"

RDEPENDS:ephemeral-port-reserve = " \
 python3 \
 "
