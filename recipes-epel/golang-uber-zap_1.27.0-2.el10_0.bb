# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-uber-zap"
PV = "1.27.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-uber-zap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-uber-zap-1.27.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db814696a6c75604b7d8ea3b712cef4e160e00e0f3d06b9c5486ee15467184fa"

URI_x86_64_v2_golang-uber-zap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-uber-zap-devel-1.27.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-uber-zap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-uber-zap-devel}"
SRC_URI[x86_64_v2_golang-uber-zap-devel.sha256sum] = "7caafc333c2d58aa252c227580e11484c13f58746b414d9d86d2704049f646c4"

URI_aarch64_golang-uber-zap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-uber-zap-devel-1.27.0-2.el10_0.noarch.rpm;name=aarch64_golang-uber-zap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-uber-zap-devel}"
SRC_URI[aarch64_golang-uber-zap-devel.sha256sum] = "a61a091440c4fabd68cae0d7a5756b31ae448e6650ec28b4096d962682d49c2e"

RDEPENDS:golang-uber-zap-devel = " \
 go-filesystem \
 golang-uber-multierr-devel \
 "
