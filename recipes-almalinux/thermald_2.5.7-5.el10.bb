# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "thermald"
PV = "2.5.7"
PR = "5.el10"
PACKAGES:x86_64_v2 = " \
 thermald \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/thermald-2.5.7-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2bd99373fc27f44a3c1ddf555c35e4dea0b5662c33bc1d4acc1cacff65756cf"

URI_x86_64_v2_thermald = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/thermald-2.5.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_thermald;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_thermald}"
SRC_URI[x86_64_v2_thermald.sha256sum] = "239a62201c024da75c5d498eca504db4731c126c7248ae14da968535dee8a1b7"

RDEPENDS:thermald = " \
 bash \
 dbus \
 glib2 \
 glibc \
 glibc-common \
 libevdev \
 libgcc \
 libstdc++ \
 libxml2 \
 shadow-utils \
 systemd \
 upower-libs \
 "
