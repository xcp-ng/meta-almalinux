# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-josepy"
PV = "2.0.0"
PR = "2.el10_0"
PACKAGES = " \
 python-josepy-doc \
 python3-josepy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-josepy-2.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27a1c0893bd965462227c0eb517fe3f6e3ee9e542c9bbc58333e9276bf74a882"

URI_x86_64_v2_python-josepy-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-josepy-doc-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-josepy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-josepy-doc}"
SRC_URI[x86_64_v2_python-josepy-doc.sha256sum] = "8da89ad8737563e345592d9b5e99899409c3ca9910d9d51b9cabc574ef828846"

URI_x86_64_v2_python3-josepy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-josepy-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-josepy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-josepy}"
SRC_URI[x86_64_v2_python3-josepy.sha256sum] = "474a1d6b3572a8e0933a59e42432ef51003d02e026f15bc9078257854e422d5c"

URI_aarch64_python-josepy-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-josepy-doc-2.0.0-2.el10_0.noarch.rpm;name=aarch64_python-josepy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-josepy-doc}"
SRC_URI[aarch64_python-josepy-doc.sha256sum] = "525e391810e619c70df2f8faa0192e2c8371bdd1dcf56ca9cda543f770bf05a5"

URI_aarch64_python3-josepy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-josepy-2.0.0-2.el10_0.noarch.rpm;name=aarch64_python3-josepy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-josepy}"
SRC_URI[aarch64_python3-josepy.sha256sum] = "8e37bab51bbce90152260d3429ff56aabf31eb543e3cab8340fcc0e2319c9b61"

RDEPENDS:python-josepy-doc = " \
 "
RDEPENDS:python3-josepy = " \
 python3 \
 python3-cryptography \
 "
