# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oidc-agent"
PV = "5.3.6"
PR = "1.el10_2"
PACKAGES = " \
 oidc-agent-cli \
 oidc-agent-desktop \
 oidc-agent-devel \
 oidc-agent-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/oidc-agent-5.3.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afdac2af261a735edccb1c463e75b08d08e5775a6dd8f6e6c0b4b2c672aabcc9"

URI_x86_64_v2_oidc-agent-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-cli-5.3.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-cli}"
SRC_URI[x86_64_v2_oidc-agent-cli.sha256sum] = "d77e626f449e87bb7c73242fbaff929bf8bd86f604ecfee4a4ab565028d95f63"

URI_x86_64_v2_oidc-agent-desktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-desktop-5.3.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-desktop}"
SRC_URI[x86_64_v2_oidc-agent-desktop.sha256sum] = "4d0e7014a49fb787ba0ad51b1cf35d8e49b75a11f6ed9f9a2eec6c741476254e"

URI_x86_64_v2_oidc-agent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-devel-5.3.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-devel}"
SRC_URI[x86_64_v2_oidc-agent-devel.sha256sum] = "95648bff71d49296832c10e588b273445c65026a1a9f6405acd35cf808330cb3"

URI_x86_64_v2_oidc-agent-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-libs-5.3.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-libs}"
SRC_URI[x86_64_v2_oidc-agent-libs.sha256sum] = "2d5378977c6507e533e34b69169add8d1b60c3dce42a9f4e8972df223262dd65"

URI_aarch64_oidc-agent-cli = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-cli-5.3.6-1.el10_2.aarch64.rpm;name=aarch64_oidc-agent-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-cli}"
SRC_URI[aarch64_oidc-agent-cli.sha256sum] = "8238bc88874ad0d916685f7d9079dbda35b98c79d4f88627ea966c33adbf69ef"

URI_aarch64_oidc-agent-desktop = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-desktop-5.3.6-1.el10_2.aarch64.rpm;name=aarch64_oidc-agent-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-desktop}"
SRC_URI[aarch64_oidc-agent-desktop.sha256sum] = "be94eb82db4c1a36b01f7eaa09f5c0612e3d8722b8c3fa27b3e1a6721ae3e832"

URI_aarch64_oidc-agent-devel = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-devel-5.3.6-1.el10_2.aarch64.rpm;name=aarch64_oidc-agent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-devel}"
SRC_URI[aarch64_oidc-agent-devel.sha256sum] = "06a6048a514f13deec3fc8f4a7b160b1d4994fb51e87622eaf9902102838302b"

URI_aarch64_oidc-agent-libs = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-libs-5.3.6-1.el10_2.aarch64.rpm;name=aarch64_oidc-agent-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-libs}"
SRC_URI[aarch64_oidc-agent-libs.sha256sum] = "94063a5a48077e4036653757fe92e8d0762df2616126c93caa83062995cd54dd"

RDEPENDS:oidc-agent-cli = " \
 bash \
 cjson \
 clibs-list \
 glibc \
 libmicrohttpd \
 libsodium \
 oidc-agent-libs \
 qrencode-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:oidc-agent-desktop = " \
 cjson \
 clibs-list \
 glib2 \
 glibc \
 gtk3 \
 javascriptcoregtk4.1 \
 libgcc \
 libsodium \
 libstdc++ \
 oidc-agent-cli \
 oidc-agent-libs \
 webkit2gtk4.1 \
 "
RDEPENDS:oidc-agent-devel = " \
 oidc-agent-libs \
 "
RDEPENDS:oidc-agent-libs = " \
 cjson \
 clibs-list \
 glibc \
 libsodium \
 "
