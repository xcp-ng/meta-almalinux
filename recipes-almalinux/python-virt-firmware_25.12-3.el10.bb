# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-virt-firmware"
PV = "25.12"
PR = "3.el10"
PACKAGES = " \
 python3-virt-firmware \
 uki-direct \
 virt-sb-certs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-virt-firmware-25.12-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5556bfa9b78ad785402e1c8e7ec168f1f60f23a8e56356c505df6d91e94f0f06"

URI_x86_64_v2_python3-virt-firmware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-virt-firmware-25.12-3.el10.noarch.rpm;name=x86_64_v2_python3-virt-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-virt-firmware}"
SRC_URI[x86_64_v2_python3-virt-firmware.sha256sum] = "0e7599fab8ac9f59c950962b3fa8294cb5be76b0ebf4e3f4d2979b440f4d9f83"

URI_x86_64_v2_uki-direct = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/uki-direct-25.12-3.el10.noarch.rpm;name=x86_64_v2_uki-direct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uki-direct}"
SRC_URI[x86_64_v2_uki-direct.sha256sum] = "1d1fc03069478d260c199d3de210c131dc80e52b9be6c7176904915cace6d4f7"

URI_x86_64_v2_virt-sb-certs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-sb-certs-25.12-3.el10.noarch.rpm;name=x86_64_v2_virt-sb-certs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-sb-certs}"
SRC_URI[x86_64_v2_virt-sb-certs.sha256sum] = "9237bef6cb2c372bd8741576997aa3f3a64913e50d705727ddb0438020e55aa5"

URI_aarch64_python3-virt-firmware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-virt-firmware-25.12-3.el10.noarch.rpm;name=aarch64_python3-virt-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-virt-firmware}"
SRC_URI[aarch64_python3-virt-firmware.sha256sum] = "0e7599fab8ac9f59c950962b3fa8294cb5be76b0ebf4e3f4d2979b440f4d9f83"

URI_aarch64_uki-direct = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/uki-direct-25.12-3.el10.noarch.rpm;name=aarch64_uki-direct;unpack=0"
SRC_URI:append = " ${URI_aarch64_uki-direct}"
SRC_URI[aarch64_uki-direct.sha256sum] = "1d1fc03069478d260c199d3de210c131dc80e52b9be6c7176904915cace6d4f7"

URI_aarch64_virt-sb-certs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-sb-certs-25.12-3.el10.noarch.rpm;name=aarch64_virt-sb-certs;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-sb-certs}"
SRC_URI[aarch64_virt-sb-certs.sha256sum] = "9237bef6cb2c372bd8741576997aa3f3a64913e50d705727ddb0438020e55aa5"

RDEPENDS:python3-virt-firmware = " \
 python3 \
 python3-cryptography \
 python3-pefile \
 python3-setuptools \
 virt-sb-certs \
 "
RDEPENDS:uki-direct = " \
 bash \
 python3-virt-firmware \
 "
RDEPENDS:virt-sb-certs = " \
 "
