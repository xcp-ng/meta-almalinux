# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-gettext"
PV = "1.07"
PR = "35.el10"
PACKAGES = " \
 perl-Locale-gettext \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-gettext-1.07-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02d00be695ef59ca3a935470765bf7017f502961338201e576c4657934f450bc"

URI_x86_64_v2_perl-Locale-gettext = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Locale-gettext-1.07-35.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Locale-gettext;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Locale-gettext}"
SRC_URI[x86_64_v2_perl-Locale-gettext.sha256sum] = "9373404b785d011ded230d1c0207520b0c617affd7c884d18968b3540f66b84a"

URI_aarch64_perl-Locale-gettext = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Locale-gettext-1.07-35.el10.aarch64.rpm;name=aarch64_perl-Locale-gettext;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Locale-gettext}"
SRC_URI[aarch64_perl-Locale-gettext.sha256sum] = "87c250da13a64f6a3151f848e332bc773ae1768ad28edb9ef7e041f36ee6d185"

RDEPENDS:perl-Locale-gettext = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-POSIX \
 perl-libs \
 "
