# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stow"
PV = "2.4.1"
PR = "4.el10_2"
PACKAGES = " \
 stow \
 stow-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stow-2.4.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f92fc02f2f13c9e8533f4ddcd9e40c448ee8adf599594917194a55f4808dc34c"

URI_x86_64_v2_stow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stow-2.4.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_stow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stow}"
SRC_URI[x86_64_v2_stow.sha256sum] = "ea89c226922c75553353acb93f9b06f7ed76a6fbfac2c85f66f5ce6969621c48"

URI_x86_64_v2_stow-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stow-doc-2.4.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_stow-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stow-doc}"
SRC_URI[x86_64_v2_stow-doc.sha256sum] = "edee29293eaf6564887d855b1caa670a836e9089934a3f87279f95decbc4993f"

URI_aarch64_stow = "${EPEL_MIRROR}/aarch64/Packages/s/stow-2.4.1-4.el10_2.noarch.rpm;name=aarch64_stow;unpack=0"
SRC_URI:append = " ${URI_aarch64_stow}"
SRC_URI[aarch64_stow.sha256sum] = "53f6e96a7704a2215d03dfac577f74f846730812cd7731e51dbceccba735bf43"

URI_aarch64_stow-doc = "${EPEL_MIRROR}/aarch64/Packages/s/stow-doc-2.4.1-4.el10_2.noarch.rpm;name=aarch64_stow-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_stow-doc}"
SRC_URI[aarch64_stow-doc.sha256sum] = "562f2183378dbfe328d209dbc0f508dd28624797f0fb0b52114bfb1f8f2db44b"

RDEPENDS:stow = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Copy \
 perl-File-Find \
 perl-Getopt-Long \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Text-ParseWords \
 perl-base \
 perl-interpreter \
 perl-libs \
 stow \
 "
RDEPENDS:stow-doc = " \
 stow \
 "
