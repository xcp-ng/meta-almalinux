# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-globset"
PV = "0.4.20"
PR = "1.el10_2"
PACKAGES = " \
 rust-globset+arbitrary-devel \
 rust-globset+default-devel \
 rust-globset+log-devel \
 rust-globset+serde-devel \
 rust-globset+serde1-devel \
 rust-globset+simd-accel-devel \
 rust-globset-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-globset-0.4.20-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bf9913035884fdae00e5e1e4f07a9f00dd76894009a9eb8c97591e2e7297109"

URI_x86_64_v2_rust-globset+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+arbitrary-devel-0.4.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-globset+arbitrary-devel.sha256sum] = "b1caf67b4f89a9b7d324633a323691ade964a297ae82098ba3312636a2eaf8bf"

URI_x86_64_v2_rust-globset+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+default-devel-0.4.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+default-devel}"
SRC_URI[x86_64_v2_rust-globset+default-devel.sha256sum] = "7d5c35608db21fe8536e6c1fd5ea4b180597d2a2442f853b6c5bc34bfdea0abb"

URI_x86_64_v2_rust-globset+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+log-devel-0.4.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+log-devel}"
SRC_URI[x86_64_v2_rust-globset+log-devel.sha256sum] = "c1415c050b21e3d166b13d34e9fe9ad7fc313bb991a591686dbb460156a9a30d"

URI_x86_64_v2_rust-globset+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+serde-devel-0.4.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+serde-devel}"
SRC_URI[x86_64_v2_rust-globset+serde-devel.sha256sum] = "4d504ed8e7c056fdc21618ae7aa7fea17be6c79214f275a1a10e957a0c2767d7"

URI_x86_64_v2_rust-globset+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+serde1-devel-0.4.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+serde1-devel}"
SRC_URI[x86_64_v2_rust-globset+serde1-devel.sha256sum] = "42f9d7af27bcb6bdd7719e296a759a1dd3ddf0482a26e275d75c3ac20b1c04f1"

URI_x86_64_v2_rust-globset+simd-accel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+simd-accel-devel-0.4.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+simd-accel-devel}"
SRC_URI[x86_64_v2_rust-globset+simd-accel-devel.sha256sum] = "136a667f59bf0eb694be9d4c489f409beec06ec91bf9437d1b4ce41ba7629e91"

URI_x86_64_v2_rust-globset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset-devel-0.4.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset-devel}"
SRC_URI[x86_64_v2_rust-globset-devel.sha256sum] = "ee398cecb1743a034371e0aba6cf619bed2d2159cd67353222247f1effc01fa3"

URI_aarch64_rust-globset+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+arbitrary-devel-0.4.20-1.el10_2.noarch.rpm;name=aarch64_rust-globset+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+arbitrary-devel}"
SRC_URI[aarch64_rust-globset+arbitrary-devel.sha256sum] = "0f2f2ddee96d1a485924600c74e111e7707cea281d011eac99e47e16eb7366ae"

URI_aarch64_rust-globset+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+default-devel-0.4.20-1.el10_2.noarch.rpm;name=aarch64_rust-globset+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+default-devel}"
SRC_URI[aarch64_rust-globset+default-devel.sha256sum] = "dcc8ed25135322631e61125e5ec8156a1808fd36af291e4afdcefe447cfce45c"

URI_aarch64_rust-globset+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+log-devel-0.4.20-1.el10_2.noarch.rpm;name=aarch64_rust-globset+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+log-devel}"
SRC_URI[aarch64_rust-globset+log-devel.sha256sum] = "9909fd9205175202b4c23f572e0dda9d8ad996dde685fda1fb0f1d84c04fd72c"

URI_aarch64_rust-globset+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+serde-devel-0.4.20-1.el10_2.noarch.rpm;name=aarch64_rust-globset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+serde-devel}"
SRC_URI[aarch64_rust-globset+serde-devel.sha256sum] = "8b4565de674dfb2886e1a221f05d52c7fc82ae897bf814a3bd093d83d7d1548c"

URI_aarch64_rust-globset+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+serde1-devel-0.4.20-1.el10_2.noarch.rpm;name=aarch64_rust-globset+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+serde1-devel}"
SRC_URI[aarch64_rust-globset+serde1-devel.sha256sum] = "c4eeb475a850a0b9753ee3ea0f7de9eebbc7a7ffcb8decaf86ebaabe4e9c1921"

URI_aarch64_rust-globset+simd-accel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+simd-accel-devel-0.4.20-1.el10_2.noarch.rpm;name=aarch64_rust-globset+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+simd-accel-devel}"
SRC_URI[aarch64_rust-globset+simd-accel-devel.sha256sum] = "c848beabcf908c40ed37cdb693a9fc7d7f59716a6d37b656dffa9a17ecb77551"

URI_aarch64_rust-globset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset-devel-0.4.20-1.el10_2.noarch.rpm;name=aarch64_rust-globset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset-devel}"
SRC_URI[aarch64_rust-globset-devel.sha256sum] = "34a66d1276f56eb0894357cf3c8881f6496f41168ff271231b3bb60b87b1b9ad"

RDEPENDS:rust-globset+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-globset-devel \
 "
RDEPENDS:rust-globset+default-devel = " \
 cargo \
 rust-globset+log-devel \
 rust-globset-devel \
 "
RDEPENDS:rust-globset+log-devel = " \
 cargo \
 rust-globset-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-globset+serde-devel = " \
 cargo \
 rust-globset-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-globset+serde1-devel = " \
 cargo \
 rust-globset+serde-devel \
 rust-globset-devel \
 "
RDEPENDS:rust-globset+simd-accel-devel = " \
 cargo \
 rust-globset-devel \
 "
RDEPENDS:rust-globset-devel = " \
 cargo \
 rust \
 rust-aho-corasick+default-devel \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 rust-regex-syntax+std-devel \
 rust-regex-syntax-devel \
 "
