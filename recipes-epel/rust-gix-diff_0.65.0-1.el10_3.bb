# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-diff"
PV = "0.65.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-diff+blob-devel \
 rust-gix-diff+default-devel \
 rust-gix-diff+document-features-devel \
 rust-gix-diff+index-devel \
 rust-gix-diff+serde-devel \
 rust-gix-diff+sha1-devel \
 rust-gix-diff+sha256-devel \
 rust-gix-diff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-diff-0.65.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5e591bc999d7e2f44db263d265b5853cf58e3243a2578c983827134185cc544"

URI_x86_64_v2_rust-gix-diff+blob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+blob-devel-0.65.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+blob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+blob-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+blob-devel.sha256sum] = "15cc9fd5c873294fa61c9ab4fc394e044002bf0be55afdd83a4058f3c02ccda1"

URI_x86_64_v2_rust-gix-diff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+default-devel-0.65.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+default-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+default-devel.sha256sum] = "c3d623f4f3ab08efeb252064b0fed46cc7df6d6c748185e1b95b70a1eac7798d"

URI_x86_64_v2_rust-gix-diff+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+document-features-devel-0.65.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+document-features-devel.sha256sum] = "a58b4e02af350e3f7c0cebe6c382d5d771e29d84c87edd0480ea7b3e1cf8d345"

URI_x86_64_v2_rust-gix-diff+index-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+index-devel-0.65.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+index-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+index-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+index-devel.sha256sum] = "e16730bd70bf05f1dfdc1aa64332c70e3aa4c337a5ce423d6b4ef6705849d59a"

URI_x86_64_v2_rust-gix-diff+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+serde-devel-0.65.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+serde-devel.sha256sum] = "9dc2e63324768d96259d0fedf30a9f5cba14e1c130014f3ad34beb9736a2539f"

URI_x86_64_v2_rust-gix-diff+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+sha1-devel-0.65.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+sha1-devel.sha256sum] = "f90880cf9092ab9a88bf6e064e6979a64b2eaef0f675a1cbcd1e90be03049f3f"

URI_x86_64_v2_rust-gix-diff+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+sha256-devel-0.65.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+sha256-devel.sha256sum] = "aa5be56bcbb0e03d7ca0b9cdb47af6d081505cf7746b5a2eaf934767adc2668b"

URI_x86_64_v2_rust-gix-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff-devel-0.65.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff-devel}"
SRC_URI[x86_64_v2_rust-gix-diff-devel.sha256sum] = "13a0e4b2c9fb0ab8da87e8bb77f5b719361850128d664bdbd90ba3a9289fe335"

URI_aarch64_rust-gix-diff+blob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+blob-devel-0.65.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-diff+blob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+blob-devel}"
SRC_URI[aarch64_rust-gix-diff+blob-devel.sha256sum] = "60f3841d4d4eff25b3e37367057f28bd9e54453c9347f44f10da1249f8d6f110"

URI_aarch64_rust-gix-diff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+default-devel-0.65.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+default-devel}"
SRC_URI[aarch64_rust-gix-diff+default-devel.sha256sum] = "73acdeef9d53f8a0cebddf8a2d282530b67465ce052cefd6910474a5ecbb76c0"

URI_aarch64_rust-gix-diff+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+document-features-devel-0.65.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-diff+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+document-features-devel}"
SRC_URI[aarch64_rust-gix-diff+document-features-devel.sha256sum] = "0c217ea0c479b20328581fca846dcd6f78fb0fc7f63e14170c78086158ad2f5b"

URI_aarch64_rust-gix-diff+index-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+index-devel-0.65.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-diff+index-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+index-devel}"
SRC_URI[aarch64_rust-gix-diff+index-devel.sha256sum] = "58535bf18c19b58cc4f161ba7d5e2979adb9aba50a417a709ed8858698e4c0ab"

URI_aarch64_rust-gix-diff+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+serde-devel-0.65.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-diff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+serde-devel}"
SRC_URI[aarch64_rust-gix-diff+serde-devel.sha256sum] = "da5d651a82287f39d8c3d46555206be7fa51316297d056b978eafd90d13c106a"

URI_aarch64_rust-gix-diff+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+sha1-devel-0.65.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-diff+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+sha1-devel}"
SRC_URI[aarch64_rust-gix-diff+sha1-devel.sha256sum] = "7449de7fc5fa96ca09a7ea2afcea37a34b7607ec947489c1d9409d963b1494ac"

URI_aarch64_rust-gix-diff+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+sha256-devel-0.65.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-diff+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+sha256-devel}"
SRC_URI[aarch64_rust-gix-diff+sha256-devel.sha256sum] = "f9abfc93d8349fa2cf3b11e04c2164967a678414703d64c9258683db07028c7c"

URI_aarch64_rust-gix-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff-devel-0.65.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff-devel}"
SRC_URI[aarch64_rust-gix-diff-devel.sha256sum] = "5a52da11765be8a3501eb662be89757042b0e42bf99a0248091709f928398f41"

RDEPENDS:rust-gix-diff+blob-devel = " \
 cargo \
 rust-gix-command+default-devel \
 rust-gix-diff-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-imara-diff+default-devel \
 rust-gix-path+default-devel \
 rust-gix-tempfile+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-traverse+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-diff+default-devel = " \
 cargo \
 rust-gix-diff+blob-devel \
 rust-gix-diff+index-devel \
 rust-gix-diff-devel \
 "
RDEPENDS:rust-gix-diff+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-diff-devel \
 "
RDEPENDS:rust-gix-diff+index-devel = " \
 cargo \
 rust-gix-attributes+default-devel \
 rust-gix-diff-devel \
 rust-gix-index+default-devel \
 rust-gix-pathspec+default-devel \
 "
RDEPENDS:rust-gix-diff+serde-devel = " \
 cargo \
 rust-gix-diff-devel \
 rust-gix-hash+serde-devel \
 rust-gix-index+default-devel \
 rust-gix-index+serde-devel \
 rust-gix-object+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-diff+sha1-devel = " \
 cargo \
 rust-gix-diff-devel \
 rust-gix-hash+sha1-devel \
 "
RDEPENDS:rust-gix-diff+sha256-devel = " \
 cargo \
 rust-gix-diff-devel \
 rust-gix-hash+sha256-devel \
 "
RDEPENDS:rust-gix-diff-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-thiserror+default-devel \
 "
