# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-lucasb-eyer-colorful"
PV = "1.2.0"
PR = "11.el10_0"
PACKAGES = " \
 golang-github-lucasb-eyer-colorful-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-lucasb-eyer-colorful-1.2.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12890d49793ad5add3f273bfd77a7e398e77db46b516644729255786336599bb"

URI_x86_64_v2_golang-github-lucasb-eyer-colorful-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-lucasb-eyer-colorful-devel-1.2.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-lucasb-eyer-colorful-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-lucasb-eyer-colorful-devel}"
SRC_URI[x86_64_v2_golang-github-lucasb-eyer-colorful-devel.sha256sum] = "f2767b61b58b39bbece9a305c4cb9749a40df8259d27d9471c15e2b2b563273b"

URI_aarch64_golang-github-lucasb-eyer-colorful-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-lucasb-eyer-colorful-devel-1.2.0-11.el10_0.noarch.rpm;name=aarch64_golang-github-lucasb-eyer-colorful-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-lucasb-eyer-colorful-devel}"
SRC_URI[aarch64_golang-github-lucasb-eyer-colorful-devel.sha256sum] = "9bcb2d94e60395eeb05137f03d0f0b91ea183504a07a8e2975be7d2aa2e5276d"

RDEPENDS:golang-github-lucasb-eyer-colorful-devel = " \
 go-filesystem \
 "
