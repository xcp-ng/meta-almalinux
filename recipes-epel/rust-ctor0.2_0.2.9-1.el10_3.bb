# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ctor0.2"
PV = "0.2.9"
PR = "1.el10_3"
PACKAGES = " \
 rust-ctor0.2+default-devel \
 rust-ctor0.2+used_linker-devel \
 rust-ctor0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ctor0.2-0.2.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b2d8583823855521dd380f1bbda1a6a70cd51c115778aafac89c8f9be0c811e"

URI_x86_64_v2_rust-ctor0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor0.2+default-devel-0.2.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctor0.2+default-devel}"
SRC_URI[x86_64_v2_rust-ctor0.2+default-devel.sha256sum] = "0a5988fa0cf32351d631f91796174557c5670b904fc32c5f35622325d4878fc3"

URI_x86_64_v2_rust-ctor0.2+used_linker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor0.2+used_linker-devel-0.2.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor0.2+used_linker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctor0.2+used_linker-devel}"
SRC_URI[x86_64_v2_rust-ctor0.2+used_linker-devel.sha256sum] = "570d6bd3b0b7d73720aa688c975ab89db6ba301fa3fad922a48b69666b5bb5af"

URI_x86_64_v2_rust-ctor0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor0.2-devel-0.2.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctor0.2-devel}"
SRC_URI[x86_64_v2_rust-ctor0.2-devel.sha256sum] = "ba22a574bf00c2e3262e2e4c4ebc1968f856c440faae0c33fc88dda2ced11c9b"

URI_aarch64_rust-ctor0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor0.2+default-devel-0.2.9-1.el10_3.noarch.rpm;name=aarch64_rust-ctor0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctor0.2+default-devel}"
SRC_URI[aarch64_rust-ctor0.2+default-devel.sha256sum] = "4496cfc408b2c98c57686c01f7ff18ba74ecc83e46cc821b874fad43f67c7943"

URI_aarch64_rust-ctor0.2+used_linker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor0.2+used_linker-devel-0.2.9-1.el10_3.noarch.rpm;name=aarch64_rust-ctor0.2+used_linker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctor0.2+used_linker-devel}"
SRC_URI[aarch64_rust-ctor0.2+used_linker-devel.sha256sum] = "3493a44a58389d9b6fcfdd409e23312ed3b33893b53f4bf0dd653397baccfb49"

URI_aarch64_rust-ctor0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor0.2-devel-0.2.9-1.el10_3.noarch.rpm;name=aarch64_rust-ctor0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctor0.2-devel}"
SRC_URI[aarch64_rust-ctor0.2-devel.sha256sum] = "a97d97561e93274d6a808b7753f2d0f262b9559cfef4106f8825f5180c0cd334"

RDEPENDS:rust-ctor0.2+default-devel = " \
 cargo \
 rust-ctor0.2-devel \
 "
RDEPENDS:rust-ctor0.2+used_linker-devel = " \
 cargo \
 rust-ctor0.2-devel \
 "
RDEPENDS:rust-ctor0.2-devel = " \
 cargo \
 rust-quote+default-devel \
 rust-syn2+full-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2+proc-macro-devel \
 rust-syn2-devel \
 "
