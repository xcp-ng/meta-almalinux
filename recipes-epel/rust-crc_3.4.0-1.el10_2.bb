# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crc"
PV = "3.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-crc+default-devel \
 rust-crc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crc-3.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c390cb2a0833f0fbdbb1d0114aef6bbf0abd8ac36dff09fd012be0aaad2a1b7"

URI_x86_64_v2_rust-crc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc+default-devel-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc+default-devel}"
SRC_URI[x86_64_v2_rust-crc+default-devel.sha256sum] = "ae30d9fbc8de6d79af8402e753045e8e45990667d85f5392be97ae627906d020"

URI_x86_64_v2_rust-crc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-devel-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-devel}"
SRC_URI[x86_64_v2_rust-crc-devel.sha256sum] = "fdb239b548238c170819c7c8db50386ff03214f413cdbd53c0f27ffd393b9e78"

URI_aarch64_rust-crc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc+default-devel-3.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc+default-devel}"
SRC_URI[aarch64_rust-crc+default-devel.sha256sum] = "fa5ca89d4f66838f0940f028011093c57ee1b7309a171b124395c521653dcb02"

URI_aarch64_rust-crc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-devel-3.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-devel}"
SRC_URI[aarch64_rust-crc-devel.sha256sum] = "c366bfece9960705bcae00ccc96c8c876e7bc7105ba59bca357b0bc7e3d8a305"

RDEPENDS:rust-crc+default-devel = " \
 cargo \
 rust-crc-devel \
 "
RDEPENDS:rust-crc-devel = " \
 cargo \
 rust \
 rust-crc-catalog+default-devel \
 "
