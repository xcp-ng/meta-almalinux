# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwalletmanager5"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kwalletmanager5 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kwalletmanager5-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "633b34fc24bf10afaaa8090deec0a2a721dcf75894277f05395f8f163cf337aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwalletmanager5-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwalletmanager5;unpack=0"
SRC_URI[x86_64_v2_kwalletmanager5.sha256sum] = "e6e27d7136dd8e9944c1a079a653893bfb7e9eb8f265c45dc5b5c077019c5f32"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kwalletmanager5-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kwalletmanager5;unpack=0"
SRC_URI[aarch64_kwalletmanager5.sha256sum] = "219d9adb0dfc9eb17d9ea4fc02a8bcece04f74e8e7cda2cc2596039ee7bd8111"

RDEPENDS:kwalletmanager5 = " \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kitemviews \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
