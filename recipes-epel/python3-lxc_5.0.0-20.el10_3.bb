# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3-lxc"
PV = "5.0.0"
PR = "20.el10_3"
PACKAGES = " \
 python3-lxc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python3-lxc-5.0.0-20.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c5794ab7902129bd0c296b5ab99c0ec6d939e2166e8cfa66a00880acae252f12"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lxc-5.0.0-20.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lxc;unpack=0"
SRC_URI[x86_64_v2_python3-lxc.sha256sum] = "a2cc016c9ceaa2fbfb4c272eb39aeee947d0b8aae112203441bcae63af697255"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-lxc-5.0.0-20.el10_3.aarch64.rpm;name=aarch64_python3-lxc;unpack=0"
SRC_URI[aarch64_python3-lxc.sha256sum] = "f903857ef6d00a4356c21d241da643d6ccafee2929fbd2c8cd0f161bf6e0a219"

RDEPENDS:python3-lxc = " \
 glibc \
 lxc-libs \
 python3 \
 "
