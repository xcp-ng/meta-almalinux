# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mstflint"
PV = "4.30.0"
PR = "1.el10"
PACKAGES = " \
 mstflint \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mstflint-4.30.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24eb1961415916d909a5c75c7c1e91e2184469c295d1f2ccfcf03b65ba78015d"

URI_x86_64_v2_mstflint = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mstflint-4.30.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_mstflint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mstflint}"
SRC_URI[x86_64_v2_mstflint.sha256sum] = "8ef291eade994b894771a48b6c8ed34595374963d729df8ef55ac663f6f974f9"

URI_aarch64_mstflint = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mstflint-4.30.0-1.el10.aarch64.rpm;name=aarch64_mstflint;unpack=0"
SRC_URI:append = " ${URI_aarch64_mstflint}"
SRC_URI[aarch64_mstflint.sha256sum] = "a26f49913b436ff0117e883d097f3ec92528d0e3ec52a993a4633cdf4993a4b2"

RDEPENDS:mstflint = " \
 bash \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 zlib-ng-compat \
 "
