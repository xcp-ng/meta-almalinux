# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdeedu-data"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kdeedu-data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdeedu-data-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e7728e2cbb3d4a2f7149fe0b0593e77785b2f769989a3d3329d79fde2485cc2"

URI_x86_64_v2_kdeedu-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeedu-data-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kdeedu-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdeedu-data}"
SRC_URI[x86_64_v2_kdeedu-data.sha256sum] = "147585fffc0195c399a996c02a74b0fdd42824328dc4cadb794296b8714629e5"

URI_aarch64_kdeedu-data = "${EPEL_MIRROR}/aarch64/Packages/k/kdeedu-data-25.08.1-1.el10_1.noarch.rpm;name=aarch64_kdeedu-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdeedu-data}"
SRC_URI[aarch64_kdeedu-data.sha256sum] = "5eadabf726a91719143d6ee303f815d7b021c9f73029916687d9ce302fac9d22"

RDEPENDS:kdeedu-data = " \
 hicolor-icon-theme \
 "
