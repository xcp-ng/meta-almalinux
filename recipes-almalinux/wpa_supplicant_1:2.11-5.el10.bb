# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wpa_supplicant"
PE = "1"
PV = "2.11"
PR = "5.el10"
PACKAGES = " \
 wpa_supplicant \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/wpa_supplicant-2.11-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fa9d68718991cdf2fb754fc17c5c0f9b2da8db2b653f1e94e367a7e69d02443"

URI_x86_64_v2_wpa_supplicant = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/wpa_supplicant-2.11-5.el10.x86_64_v2.rpm;name=x86_64_v2_wpa_supplicant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wpa_supplicant}"
SRC_URI[x86_64_v2_wpa_supplicant.sha256sum] = "769b050ba2e06c56ae9b49215803d93c58b037e58e60747a959d5b90fa678490"

URI_aarch64_wpa_supplicant = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/wpa_supplicant-2.11-5.el10.aarch64.rpm;name=aarch64_wpa_supplicant;unpack=0"
SRC_URI:append = " ${URI_aarch64_wpa_supplicant}"
SRC_URI[aarch64_wpa_supplicant.sha256sum] = "33cf552abd7453753520b5629fcee053a14aa73e8e264e413d4e2e0990a92d6c"

RDEPENDS:wpa_supplicant = " \
 bash \
 dbus-libs \
 glibc \
 libnl3 \
 openssl-libs \
 pkcs11-provider \
 systemd \
 "
