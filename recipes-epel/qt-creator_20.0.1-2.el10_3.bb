# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt-creator"
PV = "20.0.1"
PR = "2.el10_3"
PACKAGES = " \
 qt-creator \
 qt-creator-data \
 qt-creator-doc \
 qt-creator-translations \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/q/qt-creator-20.0.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b7bc3a1c60788d6f51e68444b611e0091fb66218eb85f56dd8f5217877a7a8c7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-20.0.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt-creator;unpack=0"
SRC_URI[x86_64_v2_qt-creator.sha256sum] = "3c09bef03007357c158f6eec44deaed9145c29555afb43841bc846ce9f881b66"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-data-20.0.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_qt-creator-data;unpack=0"
SRC_URI[x86_64_v2_qt-creator-data.sha256sum] = "e002c219e4783f68c006bb04150cf89d346c2f2ed02caf600ebd75e5b73ef6a3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-doc-20.0.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_qt-creator-doc;unpack=0"
SRC_URI[x86_64_v2_qt-creator-doc.sha256sum] = "c59a0b64ddb17b4632250ffff04c12d3795414a777556b5e0ff5e2b628523fd1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-translations-20.0.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_qt-creator-translations;unpack=0"
SRC_URI[x86_64_v2_qt-creator-translations.sha256sum] = "6eb15173fa454d0e6ff37608a78cfc76bfba02be6bf2ed85aa696b066a42df6b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-20.0.1-2.el10_3.aarch64.rpm;name=aarch64_qt-creator;unpack=0"
SRC_URI[aarch64_qt-creator.sha256sum] = "724ada3239df3a82e69ea01cf969a90718f8c86e09a9128907f4291ca6ceb09a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-data-20.0.1-2.el10_3.noarch.rpm;name=aarch64_qt-creator-data;unpack=0"
SRC_URI[aarch64_qt-creator-data.sha256sum] = "941748d7cd7e35d019fc6e1a59a30c06bac6381d3b65206436cca79887c5d5fd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-doc-20.0.1-2.el10_3.noarch.rpm;name=aarch64_qt-creator-doc;unpack=0"
SRC_URI[aarch64_qt-creator-doc.sha256sum] = "bea3f0e6272247e32663f9265b68d6e17c349a2c5f085aceff358530131e33d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-translations-20.0.1-2.el10_3.noarch.rpm;name=aarch64_qt-creator-translations;unpack=0"
SRC_URI[aarch64_qt-creator-translations.sha256sum] = "44f603f55cc31ced06ef13538f5bda9f29f25c38c17fe8d31f3f6e92a7d8f5e5"

RDEPENDS:qt-creator = " \
 bash \
 clang-libs \
 elfutils-libelf \
 elfutils-libs \
 glib2 \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 qt-creator-data \
 qt-creator-doc \
 qt-creator-translations \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 qt6-qtserialport \
 qt6-qtsvg \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-designercomponents \
 qt6-qttools-libs-help \
 qt6-qtwebengine \
 systemd-libs \
 xdg-utils \
 yaml-cpp \
 "
RDEPENDS:qt-creator-data = " \
 qt-creator \
 "
RDEPENDS:qt-creator-doc = " \
 qt-creator \
 "
RDEPENDS:qt-creator-translations = " \
 qt-creator-data \
 qt6-qttranslations \
 "
