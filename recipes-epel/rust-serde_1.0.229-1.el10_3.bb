# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde"
PV = "1.0.229"
PR = "1.el10_3"
PACKAGES = " \
 rust-serde+alloc-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde+serde_derive-devel \
 rust-serde+std-devel \
 rust-serde+unstable-devel \
 rust-serde-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-serde-1.0.229-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "753fe093d81ecd731d88adc3c06f055495f7529975ffa4d94d2b92ca57950443"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+alloc-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde+alloc-devel.sha256sum] = "61638586c2fca670bb152114b5aaa3a333259599b752c91ab7d5bbbbbfe9712a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+default-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde+default-devel.sha256sum] = "e21964f3ff3b744b3276ec72311c1f041b27be1bc6f08d8fdd8d2fdd6682fe63"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+derive-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde+derive-devel.sha256sum] = "0670ae4bd50f577d5c4da3498ed33ece3ebfeb68509d7df2e97eeef41de327fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+rc-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+rc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde+rc-devel.sha256sum] = "1af1cf5816a9bd71ff9909a48ae63690578a190a13ab9490ea2dd74bd070ff01"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+serde_derive-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+serde_derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde+serde_derive-devel.sha256sum] = "a3366b4fbec17687e982f456994f516be7c2b41128fa90483f19120c31e8013b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+std-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde+std-devel.sha256sum] = "934a950c10b1685401bc4ceacdfe0e825ef16531ee1137216ac8289b99bfaaee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+unstable-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+unstable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde+unstable-devel.sha256sum] = "3561f23d950b3078d5094e329593dbcb904b1a034d011fc0abe74f1dfb5a33d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde-devel.sha256sum] = "a8520ca289368d32b400bf4383dd45255143039c430fa3fd306ab76b4812db5a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+alloc-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-serde+alloc-devel.sha256sum] = "7efcbbf53623a72ad8da24e2e8a4b9efc4b8413f41ae2b744d3902633192af95"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+default-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde+default-devel;unpack=0"
SRC_URI[aarch64_rust-serde+default-devel.sha256sum] = "f9a0b7c83ee228a6028d51c2a97646a95d9cb384418bb2ea8951db623fc8f77c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+derive-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde+derive-devel;unpack=0"
SRC_URI[aarch64_rust-serde+derive-devel.sha256sum] = "8ea53d93c453b84966110461d873d9f60c87d4f9a708e69dc4e7ce40ef37d21d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+rc-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde+rc-devel;unpack=0"
SRC_URI[aarch64_rust-serde+rc-devel.sha256sum] = "222f90c76f2fda7b2442473f9541b59874236efaca3e3e2bfd00e6a83ea4a7c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+serde_derive-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde+serde_derive-devel;unpack=0"
SRC_URI[aarch64_rust-serde+serde_derive-devel.sha256sum] = "52dbf312c6bfcaf0edce5142baffa2223decc291f405d7a91e048aa801ad1cd9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+std-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde+std-devel;unpack=0"
SRC_URI[aarch64_rust-serde+std-devel.sha256sum] = "fa20b121dbdbff6d0288f2962404d3208bc46dc4dba3fc18da4ed1588ebcac27"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+unstable-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde+unstable-devel;unpack=0"
SRC_URI[aarch64_rust-serde+unstable-devel.sha256sum] = "06dc9c75d4a5854b9ab02bf1c7ff98f85af3b04e353c97d7936ab72c27cd2037"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde-devel;unpack=0"
SRC_URI[aarch64_rust-serde-devel.sha256sum] = "7b58236a7d3bcd034f9da049b2a5e7bb3a057126952bb2b6dd505147dbc349b8"

RDEPENDS:rust-serde+alloc-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+alloc-devel \
 "
RDEPENDS:rust-serde+default-devel = " \
 cargo \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-serde+derive-devel = " \
 cargo \
 rust-serde+serde_derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-serde+rc-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+rc-devel \
 "
RDEPENDS:rust-serde+serde_derive-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-serde+std-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+std-devel \
 "
RDEPENDS:rust-serde+unstable-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+unstable-devel \
 "
RDEPENDS:rust-serde-devel = " \
 cargo \
 rust \
 rust-serde_core+result-devel \
 rust-serde_core-devel \
 "
