# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-rust"
PV = "0.23.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter-rust+default-devel \
 rust-tree-sitter-rust-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-rust-0.23.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a47994ae7959a284400638e0ae2e5151d88737d8628538e9915b43dfa739a9a5"

URI_x86_64_v2_rust-tree-sitter-rust+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-rust+default-devel-0.23.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-rust+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-rust+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-rust+default-devel.sha256sum] = "9eab7e764ae51a304bed05759b40aa5223071dd3ea8dbf7d7516517b9fdb591e"

URI_x86_64_v2_rust-tree-sitter-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-rust-devel-0.23.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-rust-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-rust-devel.sha256sum] = "053ac8054e845fd1ea7723637b16ecdcfbab2fb20ba39e06c761c8f7a15e45e9"

URI_aarch64_rust-tree-sitter-rust+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-rust+default-devel-0.23.2-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-rust+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-rust+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-rust+default-devel.sha256sum] = "7e1bc6824f9c373e318899e6a32b34392e731a1f441393dc26c2df9f4ab6b08b"

URI_aarch64_rust-tree-sitter-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-rust-devel-0.23.2-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-rust-devel}"
SRC_URI[aarch64_rust-tree-sitter-rust-devel.sha256sum] = "7529c80fd29ee45a0a75e602b9aeb1bfda7071782f36463293f27d149da5d7d9"

RDEPENDS:rust-tree-sitter-rust+default-devel = " \
 cargo \
 rust-tree-sitter-rust-devel \
 "
RDEPENDS:rust-tree-sitter-rust-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
