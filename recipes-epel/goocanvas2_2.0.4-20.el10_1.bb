# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "goocanvas2"
PV = "2.0.4"
PR = "20.el10_1"
PACKAGES = " \
 goocanvas2 \
 goocanvas2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/goocanvas2-2.0.4-20.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3aa549913fbecfb1faa6e04b42d2aba9fa0c6f08b229d9871ca375cd76da595f"

URI_x86_64_v2_goocanvas2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/goocanvas2-2.0.4-20.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_goocanvas2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_goocanvas2}"
SRC_URI[x86_64_v2_goocanvas2.sha256sum] = "b0d625f1eda8a6b688ec84e21e09bd2ea5d2ef9909d1c88f7ed2364e75f67c7f"

URI_x86_64_v2_goocanvas2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/goocanvas2-devel-2.0.4-20.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_goocanvas2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_goocanvas2-devel}"
SRC_URI[x86_64_v2_goocanvas2-devel.sha256sum] = "bbfe03803cf51e946c72d62fb3ee9f094cf9a40256cee7c035f17e20e73affcd"

URI_aarch64_goocanvas2 = "${EPEL_MIRROR}/aarch64/Packages/g/goocanvas2-2.0.4-20.el10_1.aarch64.rpm;name=aarch64_goocanvas2;unpack=0"
SRC_URI:append = " ${URI_aarch64_goocanvas2}"
SRC_URI[aarch64_goocanvas2.sha256sum] = "cb53668538b30248c339de332e3e287b672297f11f1e95af5b55b8c905ee9d92"

URI_aarch64_goocanvas2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/goocanvas2-devel-2.0.4-20.el10_1.aarch64.rpm;name=aarch64_goocanvas2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_goocanvas2-devel}"
SRC_URI[aarch64_goocanvas2-devel.sha256sum] = "577b85175c6e87c366b068fcef505451d8bdb1599557122568fba414d36f2bff"

RDEPENDS:goocanvas2 = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 pango \
 "
RDEPENDS:goocanvas2-devel = " \
 cairo-devel \
 goocanvas2 \
 gtk3-devel \
 pkgconf-pkg-config \
 "
