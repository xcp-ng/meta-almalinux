# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gscan2pdf"
PV = "2.13.4"
PR = "5.el10_0"
PACKAGES = " \
 gscan2pdf \
 gscan2pdf-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gscan2pdf-2.13.4-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ed951d6d303ff873f6c9ca72c72bb0f6d03c9680760e22707f7bfc82cd9bbdb"

URI_x86_64_v2_gscan2pdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gscan2pdf-2.13.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gscan2pdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gscan2pdf}"
SRC_URI[x86_64_v2_gscan2pdf.sha256sum] = "a3fe1a21a1549a6914e8019fc3c5a97364f3d67d1bee0343a5bb09517ad684ca"

URI_x86_64_v2_gscan2pdf-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gscan2pdf-tests-2.13.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gscan2pdf-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gscan2pdf-tests}"
SRC_URI[x86_64_v2_gscan2pdf-tests.sha256sum] = "ba7d0eba628221532487db848a8ec9c0358ebc2739cdbb4f13499cc76535429f"

URI_aarch64_gscan2pdf = "${EPEL_MIRROR}/aarch64/Packages/g/gscan2pdf-2.13.4-5.el10_0.noarch.rpm;name=aarch64_gscan2pdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_gscan2pdf}"
SRC_URI[aarch64_gscan2pdf.sha256sum] = "8dd5ad8155738962a42eb976b468a7f47e41ef1f6951db8d5db68a05ee39819d"

URI_aarch64_gscan2pdf-tests = "${EPEL_MIRROR}/aarch64/Packages/g/gscan2pdf-tests-2.13.4-5.el10_0.noarch.rpm;name=aarch64_gscan2pdf-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_gscan2pdf-tests}"
SRC_URI[aarch64_gscan2pdf-tests.sha256sum] = "599625fd2ce8abb2a5808b492693487d39fc51b23065737977fb612ac992aee5"

RDEPENDS:gscan2pdf = " \
 ImageMagick \
 ImageMagick-perl \
 bash \
 gscan2pdf \
 libtiff-tools \
 perl-Archive-Tar \
 perl-Carp \
 perl-Config-General \
 perl-Data-Dumper \
 perl-Data-UUID \
 perl-Date-Calc \
 perl-Encode \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-FileHandle \
 perl-Filesys-Df \
 perl-Getopt-Long \
 perl-Glib \
 perl-Glib-Object-Introspection \
 perl-GooCanvas2 \
 perl-Gtk3 \
 perl-Gtk3-ImageView \
 perl-Gtk3-SimpleList \
 perl-HTML-Parser \
 perl-IO \
 perl-IPC-Open3 \
 perl-Image-Sane \
 perl-JSON-PP \
 perl-List-MoreUtils \
 perl-Locale-Codes \
 perl-Locale-gettext \
 perl-Log-Log4perl \
 perl-PDF-Builder \
 perl-POSIX \
 perl-PathTools \
 perl-Proc-ProcessTable \
 perl-Readonly \
 perl-Set-IntSpan \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-Text-ParseWords \
 perl-Thread-Queue \
 perl-Time-Piece \
 perl-Try-Tiny \
 perl-base \
 perl-if \
 perl-interpreter \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 perl-version \
 sane-backends \
 sane-frontends \
 "
RDEPENDS:gscan2pdf-tests = " \
 ImageMagick-djvu \
 bash \
 dejavu-sans-fonts \
 file \
 fontconfig \
 ghostscript \
 gscan2pdf \
 mutter \
 perl-Carp \
 perl-Data-Dumper \
 perl-Date-Calc \
 perl-Encode \
 perl-Exception-Class \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-File-stat \
 perl-Glib \
 perl-Gtk3 \
 perl-IPC-Cmd \
 perl-IPC-System-Simple \
 perl-Image-Sane \
 perl-Log-Log4perl \
 perl-MIME-Base64 \
 perl-PDF-Builder \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Sub-Override \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-interpreter \
 perl-libs \
 perl-version \
 poppler-utils \
 sane-backends-drivers-scanners \
 sane-frontends \
 virtual/coreutils \
 xwayland-run \
 "
