# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ttmkfdir"
PV = "3.0.9"
PR = "72.el10"
PACKAGES = " \
 ttmkfdir \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ttmkfdir-3.0.9-72.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e47b43af966868ce2f867da13cc229a8639d2b00d54eaa3294aba5829e84bc50"

URI_x86_64_v2_ttmkfdir = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ttmkfdir-3.0.9-72.el10.x86_64_v2.rpm;name=x86_64_v2_ttmkfdir;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ttmkfdir}"
SRC_URI[x86_64_v2_ttmkfdir.sha256sum] = "7b4e7dfcf63ca1443cc369b4d9e36ec6b737f5e08c639c2754d4290a138834f2"

URI_aarch64_ttmkfdir = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ttmkfdir-3.0.9-72.el10.aarch64.rpm;name=aarch64_ttmkfdir;unpack=0"
SRC_URI:append = " ${URI_aarch64_ttmkfdir}"
SRC_URI[aarch64_ttmkfdir.sha256sum] = "8e8fdecee3a488bd02822ec22491bac809bf038118381745592090e80c7e323d"

RDEPENDS:ttmkfdir = " \
 freetype \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
