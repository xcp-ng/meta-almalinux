# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-charlievieth-fastwalk"
PV = "1.0.9"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-charlievieth-fastwalk-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-charlievieth-fastwalk-1.0.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "80704e96a7d10b5df7f60990eb320bc7683fe537982f6b861424adc7059734e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-charlievieth-fastwalk-devel-1.0.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-charlievieth-fastwalk-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-charlievieth-fastwalk-devel.sha256sum] = "6bf0832c7a44a424a267e50e532a891769927cd33dd525b19e773ea4f9a9d805"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-charlievieth-fastwalk-devel-1.0.9-1.el10_0.noarch.rpm;name=aarch64_golang-github-charlievieth-fastwalk-devel;unpack=0"
SRC_URI[aarch64_golang-github-charlievieth-fastwalk-devel.sha256sum] = "da42f812dc399e121ab989f24bb7f00891f16fc352868fcd41ccf3a9c4dc403e"

RDEPENDS:golang-github-charlievieth-fastwalk-devel = " \
 go-filesystem \
 "
