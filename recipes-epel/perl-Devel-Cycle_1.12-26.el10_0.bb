# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-Cycle"
PV = "1.12"
PR = "26.el10_0"
PACKAGES = " \
 perl-Devel-Cycle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-Cycle-1.12-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7642227844f5b4e50473c32ecd78fd6d82e935c99171ad4a56a3db7e4c3d98c1"

URI_x86_64_v2_perl-Devel-Cycle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-Cycle-1.12-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Devel-Cycle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-Cycle}"
SRC_URI[x86_64_v2_perl-Devel-Cycle.sha256sum] = "25d62a173f329cdd8f60641f6edca9acca1b7f33390647c2e1cc0e2f02e08132"

URI_aarch64_perl-Devel-Cycle = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-Cycle-1.12-26.el10_0.noarch.rpm;name=aarch64_perl-Devel-Cycle;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-Cycle}"
SRC_URI[aarch64_perl-Devel-Cycle.sha256sum] = "ac5dcc068a2c31be53c913397e221324cfb624efba70ca77a0728383338d78cf"

RDEPENDS:perl-Devel-Cycle = " \
 perl-Carp \
 perl-Exporter \
 perl-PadWalker \
 perl-Scalar-List-Utils \
 perl-libs \
 "
