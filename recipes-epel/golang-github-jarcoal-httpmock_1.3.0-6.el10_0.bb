# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-jarcoal-httpmock"
PV = "1.3.0"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-jarcoal-httpmock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-jarcoal-httpmock-1.3.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9afbc429e7f34788f23d82c077f02d6dc8d4929e7516f24334c667b084a3322"

URI_x86_64_v2_golang-github-jarcoal-httpmock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-jarcoal-httpmock-devel-1.3.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-jarcoal-httpmock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-jarcoal-httpmock-devel}"
SRC_URI[x86_64_v2_golang-github-jarcoal-httpmock-devel.sha256sum] = "f425f05de3a714bc8fd4bcb61bbccb2826c54b919a5fb10f07a6f8494ee7c975"

URI_aarch64_golang-github-jarcoal-httpmock-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-jarcoal-httpmock-devel-1.3.0-6.el10_0.noarch.rpm;name=aarch64_golang-github-jarcoal-httpmock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-jarcoal-httpmock-devel}"
SRC_URI[aarch64_golang-github-jarcoal-httpmock-devel.sha256sum] = "c7d5cc89bbc3a4535a58df985d3395952a10de324bff7dd37202a4e944e7b911"

RDEPENDS:golang-github-jarcoal-httpmock-devel = " \
 go-filesystem \
 "
