# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ifaddr"
PV = "0.2.0"
PR = "4.el10"
PACKAGES = " \
 python3-ifaddr \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-ifaddr-0.2.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "379a0883242f1b177da795464b50a17c450d94198a051d853e4295fb3734b4de"

URI_x86_64_v2_python3-ifaddr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ifaddr-0.2.0-4.el10.noarch.rpm;name=x86_64_v2_python3-ifaddr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ifaddr}"
SRC_URI[x86_64_v2_python3-ifaddr.sha256sum] = "9b1c5084c9ea1b552d50b9e8b9a44bcfd409b30222d4ac634472b4a044844ecc"

URI_aarch64_python3-ifaddr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ifaddr-0.2.0-4.el10.noarch.rpm;name=aarch64_python3-ifaddr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ifaddr}"
SRC_URI[aarch64_python3-ifaddr.sha256sum] = "9b1c5084c9ea1b552d50b9e8b9a44bcfd409b30222d4ac634472b4a044844ecc"

RDEPENDS:python3-ifaddr = " \
 python3 \
 "
