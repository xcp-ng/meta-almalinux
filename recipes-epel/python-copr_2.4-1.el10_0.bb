# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-copr"
PV = "2.4"
PR = "1.el10_0"
PACKAGES = " \
 python-copr-doc \
 python3-copr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-copr-2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "197fbb7ad86f34b2d4f6ba244e9423444237cbfd9ee9d4608f431f1000a1a6c0"

URI_x86_64_v2_python-copr-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-copr-doc-2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-copr-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-copr-doc}"
SRC_URI[x86_64_v2_python-copr-doc.sha256sum] = "32a8ef5909c225ba1d09bc6a859d37b4f9c9226039d986d010dd8be71b67f101"

URI_x86_64_v2_python3-copr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-copr-2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-copr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-copr}"
SRC_URI[x86_64_v2_python3-copr.sha256sum] = "1b40318ff1d5e7515756107c57779bc406c5e61b3b288974fd58378113cb671b"

URI_aarch64_python-copr-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-copr-doc-2.4-1.el10_0.noarch.rpm;name=aarch64_python-copr-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-copr-doc}"
SRC_URI[aarch64_python-copr-doc.sha256sum] = "10171b2be4bcd8150b77105ffc1b6cb8c1244a548390bc3783ec660a5fb7c229"

URI_aarch64_python3-copr = "${EPEL_MIRROR}/aarch64/Packages/p/python3-copr-2.4-1.el10_0.noarch.rpm;name=aarch64_python3-copr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-copr}"
SRC_URI[aarch64_python3-copr.sha256sum] = "e2e85c29716f31376467a1e9108665f17c94d0808810cc32134fcd8fc222c63a"

RDEPENDS:python-copr-doc = " \
 "
RDEPENDS:python3-copr = " \
 python3 \
 python3-filelock \
 python3-munch \
 python3-requests \
 python3-requests-gssapi \
 python3-requests-toolbelt \
 python3-setuptools \
 "
