# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-view"
PV = "0.9.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-below-view+default-devel \
 rust-below-view-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-view-0.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7218c1e5d8a00ce6fe186a49a828213fbc86271ea80195fdec061bda15923f4"

URI_x86_64_v2_rust-below-view+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-view+default-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-view+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-view+default-devel}"
SRC_URI[x86_64_v2_rust-below-view+default-devel.sha256sum] = "accd2b5510020f7abc5512759dcc92a728d7869c8ed9f7f26222fdbf021353a1"

URI_x86_64_v2_rust-below-view-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-view-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-view-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-view-devel}"
SRC_URI[x86_64_v2_rust-below-view-devel.sha256sum] = "17942bf79e16910fb054ea1bd4790e0f7861edcc956d66e97867956f32e12a6c"

URI_aarch64_rust-below-view+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-view+default-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below-view+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-view+default-devel}"
SRC_URI[aarch64_rust-below-view+default-devel.sha256sum] = "b737901f012d666066894fc19c3e3ede055a2120d917dd142f5aad761850a35c"

URI_aarch64_rust-below-view-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-view-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below-view-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-view-devel}"
SRC_URI[aarch64_rust-below-view-devel.sha256sum] = "126f664a0c78c82a468fa9a9ca2e75861263595aab4ebb28dadfac0c48c09cd6"

RDEPENDS:rust-below-view+default-devel = " \
 cargo \
 rust-below-view-devel \
 "
RDEPENDS:rust-below-view-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-below-common+default-devel \
 rust-below-model+default-devel \
 rust-below-render+default-devel \
 rust-below-store+default-devel \
 rust-chrono+clock-devel \
 rust-chrono+serde-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-crossterm0.28+default-devel \
 rust-crossterm0.28+event-stream-devel \
 rust-cursive0.20+crossterm-backend-devel \
 rust-cursive0.20-devel \
 rust-cursive_buffered_backend+default-devel \
 rust-enum-iterator+default-devel \
 rust-fb_procfs+default-devel \
 rust-humantime+default-devel \
 rust-itertools0.14+default-devel \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-slog+default-devel \
 rust-slog+max_level_trace-devel \
 rust-slog+nested-values-devel \
 rust-toml0.8+default-devel \
 "
