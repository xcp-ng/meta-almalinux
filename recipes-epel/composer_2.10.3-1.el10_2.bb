# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "composer"
PV = "2.10.3"
PR = "1.el10_2"
PACKAGES = " \
 composer \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/composer-2.10.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a339bfb6c2562ef189abd2af0ea2aae5139f98d4d262c73702653b595b8a7fe6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/composer-2.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_composer;unpack=0"
SRC_URI[x86_64_v2_composer.sha256sum] = "0344fac75989061438dfa417f146ccf9970c78b1dbb452feea5af0816720580a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/composer-2.10.3-1.el10_2.noarch.rpm;name=aarch64_composer;unpack=0"
SRC_URI[aarch64_composer.sha256sum] = "9f0a00e5c2334420484f6a9c4179091031957d9e01e06b3ced6d97537bb274be"

RDEPENDS:composer = " \
 bash \
 ca-certificates \
 virtual//usr/bin/php \
 virtual/php-cli \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-date \
 virtual/php-dom \
 virtual/php-filter \
 virtual/php-hash \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-libxml \
 virtual/php-mbstring \
 virtual/php-openssl \
 virtual/php-pcntl \
 virtual/php-pcre \
 virtual/php-phar \
 virtual/php-posix \
 virtual/php-reflection \
 virtual/php-spl \
 virtual/php-tokenizer \
 virtual/php-xsl \
 virtual/php-zip \
 virtual/php-zlib \
 virtual/php_language__ge_7.2.5 \
 "
