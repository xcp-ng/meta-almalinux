# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-OpenID-Server"
PV = "1.09"
PR = "29.el10_0"
PACKAGES = " \
 perl-Net-OpenID-Server \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-OpenID-Server-1.09-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0fba3df7b1145d3892f8867a44eb0d17ee0dff7ea676eb524928c1a0e704550"

URI_x86_64_v2_perl-Net-OpenID-Server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-OpenID-Server-1.09-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-OpenID-Server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-OpenID-Server}"
SRC_URI[x86_64_v2_perl-Net-OpenID-Server.sha256sum] = "c9773ba0e1dfc82055dcf2c008e489550682cc42aa4229ee35cbe57018d552a0"

URI_aarch64_perl-Net-OpenID-Server = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-OpenID-Server-1.09-29.el10_0.noarch.rpm;name=aarch64_perl-Net-OpenID-Server;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-OpenID-Server}"
SRC_URI[aarch64_perl-Net-OpenID-Server.sha256sum] = "d5ed4c62e7e82234659fd73f6cf2950e15ef505588a7c435f3917595e82d3cee"

RDEPENDS:perl-Net-OpenID-Server = " \
 perl-Carp \
 perl-Digest-SHA \
 perl-MIME-Base64 \
 perl-Net-OpenID-Common \
 perl-Time-Local \
 perl-URI \
 perl-fields \
 perl-libs \
 "
