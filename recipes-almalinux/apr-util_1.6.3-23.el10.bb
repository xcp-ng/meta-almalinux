# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apr-util"
PV = "1.6.3"
PR = "23.el10"
PACKAGES = " \
 apr-util \
 apr-util-devel \
 apr-util-ldap \
 apr-util-lmdb \
 apr-util-mysql \
 apr-util-odbc \
 apr-util-openssl \
 apr-util-pgsql \
 apr-util-sqlite \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/apr-util-1.6.3-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43cee93cc21da34306ae443d1a398544b5d417332459730b26485a2c88eef62c"

URI_x86_64_v2_apr-util = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-1.6.3-23.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util}"
SRC_URI[x86_64_v2_apr-util.sha256sum] = "05f317a1ca074a7e3e14f709295c706024eb183ca46f1a22d3544138aac08cc3"

URI_x86_64_v2_apr-util-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-devel-1.6.3-23.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-devel}"
SRC_URI[x86_64_v2_apr-util-devel.sha256sum] = "8a3ddbdfffe31d7cb8116c5b3a6ea66bd369902e01f0992aa291eb348d9488ac"

URI_x86_64_v2_apr-util-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-ldap-1.6.3-23.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-ldap}"
SRC_URI[x86_64_v2_apr-util-ldap.sha256sum] = "6a9c98d68791dcc74294e9addae338a07ae15f8c5203968369951b1de91b5f06"

URI_x86_64_v2_apr-util-lmdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-lmdb-1.6.3-23.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-lmdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-lmdb}"
SRC_URI[x86_64_v2_apr-util-lmdb.sha256sum] = "ffd983e50df2048a72130df8dc27c7c32104e236df17e0ca46bdce6476707d16"

URI_x86_64_v2_apr-util-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-mysql-1.6.3-23.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-mysql}"
SRC_URI[x86_64_v2_apr-util-mysql.sha256sum] = "71be00307de201e71a457faa06c4fb0c2c0f8772e74e8fcbaa6e180318010b4c"

URI_x86_64_v2_apr-util-odbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-odbc-1.6.3-23.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-odbc}"
SRC_URI[x86_64_v2_apr-util-odbc.sha256sum] = "64aa0c3398e6874987d8483b79d234bfe016d828c12b26acb6433daa3dce3388"

URI_x86_64_v2_apr-util-openssl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-openssl-1.6.3-23.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-openssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-openssl}"
SRC_URI[x86_64_v2_apr-util-openssl.sha256sum] = "ee6863ebf88ec4c38f1dcf8168ec25d86d0f2385fc00f3f2e12af2d21051d0b8"

URI_x86_64_v2_apr-util-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-pgsql-1.6.3-23.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-pgsql}"
SRC_URI[x86_64_v2_apr-util-pgsql.sha256sum] = "fbf2152fc7e631ee84a4f7bc211b63bfa2aab19e170d54327edb45c54cddd5b0"

URI_x86_64_v2_apr-util-sqlite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-sqlite-1.6.3-23.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-sqlite}"
SRC_URI[x86_64_v2_apr-util-sqlite.sha256sum] = "79d025de70c684f45bddbd4e952671ab7d5f9c9310627f1bc67643cdb75bd30a"

URI_aarch64_apr-util = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-1.6.3-23.el10.aarch64.rpm;name=aarch64_apr-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util}"
SRC_URI[aarch64_apr-util.sha256sum] = "a2bf2de0de07c9d3b0c69bd65bd337e3068e26bb32145491cebcefb4c470dbaf"

URI_aarch64_apr-util-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-devel-1.6.3-23.el10.aarch64.rpm;name=aarch64_apr-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-devel}"
SRC_URI[aarch64_apr-util-devel.sha256sum] = "a91a615242ab9a3b79829ede22ef130ec8c32efb7365deee70934218a92f0795"

URI_aarch64_apr-util-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-ldap-1.6.3-23.el10.aarch64.rpm;name=aarch64_apr-util-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-ldap}"
SRC_URI[aarch64_apr-util-ldap.sha256sum] = "262923d84591adbdffce795d67bcef09ddc481b9d316ac883b907edd0b76ba0e"

URI_aarch64_apr-util-lmdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-lmdb-1.6.3-23.el10.aarch64.rpm;name=aarch64_apr-util-lmdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-lmdb}"
SRC_URI[aarch64_apr-util-lmdb.sha256sum] = "1aad3bf842b32e4ae0668e77f2f38bd745a3bf672e437a1b886e219ec9f57101"

URI_aarch64_apr-util-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-mysql-1.6.3-23.el10.aarch64.rpm;name=aarch64_apr-util-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-mysql}"
SRC_URI[aarch64_apr-util-mysql.sha256sum] = "3d34288964a1a989a3f6c6df2b05c5d36d3adc639a38166b7a82b66fae31b663"

URI_aarch64_apr-util-odbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-odbc-1.6.3-23.el10.aarch64.rpm;name=aarch64_apr-util-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-odbc}"
SRC_URI[aarch64_apr-util-odbc.sha256sum] = "e335d1b08f91a80cc54f64dc112aea61e1500e24eb852e00414278b779ef8168"

URI_aarch64_apr-util-openssl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-openssl-1.6.3-23.el10.aarch64.rpm;name=aarch64_apr-util-openssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-openssl}"
SRC_URI[aarch64_apr-util-openssl.sha256sum] = "96f433b8200e435ee8a7c2f5440dd9ccbd335b887dba85795d3b52bbebc4ea5c"

URI_aarch64_apr-util-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-pgsql-1.6.3-23.el10.aarch64.rpm;name=aarch64_apr-util-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-pgsql}"
SRC_URI[aarch64_apr-util-pgsql.sha256sum] = "0a98a818a3ac2ee09bc78a34398762d79e65377386ffe5954d59fa35e7ea1cf6"

URI_aarch64_apr-util-sqlite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-sqlite-1.6.3-23.el10.aarch64.rpm;name=aarch64_apr-util-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-sqlite}"
SRC_URI[aarch64_apr-util-sqlite.sha256sum] = "0804c7e674d3a38f80fea1af52b0414317c2e7cabc1b73cfbd16f52fa966cf68"

RDEPENDS:apr-util = " \
 apr \
 expat \
 glibc \
 libuuid \
 libxcrypt \
 "
RDEPENDS:apr-util-devel = " \
 apr-devel \
 apr-util \
 bash \
 expat-devel \
 openldap-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:apr-util-ldap = " \
 apr-util \
 glibc \
 openldap \
 "
RDEPENDS:apr-util-lmdb = " \
 apr-util \
 glibc \
 lmdb-libs \
 "
RDEPENDS:apr-util-mysql = " \
 apr-util \
 glibc \
 mariadb-connector-c \
 "
RDEPENDS:apr-util-odbc = " \
 apr-util \
 glibc \
 unixODBC \
 "
RDEPENDS:apr-util-openssl = " \
 apr-util \
 glibc \
 openssl-libs \
 "
RDEPENDS:apr-util-pgsql = " \
 apr-util \
 glibc \
 libpq \
 "
RDEPENDS:apr-util-sqlite = " \
 apr-util \
 glibc \
 sqlite-libs \
 "
