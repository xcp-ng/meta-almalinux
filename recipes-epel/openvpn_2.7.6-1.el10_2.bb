# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openvpn"
PV = "2.7.6"
PR = "1.el10_2"
PACKAGES = " \
 openvpn \
 openvpn-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openvpn-2.7.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "204f8928bb6683e68075eca4e8a7b286131692da1049c64b3dacd02a64271830"

URI_x86_64_v2_openvpn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvpn-2.7.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvpn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvpn}"
SRC_URI[x86_64_v2_openvpn.sha256sum] = "b5b2683c410220e1509ce13de9c44ef5d1451fa10be3e28c55c167658e076e38"

URI_x86_64_v2_openvpn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvpn-devel-2.7.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvpn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvpn-devel}"
SRC_URI[x86_64_v2_openvpn-devel.sha256sum] = "97f86ec6882eff68d015c3b648444012d43d3107cbf3a0eb1ad59ee97bb16557"

URI_aarch64_openvpn = "${EPEL_MIRROR}/aarch64/Packages/o/openvpn-2.7.6-1.el10_2.aarch64.rpm;name=aarch64_openvpn;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvpn}"
SRC_URI[aarch64_openvpn.sha256sum] = "f5f559a5213c982ae8cb004a8b6c7556419428d24e78babe4db5bf1e3213ffff"

URI_aarch64_openvpn-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openvpn-devel-2.7.6-1.el10_2.aarch64.rpm;name=aarch64_openvpn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvpn-devel}"
SRC_URI[aarch64_openvpn-devel.sha256sum] = "d696aff00c84fe0af6726deb01d0d63cdc513f937cb2095f1878d38a346c602b"

RDEPENDS:openvpn = " \
 bash \
 gawk \
 glibc \
 libcap-ng \
 libnl3 \
 libselinux \
 lz4-libs \
 lzo \
 openssl-libs \
 pam-libs \
 pkcs11-helper \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:openvpn-devel = " \
 "
