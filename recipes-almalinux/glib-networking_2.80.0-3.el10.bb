# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glib-networking"
PV = "2.80.0"
PR = "3.el10"
PACKAGES = " \
 glib-networking \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/glib-networking-2.80.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ca8135a4763d41cf0ca80fd60cbe85817474de3bef5b232a748bb663425b4a5"

URI_x86_64_v2_glib-networking = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glib-networking-2.80.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_glib-networking;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib-networking}"
SRC_URI[x86_64_v2_glib-networking.sha256sum] = "ef155884f1c28dbc02d2f9ccd39f614d6702220e64a1f744a143048943f4cf3a"

URI_aarch64_glib-networking = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glib-networking-2.80.0-3.el10.aarch64.rpm;name=aarch64_glib-networking;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib-networking}"
SRC_URI[aarch64_glib-networking.sha256sum] = "4c288898b2720042fb97c6fe451f27a075495c2c75293d45b8b7bc86ea0625f1"

RDEPENDS:glib-networking = " \
 ca-certificates \
 glib2 \
 glibc \
 gnutls \
 gsettings-desktop-schemas \
 libproxy \
 "
