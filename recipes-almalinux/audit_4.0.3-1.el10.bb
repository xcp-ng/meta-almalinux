# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audit"
PV = "4.0.3"
PR = "1.el10"
PACKAGES = " \
 audispd-plugins \
 audispd-plugins-zos \
 audit \
 audit-libs \
 audit-libs-devel \
 audit-rules \
 python3-audit \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/audit-4.0.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdd9d3649e2140bf43dff886716c58dcb983ca7ed9eefb7c41def27737c24db6"

URI_x86_64_v2_audispd-plugins = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audispd-plugins-4.0.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_audispd-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audispd-plugins}"
SRC_URI[x86_64_v2_audispd-plugins.sha256sum] = "3629ac3ba33559ee006ab593734b776532545578ee3720b0fabbaa16e70c07b1"

URI_x86_64_v2_audispd-plugins-zos = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audispd-plugins-zos-4.0.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_audispd-plugins-zos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audispd-plugins-zos}"
SRC_URI[x86_64_v2_audispd-plugins-zos.sha256sum] = "a142b27256c82239e1f9bc822ccc89db90072ed7631a47f0bc002fd407e7e1d6"

URI_x86_64_v2_audit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audit-4.0.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_audit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audit}"
SRC_URI[x86_64_v2_audit.sha256sum] = "b9e0c6f906fa90a90e06276536ea51e0abfafe0e523cbe7735b1a069597b2f08"

URI_x86_64_v2_audit-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audit-libs-4.0.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_audit-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audit-libs}"
SRC_URI[x86_64_v2_audit-libs.sha256sum] = "3ea9acdb8d7b4fc0126370cd22b53114e4379107f77a22443ba68fa551c204a3"

URI_x86_64_v2_audit-libs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/audit-libs-devel-4.0.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_audit-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audit-libs-devel}"
SRC_URI[x86_64_v2_audit-libs-devel.sha256sum] = "ecbf5ce11111421d06d40258ee5b49de81844b14391a3e6b7a48946cc7af6a24"

URI_x86_64_v2_audit-rules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audit-rules-4.0.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_audit-rules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audit-rules}"
SRC_URI[x86_64_v2_audit-rules.sha256sum] = "bbf964c3ec8b2d599bb50e44b304754c6711334ef11898a016ab04665d56890f"

URI_x86_64_v2_python3-audit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-audit-4.0.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-audit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-audit}"
SRC_URI[x86_64_v2_python3-audit.sha256sum] = "ff04b7cbfe47f87e32203790228f4dd67b8b62adc3b3ec7f74a36ff494e60f04"

URI_aarch64_audispd-plugins = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audispd-plugins-4.0.3-1.el10.aarch64.rpm;name=aarch64_audispd-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_audispd-plugins}"
SRC_URI[aarch64_audispd-plugins.sha256sum] = "77aedc0f89153dc127c6972351c06f297e83b9522db2cfe9c106cb283fb51515"

URI_aarch64_audispd-plugins-zos = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audispd-plugins-zos-4.0.3-1.el10.aarch64.rpm;name=aarch64_audispd-plugins-zos;unpack=0"
SRC_URI:append = " ${URI_aarch64_audispd-plugins-zos}"
SRC_URI[aarch64_audispd-plugins-zos.sha256sum] = "5982008ddba2b10227f943f31c0209967fd400791ca4ce5dca449d2794a1a715"

URI_aarch64_audit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audit-4.0.3-1.el10.aarch64.rpm;name=aarch64_audit;unpack=0"
SRC_URI:append = " ${URI_aarch64_audit}"
SRC_URI[aarch64_audit.sha256sum] = "3d458bc7b6b829246e8bcb5a1b7c68298ec62211ceec46983a992fac8b4f2806"

URI_aarch64_audit-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audit-libs-4.0.3-1.el10.aarch64.rpm;name=aarch64_audit-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_audit-libs}"
SRC_URI[aarch64_audit-libs.sha256sum] = "3f4c5d3acd8affff532e4ff2ddc71c94060ac126d9a10490ead4842eb13fb2ed"

URI_aarch64_audit-libs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/audit-libs-devel-4.0.3-1.el10.aarch64.rpm;name=aarch64_audit-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_audit-libs-devel}"
SRC_URI[aarch64_audit-libs-devel.sha256sum] = "1ea3daefbb0a5c61cdb32d8bb5de52f4126d624b1a410ccf1d17ec88bfe23743"

URI_aarch64_audit-rules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audit-rules-4.0.3-1.el10.aarch64.rpm;name=aarch64_audit-rules;unpack=0"
SRC_URI:append = " ${URI_aarch64_audit-rules}"
SRC_URI[aarch64_audit-rules.sha256sum] = "71661fc2084998425fcb3ee872f305b16b6e2446fc1067c37c5fe790dbbe74b4"

URI_aarch64_python3-audit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-audit-4.0.3-1.el10.aarch64.rpm;name=aarch64_python3-audit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-audit}"
SRC_URI[aarch64_python3-audit.sha256sum] = "4acf1d92287706cca8aa374ecdc6f3b5c22c8b2a1fe20534fa9d7f2d54007109"

RDEPENDS:audispd-plugins = " \
 audit \
 audit-libs \
 glibc \
 krb5-libs \
 libcap-ng \
 "
RDEPENDS:audispd-plugins-zos = " \
 audit \
 audit-libs \
 glibc \
 libcap-ng \
 openldap \
 "
RDEPENDS:audit = " \
 audit-libs \
 audit-rules \
 bash \
 glibc \
 krb5-libs \
 systemd \
 virtual/coreutils \
 "
RDEPENDS:audit-libs = " \
 glibc \
 libcap-ng \
 "
RDEPENDS:audit-libs-devel = " \
 audit-libs \
 kernel-headers \
 libcap-ng-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:audit-rules = " \
 audit-libs \
 bash \
 glibc \
 "
RDEPENDS:python3-audit = " \
 audit-libs \
 glibc \
 libcap-ng \
 python3 \
 "
