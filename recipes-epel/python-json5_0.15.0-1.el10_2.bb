# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-json5"
PV = "0.15.0"
PR = "1.el10_2"
PACKAGES = " \
 pyjson5 \
 python3-json5 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-json5-0.15.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1a518e0d0c86ccf68811cfd671e2ff26db0783cb90723ad5f2c2a3a9f7311b9e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pyjson5-0.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pyjson5;unpack=0"
SRC_URI[x86_64_v2_pyjson5.sha256sum] = "271f6005f36077630c44a439283ca773c6b168eab62da6ae5e2ed99cf8fb6d61"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-json5-0.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-json5;unpack=0"
SRC_URI[x86_64_v2_python3-json5.sha256sum] = "1e1abfe3a85eda9cedd743f5500b09a7bdffdb3a254e18ad3f0d5753363d30f3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pyjson5-0.15.0-1.el10_2.noarch.rpm;name=aarch64_pyjson5;unpack=0"
SRC_URI[aarch64_pyjson5.sha256sum] = "b14672f9f74e9f27b7bcd22836f7bd4a36e9e601f3a669484ce4d2f183381884"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-json5-0.15.0-1.el10_2.noarch.rpm;name=aarch64_python3-json5;unpack=0"
SRC_URI[aarch64_python3-json5.sha256sum] = "eaa79bf2d87b03ebd4d0ec50675c83fecb9c627ed7a33dd29d4d5c5b7706d348"

RDEPENDS:pyjson5 = " \
 python3 \
 python3-json5 \
 "
RDEPENDS:python3-json5 = " \
 python3 \
 "
