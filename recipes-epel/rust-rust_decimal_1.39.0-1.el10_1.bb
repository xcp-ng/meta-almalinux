# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust_decimal"
PV = "1.39.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-rust_decimal+align16-devel \
 rust-rust_decimal+c-repr-devel \
 rust-rust_decimal+default-devel \
 rust-rust_decimal+legacy-ops-devel \
 rust-rust_decimal+macros-devel \
 rust-rust_decimal+maths-devel \
 rust-rust_decimal+maths-nopanic-devel \
 rust-rust_decimal+proptest-devel \
 rust-rust_decimal+rand-0_9-devel \
 rust-rust_decimal+rand-devel \
 rust-rust_decimal+rkyv-devel \
 rust-rust_decimal+rkyv-safe-devel \
 rust-rust_decimal+serde-arbitrary-precision-devel \
 rust-rust_decimal+serde-bincode-devel \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal+serde-float-devel \
 rust-rust_decimal+serde-str-devel \
 rust-rust_decimal+serde-with-arbitrary-precision-devel \
 rust-rust_decimal+serde-with-float-devel \
 rust-rust_decimal+serde-with-str-devel \
 rust-rust_decimal+serde_json-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust_decimal-1.39.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f2c95c73021e50162a8520136fb2114e106e6788322eb1fcb09e76eaee13726"

URI_x86_64_v2_rust-rust_decimal+align16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+align16-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+align16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+align16-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+align16-devel.sha256sum] = "b979cd41328333b86b3d9afc893fa897c8895a1fae1a48c0d31b9c8e5b8a175a"

URI_x86_64_v2_rust-rust_decimal+c-repr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+c-repr-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+c-repr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+c-repr-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+c-repr-devel.sha256sum] = "590e4fa7e7ea83dacd58e2d5295db7e9da51eebca9957ed50631fe8260413083"

URI_x86_64_v2_rust-rust_decimal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+default-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+default-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+default-devel.sha256sum] = "551a697efba051fe10663e991eb7f9d0354ba580e86e27079e1af44ec5487f14"

URI_x86_64_v2_rust-rust_decimal+legacy-ops-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+legacy-ops-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+legacy-ops-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+legacy-ops-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+legacy-ops-devel.sha256sum] = "356363affc3245d6b87fba9716c4a79c0ff32b2deae38e216ac9a09fa2a965b8"

URI_x86_64_v2_rust-rust_decimal+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+macros-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+macros-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+macros-devel.sha256sum] = "298d9b356b699b7b5cd79fe0329474997c452a0705a46bea7984eab1f917c229"

URI_x86_64_v2_rust-rust_decimal+maths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+maths-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+maths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+maths-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+maths-devel.sha256sum] = "e65b12d6739a62abfac7b9d5215825943def939cd05ea442b6da796a3e398bd6"

URI_x86_64_v2_rust-rust_decimal+maths-nopanic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+maths-nopanic-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+maths-nopanic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+maths-nopanic-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+maths-nopanic-devel.sha256sum] = "16303d76f28326cfd4126cfbc603109bd847f4373ee6dcb6305d39f75da67e51"

URI_x86_64_v2_rust-rust_decimal+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+proptest-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+proptest-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+proptest-devel.sha256sum] = "114d99f910bb5fc0b6ee9bf29a8887fb59863af042eb493ccb4e7169a20e10b8"

URI_x86_64_v2_rust-rust_decimal+rand-0_9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rand-0_9-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rand-0_9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rand-0_9-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rand-0_9-devel.sha256sum] = "eeef1beb29144a7eef84b1ac032405c1563ea7204ac5e58cd143406c616c59ad"

URI_x86_64_v2_rust-rust_decimal+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rand-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rand-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rand-devel.sha256sum] = "259bb04566ad21c2bd2f90967719166097aa556a9e8c951798880843aff39cc0"

URI_x86_64_v2_rust-rust_decimal+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rkyv-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rkyv-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rkyv-devel.sha256sum] = "ea122302cd2f0cdd9401d8e9920255fddaf5ad4e015956c8aedf11efa9b00db2"

URI_x86_64_v2_rust-rust_decimal+rkyv-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rkyv-safe-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rkyv-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rkyv-safe-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rkyv-safe-devel.sha256sum] = "d2bb901b48b2e94d49978ca782c0eb45f688b59d348ec40f2243fd1a8c2f8e0a"

URI_x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-arbitrary-precision-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel.sha256sum] = "f6e1cf347810df64b2737eae596cd824eefbd31163e32c71cf2f2cbb9430d4d6"

URI_x86_64_v2_rust-rust_decimal+serde-bincode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-bincode-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-bincode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-bincode-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-bincode-devel.sha256sum] = "2adadd1cf23340318e02467c1313d1824ea6d5d211dde06f3d1abde733f90724"

URI_x86_64_v2_rust-rust_decimal+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-devel.sha256sum] = "cef066c2ad8eac49c232f12cbbc0676d182d36a161ae6131e00672b39da834fc"

URI_x86_64_v2_rust-rust_decimal+serde-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-float-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-float-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-float-devel.sha256sum] = "be2ee597c7f7e47ef00695501a9bf32823e8eec3626792cfe8325146b3fff79e"

URI_x86_64_v2_rust-rust_decimal+serde-str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-str-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-str-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-str-devel.sha256sum] = "ffd5ac3018fe7ae5b3687349c4ea2f9d66c09832ad6b91b7e27204bf19330678"

URI_x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-with-arbitrary-precision-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel.sha256sum] = "de25279a42d9f72fe6b226d61213e087d2724b2e0f356b07672b16ffbc390737"

URI_x86_64_v2_rust-rust_decimal+serde-with-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-with-float-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-with-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-with-float-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-with-float-devel.sha256sum] = "7704b69aa020ceb01cb9201276634e10411f76c90e9567a94c6e431bbc91d922"

URI_x86_64_v2_rust-rust_decimal+serde-with-str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-with-str-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-with-str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-with-str-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-with-str-devel.sha256sum] = "9808a15b368de9ef4d1fee65d3e20ea7ba3dd3b27bc60794c1c3fb764b8d6266"

URI_x86_64_v2_rust-rust_decimal+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde_json-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde_json-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde_json-devel.sha256sum] = "fc7733cfbceecdae9fcca22182f64ff0421d8230ff7b4fc20700fb6d25ba7c63"

URI_x86_64_v2_rust-rust_decimal+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+std-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+std-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+std-devel.sha256sum] = "372b27bec08f9d0a09e6a31a442bd3c7c3c1d5ad278fe9d16185e9206dc1fcfb"

URI_x86_64_v2_rust-rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal-devel.sha256sum] = "24c08db3da486ab43fe597eb794e446f268356d7cc192926328994c3c43c6b2a"

URI_aarch64_rust-rust_decimal+align16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+align16-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+align16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+align16-devel}"
SRC_URI[aarch64_rust-rust_decimal+align16-devel.sha256sum] = "5977b17c2262f63a6bdd3c9e9b117f454a5717d107ac244b4eb80f066a415f10"

URI_aarch64_rust-rust_decimal+c-repr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+c-repr-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+c-repr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+c-repr-devel}"
SRC_URI[aarch64_rust-rust_decimal+c-repr-devel.sha256sum] = "8c89c89cda1aacca0833af6dedaf9c25e0693a157d72f55b57bd8b8d7d976989"

URI_aarch64_rust-rust_decimal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+default-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+default-devel}"
SRC_URI[aarch64_rust-rust_decimal+default-devel.sha256sum] = "dc205b3e925f471e6e99c05d0d7d7780755dc2edb09f7b50047fe7732757e28b"

URI_aarch64_rust-rust_decimal+legacy-ops-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+legacy-ops-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+legacy-ops-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+legacy-ops-devel}"
SRC_URI[aarch64_rust-rust_decimal+legacy-ops-devel.sha256sum] = "383e10cc17b8b89063bb3820ff76fdac50d8b417e6c9a134562762c467579310"

URI_aarch64_rust-rust_decimal+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+macros-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+macros-devel}"
SRC_URI[aarch64_rust-rust_decimal+macros-devel.sha256sum] = "06661dce9b7aa3fc6895dc6c90b9f4f3a8c4d21ab20301ae8822c8785d9718bf"

URI_aarch64_rust-rust_decimal+maths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+maths-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+maths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+maths-devel}"
SRC_URI[aarch64_rust-rust_decimal+maths-devel.sha256sum] = "46013eb7f6bbb624a6ef91f0abf0e7894004e973b6f5f992f2682407bd80a7a2"

URI_aarch64_rust-rust_decimal+maths-nopanic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+maths-nopanic-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+maths-nopanic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+maths-nopanic-devel}"
SRC_URI[aarch64_rust-rust_decimal+maths-nopanic-devel.sha256sum] = "1803eacb74a97cb318907363b26ec49dd5204b27177c4679eb734aff577dbf6f"

URI_aarch64_rust-rust_decimal+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+proptest-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+proptest-devel}"
SRC_URI[aarch64_rust-rust_decimal+proptest-devel.sha256sum] = "e2f97941a907bcb99313ca75d983f7824682f5d59bb7d92e09a84f6442c8bc46"

URI_aarch64_rust-rust_decimal+rand-0_9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rand-0_9-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+rand-0_9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rand-0_9-devel}"
SRC_URI[aarch64_rust-rust_decimal+rand-0_9-devel.sha256sum] = "a68e23d841fade8728dfd1f1ed5afaac5829c50c68f70f6964e93197e7b78ba5"

URI_aarch64_rust-rust_decimal+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rand-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rand-devel}"
SRC_URI[aarch64_rust-rust_decimal+rand-devel.sha256sum] = "9790bd0e3aaa01db77316eb94fdfa2bd077d1e3fefda3cdbbde753b126f71c1e"

URI_aarch64_rust-rust_decimal+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rkyv-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rkyv-devel}"
SRC_URI[aarch64_rust-rust_decimal+rkyv-devel.sha256sum] = "674e81c5b44c480a2d6d027be83eb22f41fbfe88f97b812c099f3193fa66d6c6"

URI_aarch64_rust-rust_decimal+rkyv-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rkyv-safe-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+rkyv-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rkyv-safe-devel}"
SRC_URI[aarch64_rust-rust_decimal+rkyv-safe-devel.sha256sum] = "7cd90782441062ba80e396239c54a4af86c531a7c09fda8c8a571f3ffde602d1"

URI_aarch64_rust-rust_decimal+serde-arbitrary-precision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-arbitrary-precision-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+serde-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-arbitrary-precision-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-arbitrary-precision-devel.sha256sum] = "6ad962e546ea96439d7001ea525400261f8125b9d9d1db1cce4b961a99c0ca8c"

URI_aarch64_rust-rust_decimal+serde-bincode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-bincode-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+serde-bincode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-bincode-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-bincode-devel.sha256sum] = "a2540443cbb13698df43ff068a4684e59af6f11c422e46ab24b9b2b7e9392b46"

URI_aarch64_rust-rust_decimal+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-devel.sha256sum] = "7329161eeae77b3c45e33731e40f64f4a414c5af18fd8bdeb4a0402651816369"

URI_aarch64_rust-rust_decimal+serde-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-float-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+serde-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-float-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-float-devel.sha256sum] = "029ae3ffc2e06f6ed78b3cf402df390ae29af18333a09333f02556a4d84f3f95"

URI_aarch64_rust-rust_decimal+serde-str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-str-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+serde-str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-str-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-str-devel.sha256sum] = "f1501ae91d97d2ee2eba13a1a18639c85eaf0241d940f5fa2ab3ac4e85427d95"

URI_aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-with-arbitrary-precision-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel.sha256sum] = "d4f0da48fc00a20e651854953acc5b68df1bc8c7427c1b6ac6c998880ed0b96c"

URI_aarch64_rust-rust_decimal+serde-with-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-with-float-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+serde-with-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-with-float-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-with-float-devel.sha256sum] = "d734709a6c4c6e6ec079ee5952138aa7e183668f8d8a84de5ef43b1906d57e7a"

URI_aarch64_rust-rust_decimal+serde-with-str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-with-str-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+serde-with-str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-with-str-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-with-str-devel.sha256sum] = "3a93cfd6418573d0c64712683ce2627b65157d150b2aa4690b56608a0eea0045"

URI_aarch64_rust-rust_decimal+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde_json-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde_json-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde_json-devel.sha256sum] = "d1deeff827d600d7fec6dbdac70313d44cf0ae71b1dad09ae35440947481dbbd"

URI_aarch64_rust-rust_decimal+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+std-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+std-devel}"
SRC_URI[aarch64_rust-rust_decimal+std-devel.sha256sum] = "934996d5f9ea8ed496c14dc168e075a46720e90b82643aeb501d59d391945855"

URI_aarch64_rust-rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal-devel}"
SRC_URI[aarch64_rust-rust_decimal-devel.sha256sum] = "b83b906a21a66e23fcaee579ff0835e67d019f561b0b6abf62c1c1e0eb31fc77"

RDEPENDS:rust-rust_decimal+align16-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+c-repr-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+default-devel = " \
 cargo \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+legacy-ops-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+macros-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-rust_decimal_macros-devel \
 "
RDEPENDS:rust-rust_decimal+maths-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+maths-nopanic-devel = " \
 cargo \
 rust-rust_decimal+maths-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+proptest-devel = " \
 cargo \
 rust-proptest+std-devel \
 rust-proptest-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rand-0_9-devel = " \
 cargo \
 rust-rand-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rand-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rkyv-devel = " \
 cargo \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rkyv-safe-devel = " \
 cargo \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7+validation-devel \
 rust-rkyv0.7-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-arbitrary-precision-devel = " \
 cargo \
 rust-rust_decimal+serde-with-arbitrary-precision-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-bincode-devel = " \
 cargo \
 rust-rust_decimal+serde-str-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rust_decimal+serde-float-devel = " \
 cargo \
 rust-rust_decimal+serde-with-float-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-str-devel = " \
 cargo \
 rust-rust_decimal+serde-with-str-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-with-arbitrary-precision-devel = " \
 cargo \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal-devel \
 rust-serde_json+arbitrary_precision-devel \
 rust-serde_json+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-rust_decimal+serde-with-float-devel = " \
 cargo \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-with-str-devel = " \
 cargo \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde_json-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-rust_decimal+std-devel = " \
 cargo \
 rust-arrayvec+std-devel \
 rust-bytes+std-devel \
 rust-bytes-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7-devel \
 rust-rust_decimal-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-serde_json+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-rust_decimal-devel = " \
 cargo \
 rust \
 rust-arrayvec-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
