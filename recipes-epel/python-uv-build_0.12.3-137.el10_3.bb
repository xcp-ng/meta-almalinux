# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-uv-build"
PV = "0.12.3"
PR = "137.el10_3"
PACKAGES = " \
 python3-uv-build \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-uv-build-0.12.3-137.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2440a4d36310f56c762ed221ec931cfd8dc56e3212b7b9aa86c8106ade913f9f"

URI_aarch64_python3-uv-build = "${EPEL_MIRROR}/aarch64/Packages/p/python3-uv-build-0.12.3-137.el10_3.aarch64.rpm;name=aarch64_python3-uv-build;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-uv-build}"
SRC_URI[aarch64_python3-uv-build.sha256sum] = "c6b29339bdfc8e71ffc8708c6264ef8668deeed7bf8446ab48bcbe8adebf1899"

RDEPENDS:python3-uv-build = " \
 glibc \
 libgcc \
 libzstd \
 python3 \
 "
