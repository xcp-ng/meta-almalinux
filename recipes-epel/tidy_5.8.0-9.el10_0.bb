# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tidy"
PV = "5.8.0"
PR = "9.el10_0"
PACKAGES = " \
 libtidy \
 libtidy-devel \
 tidy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tidy-5.8.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c43da6dac3a5827b278aba6c4cb35b9a673535841cd2704a7aa8836adec5009"

URI_x86_64_v2_libtidy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtidy-5.8.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtidy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtidy}"
SRC_URI[x86_64_v2_libtidy.sha256sum] = "2272bb4d855b09746cc49229c29f5b81f6b666f2dc4152e8cbd6e99879d3fb72"

URI_x86_64_v2_libtidy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtidy-devel-5.8.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtidy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtidy-devel}"
SRC_URI[x86_64_v2_libtidy-devel.sha256sum] = "15e80872ca174fc2ee155ea6f11e38b7d59d812c1536fd4eda76a3c8a2f3685a"

URI_x86_64_v2_tidy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tidy-5.8.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tidy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tidy}"
SRC_URI[x86_64_v2_tidy.sha256sum] = "6b211e8637f4358811cda05819f52a3d19feb220fe995316a0ebea9e5ae632ef"

URI_aarch64_libtidy = "${EPEL_MIRROR}/aarch64/Packages/l/libtidy-5.8.0-9.el10_0.aarch64.rpm;name=aarch64_libtidy;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtidy}"
SRC_URI[aarch64_libtidy.sha256sum] = "68674e4703f7c08c2f3d8e02475561459368a58f758193179440f8c035ecfb98"

URI_aarch64_libtidy-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libtidy-devel-5.8.0-9.el10_0.aarch64.rpm;name=aarch64_libtidy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtidy-devel}"
SRC_URI[aarch64_libtidy-devel.sha256sum] = "90c937845fad1f4561e768083037a603090f697696786f40fcbd506ba28e48ef"

URI_aarch64_tidy = "${EPEL_MIRROR}/aarch64/Packages/t/tidy-5.8.0-9.el10_0.aarch64.rpm;name=aarch64_tidy;unpack=0"
SRC_URI:append = " ${URI_aarch64_tidy}"
SRC_URI[aarch64_tidy.sha256sum] = "0aa0a7bfe61e5b35710f15fb6c687086ebae846fe8f193ae07fa04c63b878b17"

RDEPENDS:libtidy = " \
 glibc \
 "
RDEPENDS:libtidy-devel = " \
 libtidy \
 pkgconf-pkg-config \
 "
RDEPENDS:tidy = " \
 glibc \
 libtidy \
 "
