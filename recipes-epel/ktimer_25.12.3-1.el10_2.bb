# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktimer"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 ktimer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktimer-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b1b615f6979bded62947946080f2f65c6c219ce07064a0c4da1471e1022ac07"

URI_x86_64_v2_ktimer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktimer-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktimer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktimer}"
SRC_URI[x86_64_v2_ktimer.sha256sum] = "b7e2d3e24dbd75de02e4f528b250f77a9d5f6f98b6afd464ee3981e066b06c37"

URI_aarch64_ktimer = "${EPEL_MIRROR}/aarch64/Packages/k/ktimer-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ktimer;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktimer}"
SRC_URI[aarch64_ktimer.sha256sum] = "21d3b746ef10bcafdca397449fc9583a33bbfb43ea36a855896b90a11ea60cd2"

RDEPENDS:ktimer = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
