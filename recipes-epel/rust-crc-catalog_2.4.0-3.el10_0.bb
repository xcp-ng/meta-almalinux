# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crc-catalog"
PV = "2.4.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-crc-catalog+default-devel \
 rust-crc-catalog-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crc-catalog-2.4.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "951c640c150de9ac9ac7b2be06fb2b2859d02173172c0ad16399fd9ff8a6bdb6"

URI_x86_64_v2_rust-crc-catalog+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-catalog+default-devel-2.4.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-catalog+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-catalog+default-devel}"
SRC_URI[x86_64_v2_rust-crc-catalog+default-devel.sha256sum] = "44f1b6008879120d37c6a46c57df809485915c9f20bfcf46de0beada1de5fb57"

URI_x86_64_v2_rust-crc-catalog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-catalog-devel-2.4.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-catalog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-catalog-devel}"
SRC_URI[x86_64_v2_rust-crc-catalog-devel.sha256sum] = "c08dffdf8f5113b195c11b018cea1d0e798793cd5464772874980a63104839e4"

URI_aarch64_rust-crc-catalog+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-catalog+default-devel-2.4.0-3.el10_0.noarch.rpm;name=aarch64_rust-crc-catalog+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-catalog+default-devel}"
SRC_URI[aarch64_rust-crc-catalog+default-devel.sha256sum] = "9dcde662f9943caa49d9bc50d387d83d59a67f657ae059fb938c1890fadd0083"

URI_aarch64_rust-crc-catalog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-catalog-devel-2.4.0-3.el10_0.noarch.rpm;name=aarch64_rust-crc-catalog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-catalog-devel}"
SRC_URI[aarch64_rust-crc-catalog-devel.sha256sum] = "69b4ae57ca39c83a282ebf65c9570b8f98011965982aa67ee24fdcc5a41da7d2"

RDEPENDS:rust-crc-catalog+default-devel = " \
 cargo \
 rust-crc-catalog-devel \
 "
RDEPENDS:rust-crc-catalog-devel = " \
 cargo \
 "
