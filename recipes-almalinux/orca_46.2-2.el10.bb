# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "orca"
PV = "46.2"
PR = "2.el10"
PACKAGES = " \
 orca \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/orca-46.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "135fc74cf9bf96a31f06780b1af94401898821c33e601ce4e61707b94652fe0b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/orca-46.2-2.el10.noarch.rpm;name=x86_64_v2_orca;unpack=0"
SRC_URI[x86_64_v2_orca.sha256sum] = "663ea4e3307cb9136baf22781d14447fbee8bb6803e7f181e4f2a30ebb00a793"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/orca-46.2-2.el10.noarch.rpm;name=aarch64_orca;unpack=0"
SRC_URI[aarch64_orca.sha256sum] = "663ea4e3307cb9136baf22781d14447fbee8bb6803e7f181e4f2a30ebb00a793"

RDEPENDS:orca = " \
 libwnck3 \
 python3 \
 python3-brlapi \
 python3-louis \
 python3-pyatspi \
 python3-speechd \
 speech-dispatcher \
 "
