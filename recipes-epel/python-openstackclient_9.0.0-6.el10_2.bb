# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openstackclient"
PV = "9.0.0"
PR = "6.el10_2"
PACKAGES = " \
 python-openstackclient-doc \
 python-openstackclient-lang \
 python3-openstackclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openstackclient-9.0.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ce8dbb3787aa547e4c33935a7dcaa45cde877240f995dfc132d1f5e0da97be5"

URI_x86_64_v2_python-openstackclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-openstackclient-doc-9.0.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-openstackclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-openstackclient-doc}"
SRC_URI[x86_64_v2_python-openstackclient-doc.sha256sum] = "e850f061de043c33a5cef68d870978c0efd12a418710045ea043407e8631e217"

URI_x86_64_v2_python-openstackclient-lang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-openstackclient-lang-9.0.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-openstackclient-lang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-openstackclient-lang}"
SRC_URI[x86_64_v2_python-openstackclient-lang.sha256sum] = "3c8efc66f499b77c3ae391a2c347d995323471f320124a4c39de5fa808eb51a1"

URI_x86_64_v2_python3-openstackclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openstackclient-9.0.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openstackclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openstackclient}"
SRC_URI[x86_64_v2_python3-openstackclient.sha256sum] = "3c1d6554dfd3aeaa77b65d5e4fd1dc64979a36c9c4f4bc2523cba27ddaf9d478"

URI_aarch64_python-openstackclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-openstackclient-doc-9.0.0-6.el10_2.noarch.rpm;name=aarch64_python-openstackclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-openstackclient-doc}"
SRC_URI[aarch64_python-openstackclient-doc.sha256sum] = "6c29224bb825509d0404f6f23f6fe32eb66d69f747b37f4e3738467d7670e4c4"

URI_aarch64_python-openstackclient-lang = "${EPEL_MIRROR}/aarch64/Packages/p/python-openstackclient-lang-9.0.0-6.el10_2.noarch.rpm;name=aarch64_python-openstackclient-lang;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-openstackclient-lang}"
SRC_URI[aarch64_python-openstackclient-lang.sha256sum] = "4537b564ca758d38733155cd489222c88c79d2025fdb5b77e3f72196dd6af638"

URI_aarch64_python3-openstackclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openstackclient-9.0.0-6.el10_2.noarch.rpm;name=aarch64_python3-openstackclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openstackclient}"
SRC_URI[aarch64_python3-openstackclient.sha256sum] = "0af856abb40e73581f6b74cc8fa744122f429d134c47cd2532683ac8d6a7be7d"

RDEPENDS:python-openstackclient-doc = " \
 python3-openstackclient \
 "
RDEPENDS:python-openstackclient-lang = " \
 "
RDEPENDS:python3-openstackclient = " \
 bash \
 python-openstackclient-lang \
 python3 \
 python3-cinderclient \
 python3-cliff \
 python3-cryptography \
 python3-iso8601 \
 python3-keystoneclient \
 python3-openstacksdk \
 python3-osc-lib \
 python3-oslo-i18n \
 python3-pbr \
 python3-requests \
 python3-stevedore \
 "
