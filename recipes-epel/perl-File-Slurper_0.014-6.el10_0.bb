# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-Slurper"
PV = "0.014"
PR = "6.el10_0"
PACKAGES = " \
 perl-File-Slurper \
 perl-File-Slurper-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-Slurper-0.014-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a8deb996bb039c031f4d245170591b7fd9b7d0ea9ffd74e4a8dd957e0f79823"

URI_x86_64_v2_perl-File-Slurper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Slurper-0.014-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Slurper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Slurper}"
SRC_URI[x86_64_v2_perl-File-Slurper.sha256sum] = "330f2f89703946bee902816481c21d3270b9e4b7f8d0666ecc99cf4f34f06353"

URI_x86_64_v2_perl-File-Slurper-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Slurper-tests-0.014-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Slurper-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Slurper-tests}"
SRC_URI[x86_64_v2_perl-File-Slurper-tests.sha256sum] = "58a2fc7f122d6f8920745c3e6dda0914eb96fbb69a4579d12afee3de2fd09de4"

URI_aarch64_perl-File-Slurper = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Slurper-0.014-6.el10_0.noarch.rpm;name=aarch64_perl-File-Slurper;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Slurper}"
SRC_URI[aarch64_perl-File-Slurper.sha256sum] = "3b7abf23e1b210bfb8c530677dd759be70040cf415109f5cfb13f778d81f7cd6"

URI_aarch64_perl-File-Slurper-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Slurper-tests-0.014-6.el10_0.noarch.rpm;name=aarch64_perl-File-Slurper-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Slurper-tests}"
SRC_URI[aarch64_perl-File-Slurper-tests.sha256sum] = "86d74c670952b35c4a96e7c8c2665ef076456519c0259d13d162614fdb09ea37"

RDEPENDS:perl-File-Slurper = " \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-File-Slurper-tests = " \
 bash \
 perl-File-Slurper \
 perl-File-Temp \
 perl-FindBin \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Test-Warnings \
 perl-interpreter \
 perl-libs \
 "
