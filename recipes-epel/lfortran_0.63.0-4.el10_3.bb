# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lfortran"
PV = "0.63.0"
PR = "4.el10_3"
PACKAGES:x86_64_v2 = " \
 lfortran \
 lfortran-devel \
 lfortran-jupyter \
 lfortran-shared \
 lfortran-static \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/l/lfortran-0.63.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5abca02bf81d4b53efab556da1c7091d2c99973bac1304361e76751ac8bb11eb"

URI_x86_64_v2_lfortran = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lfortran-0.63.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lfortran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lfortran}"
SRC_URI[x86_64_v2_lfortran.sha256sum] = "61aba2bb3d45a3200cf7d35208088461033ded23f8daad057e1f20544be2089a"

URI_x86_64_v2_lfortran-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lfortran-devel-0.63.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lfortran-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lfortran-devel}"
SRC_URI[x86_64_v2_lfortran-devel.sha256sum] = "da889313c14bf7c6508623ccec193e276617b90dcc2e9b2360b6fbb28e98ecc5"

URI_x86_64_v2_lfortran-jupyter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lfortran-jupyter-0.63.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lfortran-jupyter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lfortran-jupyter}"
SRC_URI[x86_64_v2_lfortran-jupyter.sha256sum] = "7bc15d787c38e6704c6a9d484e4bb50e52394f1ba7bef0a778fbc0a6d1542d1c"

URI_x86_64_v2_lfortran-shared = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lfortran-shared-0.63.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lfortran-shared;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lfortran-shared}"
SRC_URI[x86_64_v2_lfortran-shared.sha256sum] = "dcad9205c21f8ec15b9f168147bb29be5ddcec7eedc9b519a431455e1c82e43a"

URI_x86_64_v2_lfortran-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lfortran-static-0.63.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lfortran-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lfortran-static}"
SRC_URI[x86_64_v2_lfortran-static.sha256sum] = "a7fcad1dc002b0f6ae281abc52dcc4740a0f52d1ed8ea099e7c2cbd34dc0a798"

RDEPENDS:lfortran = " \
 glibc \
 kokkos-devel \
 lfortran-shared \
 libgcc \
 libstdc++ \
 libzstd \
 xeus \
 xeus-zmq \
 "
RDEPENDS:lfortran-devel = " \
 lfortran \
 python3 \
 "
RDEPENDS:lfortran-jupyter = " \
 jupyterlab \
 lfortran \
 python-jupyter-filesystem \
 "
RDEPENDS:lfortran-shared = " \
 glibc \
 "
RDEPENDS:lfortran-static = " \
 "
