# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num_enum"
PV = "0.7.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-num_enum+complex-expressions-devel \
 rust-num_enum+default-devel \
 rust-num_enum+external_doc-devel \
 rust-num_enum+std-devel \
 rust-num_enum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num_enum-0.7.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efe810eed57a36fb9fee4241b8b337f54298db520d962c49f1d4738643dc717c"

URI_x86_64_v2_rust-num_enum+complex-expressions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum+complex-expressions-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum+complex-expressions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum+complex-expressions-devel}"
SRC_URI[x86_64_v2_rust-num_enum+complex-expressions-devel.sha256sum] = "7d6f3189bddcbe187391de8c9307355d88ad6b7ad42ff649463038d11994cda8"

URI_x86_64_v2_rust-num_enum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum+default-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum+default-devel}"
SRC_URI[x86_64_v2_rust-num_enum+default-devel.sha256sum] = "8851cb3012bdf3afeaab968fa4747d9a79635bc941e1edd229d7570a03856c4c"

URI_x86_64_v2_rust-num_enum+external_doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum+external_doc-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum+external_doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum+external_doc-devel}"
SRC_URI[x86_64_v2_rust-num_enum+external_doc-devel.sha256sum] = "3451106f04f1628dd13a65afc5ae1da0b16ed13722ed1af4d25eba3233d0b00f"

URI_x86_64_v2_rust-num_enum+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum+std-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum+std-devel}"
SRC_URI[x86_64_v2_rust-num_enum+std-devel.sha256sum] = "f2e5bc6d3b6de9df3091c2dd41e61f61f45fab8c59b5eb74be307b865535332b"

URI_x86_64_v2_rust-num_enum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum-devel}"
SRC_URI[x86_64_v2_rust-num_enum-devel.sha256sum] = "996935d1995ade8c78be5a38c6b3fa5cf54d2380615ff8e360d5b8c93fd14ec6"

URI_aarch64_rust-num_enum+complex-expressions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum+complex-expressions-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-num_enum+complex-expressions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum+complex-expressions-devel}"
SRC_URI[aarch64_rust-num_enum+complex-expressions-devel.sha256sum] = "028a0937995dccefe3975775705e18b3949725ab84572f4747a20ca86eace95a"

URI_aarch64_rust-num_enum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum+default-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-num_enum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum+default-devel}"
SRC_URI[aarch64_rust-num_enum+default-devel.sha256sum] = "e383ce54b8cc94a7b484849740571c45dc00978b15bea2cafad3c7aaa0e88e14"

URI_aarch64_rust-num_enum+external_doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum+external_doc-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-num_enum+external_doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum+external_doc-devel}"
SRC_URI[aarch64_rust-num_enum+external_doc-devel.sha256sum] = "b38313314179f2640cca7674c41344c4bf19a4f9dea1a9eda98bec5ad6ed87aa"

URI_aarch64_rust-num_enum+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum+std-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-num_enum+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum+std-devel}"
SRC_URI[aarch64_rust-num_enum+std-devel.sha256sum] = "ef0cf7a53db374e3e74985735c2cc901c48cd592375c931dc07b54a2c3b1371a"

URI_aarch64_rust-num_enum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-num_enum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum-devel}"
SRC_URI[aarch64_rust-num_enum-devel.sha256sum] = "4fb90f29f848124ad972c5d0f7cc508e098aa3db0c606ec92e3b2d8cd77c5cc9"

RDEPENDS:rust-num_enum+complex-expressions-devel = " \
 cargo \
 rust-num_enum-devel \
 rust-num_enum_derive+complex-expressions-devel \
 "
RDEPENDS:rust-num_enum+default-devel = " \
 cargo \
 rust-num_enum+std-devel \
 rust-num_enum-devel \
 "
RDEPENDS:rust-num_enum+external_doc-devel = " \
 cargo \
 rust-num_enum-devel \
 "
RDEPENDS:rust-num_enum+std-devel = " \
 cargo \
 rust-num_enum-devel \
 rust-num_enum_derive+std-devel \
 "
RDEPENDS:rust-num_enum-devel = " \
 cargo \
 rust \
 rust-num_enum_derive-devel \
 rust-rustversion+default-devel \
 "
