# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-String-Similarity"
PV = "1.04"
PR = "51.el10_3"
PACKAGES = " \
 perl-String-Similarity \
 perl-String-Similarity-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-String-Similarity-1.04-51.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dee5130c910df7039f5cd69ca3194ef4a3788105092bd31c64b5e634412efa28"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-String-Similarity-1.04-51.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-String-Similarity;unpack=0"
SRC_URI[x86_64_v2_perl-String-Similarity.sha256sum] = "6f7f6142fcfd804a3e4e22f3f943014aec8f2ecf0f98b29f31e8c6bdd761385e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-String-Similarity-tests-1.04-51.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-String-Similarity-tests;unpack=0"
SRC_URI[x86_64_v2_perl-String-Similarity-tests.sha256sum] = "acfcdf0a1db7f710141aec3852825e3e6e4ec5af26a748b5017873b0bbd1a911"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-String-Similarity-1.04-51.el10_3.aarch64.rpm;name=aarch64_perl-String-Similarity;unpack=0"
SRC_URI[aarch64_perl-String-Similarity.sha256sum] = "1641f39c84eb6bb37898fb0de8a7c45b89d69b1be1233de9d58e2110ad9dcb0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-String-Similarity-tests-1.04-51.el10_3.noarch.rpm;name=aarch64_perl-String-Similarity-tests;unpack=0"
SRC_URI[aarch64_perl-String-Similarity-tests.sha256sum] = "34e3d8888ed32a2ce2e96cf9b67e7ed1879c17d3c0b9fd2eb91f9f75aedeb728"

RDEPENDS:perl-String-Similarity = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-String-Similarity-tests = " \
 bash \
 perl-Encode \
 perl-String-Similarity \
 perl-Test-Harness \
 perl-libs \
 "
