# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tendril"
PV = "0.4.3"
PR = "10.el10_0"
PACKAGES = " \
 rust-tendril+bench-devel \
 rust-tendril+default-devel \
 rust-tendril+encoding_rs-devel \
 rust-tendril-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tendril-0.4.3-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "242d37af12e62a648ae5e1570f09a49ae4d8f74eee8a8fbd5df911076e733c9d"

URI_x86_64_v2_rust-tendril+bench-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tendril+bench-devel-0.4.3-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tendril+bench-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tendril+bench-devel}"
SRC_URI[x86_64_v2_rust-tendril+bench-devel.sha256sum] = "d01b9b5fb4e239c40f8bdf3ec727508c5ff1285bb87f2e4962738b5299685822"

URI_x86_64_v2_rust-tendril+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tendril+default-devel-0.4.3-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tendril+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tendril+default-devel}"
SRC_URI[x86_64_v2_rust-tendril+default-devel.sha256sum] = "e6301b3fa7464866f87225870c4e156b8080efd00937a9650aa307d39b1ac293"

URI_x86_64_v2_rust-tendril+encoding_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tendril+encoding_rs-devel-0.4.3-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tendril+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tendril+encoding_rs-devel}"
SRC_URI[x86_64_v2_rust-tendril+encoding_rs-devel.sha256sum] = "41e66405f865b1a4566974f9b1da026158061dfc15d6a880de5047e56cde118d"

URI_x86_64_v2_rust-tendril-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tendril-devel-0.4.3-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tendril-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tendril-devel}"
SRC_URI[x86_64_v2_rust-tendril-devel.sha256sum] = "f072128d6df97a36a091fadd938ace07bfe4317a1d674895d40ae77b4115ba38"

URI_aarch64_rust-tendril+bench-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tendril+bench-devel-0.4.3-10.el10_0.noarch.rpm;name=aarch64_rust-tendril+bench-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tendril+bench-devel}"
SRC_URI[aarch64_rust-tendril+bench-devel.sha256sum] = "557c4f89e3818bce52fb4ab721106d3f2528a5c8e3ecd61bb80288a4d690a11a"

URI_aarch64_rust-tendril+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tendril+default-devel-0.4.3-10.el10_0.noarch.rpm;name=aarch64_rust-tendril+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tendril+default-devel}"
SRC_URI[aarch64_rust-tendril+default-devel.sha256sum] = "f0f280a6b5b993f82864555f84216fc786095b8d2f7c3682cf87f675c1aa0e00"

URI_aarch64_rust-tendril+encoding_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tendril+encoding_rs-devel-0.4.3-10.el10_0.noarch.rpm;name=aarch64_rust-tendril+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tendril+encoding_rs-devel}"
SRC_URI[aarch64_rust-tendril+encoding_rs-devel.sha256sum] = "d0ac3fe954e83d630d805d82acd62d56f80cbab8980d58f11ea11028639970b5"

URI_aarch64_rust-tendril-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tendril-devel-0.4.3-10.el10_0.noarch.rpm;name=aarch64_rust-tendril-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tendril-devel}"
SRC_URI[aarch64_rust-tendril-devel.sha256sum] = "8959ee36b20d43a753ca4b744775204212b55cba22ca2c2c03dd6a986dad5f39"

RDEPENDS:rust-tendril+bench-devel = " \
 cargo \
 rust-tendril-devel \
 "
RDEPENDS:rust-tendril+default-devel = " \
 cargo \
 rust-tendril-devel \
 "
RDEPENDS:rust-tendril+encoding_rs-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-tendril-devel \
 "
RDEPENDS:rust-tendril-devel = " \
 cargo \
 rust-futf+default-devel \
 rust-mac+default-devel \
 rust-utf-8+default-devel \
 "
