# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-safe_arch"
PV = "0.7.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-safe_arch+bytemuck-devel \
 rust-safe_arch+default-devel \
 rust-safe_arch-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-safe_arch-0.7.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c992b76e364005dc16be2675ada3c3d306b6343bc1a271cb5acc771579c4b0f0"

URI_x86_64_v2_rust-safe_arch+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-safe_arch+bytemuck-devel-0.7.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-safe_arch+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-safe_arch+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-safe_arch+bytemuck-devel.sha256sum] = "444db82ede84011bac6a750aafbeabb450a3dddb5ac049a72ee56f204dd50cf4"

URI_x86_64_v2_rust-safe_arch+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-safe_arch+default-devel-0.7.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-safe_arch+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-safe_arch+default-devel}"
SRC_URI[x86_64_v2_rust-safe_arch+default-devel.sha256sum] = "e1219cb756b757644295d6a3953a0849699c6ab6b8a53487fbb329e0b08bda3e"

URI_x86_64_v2_rust-safe_arch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-safe_arch-devel-0.7.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-safe_arch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-safe_arch-devel}"
SRC_URI[x86_64_v2_rust-safe_arch-devel.sha256sum] = "14696be3c92d4b0d7e8740bcbf95f90b2a258c7fe924ad1f9e8802f2c9dab0ed"

URI_aarch64_rust-safe_arch+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-safe_arch+bytemuck-devel-0.7.4-1.el10_1.noarch.rpm;name=aarch64_rust-safe_arch+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-safe_arch+bytemuck-devel}"
SRC_URI[aarch64_rust-safe_arch+bytemuck-devel.sha256sum] = "40c2af22cbe8fc89bbebc5a6d02f0f741daae4a2146f3810c58e82bc1b700dbf"

URI_aarch64_rust-safe_arch+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-safe_arch+default-devel-0.7.4-1.el10_1.noarch.rpm;name=aarch64_rust-safe_arch+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-safe_arch+default-devel}"
SRC_URI[aarch64_rust-safe_arch+default-devel.sha256sum] = "63c8da42136ea498b9475d397f3b0382b99f99d2cbcf735a90e5040cc25ea527"

URI_aarch64_rust-safe_arch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-safe_arch-devel-0.7.4-1.el10_1.noarch.rpm;name=aarch64_rust-safe_arch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-safe_arch-devel}"
SRC_URI[aarch64_rust-safe_arch-devel.sha256sum] = "9bb05b14f8437a4c0d4968ca702c0dc746a67a3adb5496d0a3d5f93969865fee"

RDEPENDS:rust-safe_arch+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-safe_arch-devel \
 "
RDEPENDS:rust-safe_arch+default-devel = " \
 cargo \
 rust-safe_arch-devel \
 "
RDEPENDS:rust-safe_arch-devel = " \
 cargo \
 "
