# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-math-functions"
PV = "0.3.4.4"
PR = "1.el10_0"
PACKAGES = " \
 ghc-math-functions \
 ghc-math-functions-devel \
 ghc-math-functions-doc \
 ghc-math-functions-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-math-functions-0.3.4.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c66e3c27ebfe7c16518c12acaedb02a145f8120a80ebe2ef51f3ae41a186a7a"

URI_x86_64_v2_ghc-math-functions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-math-functions-0.3.4.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-math-functions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-math-functions}"
SRC_URI[x86_64_v2_ghc-math-functions.sha256sum] = "3f36a0aa7919a157c253dd51ca426e563e72c79bfd8ee6f0b162f4c92e8329f1"

URI_x86_64_v2_ghc-math-functions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-math-functions-devel-0.3.4.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-math-functions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-math-functions-devel}"
SRC_URI[x86_64_v2_ghc-math-functions-devel.sha256sum] = "07a9861e688738dc32e62656a0d9eb51c376a69570f2a728d9e3c40c93b074a3"

URI_x86_64_v2_ghc-math-functions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-math-functions-doc-0.3.4.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-math-functions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-math-functions-doc}"
SRC_URI[x86_64_v2_ghc-math-functions-doc.sha256sum] = "59987ba6cca8f61741f65324a9500d14d8c51e1c01423f6e51ad8dadca724317"

URI_x86_64_v2_ghc-math-functions-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-math-functions-prof-0.3.4.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-math-functions-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-math-functions-prof}"
SRC_URI[x86_64_v2_ghc-math-functions-prof.sha256sum] = "d281acc1f6e6ed0845c8fbc387f6360bfd5a7a5b094d1538da7b5f7db752523f"

URI_aarch64_ghc-math-functions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-math-functions-0.3.4.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-math-functions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-math-functions}"
SRC_URI[aarch64_ghc-math-functions.sha256sum] = "a9c432502a35b823211b76bef3c8ac3d83f31bb56903bf0100b7ec7e75162efa"

URI_aarch64_ghc-math-functions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-math-functions-devel-0.3.4.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-math-functions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-math-functions-devel}"
SRC_URI[aarch64_ghc-math-functions-devel.sha256sum] = "98f8e0d3d120b0c58bb764ca26cca482cdaff4b297e073bae5e0850af5e8c78d"

URI_aarch64_ghc-math-functions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-math-functions-doc-0.3.4.4-1.el10_0.noarch.rpm;name=aarch64_ghc-math-functions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-math-functions-doc}"
SRC_URI[aarch64_ghc-math-functions-doc.sha256sum] = "296fec3202b946453775d2fd526cbd7d81f92afa9a557175170d6d9efa5c5b12"

URI_aarch64_ghc-math-functions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-math-functions-prof-0.3.4.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-math-functions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-math-functions-prof}"
SRC_URI[aarch64_ghc-math-functions-prof.sha256sum] = "7b4ea3b37ebdd8755545267b16c9d4538f519a949abb06d576ed87f737915357"

RDEPENDS:ghc-math-functions = " \
 ghc-array \
 ghc-base \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-primitive \
 ghc-template-haskell \
 ghc-transformers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-math-functions-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-data-default-class-devel \
 ghc-deepseq-devel \
 ghc-math-functions \
 ghc-primitive-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-math-functions-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-math-functions-prof = " \
 ghc-base-prof \
 ghc-data-default-class-prof \
 ghc-deepseq-prof \
 ghc-math-functions-devel \
 ghc-primitive-prof \
 ghc-vector-prof \
 "
