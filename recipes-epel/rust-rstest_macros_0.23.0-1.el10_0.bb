# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rstest_macros"
PV = "0.23.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-rstest_macros+async-timeout-devel \
 rust-rstest_macros+crate-name-devel \
 rust-rstest_macros+default-devel \
 rust-rstest_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rstest_macros-0.23.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1dbb764674e24aa8cd36e8018f9f49a0878a63982f8aa7e967bcd1f307ed36bf"

URI_x86_64_v2_rust-rstest_macros+async-timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest_macros+async-timeout-devel-0.23.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest_macros+async-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest_macros+async-timeout-devel}"
SRC_URI[x86_64_v2_rust-rstest_macros+async-timeout-devel.sha256sum] = "1d1d30693f601e1bf66e22f69751c03e9fc17ce31d117e77af5fa041be2cd3d9"

URI_x86_64_v2_rust-rstest_macros+crate-name-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest_macros+crate-name-devel-0.23.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest_macros+crate-name-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest_macros+crate-name-devel}"
SRC_URI[x86_64_v2_rust-rstest_macros+crate-name-devel.sha256sum] = "f3c21203977bc37cd9bdadeadf96040257b6f680770b4c51ca4e4018f2d7f2ef"

URI_x86_64_v2_rust-rstest_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest_macros+default-devel-0.23.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest_macros+default-devel}"
SRC_URI[x86_64_v2_rust-rstest_macros+default-devel.sha256sum] = "3be47b7bee3a23f1fa62bb0328d33cf27c916c31bc6468acb06bf68b9c9b7e23"

URI_x86_64_v2_rust-rstest_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest_macros-devel-0.23.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest_macros-devel}"
SRC_URI[x86_64_v2_rust-rstest_macros-devel.sha256sum] = "70ab4868d82f78a02da36b9817e8b7b7d1bb6c40372d2ff68a0abcef0e1ce806"

URI_aarch64_rust-rstest_macros+async-timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest_macros+async-timeout-devel-0.23.0-1.el10_0.noarch.rpm;name=aarch64_rust-rstest_macros+async-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest_macros+async-timeout-devel}"
SRC_URI[aarch64_rust-rstest_macros+async-timeout-devel.sha256sum] = "56720f502f78c6374255a166fdd485bf03dab9b23692986ec678b97badc3ace3"

URI_aarch64_rust-rstest_macros+crate-name-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest_macros+crate-name-devel-0.23.0-1.el10_0.noarch.rpm;name=aarch64_rust-rstest_macros+crate-name-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest_macros+crate-name-devel}"
SRC_URI[aarch64_rust-rstest_macros+crate-name-devel.sha256sum] = "c961d3345996acdddafc458c7084de9dfb4e1184808ab404eb40c9bf0ba96347"

URI_aarch64_rust-rstest_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest_macros+default-devel-0.23.0-1.el10_0.noarch.rpm;name=aarch64_rust-rstest_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest_macros+default-devel}"
SRC_URI[aarch64_rust-rstest_macros+default-devel.sha256sum] = "7a85512895364edd3239325735fca6d6beef16edf9b38c349eeb16b4be481302"

URI_aarch64_rust-rstest_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest_macros-devel-0.23.0-1.el10_0.noarch.rpm;name=aarch64_rust-rstest_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest_macros-devel}"
SRC_URI[aarch64_rust-rstest_macros-devel.sha256sum] = "ede738634d2163e57bd95189c10f22bbaaf1d94c7ac08fec4d2b8f9a0cb6e311"

RDEPENDS:rust-rstest_macros+async-timeout-devel = " \
 cargo \
 rust-rstest_macros-devel \
 "
RDEPENDS:rust-rstest_macros+crate-name-devel = " \
 cargo \
 rust-proc-macro-crate+default-devel \
 rust-rstest_macros-devel \
 "
RDEPENDS:rust-rstest_macros+default-devel = " \
 cargo \
 rust-rstest_macros+async-timeout-devel \
 rust-rstest_macros+crate-name-devel \
 rust-rstest_macros-devel \
 "
RDEPENDS:rust-rstest_macros-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-glob+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-regex+default-devel \
 rust-relative-path+default-devel \
 rust-rustc_version+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+visit-devel \
 rust-syn+visit-mut-devel \
 rust-unicode-ident+default-devel \
 "
