# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "afetch"
PV = "2.2.0"
PR = "7.el10_0"
PACKAGES = " \
 afetch \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/afetch-2.2.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5f7e7386eea9ade89167521cd017c679cca1dd40cc20103606975b40fad2c998"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/afetch-2.2.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_afetch;unpack=0"
SRC_URI[x86_64_v2_afetch.sha256sum] = "e6e2f0d3df4f04e06506cd2000e77ceef1e172cbcb82a1dbbecfb70058e1b289"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/afetch-2.2.0-7.el10_0.aarch64.rpm;name=aarch64_afetch;unpack=0"
SRC_URI[aarch64_afetch.sha256sum] = "a59b1704437b2b47dc43a56f3920484821ff52df061b6bb473533c2e79d6088f"

RDEPENDS:afetch = " \
 glibc \
 "
