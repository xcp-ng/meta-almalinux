# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgamma"
PE = "1"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kgamma \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgamma-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "697b3284546fc324adb829fd87fe36d4f5726914665329cdf1adaf53c6e8900e"

URI_x86_64_v2_kgamma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgamma-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgamma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgamma}"
SRC_URI[x86_64_v2_kgamma.sha256sum] = "dbb203682cabf3b367de0f49df2c09340dabadc3d7691ce15032c6fabbc32d11"

URI_aarch64_kgamma = "${EPEL_MIRROR}/aarch64/Packages/k/kgamma-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kgamma;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgamma}"
SRC_URI[aarch64_kgamma.sha256sum] = "2995ab5ffbd9b17dc8fab4f9aba3a831d028028ec81e8586bc4b86516122c882"

RDEPENDS:kgamma = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libX11 \
 libXxf86vm \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
