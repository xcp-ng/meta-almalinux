# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "munge"
PV = "0.5.15"
PR = "11.el10_1"
PACKAGES = " \
 munge \
 munge-devel \
 munge-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/munge-0.5.15-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4f296904131bc06c1bb0963d2caea9094cbf34b095fd30038a08c632136afdd"

URI_x86_64_v2_munge = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/munge-0.5.15-11.el10_1.x86_64_v2.rpm;name=x86_64_v2_munge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_munge}"
SRC_URI[x86_64_v2_munge.sha256sum] = "8cddd6311e581fa1fc5e205350bf493050f03d025a67e82aad166be7e51100af"

URI_x86_64_v2_munge-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/munge-devel-0.5.15-11.el10_1.x86_64_v2.rpm;name=x86_64_v2_munge-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_munge-devel}"
SRC_URI[x86_64_v2_munge-devel.sha256sum] = "36eb6230ade313ad636fe870de86baa568e2627671820d2bf6987adb4cdbeb27"

URI_x86_64_v2_munge-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/munge-libs-0.5.15-11.el10_1.x86_64_v2.rpm;name=x86_64_v2_munge-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_munge-libs}"
SRC_URI[x86_64_v2_munge-libs.sha256sum] = "595d1b31b5f589f75257903e3f48301d4879f433a011bdfb438a5768794eee17"

URI_aarch64_munge = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/munge-0.5.15-11.el10_1.aarch64.rpm;name=aarch64_munge;unpack=0"
SRC_URI:append = " ${URI_aarch64_munge}"
SRC_URI[aarch64_munge.sha256sum] = "0bf19fc4cbe4da93befe6f68f14dde7d34216beae88e6c405a10f68dab2e8bed"

URI_aarch64_munge-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/munge-devel-0.5.15-11.el10_1.aarch64.rpm;name=aarch64_munge-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_munge-devel}"
SRC_URI[aarch64_munge-devel.sha256sum] = "138b865ee1818353c7cd178ab5dcc49ee5a36297f4307f7574bf5d0a9ca26771"

URI_aarch64_munge-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/munge-libs-0.5.15-11.el10_1.aarch64.rpm;name=aarch64_munge-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_munge-libs}"
SRC_URI[aarch64_munge-libs.sha256sum] = "994fa06df42cdba490d6464eaa9f96928b750b1d2a347a26d9e350834ef56ca0"

RDEPENDS:munge = " \
 bash \
 bzip2-libs \
 glibc \
 libgcc \
 logrotate \
 munge-libs \
 openssl-libs \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
RDEPENDS:munge-devel = " \
 munge-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:munge-libs = " \
 glibc \
 "
