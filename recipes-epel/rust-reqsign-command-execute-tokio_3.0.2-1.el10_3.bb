# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-command-execute-tokio"
PV = "3.0.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-command-execute-tokio+default-devel \
 rust-reqsign-command-execute-tokio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-command-execute-tokio-3.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f969a4a6442a9d0c0cbd9128292628b5c67a100eda5bb492fde59d0756b05028"

URI_x86_64_v2_rust-reqsign-command-execute-tokio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-command-execute-tokio+default-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-command-execute-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-command-execute-tokio+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-command-execute-tokio+default-devel.sha256sum] = "4736809ced85d62b776578a48309fcf186f1139a319dd1951472bf21734a8800"

URI_x86_64_v2_rust-reqsign-command-execute-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-command-execute-tokio-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-command-execute-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-command-execute-tokio-devel}"
SRC_URI[x86_64_v2_rust-reqsign-command-execute-tokio-devel.sha256sum] = "9cfb83677703f2bb737ee69d3e9b62b6e31f9cd364d037db2c9776c3dba3bd37"

URI_aarch64_rust-reqsign-command-execute-tokio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-command-execute-tokio+default-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-command-execute-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-command-execute-tokio+default-devel}"
SRC_URI[aarch64_rust-reqsign-command-execute-tokio+default-devel.sha256sum] = "94626c2f168a0ef4d1ddc5048010a483f88274a4dabf13703dfd031f38eeb7d9"

URI_aarch64_rust-reqsign-command-execute-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-command-execute-tokio-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-command-execute-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-command-execute-tokio-devel}"
SRC_URI[aarch64_rust-reqsign-command-execute-tokio-devel.sha256sum] = "e1dfd406122cd72cefc827588212ac054b23f52294b84c83a926cc62b485ebc5"

RDEPENDS:rust-reqsign-command-execute-tokio+default-devel = " \
 cargo \
 rust-reqsign-command-execute-tokio-devel \
 "
RDEPENDS:rust-reqsign-command-execute-tokio-devel = " \
 cargo \
 rust \
 rust-reqsign-core+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+process-devel \
 rust-tokio-devel \
 "
