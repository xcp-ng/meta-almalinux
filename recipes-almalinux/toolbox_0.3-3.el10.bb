# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "toolbox"
PV = "0.3"
PR = "3.el10"
PACKAGES = " \
 toolbox \
 toolbox-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/toolbox-0.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f543ab83475a379ed7b494ced1a88cda8f2b8b00a6372617b49afeb8c11b0750"

URI_x86_64_v2_toolbox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/toolbox-0.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_toolbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_toolbox}"
SRC_URI[x86_64_v2_toolbox.sha256sum] = "34016beefd84a9b5e85ea397a46316755ca92762f84a43c41700e2b24566ba9b"

URI_x86_64_v2_toolbox-tests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/toolbox-tests-0.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_toolbox-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_toolbox-tests}"
SRC_URI[x86_64_v2_toolbox-tests.sha256sum] = "e70a4839c07b472de6258a88eb0697480e3328965ca9b79a6662301315bb3fb1"

URI_aarch64_toolbox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/toolbox-0.3-3.el10.aarch64.rpm;name=aarch64_toolbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_toolbox}"
SRC_URI[aarch64_toolbox.sha256sum] = "b9b1436cdddfe216b9e4090eb77fada966c0378d7a100f9d02fff5a616d503f3"

URI_aarch64_toolbox-tests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/toolbox-tests-0.3-3.el10.aarch64.rpm;name=aarch64_toolbox-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_toolbox-tests}"
SRC_URI[aarch64_toolbox-tests.sha256sum] = "842163904690879533b6a221b2c969fe05bc6a5cba79a1f5026805bf4deac216"

RDEPENDS:toolbox = " \
 containers-common \
 flatpak-session-helper \
 glibc \
 podman \
 shadow-utils-subid \
 "
RDEPENDS:toolbox-tests = " \
 diffutils \
 glib2 \
 grep \
 httpd-tools \
 openssl \
 python3 \
 skopeo \
 toolbox \
 virtual/coreutils \
 "
