# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uv"
PV = "0.8.24"
PR = "2.el10_1"
PACKAGES = " \
 python3-uv \
 uv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uv-0.8.24-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2bbe0d7bd70c78a44598160279a39730fd80a37730fb5dd9841f2b66568cc6a"

URI_aarch64_python3-uv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-uv-0.8.24-2.el10_1.noarch.rpm;name=aarch64_python3-uv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-uv}"
SRC_URI[aarch64_python3-uv.sha256sum] = "d0afd9b690444578932dc6b9d1a6812f7405ac0ed6e0832c8de968fbcd4c33f8"

URI_aarch64_uv = "${EPEL_MIRROR}/aarch64/Packages/u/uv-0.8.24-2.el10_1.aarch64.rpm;name=aarch64_uv;unpack=0"
SRC_URI:append = " ${URI_aarch64_uv}"
SRC_URI[aarch64_uv.sha256sum] = "3be4042b963a9a4b373a8de818a6ba4a27561489cf8d7c0160d5c7a1b51854a4"

RDEPENDS:python3-uv = " \
 python3 \
 uv \
 "
RDEPENDS:uv = " \
 bzip2-libs \
 glibc \
 jemalloc \
 libgcc \
 libzstd \
 xz-libs \
 "
