# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bdii"
PV = "6.0.3"
PR = "1.el10_1"
PACKAGES = " \
 bdii \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bdii-6.0.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5599d3d8c761453bb572114ca32ff283aa3f396ef63e32e2dc275ca1da4508a6"

URI_x86_64_v2_bdii = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bdii-6.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_bdii;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bdii}"
SRC_URI[x86_64_v2_bdii.sha256sum] = "2eb8bd0686d7c8e6b992845c759cde99047c2a69f157e31983cde4b41e2d622f"

URI_aarch64_bdii = "${EPEL_MIRROR}/aarch64/Packages/b/bdii-6.0.3-1.el10_1.noarch.rpm;name=aarch64_bdii;unpack=0"
SRC_URI:append = " ${URI_aarch64_bdii}"
SRC_URI[aarch64_bdii.sha256sum] = "28a74329e756ad9eec956000e1c0cda0962e5302837430589c101d72c291cbf9"

RDEPENDS:bdii = " \
 bash \
 glue-schema \
 logrotate \
 mkpasswd \
 openldap-clients \
 openldap-servers \
 policycoreutils-python-utils \
 python3 \
 systemd \
 "
