# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-merge"
PV = "0.8.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-merge+default-devel \
 rust-gix-merge+document-features-devel \
 rust-gix-merge+serde-devel \
 rust-gix-merge-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-merge-0.8.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1762c9adcf276951bca888c1173539cdc72941f4a795db24dc729610852cc25"

URI_x86_64_v2_rust-gix-merge+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-merge+default-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-merge+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-merge+default-devel}"
SRC_URI[x86_64_v2_rust-gix-merge+default-devel.sha256sum] = "f111fefcd828b81e005a637e16d5fb71882167e040f8397b3088cf63c997394e"

URI_x86_64_v2_rust-gix-merge+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-merge+document-features-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-merge+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-merge+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-merge+document-features-devel.sha256sum] = "966648462042611ed0b6f8a8537e93303df00a68024d7430b3058ecf04be8c9c"

URI_x86_64_v2_rust-gix-merge+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-merge+serde-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-merge+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-merge+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-merge+serde-devel.sha256sum] = "b0e169556fa83edd9dc81804a0791de563b3bd15e8336c1eee1fe620e8b46f46"

URI_x86_64_v2_rust-gix-merge-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-merge-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-merge-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-merge-devel}"
SRC_URI[x86_64_v2_rust-gix-merge-devel.sha256sum] = "336242736739f4dd2a600288c6da80d8692fb563dac57c6f23666df809f6b589"

URI_aarch64_rust-gix-merge+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-merge+default-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-merge+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-merge+default-devel}"
SRC_URI[aarch64_rust-gix-merge+default-devel.sha256sum] = "a3cb18636c69f267a8fc7a6abcd25634292d1b55a114ae2dec3225212395225f"

URI_aarch64_rust-gix-merge+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-merge+document-features-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-merge+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-merge+document-features-devel}"
SRC_URI[aarch64_rust-gix-merge+document-features-devel.sha256sum] = "932a78e87525cd3f8ae5c9a296063b1982facec70ba37b0e26490891d7179ab4"

URI_aarch64_rust-gix-merge+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-merge+serde-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-merge+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-merge+serde-devel}"
SRC_URI[aarch64_rust-gix-merge+serde-devel.sha256sum] = "bb9acbd82b7fa0be86329fdc47712bfe95fce871006286eed17fb64f6c439295"

URI_aarch64_rust-gix-merge-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-merge-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-merge-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-merge-devel}"
SRC_URI[aarch64_rust-gix-merge-devel.sha256sum] = "d3497d48b2015fc8b5c8ec9f1e3df3e76690eb08fed96fbad3aa1fe05e993bdf"

RDEPENDS:rust-gix-merge+default-devel = " \
 cargo \
 rust-gix-merge-devel \
 "
RDEPENDS:rust-gix-merge+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-merge-devel \
 "
RDEPENDS:rust-gix-merge+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-merge-devel \
 rust-gix-object+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-merge-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-command+default-devel \
 rust-gix-diff+blob-devel \
 rust-gix-diff-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-revision+merge_base-devel \
 rust-gix-revision-devel \
 rust-gix-revwalk+default-devel \
 rust-gix-tempfile+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-imara-diff0.1+default-devel \
 rust-thiserror+default-devel \
 "
