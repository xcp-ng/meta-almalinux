# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-piper"
PV = "0.2.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-piper+default-devel \
 rust-piper+futures-io-devel \
 rust-piper+portable-atomic-devel \
 rust-piper+portable-atomic-util-devel \
 rust-piper+portable_atomic_crate-devel \
 rust-piper+std-devel \
 rust-piper-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-piper-0.2.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1085217070c663d4af00e261782563d951fa1d3a038b297f8e2c61ba71889be4"

URI_x86_64_v2_rust-piper+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+default-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-piper+default-devel}"
SRC_URI[x86_64_v2_rust-piper+default-devel.sha256sum] = "92db48b46c5e9275c43bc881ea1fbad6f69884ed6227dd84f011c944065ac7a2"

URI_x86_64_v2_rust-piper+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+futures-io-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-piper+futures-io-devel}"
SRC_URI[x86_64_v2_rust-piper+futures-io-devel.sha256sum] = "a87700a8d270c6d0d499dc4385b607f38b2e66e3770f232abc256dcde471977e"

URI_x86_64_v2_rust-piper+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+portable-atomic-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-piper+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-piper+portable-atomic-devel.sha256sum] = "c74a7dbb43604c10364c7cea5a076d20d664b22f679d21eacfd2eaf2b7344315"

URI_x86_64_v2_rust-piper+portable-atomic-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+portable-atomic-util-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-piper+portable-atomic-util-devel}"
SRC_URI[x86_64_v2_rust-piper+portable-atomic-util-devel.sha256sum] = "dbc70ba27a4980f5489b449bde7f17ce67cea87afe1673f22600572d068a7a4c"

URI_x86_64_v2_rust-piper+portable_atomic_crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+portable_atomic_crate-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+portable_atomic_crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-piper+portable_atomic_crate-devel}"
SRC_URI[x86_64_v2_rust-piper+portable_atomic_crate-devel.sha256sum] = "3e165a58f3c241e933775fe7d2592df444f609a09687bce4471735bbb6e5d16b"

URI_x86_64_v2_rust-piper+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+std-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-piper+std-devel}"
SRC_URI[x86_64_v2_rust-piper+std-devel.sha256sum] = "07aa779325744d670e6778e48d56b936f901cc295ba222343df8bff6e3656d72"

URI_x86_64_v2_rust-piper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-piper-devel}"
SRC_URI[x86_64_v2_rust-piper-devel.sha256sum] = "a0844960a8d734edb97812c6ffea504cdab45da7a4a3f99eecf5bd317e2f997f"

URI_aarch64_rust-piper+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+default-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-piper+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-piper+default-devel}"
SRC_URI[aarch64_rust-piper+default-devel.sha256sum] = "f7005055d8b2b85eb6e5c3b04ea3859e74cc2cbba28ca72415048d8139f190fd"

URI_aarch64_rust-piper+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+futures-io-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-piper+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-piper+futures-io-devel}"
SRC_URI[aarch64_rust-piper+futures-io-devel.sha256sum] = "d6285548f5cf3bf3775911195451af8655fa550d3e77b0bacc12562c9d854df6"

URI_aarch64_rust-piper+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+portable-atomic-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-piper+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-piper+portable-atomic-devel}"
SRC_URI[aarch64_rust-piper+portable-atomic-devel.sha256sum] = "d437229a48561e76ec2e8522344c4854429e9e64ae700139d2ead0806d256eff"

URI_aarch64_rust-piper+portable-atomic-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+portable-atomic-util-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-piper+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-piper+portable-atomic-util-devel}"
SRC_URI[aarch64_rust-piper+portable-atomic-util-devel.sha256sum] = "f8eaf78983623753e44ef582f6d29db2145a8a9eccb52883e627cbd34932ba61"

URI_aarch64_rust-piper+portable_atomic_crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+portable_atomic_crate-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-piper+portable_atomic_crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-piper+portable_atomic_crate-devel}"
SRC_URI[aarch64_rust-piper+portable_atomic_crate-devel.sha256sum] = "6ed981f7b26f26162662f9947ebffe1ec9b69122e23e3e439e9838610d096b21"

URI_aarch64_rust-piper+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+std-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-piper+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-piper+std-devel}"
SRC_URI[aarch64_rust-piper+std-devel.sha256sum] = "26f33e934b7cb28484a2f9e776758e84f0966f73bf902bab6de08fdbc67c06a3"

URI_aarch64_rust-piper-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-piper-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-piper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-piper-devel}"
SRC_URI[aarch64_rust-piper-devel.sha256sum] = "18532a36a4dbd28d8f2bbc295372a5e8ddd34fc3324c6907b7924e9d85c55b8b"

RDEPENDS:rust-piper+default-devel = " \
 cargo \
 rust-piper+std-devel \
 rust-piper-devel \
 "
RDEPENDS:rust-piper+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-piper-devel \
 "
RDEPENDS:rust-piper+portable-atomic-devel = " \
 cargo \
 rust-atomic-waker+portable-atomic-devel \
 rust-piper+portable-atomic-util-devel \
 rust-piper+portable_atomic_crate-devel \
 rust-piper-devel \
 "
RDEPENDS:rust-piper+portable-atomic-util-devel = " \
 cargo \
 rust-piper-devel \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util+default-devel \
 "
RDEPENDS:rust-piper+portable_atomic_crate-devel = " \
 cargo \
 rust-piper-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-piper+std-devel = " \
 cargo \
 rust-fastrand+std-devel \
 rust-piper+futures-io-devel \
 rust-piper-devel \
 "
RDEPENDS:rust-piper-devel = " \
 cargo \
 rust \
 rust-atomic-waker+default-devel \
 rust-fastrand-devel \
 "
