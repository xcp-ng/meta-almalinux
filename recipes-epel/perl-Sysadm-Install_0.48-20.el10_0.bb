# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sysadm-Install"
PV = "0.48"
PR = "20.el10_0"
PACKAGES = " \
 perl-Sysadm-Install \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sysadm-Install-0.48-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "974c161c23b865649b1a57dd6db63700488ccf77355e94ee7e275196f2650baa"

URI_x86_64_v2_perl-Sysadm-Install = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sysadm-Install-0.48-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sysadm-Install;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sysadm-Install}"
SRC_URI[x86_64_v2_perl-Sysadm-Install.sha256sum] = "8d5e99cc95fa7e4b93240978db94428b45959e302146ca882078587688be934c"

URI_aarch64_perl-Sysadm-Install = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sysadm-Install-0.48-20.el10_0.noarch.rpm;name=aarch64_perl-Sysadm-Install;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sysadm-Install}"
SRC_URI[aarch64_perl-Sysadm-Install.sha256sum] = "d6c6bfe6a2275d3017842a62651594d6718b994cdf9dde277ab1a64afd0ec0dd"

RDEPENDS:perl-Sysadm-Install = " \
 perl-Archive-Tar \
 perl-Encode \
 perl-Expect \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-File-Which \
 perl-HTTP-Message \
 perl-Log-Log4perl \
 perl-PathTools \
 perl-TermReadKey \
 perl-libs \
 perl-libwww-perl \
 "
