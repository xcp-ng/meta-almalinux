# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kscreenlocker"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kscreenlocker \
 kscreenlocker-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kscreenlocker-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0e30e81f04514aefcb77001b5615f91058b0b93378e2d4e3951039854cbba6de"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kscreenlocker-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kscreenlocker;unpack=0"
SRC_URI[x86_64_v2_kscreenlocker.sha256sum] = "171596f3d035936ca179ccd1ed957878565cc103c21e0402cafb71ae2b26ff1d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kscreenlocker-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kscreenlocker-devel;unpack=0"
SRC_URI[x86_64_v2_kscreenlocker-devel.sha256sum] = "38140ac684c82e3a11871e01995308f2fab310940404a8bd041888a97233d485"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kscreenlocker-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kscreenlocker;unpack=0"
SRC_URI[aarch64_kscreenlocker.sha256sum] = "5f294c5af7cb7f337e9fb9c16a75593845b8ffc424cc404a6e1a7fa184345262"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kscreenlocker-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kscreenlocker-devel;unpack=0"
SRC_URI[aarch64_kscreenlocker-devel.sha256sum] = "b584b413868fa749b02675c301de113064774fd3a9b7f3efbde8e529932ea594"

RDEPENDS:kscreenlocker = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 layer-shell-qt \
 libX11 \
 libXi \
 libkscreen \
 libplasma \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 libxcb \
 pam-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xcb-util-keysyms \
 "
RDEPENDS:kscreenlocker-devel = " \
 cmake-filesystem \
 kscreenlocker \
 "
