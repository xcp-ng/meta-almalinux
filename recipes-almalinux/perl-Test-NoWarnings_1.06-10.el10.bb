# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-NoWarnings"
PV = "1.06"
PR = "10.el10"
PACKAGES = " \
 perl-Test-NoWarnings \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Test-NoWarnings-1.06-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48ec2c7aca7cd2741a1f8c770bafed3cd6816f5ae12766f49b369a7d329a0e9c"

URI_x86_64_v2_perl-Test-NoWarnings = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Test-NoWarnings-1.06-10.el10.noarch.rpm;name=x86_64_v2_perl-Test-NoWarnings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-NoWarnings}"
SRC_URI[x86_64_v2_perl-Test-NoWarnings.sha256sum] = "bb0ceeafd3a5801c1b86b512702163baa58f6c6b11a9e838feed7ecbd3460c95"

URI_aarch64_perl-Test-NoWarnings = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Test-NoWarnings-1.06-10.el10.noarch.rpm;name=aarch64_perl-Test-NoWarnings;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-NoWarnings}"
SRC_URI[aarch64_perl-Test-NoWarnings.sha256sum] = "bb0ceeafd3a5801c1b86b512702163baa58f6c6b11a9e838feed7ecbd3460c95"

RDEPENDS:perl-Test-NoWarnings = " \
 perl-Carp \
 perl-Exporter \
 perl-Test-NoWarnings \
 perl-Test-Simple \
 perl-libs \
 "
