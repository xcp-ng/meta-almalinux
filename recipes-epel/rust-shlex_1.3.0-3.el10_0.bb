# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-shlex"
PV = "1.3.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-shlex+default-devel \
 rust-shlex+std-devel \
 rust-shlex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-shlex-1.3.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d37690c7a2c0396ffc74001a4e4fd730e4dbd5daf03b4ea7266443bd74035f76"

URI_x86_64_v2_rust-shlex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shlex+default-devel-1.3.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shlex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shlex+default-devel}"
SRC_URI[x86_64_v2_rust-shlex+default-devel.sha256sum] = "2c6177f5e6c84f750ef17118193fa752edbaf29376e83506c73f5b360fbcc3c1"

URI_x86_64_v2_rust-shlex+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shlex+std-devel-1.3.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shlex+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shlex+std-devel}"
SRC_URI[x86_64_v2_rust-shlex+std-devel.sha256sum] = "5e44280ac5ea87465dd94a3f3a2d4aedcd75a056c52aa382f99a960547ecfdbe"

URI_x86_64_v2_rust-shlex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shlex-devel-1.3.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shlex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shlex-devel}"
SRC_URI[x86_64_v2_rust-shlex-devel.sha256sum] = "aba3a046274f3a0b9def76a4377a5a62e26a81604e8a305f532350a1b04f58bf"

URI_aarch64_rust-shlex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shlex+default-devel-1.3.0-3.el10_0.noarch.rpm;name=aarch64_rust-shlex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shlex+default-devel}"
SRC_URI[aarch64_rust-shlex+default-devel.sha256sum] = "999d5060a54d23226ffeabd207d51a2d22c7fb14ae174961dc0cd56e74eb8379"

URI_aarch64_rust-shlex+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shlex+std-devel-1.3.0-3.el10_0.noarch.rpm;name=aarch64_rust-shlex+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shlex+std-devel}"
SRC_URI[aarch64_rust-shlex+std-devel.sha256sum] = "999afc7bf04fcf135387fb17a59cacdb632422cd997231019391eb8537a0d19d"

URI_aarch64_rust-shlex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shlex-devel-1.3.0-3.el10_0.noarch.rpm;name=aarch64_rust-shlex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shlex-devel}"
SRC_URI[aarch64_rust-shlex-devel.sha256sum] = "7c885b32c1f29ba3c54362c2bd1e58c86eed4e502fb0d507f152c68192797675"

RDEPENDS:rust-shlex+default-devel = " \
 cargo \
 rust-shlex+std-devel \
 rust-shlex-devel \
 "
RDEPENDS:rust-shlex+std-devel = " \
 cargo \
 rust-shlex-devel \
 "
RDEPENDS:rust-shlex-devel = " \
 cargo \
 rust \
 "
