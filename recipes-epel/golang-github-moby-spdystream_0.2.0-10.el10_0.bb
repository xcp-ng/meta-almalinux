# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-moby-spdystream"
PV = "0.2.0"
PR = "10.el10_0"
PACKAGES = " \
 golang-github-moby-spdystream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-moby-spdystream-0.2.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24d7bfa0bc3328a25490a22bd445a0316075e6944988e7f8544f145e71793383"

URI_x86_64_v2_golang-github-moby-spdystream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-moby-spdystream-devel-0.2.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-moby-spdystream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-moby-spdystream-devel}"
SRC_URI[x86_64_v2_golang-github-moby-spdystream-devel.sha256sum] = "64db9a91b487843e64867f64f70f317867dda454c006bca68eacb97ed1740e98"

URI_aarch64_golang-github-moby-spdystream-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-moby-spdystream-devel-0.2.0-10.el10_0.noarch.rpm;name=aarch64_golang-github-moby-spdystream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-moby-spdystream-devel}"
SRC_URI[aarch64_golang-github-moby-spdystream-devel.sha256sum] = "84db22ce07ce18995376be2cb80982df8a6b62e7ab42989cfec13ee941f9dc45"

RDEPENDS:golang-github-moby-spdystream-devel = " \
 go-filesystem \
 golang-github-gorilla-websocket-devel \
 "
