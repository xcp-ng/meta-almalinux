# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wp-cli"
PV = "2.12.0"
PR = "1.el10_1"
PACKAGES = " \
 wp-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wp-cli-2.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68606f7d311a95fc8a5218fc180d541f3c748626c01f9536b1a36c9c7596fd51"

URI_x86_64_v2_wp-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wp-cli-2.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_wp-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wp-cli}"
SRC_URI[x86_64_v2_wp-cli.sha256sum] = "8b0408671a0c82a07e9692438aef9a26e862b421e8d8312988d3747e914a5751"

URI_aarch64_wp-cli = "${EPEL_MIRROR}/aarch64/Packages/w/wp-cli-2.12.0-1.el10_1.noarch.rpm;name=aarch64_wp-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_wp-cli}"
SRC_URI[aarch64_wp-cli.sha256sum] = "7108d867e398d47fc6d047891c1d2edb3ddb2d33a8153e84b7d59da593a46308"

RDEPENDS:wp-cli = " \
 "
