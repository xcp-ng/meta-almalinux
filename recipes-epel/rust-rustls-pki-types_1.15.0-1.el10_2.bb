# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-pki-types"
PV = "1.15.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-pki-types+std-devel \
 rust-rustls-pki-types+web-devel \
 rust-rustls-pki-types-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-pki-types-1.15.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8db55965a6f869f848ecec10c2045d923b53a9d2c9999f03ed3aa32c995e36a"

URI_x86_64_v2_rust-rustls-pki-types+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+alloc-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+alloc-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+alloc-devel.sha256sum] = "57a4ed158b2f0fadd0ed9a44d3bf2097265d769d8f544357bf68c3013d007c40"

URI_x86_64_v2_rust-rustls-pki-types+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+default-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+default-devel.sha256sum] = "87f0508eb3c86d0e3136d3e71c929d1ee53d76982c2c2dea30ccf94d2939e5aa"

URI_x86_64_v2_rust-rustls-pki-types+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+std-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+std-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+std-devel.sha256sum] = "666d062eb436476e623c23bf54b20bb0af65c24e707c63e5a0a278a58a38e6ed"

URI_x86_64_v2_rust-rustls-pki-types+web-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+web-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+web-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+web-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+web-devel.sha256sum] = "c2fe4610abc64be14a9902ac62b457ecbd3df09f5d6c57fcfb3d19fd9fe1a986"

URI_x86_64_v2_rust-rustls-pki-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types-devel.sha256sum] = "adba66f6b33b74a014a686ba43fca9c6417ec7222d63c2cf791d46c7292d30fd"

URI_aarch64_rust-rustls-pki-types+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+alloc-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-pki-types+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+alloc-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+alloc-devel.sha256sum] = "0088e8c681356735af9ef65c056cf3afc3e2e0abf7a6de5c8602b4249881ef34"

URI_aarch64_rust-rustls-pki-types+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+default-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-pki-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+default-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+default-devel.sha256sum] = "a92378d748336d2c768c46ea7c149234d059d1f317d2301ae08f5e738d9eeaf2"

URI_aarch64_rust-rustls-pki-types+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+std-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-pki-types+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+std-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+std-devel.sha256sum] = "703fcac5f384ff4824f6d282b7a4a83f683c001cd35300303068367635973ab6"

URI_aarch64_rust-rustls-pki-types+web-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+web-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-pki-types+web-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+web-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+web-devel.sha256sum] = "ece5d6939e412c1eedfb1fcff94f317503d2908da68449cc49b3ecc2157c1b4a"

URI_aarch64_rust-rustls-pki-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types-devel}"
SRC_URI[aarch64_rust-rustls-pki-types-devel.sha256sum] = "88d640fc3d2dba75348a3ef7070e217ec4d92fca043c9a2674d61fc254712cdd"

RDEPENDS:rust-rustls-pki-types+alloc-devel = " \
 cargo \
 rust-rustls-pki-types-devel \
 rust-zeroize+default-devel \
 "
RDEPENDS:rust-rustls-pki-types+default-devel = " \
 cargo \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types-devel \
 "
RDEPENDS:rust-rustls-pki-types+std-devel = " \
 cargo \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types-devel \
 "
RDEPENDS:rust-rustls-pki-types+web-devel = " \
 cargo \
 rust-rustls-pki-types-devel \
 "
RDEPENDS:rust-rustls-pki-types-devel = " \
 cargo \
 rust \
 "
