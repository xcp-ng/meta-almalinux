# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typetag"
PV = "0.2.23"
PR = "1.el10_3"
PACKAGES = " \
 rust-typetag+default-devel \
 rust-typetag-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-typetag-0.2.23-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b717a44749ea16f3cfb0e37494753cd081a161bf8bf1c26f8641ef3f2110e9f9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag+default-devel-0.2.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-typetag+default-devel.sha256sum] = "8fb90affd0f2160c6a98a1751bc88c99ba9e91f161084aceeea52c89f10f78c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag-devel-0.2.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag-devel;unpack=0"
SRC_URI[x86_64_v2_rust-typetag-devel.sha256sum] = "35646242c9d7891c46cf08fa00bfe12b1e401422fb661084cc9d0707e2a4c32b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag+default-devel-0.2.23-1.el10_3.noarch.rpm;name=aarch64_rust-typetag+default-devel;unpack=0"
SRC_URI[aarch64_rust-typetag+default-devel.sha256sum] = "57d022ee4ea207c6cbf23ae3c80551e5e17ff11be5534401479a14621d632fab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag-devel-0.2.23-1.el10_3.noarch.rpm;name=aarch64_rust-typetag-devel;unpack=0"
SRC_URI[aarch64_rust-typetag-devel.sha256sum] = "27c3929b7c4da7dab7b96090073a6c563da53565a6089e7f2f8c32fa4ecdce77"

RDEPENDS:rust-typetag+default-devel = " \
 cargo \
 rust-typetag-devel \
 "
RDEPENDS:rust-typetag-devel = " \
 cargo \
 rust \
 rust-erased-serde+alloc-devel \
 rust-erased-serde-devel \
 rust-inventory+default-devel \
 rust-once_cell+alloc-devel \
 rust-once_cell-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-typetag-impl+default-devel \
 "
