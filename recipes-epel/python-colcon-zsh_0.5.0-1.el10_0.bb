# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-zsh"
PV = "0.5.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-zsh \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-zsh-0.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e109f96cc8f29447202dd4e880c316df5a23047a0c60593c49530d01b852254d"

URI_x86_64_v2_python3-colcon-zsh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-zsh-0.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-zsh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-zsh}"
SRC_URI[x86_64_v2_python3-colcon-zsh.sha256sum] = "783e6398720ed06e2b5deb532728a31469720475c36006e1d17e6e6e10e91a52"

URI_aarch64_python3-colcon-zsh = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-zsh-0.5.0-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-zsh;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-zsh}"
SRC_URI[aarch64_python3-colcon-zsh.sha256sum] = "39dd0eff601084728226104b04bf5595123dfb62d9fae1567e839d2415a39410"

RDEPENDS:python3-colcon-zsh = " \
 python3 \
 python3-colcon-core \
 "
