# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glibc"
PV = "2.39"
PR = "130.el10.alma.1"
PACKAGES = " \
 glibc \
 glibc-all-langpacks \
 glibc-benchtests \
 glibc-common \
 glibc-devel \
 glibc-doc \
 glibc-gconv-extra \
 glibc-langpack-aa \
 glibc-langpack-af \
 glibc-langpack-agr \
 glibc-langpack-ak \
 glibc-langpack-am \
 glibc-langpack-an \
 glibc-langpack-anp \
 glibc-langpack-ar \
 glibc-langpack-as \
 glibc-langpack-ast \
 glibc-langpack-ayc \
 glibc-langpack-az \
 glibc-langpack-be \
 glibc-langpack-bem \
 glibc-langpack-ber \
 glibc-langpack-bg \
 glibc-langpack-bhb \
 glibc-langpack-bho \
 glibc-langpack-bi \
 glibc-langpack-bn \
 glibc-langpack-bo \
 glibc-langpack-br \
 glibc-langpack-brx \
 glibc-langpack-bs \
 glibc-langpack-byn \
 glibc-langpack-ca \
 glibc-langpack-ce \
 glibc-langpack-chr \
 glibc-langpack-ckb \
 glibc-langpack-cmn \
 glibc-langpack-crh \
 glibc-langpack-cs \
 glibc-langpack-csb \
 glibc-langpack-cv \
 glibc-langpack-cy \
 glibc-langpack-da \
 glibc-langpack-de \
 glibc-langpack-doi \
 glibc-langpack-dsb \
 glibc-langpack-dv \
 glibc-langpack-dz \
 glibc-langpack-el \
 glibc-langpack-en \
 glibc-langpack-eo \
 glibc-langpack-es \
 glibc-langpack-et \
 glibc-langpack-eu \
 glibc-langpack-fa \
 glibc-langpack-ff \
 glibc-langpack-fi \
 glibc-langpack-fil \
 glibc-langpack-fo \
 glibc-langpack-fr \
 glibc-langpack-fur \
 glibc-langpack-fy \
 glibc-langpack-ga \
 glibc-langpack-gbm \
 glibc-langpack-gd \
 glibc-langpack-gez \
 glibc-langpack-gl \
 glibc-langpack-gu \
 glibc-langpack-gv \
 glibc-langpack-ha \
 glibc-langpack-hak \
 glibc-langpack-he \
 glibc-langpack-hi \
 glibc-langpack-hif \
 glibc-langpack-hne \
 glibc-langpack-hr \
 glibc-langpack-hsb \
 glibc-langpack-ht \
 glibc-langpack-hu \
 glibc-langpack-hy \
 glibc-langpack-ia \
 glibc-langpack-id \
 glibc-langpack-ig \
 glibc-langpack-ik \
 glibc-langpack-is \
 glibc-langpack-it \
 glibc-langpack-iu \
 glibc-langpack-ja \
 glibc-langpack-ka \
 glibc-langpack-kab \
 glibc-langpack-kk \
 glibc-langpack-kl \
 glibc-langpack-km \
 glibc-langpack-kn \
 glibc-langpack-ko \
 glibc-langpack-kok \
 glibc-langpack-ks \
 glibc-langpack-ku \
 glibc-langpack-kv \
 glibc-langpack-kw \
 glibc-langpack-ky \
 glibc-langpack-lb \
 glibc-langpack-lg \
 glibc-langpack-li \
 glibc-langpack-lij \
 glibc-langpack-ln \
 glibc-langpack-lo \
 glibc-langpack-lt \
 glibc-langpack-lv \
 glibc-langpack-lzh \
 glibc-langpack-mag \
 glibc-langpack-mai \
 glibc-langpack-mfe \
 glibc-langpack-mg \
 glibc-langpack-mhr \
 glibc-langpack-mi \
 glibc-langpack-miq \
 glibc-langpack-mjw \
 glibc-langpack-mk \
 glibc-langpack-ml \
 glibc-langpack-mn \
 glibc-langpack-mni \
 glibc-langpack-mnw \
 glibc-langpack-mr \
 glibc-langpack-ms \
 glibc-langpack-mt \
 glibc-langpack-my \
 glibc-langpack-nan \
 glibc-langpack-nb \
 glibc-langpack-nds \
 glibc-langpack-ne \
 glibc-langpack-nhn \
 glibc-langpack-niu \
 glibc-langpack-nl \
 glibc-langpack-nn \
 glibc-langpack-nr \
 glibc-langpack-nso \
 glibc-langpack-oc \
 glibc-langpack-om \
 glibc-langpack-or \
 glibc-langpack-os \
 glibc-langpack-pa \
 glibc-langpack-pap \
 glibc-langpack-pl \
 glibc-langpack-ps \
 glibc-langpack-pt \
 glibc-langpack-quz \
 glibc-langpack-raj \
 glibc-langpack-rif \
 glibc-langpack-ro \
 glibc-langpack-ru \
 glibc-langpack-rw \
 glibc-langpack-sa \
 glibc-langpack-sah \
 glibc-langpack-sat \
 glibc-langpack-sc \
 glibc-langpack-sd \
 glibc-langpack-se \
 glibc-langpack-sgs \
 glibc-langpack-shn \
 glibc-langpack-shs \
 glibc-langpack-si \
 glibc-langpack-sid \
 glibc-langpack-sk \
 glibc-langpack-sl \
 glibc-langpack-sm \
 glibc-langpack-so \
 glibc-langpack-sq \
 glibc-langpack-sr \
 glibc-langpack-ss \
 glibc-langpack-ssy \
 glibc-langpack-st \
 glibc-langpack-su \
 glibc-langpack-sv \
 glibc-langpack-sw \
 glibc-langpack-syr \
 glibc-langpack-szl \
 glibc-langpack-ta \
 glibc-langpack-tcy \
 glibc-langpack-te \
 glibc-langpack-tg \
 glibc-langpack-th \
 glibc-langpack-the \
 glibc-langpack-ti \
 glibc-langpack-tig \
 glibc-langpack-tk \
 glibc-langpack-tl \
 glibc-langpack-tn \
 glibc-langpack-to \
 glibc-langpack-tok \
 glibc-langpack-tpi \
 glibc-langpack-tr \
 glibc-langpack-ts \
 glibc-langpack-tt \
 glibc-langpack-ug \
 glibc-langpack-uk \
 glibc-langpack-unm \
 glibc-langpack-ur \
 glibc-langpack-uz \
 glibc-langpack-ve \
 glibc-langpack-vi \
 glibc-langpack-wa \
 glibc-langpack-wae \
 glibc-langpack-wal \
 glibc-langpack-wo \
 glibc-langpack-xh \
 glibc-langpack-yi \
 glibc-langpack-yo \
 glibc-langpack-yue \
 glibc-langpack-yuw \
 glibc-langpack-zgh \
 glibc-langpack-zh \
 glibc-langpack-zu \
 glibc-locale-source \
 glibc-minimal-langpack \
 glibc-nss-devel \
 glibc-static \
 glibc-utils \
 libnsl \
 nss_db \
 nss_hesiod \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/glibc-2.39-130.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "476ede52bc0e27dc60830b679b551cac5cca665391d8fcd9c688f4437a3754ba"

URI_x86_64_v2_glibc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc}"
SRC_URI[x86_64_v2_glibc.sha256sum] = "d339b17b56fd85626d94cf61a5b7d8eeef76785283a28b4f5c628c2445fa5b0a"

URI_x86_64_v2_glibc-all-langpacks = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-all-langpacks-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-all-langpacks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-all-langpacks}"
SRC_URI[x86_64_v2_glibc-all-langpacks.sha256sum] = "2018dc17ada9759e8d0116807ba416206d2707856f225039879f63deb58b5ecc"
RPROVIDES:glibc-all-langpacks:x86_64_v2 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-benchtests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibc-benchtests-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-benchtests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-benchtests}"
SRC_URI[x86_64_v2_glibc-benchtests.sha256sum] = "27d70124f7c2ba18102582ccafd7f40832a79b02e9e4c688b9448aa9be26b8be"

URI_x86_64_v2_glibc-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-common-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-common}"
SRC_URI[x86_64_v2_glibc-common.sha256sum] = "f131dfb2e4acafbe6ef51e2413cc63ab8c80aa0fc23d299df3e7a135c5b188f5"

URI_x86_64_v2_glibc-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-devel-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-devel}"
SRC_URI[x86_64_v2_glibc-devel.sha256sum] = "7e4b7d778f435d36d0990cdd9a6cf86a6f9a276af71177054a17ae0023040ac1"

URI_x86_64_v2_glibc-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-doc-2.39-130.el10.alma.1.noarch.rpm;name=x86_64_v2_glibc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-doc}"
SRC_URI[x86_64_v2_glibc-doc.sha256sum] = "cedf64eda4b97e1f699ad12b8060f179304957b154578121630ebc09b8e1e092"

URI_x86_64_v2_glibc-gconv-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-gconv-extra-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-gconv-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-gconv-extra}"
SRC_URI[x86_64_v2_glibc-gconv-extra.sha256sum] = "8b3f5ed1c788704cc64aeef0da188311446e7b410cb93578c7af365fb86eff74"

URI_x86_64_v2_glibc-langpack-aa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-aa-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-aa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-aa}"
SRC_URI[x86_64_v2_glibc-langpack-aa.sha256sum] = "37f2665760a59cb27dc0ede6c32647e94d992e8806a5920418852163d1915dbe"
RPROVIDES:glibc-langpack-aa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-af = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-af-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-af;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-af}"
SRC_URI[x86_64_v2_glibc-langpack-af.sha256sum] = "80d5b7d5aee3fe15a431af166297e659d1c3b8239e2806fda58fa1c9a57f22f8"
RPROVIDES:glibc-langpack-af:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-agr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-agr-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-agr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-agr}"
SRC_URI[x86_64_v2_glibc-langpack-agr.sha256sum] = "f537958d7c6694701ced4b77b67766a8b5002799873b391ce895ceeda9c06d71"
RPROVIDES:glibc-langpack-agr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ak = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ak-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ak}"
SRC_URI[x86_64_v2_glibc-langpack-ak.sha256sum] = "269703396a641afe8a33af64d6e1682de8bd3f173f8a1c83688a42a7ba37caa8"
RPROVIDES:glibc-langpack-ak:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-am = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-am-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-am;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-am}"
SRC_URI[x86_64_v2_glibc-langpack-am.sha256sum] = "0866359b2464aee196225452566f0e8e2c19a80c856788071cda1dcc0b866bc5"
RPROVIDES:glibc-langpack-am:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-an = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-an-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-an;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-an}"
SRC_URI[x86_64_v2_glibc-langpack-an.sha256sum] = "f12ca56d4722821d39bda797153e58f370b392cc7c86effd2589151a4777b49a"
RPROVIDES:glibc-langpack-an:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-anp = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-anp-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-anp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-anp}"
SRC_URI[x86_64_v2_glibc-langpack-anp.sha256sum] = "9c3421e61c84f57f84576fc263dc603f82c6e0bb797e5ccd896b793f05e35b01"
RPROVIDES:glibc-langpack-anp:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ar = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ar-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ar}"
SRC_URI[x86_64_v2_glibc-langpack-ar.sha256sum] = "08b531b15e4695d66517090f34735ed16e7bc1b25eff60e3e8caeed22618adcf"
RPROVIDES:glibc-langpack-ar:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-as = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-as-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-as;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-as}"
SRC_URI[x86_64_v2_glibc-langpack-as.sha256sum] = "66f975f9c829dd0d0ed8554c01441ea9c9aba27cfb267ce4193ec375085d0020"
RPROVIDES:glibc-langpack-as:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ast = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ast-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ast}"
SRC_URI[x86_64_v2_glibc-langpack-ast.sha256sum] = "8351f79311831c870fbc52139750f5058b2f3d85d1a2795a770e4f4cd44548f2"
RPROVIDES:glibc-langpack-ast:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ayc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ayc-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ayc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ayc}"
SRC_URI[x86_64_v2_glibc-langpack-ayc.sha256sum] = "286ddd9d818759dd388b11cdf9235db8f2bb604bd9df73554d3c5c14959375a6"
RPROVIDES:glibc-langpack-ayc:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-az = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-az-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-az;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-az}"
SRC_URI[x86_64_v2_glibc-langpack-az.sha256sum] = "8aa1f02d735c4f37f49c0ac8202476f362c286d15872c65c15886387aa21adec"
RPROVIDES:glibc-langpack-az:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-be = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-be-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-be;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-be}"
SRC_URI[x86_64_v2_glibc-langpack-be.sha256sum] = "52b49e43a99c8f34e3eba95c8724c06003e0426fe4c93065d5ad70a132a72516"
RPROVIDES:glibc-langpack-be:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-bem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bem-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bem}"
SRC_URI[x86_64_v2_glibc-langpack-bem.sha256sum] = "5e836a3365c5e93510b0716ef85195053fc972cd27ef0a7879ce47c022d1f3f1"
RPROVIDES:glibc-langpack-bem:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ber = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ber-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ber}"
SRC_URI[x86_64_v2_glibc-langpack-ber.sha256sum] = "52174d44ee4b35922b5f7bdc0d676d4070773c1775c32ac8c4796c45f50a8aa7"
RPROVIDES:glibc-langpack-ber:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-bg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bg-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bg}"
SRC_URI[x86_64_v2_glibc-langpack-bg.sha256sum] = "5f583a8bceb69f8548fc512e2340068879c3b7792f1bada2da49316f6dabee28"
RPROVIDES:glibc-langpack-bg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-bhb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bhb-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bhb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bhb}"
SRC_URI[x86_64_v2_glibc-langpack-bhb.sha256sum] = "5c8ebfa06c5062b1c7067bea022704597cae64edcfc8f861abf5b6ad416a7438"
RPROVIDES:glibc-langpack-bhb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-bho = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bho-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bho;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bho}"
SRC_URI[x86_64_v2_glibc-langpack-bho.sha256sum] = "a336b20b15469ddf016ea2470fc314845b0122e4d030392d0e55b543fe464b91"
RPROVIDES:glibc-langpack-bho:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-bi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bi-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bi}"
SRC_URI[x86_64_v2_glibc-langpack-bi.sha256sum] = "977a37124c2425c7bc19e87055a4dd77b6badbc4e6bb535d56ac9f3f0743e103"
RPROVIDES:glibc-langpack-bi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-bn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bn-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bn}"
SRC_URI[x86_64_v2_glibc-langpack-bn.sha256sum] = "ef4260f9f2ed4a56194912fe1e5bbd2d4426382aac5e7bda8736728c5b3efb34"
RPROVIDES:glibc-langpack-bn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-bo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bo-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bo}"
SRC_URI[x86_64_v2_glibc-langpack-bo.sha256sum] = "afb38040da31cb4ac936bcc4b5e7a14af876e661a42bb6ee6246dc678b0abc7c"
RPROVIDES:glibc-langpack-bo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-br = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-br-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-br;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-br}"
SRC_URI[x86_64_v2_glibc-langpack-br.sha256sum] = "e3db80893294b0d40fa1a7fae1d72c0f416294d56781493d5d41f88da3afbb73"
RPROVIDES:glibc-langpack-br:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-brx = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-brx-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-brx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-brx}"
SRC_URI[x86_64_v2_glibc-langpack-brx.sha256sum] = "f6e587ef8a82ceca2e88a501a0f41b043b5a2482b39df28082da9ba906a0a3e4"
RPROVIDES:glibc-langpack-brx:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-bs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bs-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bs}"
SRC_URI[x86_64_v2_glibc-langpack-bs.sha256sum] = "ee0bb2612da534c4976be5f709642208df29e44af950a7ee8987e7392751f181"
RPROVIDES:glibc-langpack-bs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-byn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-byn-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-byn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-byn}"
SRC_URI[x86_64_v2_glibc-langpack-byn.sha256sum] = "cb577e3ba12586b9b5f478315881f5b9330da13342ecb3d934a8c3161f46b9e5"
RPROVIDES:glibc-langpack-byn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ca = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ca-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ca}"
SRC_URI[x86_64_v2_glibc-langpack-ca.sha256sum] = "6f46ef8707ca0f8bec0764703d08789808a949168d339b1458d180e653f40e74"
RPROVIDES:glibc-langpack-ca:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ce = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ce-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ce}"
SRC_URI[x86_64_v2_glibc-langpack-ce.sha256sum] = "345aa0d2403ab8c32581b10d122fe59ab971a8d8a0e1cc1275213bc6fe94d168"
RPROVIDES:glibc-langpack-ce:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-chr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-chr-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-chr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-chr}"
SRC_URI[x86_64_v2_glibc-langpack-chr.sha256sum] = "546293a4ba0e64fe0794d378ac5dfc174d1d8a50e8d3bfddf70f61b2695440fd"
RPROVIDES:glibc-langpack-chr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ckb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ckb-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ckb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ckb}"
SRC_URI[x86_64_v2_glibc-langpack-ckb.sha256sum] = "b8081ca475dffd42136211ec2f97dcaddc6d37013b1960fc40cb034cdcc72a06"
RPROVIDES:glibc-langpack-ckb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-cmn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cmn-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cmn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cmn}"
SRC_URI[x86_64_v2_glibc-langpack-cmn.sha256sum] = "0435f39b897604a00ba63beccd70af31afdbb738d11bd217e84cd14eef969d90"
RPROVIDES:glibc-langpack-cmn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-crh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-crh-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-crh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-crh}"
SRC_URI[x86_64_v2_glibc-langpack-crh.sha256sum] = "b47ef6a383603105b0caf9cd131a8210e20101756d47b66ed7efed83b4506d39"
RPROVIDES:glibc-langpack-crh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-cs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cs-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cs}"
SRC_URI[x86_64_v2_glibc-langpack-cs.sha256sum] = "e07a3f737fba30888354da230a78ae1f205b9386f32e7923df99def6f575ca79"
RPROVIDES:glibc-langpack-cs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-csb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-csb-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-csb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-csb}"
SRC_URI[x86_64_v2_glibc-langpack-csb.sha256sum] = "7baee8eba7f990dfd5a46f03409b58d01efefd0905058e71caff620ac330a66a"
RPROVIDES:glibc-langpack-csb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-cv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cv-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cv}"
SRC_URI[x86_64_v2_glibc-langpack-cv.sha256sum] = "e5c6213a4f37aef7665ca32ffe5293b74b32bcda7f6662c3e42ab8c32d600a84"
RPROVIDES:glibc-langpack-cv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-cy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cy-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cy}"
SRC_URI[x86_64_v2_glibc-langpack-cy.sha256sum] = "df093a4bbf7e3afde40fa7fd0adc2e5f107c7b644c677e2dc9972775764cb43c"
RPROVIDES:glibc-langpack-cy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-da = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-da-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-da;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-da}"
SRC_URI[x86_64_v2_glibc-langpack-da.sha256sum] = "0a7349cbb07e473586c6e2879184631531969ea51a08fdc782cbfe205977eeb0"
RPROVIDES:glibc-langpack-da:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-de = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-de-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-de;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-de}"
SRC_URI[x86_64_v2_glibc-langpack-de.sha256sum] = "25c10648c3944a9b7a664e9f3c0c1d3395261cd91638e81a176bc3c463c9cf2d"
RPROVIDES:glibc-langpack-de:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-doi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-doi-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-doi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-doi}"
SRC_URI[x86_64_v2_glibc-langpack-doi.sha256sum] = "d8d60e15b33b94d6fe704351ad91aedea68c20208708c8e6b7286de5f7f5a298"
RPROVIDES:glibc-langpack-doi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-dsb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dsb-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-dsb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-dsb}"
SRC_URI[x86_64_v2_glibc-langpack-dsb.sha256sum] = "740cd3bf23dc7ec7b7aef2355a58e7d51497f22c4ad8c21292fc610b77749ad7"
RPROVIDES:glibc-langpack-dsb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-dv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dv-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-dv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-dv}"
SRC_URI[x86_64_v2_glibc-langpack-dv.sha256sum] = "a2910e39082e5d88d4eccc57f9bf888f7cef47443daad2c6b493d9ebc161c8d4"
RPROVIDES:glibc-langpack-dv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-dz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dz-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-dz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-dz}"
SRC_URI[x86_64_v2_glibc-langpack-dz.sha256sum] = "067f147eecf336e3f2fa9dab84edd7387acd5c7a6dfed56d31dabdd2ee9b5703"
RPROVIDES:glibc-langpack-dz:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-el = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-el-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-el;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-el}"
SRC_URI[x86_64_v2_glibc-langpack-el.sha256sum] = "830315ba7157ee2b2cb55c41f38a96c5ac936792ce8fe729835755091ddfea70"
RPROVIDES:glibc-langpack-el:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-en = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-en-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-en;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-en}"
SRC_URI[x86_64_v2_glibc-langpack-en.sha256sum] = "4b430ccfe83d4db0a93fc8da1bbc7366022a600f6e54d3d8a6200b0cb2b77e07"
RPROVIDES:glibc-langpack-en:x86_64_v2 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-eo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-eo-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-eo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-eo}"
SRC_URI[x86_64_v2_glibc-langpack-eo.sha256sum] = "0e8c556b7f242669b96589e8c5fcdc58a7eeb970ea36145799d1231a52c068d1"
RPROVIDES:glibc-langpack-eo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-es = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-es-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-es;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-es}"
SRC_URI[x86_64_v2_glibc-langpack-es.sha256sum] = "229adea577138a67697842852e874d66908a6dcd41fc97a650ec27f69c17e4ee"
RPROVIDES:glibc-langpack-es:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-et = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-et-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-et;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-et}"
SRC_URI[x86_64_v2_glibc-langpack-et.sha256sum] = "050e6956250ea061b7ea148e73353413e8d98c7d24c37abdb61571bc97b25931"
RPROVIDES:glibc-langpack-et:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-eu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-eu-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-eu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-eu}"
SRC_URI[x86_64_v2_glibc-langpack-eu.sha256sum] = "7f8ca09f78279ecb46495f26ca9326232f5535d2907ba89a0b33f0ac992f3df5"
RPROVIDES:glibc-langpack-eu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-fa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fa-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fa}"
SRC_URI[x86_64_v2_glibc-langpack-fa.sha256sum] = "08d2ac63234245d6ff429b9bc88a511dfbf91a4a3cb910e1546e134d55beb95f"
RPROVIDES:glibc-langpack-fa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ff = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ff-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ff}"
SRC_URI[x86_64_v2_glibc-langpack-ff.sha256sum] = "98be58032dad7872a60c3a9d30e8866ab116baae79a1db4b0d612fd1c66b808c"
RPROVIDES:glibc-langpack-ff:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-fi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fi-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fi}"
SRC_URI[x86_64_v2_glibc-langpack-fi.sha256sum] = "15af13a8c89f25cd98f10a7970cf0976c27c5ec3ae8c5aadeb30f2d27ae4a869"
RPROVIDES:glibc-langpack-fi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-fil = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fil-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fil}"
SRC_URI[x86_64_v2_glibc-langpack-fil.sha256sum] = "90d738aca46a3c31107b2393eae4e17311e5f97b4286eb2c906af20e5771d8ff"
RPROVIDES:glibc-langpack-fil:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-fo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fo-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fo}"
SRC_URI[x86_64_v2_glibc-langpack-fo.sha256sum] = "c3b8f8f9d3adc3aad2a7c82fb0368d0e69b8dcb164fa8ecf7f7b16c82d297514"
RPROVIDES:glibc-langpack-fo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-fr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fr-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fr}"
SRC_URI[x86_64_v2_glibc-langpack-fr.sha256sum] = "3110a23f5cfb790394a3c42c2c1893497984b2b5436abb759e917a7f35ab2a78"
RPROVIDES:glibc-langpack-fr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-fur = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fur-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fur}"
SRC_URI[x86_64_v2_glibc-langpack-fur.sha256sum] = "9ec946941adcd5041c10c0e8f40f226837a9b339fb94dc9a4a522e72819c906f"
RPROVIDES:glibc-langpack-fur:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-fy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fy-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fy}"
SRC_URI[x86_64_v2_glibc-langpack-fy.sha256sum] = "60938422e7ee5cd62f6905b9820ac79b70b76193a05b0d6e748175da090412ce"
RPROVIDES:glibc-langpack-fy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ga = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ga-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ga;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ga}"
SRC_URI[x86_64_v2_glibc-langpack-ga.sha256sum] = "0fdb6e1d72e583bba655a2036b8fe99f520c68886aef0a72db68d3026dce3541"
RPROVIDES:glibc-langpack-ga:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-gbm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gbm-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gbm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gbm}"
SRC_URI[x86_64_v2_glibc-langpack-gbm.sha256sum] = "c8e2dff11cc3d19f796bf11c7b4518e609a6a541ebcf63409de717fbc88d05d6"
RPROVIDES:glibc-langpack-gbm:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-gd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gd-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gd}"
SRC_URI[x86_64_v2_glibc-langpack-gd.sha256sum] = "b34a1934615db0e660b840cefc9346783db8ad62f35b9add31a3df5405ea528b"
RPROVIDES:glibc-langpack-gd:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-gez = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gez-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gez;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gez}"
SRC_URI[x86_64_v2_glibc-langpack-gez.sha256sum] = "63a99e7b659cbe617833d945d495bc1729f027c066bcf8854d34c3b6a6c95453"
RPROVIDES:glibc-langpack-gez:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-gl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gl-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gl}"
SRC_URI[x86_64_v2_glibc-langpack-gl.sha256sum] = "aa6876ddf1a1238d06504e049c20ad3bab8759cc4b643a365461228aeb9d42ad"
RPROVIDES:glibc-langpack-gl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-gu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gu-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gu}"
SRC_URI[x86_64_v2_glibc-langpack-gu.sha256sum] = "5382abddf14cb4127b3ade5c9d6fbd21e9a88b3c198f8b05305378076430342b"
RPROVIDES:glibc-langpack-gu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-gv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gv-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gv}"
SRC_URI[x86_64_v2_glibc-langpack-gv.sha256sum] = "5d93c76238d35be64aadc9b4af81a2e3bfff12bb1ea5727fd5b6223646953e64"
RPROVIDES:glibc-langpack-gv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ha = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ha-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ha;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ha}"
SRC_URI[x86_64_v2_glibc-langpack-ha.sha256sum] = "68943526a4474faeaf5c380c52592f890f13fd5b5b899d4e665dc6bac4b36b8f"
RPROVIDES:glibc-langpack-ha:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-hak = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hak-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hak}"
SRC_URI[x86_64_v2_glibc-langpack-hak.sha256sum] = "3ecf8e17e64528a51b2be5747b5001c447b481d60ba3ef1c42676b0e6f6bea45"
RPROVIDES:glibc-langpack-hak:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-he = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-he-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-he;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-he}"
SRC_URI[x86_64_v2_glibc-langpack-he.sha256sum] = "df522c0705d892e5cd9db5e5de149a0d9514346f09931d52cfb3bcbc1941146c"
RPROVIDES:glibc-langpack-he:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-hi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hi-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hi}"
SRC_URI[x86_64_v2_glibc-langpack-hi.sha256sum] = "a282062d853f2016e7fc714d2b552d885af429e51492b3cadda735e8ef8f9a8d"
RPROVIDES:glibc-langpack-hi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-hif = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hif-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hif}"
SRC_URI[x86_64_v2_glibc-langpack-hif.sha256sum] = "44f77303f691402f311789958e4f4013abbcab5bed501e101b2b454608c1e63f"
RPROVIDES:glibc-langpack-hif:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-hne = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hne-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hne;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hne}"
SRC_URI[x86_64_v2_glibc-langpack-hne.sha256sum] = "243a41e44132275f0bb86c8f2efdef9641b90b688621ab10690fa44f2a2139d8"
RPROVIDES:glibc-langpack-hne:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-hr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hr-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hr}"
SRC_URI[x86_64_v2_glibc-langpack-hr.sha256sum] = "0f98b79d242832c13e23d3864a00bb5678c5aedc1ab6c97f25931e4099bb3a9f"
RPROVIDES:glibc-langpack-hr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-hsb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hsb-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hsb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hsb}"
SRC_URI[x86_64_v2_glibc-langpack-hsb.sha256sum] = "300d47537a10d96c2a6e1eaf33c142ed24e997d2dc99e3b508af270e2225ebc8"
RPROVIDES:glibc-langpack-hsb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ht = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ht-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ht;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ht}"
SRC_URI[x86_64_v2_glibc-langpack-ht.sha256sum] = "c2d1a71ef3e2b3181ac6dea95550b3f0c6c00d00a775340d0027a0f699da6084"
RPROVIDES:glibc-langpack-ht:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-hu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hu-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hu}"
SRC_URI[x86_64_v2_glibc-langpack-hu.sha256sum] = "cc211bd4945e4bd9fe0b7c0a63352437414fa6547f883842b188dd21034586d7"
RPROVIDES:glibc-langpack-hu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-hy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hy-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hy}"
SRC_URI[x86_64_v2_glibc-langpack-hy.sha256sum] = "c1303f2a94af6089da31d0fd32a17d37cabf88ad6a42cae4c08328ac932af398"
RPROVIDES:glibc-langpack-hy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ia = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ia-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ia}"
SRC_URI[x86_64_v2_glibc-langpack-ia.sha256sum] = "da1e71da58b4757f39be5e2a2718c04ca6dbd93974dba5102c8213611a8f8c98"
RPROVIDES:glibc-langpack-ia:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-id = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-id-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-id;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-id}"
SRC_URI[x86_64_v2_glibc-langpack-id.sha256sum] = "05ec988de80a0da1a23aaae311f622efd69ef55a48c9f7f8a2803436f87569b9"
RPROVIDES:glibc-langpack-id:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ig = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ig-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ig}"
SRC_URI[x86_64_v2_glibc-langpack-ig.sha256sum] = "a57587830935cb63a950e84a461f951e46fd79fbb158c5b6b352e38e3fc69549"
RPROVIDES:glibc-langpack-ig:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ik = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ik-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ik;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ik}"
SRC_URI[x86_64_v2_glibc-langpack-ik.sha256sum] = "1f81c693eb2e2b72dbac31e811fda85f498b0750bcdd1cce58ee5cac338974dd"
RPROVIDES:glibc-langpack-ik:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-is = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-is-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-is;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-is}"
SRC_URI[x86_64_v2_glibc-langpack-is.sha256sum] = "92e11e323f464a176b70876ebda51b306fde8eb4f1c66490eb2a325edc69a832"
RPROVIDES:glibc-langpack-is:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-it = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-it-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-it;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-it}"
SRC_URI[x86_64_v2_glibc-langpack-it.sha256sum] = "a946b06fddd60c9f83d99d8c73a350e966cc0875be0cbe2769eca6773094983a"
RPROVIDES:glibc-langpack-it:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-iu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-iu-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-iu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-iu}"
SRC_URI[x86_64_v2_glibc-langpack-iu.sha256sum] = "5955b192a1fc8291796907606a27155514a6cb26bea696f579e14142840ea366"
RPROVIDES:glibc-langpack-iu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ja = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ja-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ja;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ja}"
SRC_URI[x86_64_v2_glibc-langpack-ja.sha256sum] = "6cdca1faaccc92b56a5cedab7f3f9386e99beac9df5b296ab9682d41b2e5a8df"
RPROVIDES:glibc-langpack-ja:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ka = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ka-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ka}"
SRC_URI[x86_64_v2_glibc-langpack-ka.sha256sum] = "70570ac8b81aac5a8835ab034ed6e723f510f2703e703ab53bdf010dc25077c1"
RPROVIDES:glibc-langpack-ka:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-kab = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kab-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kab}"
SRC_URI[x86_64_v2_glibc-langpack-kab.sha256sum] = "f38f9269cf15964821580a342e19a5686df152f19d06d942784d9d32f5d30f42"
RPROVIDES:glibc-langpack-kab:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-kk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kk-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kk}"
SRC_URI[x86_64_v2_glibc-langpack-kk.sha256sum] = "7138fc662d077ff9df49e24ef69d5969d89ddcbf3a057941e2112db59d02437a"
RPROVIDES:glibc-langpack-kk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-kl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kl-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kl}"
SRC_URI[x86_64_v2_glibc-langpack-kl.sha256sum] = "df15520576e15ca85835540dbbbfc158b73648876df3fbe1d8b8e5f0e38e0409"
RPROVIDES:glibc-langpack-kl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-km = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-km-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-km;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-km}"
SRC_URI[x86_64_v2_glibc-langpack-km.sha256sum] = "51fd8a380a3469e244e6f5b71ebd845e81cdef30539076d31405c4348a5ffcf1"
RPROVIDES:glibc-langpack-km:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-kn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kn-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kn}"
SRC_URI[x86_64_v2_glibc-langpack-kn.sha256sum] = "cf2c6b5bd60cec2e95a96a8168c74e68fed366f4f694c441f31075eff1df3594"
RPROVIDES:glibc-langpack-kn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ko = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ko-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ko}"
SRC_URI[x86_64_v2_glibc-langpack-ko.sha256sum] = "2e4226bd0f917b03f71a3c0e1854e9a22e6e93b583aa966637fdaa9e84ddb709"
RPROVIDES:glibc-langpack-ko:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-kok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kok-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kok}"
SRC_URI[x86_64_v2_glibc-langpack-kok.sha256sum] = "af08e9ca5ed5f266ac5bf5057830634e04c17a196f5e9e29bfcfa34539de858e"
RPROVIDES:glibc-langpack-kok:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ks = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ks-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ks}"
SRC_URI[x86_64_v2_glibc-langpack-ks.sha256sum] = "67bb48e9f4126a6fe93d891367292a899c10f073b5c75176bf37b0e60919c114"
RPROVIDES:glibc-langpack-ks:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ku = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ku-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ku;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ku}"
SRC_URI[x86_64_v2_glibc-langpack-ku.sha256sum] = "7e03bb493c29ed3f8fa68bf663978a2af3e574161192d9096fc0b568b549bd89"
RPROVIDES:glibc-langpack-ku:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-kv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kv-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kv}"
SRC_URI[x86_64_v2_glibc-langpack-kv.sha256sum] = "6520108807bd63385000e4d0a774750f4f6c11d3a32ae791e7c91a8a3f28853e"
RPROVIDES:glibc-langpack-kv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-kw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kw-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kw}"
SRC_URI[x86_64_v2_glibc-langpack-kw.sha256sum] = "b2146c3a2d4c60d1c691b25aa38c97c58b128740bcfe6faab1292ed47f778800"
RPROVIDES:glibc-langpack-kw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ky = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ky-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ky;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ky}"
SRC_URI[x86_64_v2_glibc-langpack-ky.sha256sum] = "d4c7ebac0bb81030a73968fe0a597931cad46fa702224d6fbb2ee7acfdcd16f4"
RPROVIDES:glibc-langpack-ky:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-lb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lb-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lb}"
SRC_URI[x86_64_v2_glibc-langpack-lb.sha256sum] = "560e173658d3778e84c14328b29e61b720ac9f0b7a89acc0a7e7bca045ab4215"
RPROVIDES:glibc-langpack-lb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-lg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lg-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lg}"
SRC_URI[x86_64_v2_glibc-langpack-lg.sha256sum] = "f49fb29d33e1501b81ece1ae7fbf5383c86d7398246af662b13f4749994fc8f6"
RPROVIDES:glibc-langpack-lg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-li = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-li-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-li;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-li}"
SRC_URI[x86_64_v2_glibc-langpack-li.sha256sum] = "998ce15b80ec7e69ed13e6a7be756b9d4f0264509dcc405285723e975de4a589"
RPROVIDES:glibc-langpack-li:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-lij = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lij-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lij;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lij}"
SRC_URI[x86_64_v2_glibc-langpack-lij.sha256sum] = "95e8741e6c050cf89cc8bc89a59a05c8e663ed901c977dd78de5ac01d2a1018f"
RPROVIDES:glibc-langpack-lij:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ln = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ln-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ln;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ln}"
SRC_URI[x86_64_v2_glibc-langpack-ln.sha256sum] = "d561901fe1215cdf26560c5b2eb37323db0ee3f9fad639352bb74ce988fb770f"
RPROVIDES:glibc-langpack-ln:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-lo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lo-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lo}"
SRC_URI[x86_64_v2_glibc-langpack-lo.sha256sum] = "33b5a459f870f5565af17bc913a931f70bdb88be68dfe00f0611355937cecceb"
RPROVIDES:glibc-langpack-lo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-lt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lt-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lt}"
SRC_URI[x86_64_v2_glibc-langpack-lt.sha256sum] = "e1a83dc499ce5c603b0238f87409fa4f1ded2406f7eb5e2307d6bcc03bd35516"
RPROVIDES:glibc-langpack-lt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-lv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lv-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lv}"
SRC_URI[x86_64_v2_glibc-langpack-lv.sha256sum] = "2cb2c9be3af4a1c09ab9f4850bf5f8bcdde6a559499ac7ade213fce326a04e25"
RPROVIDES:glibc-langpack-lv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-lzh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lzh-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lzh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lzh}"
SRC_URI[x86_64_v2_glibc-langpack-lzh.sha256sum] = "86a764e117d3da73b05c8aac6dab25e51a26476e6caf2a2c5612ffa580581134"
RPROVIDES:glibc-langpack-lzh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-mag = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mag-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mag;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mag}"
SRC_URI[x86_64_v2_glibc-langpack-mag.sha256sum] = "81268a53fdb87be11630136d3055455c45221b53c15fb8471158ce47d46c9f70"
RPROVIDES:glibc-langpack-mag:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-mai = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mai-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mai;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mai}"
SRC_URI[x86_64_v2_glibc-langpack-mai.sha256sum] = "9e5b9505b37fe7ca9dd4b1b1a8742fca4e772a1bb15b0176bc1ab0a27c301eab"
RPROVIDES:glibc-langpack-mai:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-mfe = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mfe-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mfe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mfe}"
SRC_URI[x86_64_v2_glibc-langpack-mfe.sha256sum] = "8f3306ab124598926dc4d2e77b08582de971d4791937f390d66739d9fb7131fc"
RPROVIDES:glibc-langpack-mfe:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-mg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mg-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mg}"
SRC_URI[x86_64_v2_glibc-langpack-mg.sha256sum] = "310238faf443d911f941e88781188fd82ea5705365f76aebd51236566fc8b16b"
RPROVIDES:glibc-langpack-mg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-mhr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mhr-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mhr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mhr}"
SRC_URI[x86_64_v2_glibc-langpack-mhr.sha256sum] = "3269fb19877e15397a702bf37027181432ded7c1f2f96e0a09fa01c4f20e1b1c"
RPROVIDES:glibc-langpack-mhr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-mi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mi-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mi}"
SRC_URI[x86_64_v2_glibc-langpack-mi.sha256sum] = "864de074daa2035b9738ae944698105c661e0f20bdaf6f23fe773cd0a6c41d59"
RPROVIDES:glibc-langpack-mi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-miq = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-miq-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-miq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-miq}"
SRC_URI[x86_64_v2_glibc-langpack-miq.sha256sum] = "8096ce4cfa5f531a997255c6a3d522af281dfd52cd8d479bacbd0a9f4424e75b"
RPROVIDES:glibc-langpack-miq:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-mjw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mjw-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mjw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mjw}"
SRC_URI[x86_64_v2_glibc-langpack-mjw.sha256sum] = "f9515c78b614565e7d1ead8198a9b3c9aac7b00e3fa0264b3b20c3f53035095d"
RPROVIDES:glibc-langpack-mjw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-mk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mk-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mk}"
SRC_URI[x86_64_v2_glibc-langpack-mk.sha256sum] = "4f51a68237b91da8f15a2eaf6a2cc7b7c1dfb16bc01ca16f28582792bd9827ba"
RPROVIDES:glibc-langpack-mk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ml = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ml-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ml}"
SRC_URI[x86_64_v2_glibc-langpack-ml.sha256sum] = "778b293c2cff37a36e065ad2ce0bcd51d1fc60b38085893be36f4b989b5bb45d"
RPROVIDES:glibc-langpack-ml:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-mn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mn-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mn}"
SRC_URI[x86_64_v2_glibc-langpack-mn.sha256sum] = "deaa3ac3bc832bd848b743df250c27e5752d1ebfb1b0abafac3085adc078b7f7"
RPROVIDES:glibc-langpack-mn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-mni = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mni-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mni;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mni}"
SRC_URI[x86_64_v2_glibc-langpack-mni.sha256sum] = "a50663980d71d8cf8739509a98d9599bbcd4428656403d61283685aa3d8e85c3"
RPROVIDES:glibc-langpack-mni:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-mnw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mnw-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mnw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mnw}"
SRC_URI[x86_64_v2_glibc-langpack-mnw.sha256sum] = "c664c04f05f5a8eab174bfe6dce573c9c334144a7673c93fb89e75d865e1c6d3"
RPROVIDES:glibc-langpack-mnw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-mr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mr-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mr}"
SRC_URI[x86_64_v2_glibc-langpack-mr.sha256sum] = "0e488c7fcef32cc77bd468020589c2a2f3ca2d1c95eb9770b742e1fdfed494df"
RPROVIDES:glibc-langpack-mr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ms = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ms-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ms}"
SRC_URI[x86_64_v2_glibc-langpack-ms.sha256sum] = "f11d13491a3b651e22db0d7e40d952fb5b97e63d2e9a26e6331c293335626662"
RPROVIDES:glibc-langpack-ms:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-mt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mt-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mt}"
SRC_URI[x86_64_v2_glibc-langpack-mt.sha256sum] = "147cb10684c188dc2467bff9535df35504140ab979c8cc999bc922bbbb7f8894"
RPROVIDES:glibc-langpack-mt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-my = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-my-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-my;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-my}"
SRC_URI[x86_64_v2_glibc-langpack-my.sha256sum] = "132efade7d5ba969b6e44a8ab0c5a8b8976a17e45c78c3b941388ff5bffa9091"
RPROVIDES:glibc-langpack-my:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-nan = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nan-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nan}"
SRC_URI[x86_64_v2_glibc-langpack-nan.sha256sum] = "952b04b40b793413798285471b340828b0365435032acaf907631d917e8b24f8"
RPROVIDES:glibc-langpack-nan:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-nb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nb-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nb}"
SRC_URI[x86_64_v2_glibc-langpack-nb.sha256sum] = "56a75fb08566986b62fd96c1685d77a6d1fa38c59ff04d9b23744f20f67f449d"
RPROVIDES:glibc-langpack-nb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-nds = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nds-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nds}"
SRC_URI[x86_64_v2_glibc-langpack-nds.sha256sum] = "781b70b78a769b105e02f1f882f310b13d4b3e4781a02e3c0b151360fadc1852"
RPROVIDES:glibc-langpack-nds:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ne = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ne-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ne;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ne}"
SRC_URI[x86_64_v2_glibc-langpack-ne.sha256sum] = "1724bcb6cfee1b4b61dbb4b7b93d8ae409f6cd7e397c4b3268a406166db9999a"
RPROVIDES:glibc-langpack-ne:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-nhn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nhn-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nhn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nhn}"
SRC_URI[x86_64_v2_glibc-langpack-nhn.sha256sum] = "dc0ac641d2a565952bd099d7a05a7c54faf9653bde4b3c543345966551f05c72"
RPROVIDES:glibc-langpack-nhn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-niu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-niu-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-niu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-niu}"
SRC_URI[x86_64_v2_glibc-langpack-niu.sha256sum] = "e6131fb7dc0c60632c58920cac67e43c13da05d2ec7fdd5a9da891ece8c8d817"
RPROVIDES:glibc-langpack-niu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-nl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nl-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nl}"
SRC_URI[x86_64_v2_glibc-langpack-nl.sha256sum] = "86a5f51ba08c9e0982ea3e98f8c207e2a075672b1dde707e1dade8df7f13b352"
RPROVIDES:glibc-langpack-nl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-nn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nn-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nn}"
SRC_URI[x86_64_v2_glibc-langpack-nn.sha256sum] = "a2666831176ca0a1152fdcb8e6c51229c6c6b1c8c323100dfb183ec15e9d7b04"
RPROVIDES:glibc-langpack-nn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-nr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nr-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nr}"
SRC_URI[x86_64_v2_glibc-langpack-nr.sha256sum] = "2ca0e77fa29034b083f475565e6a6a3d9039a7ed48d80d85639951f13e79716c"
RPROVIDES:glibc-langpack-nr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-nso = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nso-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nso;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nso}"
SRC_URI[x86_64_v2_glibc-langpack-nso.sha256sum] = "dfce043a853d8442cec1767ae90795d0e245b17ef94f553940ae7b3c6cd96977"
RPROVIDES:glibc-langpack-nso:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-oc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-oc-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-oc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-oc}"
SRC_URI[x86_64_v2_glibc-langpack-oc.sha256sum] = "94b4dec7c1a6a72056b3f5107a53c6c1d78435ee0a516c692104d6fb93742171"
RPROVIDES:glibc-langpack-oc:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-om = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-om-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-om;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-om}"
SRC_URI[x86_64_v2_glibc-langpack-om.sha256sum] = "18df87d4cc6e2328204fa3db21c4296610d6194eefe60ca6ad30cdc243508482"
RPROVIDES:glibc-langpack-om:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-or = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-or-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-or;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-or}"
SRC_URI[x86_64_v2_glibc-langpack-or.sha256sum] = "843dda446406137e7a7a676b289263610c9c4d4e08e6ec066ab4dce52b5b0408"
RPROVIDES:glibc-langpack-or:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-os = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-os-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-os;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-os}"
SRC_URI[x86_64_v2_glibc-langpack-os.sha256sum] = "d7021215c0b8e111a9f930bdf8dc98ea03388bb3d783f2e10c29d99538f09e18"
RPROVIDES:glibc-langpack-os:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-pa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pa-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pa}"
SRC_URI[x86_64_v2_glibc-langpack-pa.sha256sum] = "228beb07f8e5f4cc3eec0e78991a0792fdc6a36051116bc59ab6e140b97cb419"
RPROVIDES:glibc-langpack-pa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-pap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pap-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pap}"
SRC_URI[x86_64_v2_glibc-langpack-pap.sha256sum] = "b2642de4c57caabe2efbd83e3a09da2311f97df3ea1b0668e18ba5fd068271bd"
RPROVIDES:glibc-langpack-pap:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-pl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pl-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pl}"
SRC_URI[x86_64_v2_glibc-langpack-pl.sha256sum] = "8ee537885874dfb2bc472e0969ae83b6b9e94e096c43f740f214215fe67f50bb"
RPROVIDES:glibc-langpack-pl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ps = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ps-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ps}"
SRC_URI[x86_64_v2_glibc-langpack-ps.sha256sum] = "1d0ef0df0940e51dec98da5dafde1dcfa81d20bca0dfbf72252d0933c5403768"
RPROVIDES:glibc-langpack-ps:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-pt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pt-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pt}"
SRC_URI[x86_64_v2_glibc-langpack-pt.sha256sum] = "a9d9ad132a0cc0dcf281f7f47afa17fab44f16be4d7ee72c67291540111a7ff3"
RPROVIDES:glibc-langpack-pt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-quz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-quz-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-quz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-quz}"
SRC_URI[x86_64_v2_glibc-langpack-quz.sha256sum] = "419e7a58ac89d63ebb5d4d97a02258eabe633a0033b493b560b531cf8ff4556e"
RPROVIDES:glibc-langpack-quz:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-raj = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-raj-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-raj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-raj}"
SRC_URI[x86_64_v2_glibc-langpack-raj.sha256sum] = "c686951aa973488ac7c2b2c535319e7869c211001eea8553ad78e53fb1447a30"
RPROVIDES:glibc-langpack-raj:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-rif = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-rif-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-rif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-rif}"
SRC_URI[x86_64_v2_glibc-langpack-rif.sha256sum] = "988d8283a980a7d3ae7772734432fcb1c858dda661281232184b74836154fcd3"
RPROVIDES:glibc-langpack-rif:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ro = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ro-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ro}"
SRC_URI[x86_64_v2_glibc-langpack-ro.sha256sum] = "3d8165c6c52820d40b3925046c695711827ab67519389f6b8323d06fc2e40f13"
RPROVIDES:glibc-langpack-ro:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ru = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ru-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ru;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ru}"
SRC_URI[x86_64_v2_glibc-langpack-ru.sha256sum] = "19f68a7f3ca279c0c4911c572a11c79cc186d6e533e9f6e72c0a656fd4d19750"
RPROVIDES:glibc-langpack-ru:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-rw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-rw-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-rw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-rw}"
SRC_URI[x86_64_v2_glibc-langpack-rw.sha256sum] = "ea1d3e904da82a2c76883caa24c7aae26bd01100af44760d1797a085f9ed862c"
RPROVIDES:glibc-langpack-rw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-sa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sa-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sa}"
SRC_URI[x86_64_v2_glibc-langpack-sa.sha256sum] = "44b40e3f1c11c497ce352e44e86ef40a036c6a97f1664ece0f8eb9909b34f2f9"
RPROVIDES:glibc-langpack-sa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-sah = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sah-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sah;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sah}"
SRC_URI[x86_64_v2_glibc-langpack-sah.sha256sum] = "abdeeb64d64d387d7765b0fdf9e21c96500071bb7cc5d14bd14553603effb70d"
RPROVIDES:glibc-langpack-sah:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-sat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sat-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sat}"
SRC_URI[x86_64_v2_glibc-langpack-sat.sha256sum] = "498574b60151795a796cc78ec34b871a64da4a72e79011fd0a136fc90dc23299"
RPROVIDES:glibc-langpack-sat:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-sc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sc-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sc}"
SRC_URI[x86_64_v2_glibc-langpack-sc.sha256sum] = "33e1cf9ec3a563961dee18508086d09ad2cc67ce321ae306bed7a82a8ba8aeb8"
RPROVIDES:glibc-langpack-sc:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-sd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sd-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sd}"
SRC_URI[x86_64_v2_glibc-langpack-sd.sha256sum] = "d2bac547b3142c5a867a9ce22d2643283c878b73f1fa78943bc026a4ad48c882"
RPROVIDES:glibc-langpack-sd:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-se = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-se-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-se;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-se}"
SRC_URI[x86_64_v2_glibc-langpack-se.sha256sum] = "58ec1e5d544ae2df08c6a8ad20cb5726a86ffc96b55486dc9d409c42301cbd53"
RPROVIDES:glibc-langpack-se:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-sgs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sgs-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sgs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sgs}"
SRC_URI[x86_64_v2_glibc-langpack-sgs.sha256sum] = "9f478c763aaead289d8fe58242f68e42263bfae756cd73f536104e1979b850f9"
RPROVIDES:glibc-langpack-sgs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-shn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-shn-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-shn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-shn}"
SRC_URI[x86_64_v2_glibc-langpack-shn.sha256sum] = "1c821cc12eae085f76767314703d9d3b8460dcef0692541c2a7d6dbfb1fb29be"
RPROVIDES:glibc-langpack-shn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-shs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-shs-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-shs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-shs}"
SRC_URI[x86_64_v2_glibc-langpack-shs.sha256sum] = "89a17afec6c410be634656054c8cb78e438ff8160c447bf027fa3599377149b7"
RPROVIDES:glibc-langpack-shs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-si = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-si-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-si;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-si}"
SRC_URI[x86_64_v2_glibc-langpack-si.sha256sum] = "76f0bb0a435eb06d22a87497afbbe3cee05c49b3690ebfa8e5095a2ce3741436"
RPROVIDES:glibc-langpack-si:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-sid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sid-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sid}"
SRC_URI[x86_64_v2_glibc-langpack-sid.sha256sum] = "600d35de56ea9622077134e63e7b970b824e0e1774969f9c8887058df593ae42"
RPROVIDES:glibc-langpack-sid:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-sk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sk-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sk}"
SRC_URI[x86_64_v2_glibc-langpack-sk.sha256sum] = "8c7f606f80b1638c24428ec27feab1b811f9b8a51f1f6c83c38fc9446c16bcd0"
RPROVIDES:glibc-langpack-sk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-sl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sl-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sl}"
SRC_URI[x86_64_v2_glibc-langpack-sl.sha256sum] = "bb77d6b7bfd275002283d8196f30375c5c47a7e6ddc4b3f5e0fea68d135fe35a"
RPROVIDES:glibc-langpack-sl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-sm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sm-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sm}"
SRC_URI[x86_64_v2_glibc-langpack-sm.sha256sum] = "a575df8123d31607cc2a9b6b1f5f8a544de0a7941e2b273013d407f6d704e241"
RPROVIDES:glibc-langpack-sm:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-so = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-so-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-so;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-so}"
SRC_URI[x86_64_v2_glibc-langpack-so.sha256sum] = "4e691ecb950b7463220734ba840037614d128c487102d65035f0f871541e6480"
RPROVIDES:glibc-langpack-so:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-sq = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sq-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sq}"
SRC_URI[x86_64_v2_glibc-langpack-sq.sha256sum] = "d65f43e1e9cf1703a039c2084f151930aca84b10d6f0b399251e43639b424037"
RPROVIDES:glibc-langpack-sq:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-sr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sr-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sr}"
SRC_URI[x86_64_v2_glibc-langpack-sr.sha256sum] = "e1742ba9e7e0d08f016a3e13e9b904a55f1c066e02d6c3dd7faac481c23838c0"
RPROVIDES:glibc-langpack-sr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ss = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ss-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ss}"
SRC_URI[x86_64_v2_glibc-langpack-ss.sha256sum] = "66303f651df7ef12b4187f1214c79b8a8bf119015d2ffe27eb7b0d493bad16e6"
RPROVIDES:glibc-langpack-ss:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ssy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ssy-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ssy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ssy}"
SRC_URI[x86_64_v2_glibc-langpack-ssy.sha256sum] = "285fc42e6cfbc6928b00e8784089ac14d754f4f96b9e3d0f3ba0d1a784989571"
RPROVIDES:glibc-langpack-ssy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-st = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-st-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-st;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-st}"
SRC_URI[x86_64_v2_glibc-langpack-st.sha256sum] = "6dab98bdf3d0cd821765207cbfd59fda46a67e290d6affc7481bc67fa199456a"
RPROVIDES:glibc-langpack-st:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-su = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-su-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-su;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-su}"
SRC_URI[x86_64_v2_glibc-langpack-su.sha256sum] = "90815e717f0ba4739ab385a862f74e1f4d51897f905d65a85f00c9e5c14dcd23"
RPROVIDES:glibc-langpack-su:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-sv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sv-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sv}"
SRC_URI[x86_64_v2_glibc-langpack-sv.sha256sum] = "0858229a7456cf0625f90c287d33742dff7bd852a9dda63707b23c00a0be4afe"
RPROVIDES:glibc-langpack-sv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-sw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sw-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sw}"
SRC_URI[x86_64_v2_glibc-langpack-sw.sha256sum] = "50870e2c0eaab77f867979e0c3d3cea64393c12335b4bb9994c9542d12bf88e9"
RPROVIDES:glibc-langpack-sw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-syr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-syr-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-syr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-syr}"
SRC_URI[x86_64_v2_glibc-langpack-syr.sha256sum] = "678140fb17febc4cb2d7cdd647742e1f4a5f85d8d158315abd28bc1cb65e0abb"
RPROVIDES:glibc-langpack-syr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-szl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-szl-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-szl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-szl}"
SRC_URI[x86_64_v2_glibc-langpack-szl.sha256sum] = "955920b3ec83f5c1c73580794c8726249f5c1add4046a0bfa8fc4de9fd1c4f07"
RPROVIDES:glibc-langpack-szl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ta = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ta-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ta;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ta}"
SRC_URI[x86_64_v2_glibc-langpack-ta.sha256sum] = "9f2527c6f06594d6fcad77b01b2c61e3bb6d30613ecfac3e12d663b10c4602cf"
RPROVIDES:glibc-langpack-ta:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-tcy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tcy-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tcy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tcy}"
SRC_URI[x86_64_v2_glibc-langpack-tcy.sha256sum] = "d8b1e8b8931ea8b99ad22c181726bd8ef332a9562beab343fcabd5763e09d5e4"
RPROVIDES:glibc-langpack-tcy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-te = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-te-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-te;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-te}"
SRC_URI[x86_64_v2_glibc-langpack-te.sha256sum] = "18591b149900835a1913391f42fd1d212ca26d8b4c3775b06be843309aad819b"
RPROVIDES:glibc-langpack-te:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-tg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tg-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tg}"
SRC_URI[x86_64_v2_glibc-langpack-tg.sha256sum] = "27242434b7ba8403cff2fd347f5e6f983b3949a1857bb2804700f8ce3ea5a527"
RPROVIDES:glibc-langpack-tg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-th = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-th-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-th}"
SRC_URI[x86_64_v2_glibc-langpack-th.sha256sum] = "38f5ab6512bb9c0b6730ed95beefaff9fa1203b9343bb25d48267398ebdae746"
RPROVIDES:glibc-langpack-th:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-the = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-the-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-the;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-the}"
SRC_URI[x86_64_v2_glibc-langpack-the.sha256sum] = "9fed1bf51f074e3881855a40142e279e4bb67573532816757f80eb5747da6f44"
RPROVIDES:glibc-langpack-the:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ti = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ti-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ti;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ti}"
SRC_URI[x86_64_v2_glibc-langpack-ti.sha256sum] = "4acabce9f7797f6412f33c00cb407379ed913febc1a300ce0ee70093f2327f20"
RPROVIDES:glibc-langpack-ti:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-tig = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tig-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tig}"
SRC_URI[x86_64_v2_glibc-langpack-tig.sha256sum] = "8f125d540f3eb9dc25d290b35fa04cd3000d5f4748e69a147b014104bd64467f"
RPROVIDES:glibc-langpack-tig:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-tk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tk-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tk}"
SRC_URI[x86_64_v2_glibc-langpack-tk.sha256sum] = "10ec2d4765cfcb8035edd0390065d38fb0e262b821d4a14d41a965670332675d"
RPROVIDES:glibc-langpack-tk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-tl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tl-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tl}"
SRC_URI[x86_64_v2_glibc-langpack-tl.sha256sum] = "e4bcd1729fb57d752c6099a2a0e15a6055d7305ae30b6256716c6ed602bcdcd6"
RPROVIDES:glibc-langpack-tl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-tn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tn-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tn}"
SRC_URI[x86_64_v2_glibc-langpack-tn.sha256sum] = "3cda95af06e2f7d11c7e10a4358e83ee8fa5e2e43d8da9f04334952a17c2e31a"
RPROVIDES:glibc-langpack-tn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-to = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-to-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-to;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-to}"
SRC_URI[x86_64_v2_glibc-langpack-to.sha256sum] = "d08892a3a734a048c11be8387571de6d1113e4a55966620e4f91809c2f1c0d27"
RPROVIDES:glibc-langpack-to:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-tok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tok-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tok}"
SRC_URI[x86_64_v2_glibc-langpack-tok.sha256sum] = "bf9c9690173a924d3ef0b18ba7e55a401ca3e97b4eb4f39aad6303425e95c8da"
RPROVIDES:glibc-langpack-tok:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-tpi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tpi-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tpi}"
SRC_URI[x86_64_v2_glibc-langpack-tpi.sha256sum] = "fc9a7d089f37e705cc73925fa178992e8034a0907eab0aa79d885fa160e1c698"
RPROVIDES:glibc-langpack-tpi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-tr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tr-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tr}"
SRC_URI[x86_64_v2_glibc-langpack-tr.sha256sum] = "75539cdf483230aee8be0fb84e362373af6e19fbc3663b5034986091f6ea19ce"
RPROVIDES:glibc-langpack-tr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ts-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ts}"
SRC_URI[x86_64_v2_glibc-langpack-ts.sha256sum] = "e5ce685b4f50da30655f00de2401df4e621854b72b153f88255c89f183527186"
RPROVIDES:glibc-langpack-ts:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-tt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tt-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tt}"
SRC_URI[x86_64_v2_glibc-langpack-tt.sha256sum] = "cf6e81cb64c25c0e0683b99742849e7cf5e9a946a863fcb09935ac650a8a5703"
RPROVIDES:glibc-langpack-tt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ug = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ug-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ug}"
SRC_URI[x86_64_v2_glibc-langpack-ug.sha256sum] = "97c3e73512d03d7c17c0d49ba389b5640090ee6ce544aa4135acb79936428612"
RPROVIDES:glibc-langpack-ug:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-uk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-uk-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-uk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-uk}"
SRC_URI[x86_64_v2_glibc-langpack-uk.sha256sum] = "2ebf97380988f79a623ca3e658a53525bbb493ab84a2d588809380a7f5902885"
RPROVIDES:glibc-langpack-uk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-unm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-unm-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-unm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-unm}"
SRC_URI[x86_64_v2_glibc-langpack-unm.sha256sum] = "30944f0418510f39fcb220ac5f0d5915ef1d5f651e94be31c7cc7adfce3689d6"
RPROVIDES:glibc-langpack-unm:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ur = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ur-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ur}"
SRC_URI[x86_64_v2_glibc-langpack-ur.sha256sum] = "f956647b49b4b276346d0a7f3580b8e4cf61d819aa1059af2a9ac6bdc220f4f5"
RPROVIDES:glibc-langpack-ur:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-uz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-uz-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-uz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-uz}"
SRC_URI[x86_64_v2_glibc-langpack-uz.sha256sum] = "1a6f028d16e92faf0bf04d84bfdb9a08925aae79cb9f048ffa25aad81ff001a5"
RPROVIDES:glibc-langpack-uz:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-ve = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ve-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ve}"
SRC_URI[x86_64_v2_glibc-langpack-ve.sha256sum] = "eb0af664e0866c59ad84d560a6a58a0a9802cef6ee14839f17fc3823f70e36fd"
RPROVIDES:glibc-langpack-ve:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-vi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-vi-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-vi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-vi}"
SRC_URI[x86_64_v2_glibc-langpack-vi.sha256sum] = "fa99612e015757484dfeb3f6332859fdf8270d419a8cac929dcd1ec8ca33278a"
RPROVIDES:glibc-langpack-vi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-wa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wa-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wa}"
SRC_URI[x86_64_v2_glibc-langpack-wa.sha256sum] = "10d8ae05f042aeedc09cf1b7a637972d0a9fd6bb302fb907144deeb23fb455d0"
RPROVIDES:glibc-langpack-wa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-wae = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wae-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wae;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wae}"
SRC_URI[x86_64_v2_glibc-langpack-wae.sha256sum] = "b3c866de4b872c76b97e28180c5e82a3614d1bfed5036298a5a1254198af9f78"
RPROVIDES:glibc-langpack-wae:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-wal = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wal-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wal}"
SRC_URI[x86_64_v2_glibc-langpack-wal.sha256sum] = "771366117015cf96ec99d2406590a9e3ac6f2d9495bf4746159234e6a6552ec7"
RPROVIDES:glibc-langpack-wal:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-wo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wo-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wo}"
SRC_URI[x86_64_v2_glibc-langpack-wo.sha256sum] = "2e224d687ef0ff41c8adf406c9b39e7192cb67380e44941552d3758458e6875f"
RPROVIDES:glibc-langpack-wo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-xh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-xh-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-xh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-xh}"
SRC_URI[x86_64_v2_glibc-langpack-xh.sha256sum] = "6c3f6961cd8d3b80568c7b9717e8807f09db9dc324eaacd3962700c07816ee57"
RPROVIDES:glibc-langpack-xh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-yi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yi-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yi}"
SRC_URI[x86_64_v2_glibc-langpack-yi.sha256sum] = "736196372d078081d91a16d1881b8a06e10905aa33c31c1932172801488d856f"
RPROVIDES:glibc-langpack-yi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-yo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yo-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yo}"
SRC_URI[x86_64_v2_glibc-langpack-yo.sha256sum] = "aca45ba88e0fde670ff5c6516b2a2901ed4bbbf996bd02dd6c3a0612ab98aa16"
RPROVIDES:glibc-langpack-yo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-yue = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yue-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yue}"
SRC_URI[x86_64_v2_glibc-langpack-yue.sha256sum] = "ab9d4be66a1a611a2b37c56afe929e7e172fb6cb3c5403e0b11c596d21cf0994"
RPROVIDES:glibc-langpack-yue:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-yuw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yuw-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yuw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yuw}"
SRC_URI[x86_64_v2_glibc-langpack-yuw.sha256sum] = "623d19f59f77d97c581d418021e3e6557e6e052ddc2c6494db6582464f8e3a37"
RPROVIDES:glibc-langpack-yuw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-zgh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zgh-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-zgh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-zgh}"
SRC_URI[x86_64_v2_glibc-langpack-zgh.sha256sum] = "0f68a70f5bf622843dd710a7dff1ba36cc8bcbf3f1abef416b262d284d30d2ac"
RPROVIDES:glibc-langpack-zgh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-zh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zh-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-zh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-zh}"
SRC_URI[x86_64_v2_glibc-langpack-zh.sha256sum] = "e6a3953f01292f2a362e5db1a3703ed4480a0642d7d89f9d76f405b20756bda4"
RPROVIDES:glibc-langpack-zh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-langpack-zu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zu-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-zu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-zu}"
SRC_URI[x86_64_v2_glibc-langpack-zu.sha256sum] = "05f957b85c15da1055c5b8c57f13721a448b04ffcc78d867fc0662411dc5073e"
RPROVIDES:glibc-langpack-zu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-locale-source = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-locale-source-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-locale-source;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-locale-source}"
SRC_URI[x86_64_v2_glibc-locale-source.sha256sum] = "b9d81f5c356e820cdd6404027f75119f506372fdb171eaabc02836e0d9ff63b5"

URI_x86_64_v2_glibc-minimal-langpack = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-minimal-langpack-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-minimal-langpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-minimal-langpack}"
SRC_URI[x86_64_v2_glibc-minimal-langpack.sha256sum] = "c18e183d1976e7793918b1dac71d418d73404a35d37b41b218d4c60712c4e20e"
RPROVIDES:glibc-minimal-langpack:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_x86_64_v2_glibc-nss-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibc-nss-devel-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-nss-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-nss-devel}"
SRC_URI[x86_64_v2_glibc-nss-devel.sha256sum] = "2711fd3ceadd0e5caf2f1d37d0a7ba5f57a3e95556ed92741b0064402949f78b"

URI_x86_64_v2_glibc-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibc-static-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-static}"
SRC_URI[x86_64_v2_glibc-static.sha256sum] = "159dd7abc8d35337ef574fd6e01770cee7d808cf04b0e4352c146f51138a5753"

URI_x86_64_v2_glibc-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-utils-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-utils}"
SRC_URI[x86_64_v2_glibc-utils.sha256sum] = "e9bdcbc3ef46c55771bc85f365c9e8c318fed5a6b70e5bd32924b16d81c04d0f"

URI_x86_64_v2_libnsl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnsl-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libnsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnsl}"
SRC_URI[x86_64_v2_libnsl.sha256sum] = "ef7c1fa35cd04378bba4eb33a52f062add7f5658978a98c50439560ec3c0bd9e"

URI_x86_64_v2_nss_db = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nss_db-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_nss_db;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss_db}"
SRC_URI[x86_64_v2_nss_db.sha256sum] = "e4be10b5551187dbbbe3ce05512eb450c955c5d84e7bed6439e67657189a3e99"

URI_x86_64_v2_nss_hesiod = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nss_hesiod-2.39-130.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_nss_hesiod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss_hesiod}"
SRC_URI[x86_64_v2_nss_hesiod.sha256sum] = "7c35df085c825546b535cdfcdec8dc57730ca4cae00552ed0c5cf9ce366419b2"

URI_aarch64_glibc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc}"
SRC_URI[aarch64_glibc.sha256sum] = "43520489d30f5484dd6c3b9c2957c405eb016692512f78dc7e4e1a56a4f4e775"

URI_aarch64_glibc-all-langpacks = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-all-langpacks-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-all-langpacks;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-all-langpacks}"
SRC_URI[aarch64_glibc-all-langpacks.sha256sum] = "11cea79b28f5c27adf2c130a61e89856f276837d5b7375a8ed4b559091ddcace"
RPROVIDES:glibc-all-langpacks:aarch64 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-benchtests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibc-benchtests-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-benchtests;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-benchtests}"
SRC_URI[aarch64_glibc-benchtests.sha256sum] = "a5ba583b52d9bb1124ff9b34b428ca3c012e171f3e7207289fbd0bd865014578"

URI_aarch64_glibc-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-common-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-common}"
SRC_URI[aarch64_glibc-common.sha256sum] = "6abf8fe73d475f4ee550496c2cb38e8f2f0c48b5d8dfd86cbf172e1fbe5d0762"

URI_aarch64_glibc-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-devel-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-devel}"
SRC_URI[aarch64_glibc-devel.sha256sum] = "8d555b308299dbbd0817f2b4b8d1d237c7e66bd391056274d155df2a62e9d6b3"

URI_aarch64_glibc-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-doc-2.39-130.el10.alma.1.noarch.rpm;name=aarch64_glibc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-doc}"
SRC_URI[aarch64_glibc-doc.sha256sum] = "cedf64eda4b97e1f699ad12b8060f179304957b154578121630ebc09b8e1e092"

URI_aarch64_glibc-gconv-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-gconv-extra-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-gconv-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-gconv-extra}"
SRC_URI[aarch64_glibc-gconv-extra.sha256sum] = "55fc8961501b3c84ff5c585ffdcaccfcc077c52cf75ec253a2af33485d2b951d"

URI_aarch64_glibc-langpack-aa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-aa-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-aa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-aa}"
SRC_URI[aarch64_glibc-langpack-aa.sha256sum] = "ab1b0506806205e513e1654bc6eafead4f6f0ade5166b59cf9f7d084c679862c"
RPROVIDES:glibc-langpack-aa:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-af = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-af-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-af;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-af}"
SRC_URI[aarch64_glibc-langpack-af.sha256sum] = "b64da9ff2ff05ddd12ae31e97f726027fe8a5db8efadefc4bc4a3f85b475af81"
RPROVIDES:glibc-langpack-af:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-agr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-agr-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-agr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-agr}"
SRC_URI[aarch64_glibc-langpack-agr.sha256sum] = "e7555b73f168a4f64580508cbd8a877ce4421b074b9c3b3ef8282115ef613239"
RPROVIDES:glibc-langpack-agr:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ak = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ak-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ak;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ak}"
SRC_URI[aarch64_glibc-langpack-ak.sha256sum] = "c6c032f8a001265bc2742c76a4a2bd80681f720240f0ee2888e3103d9256e2bd"
RPROVIDES:glibc-langpack-ak:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-am = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-am-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-am;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-am}"
SRC_URI[aarch64_glibc-langpack-am.sha256sum] = "5bb91c3745193b70f77fe346353ddde768437be36f45a8076b99e96ffa78a4e8"
RPROVIDES:glibc-langpack-am:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-an = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-an-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-an;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-an}"
SRC_URI[aarch64_glibc-langpack-an.sha256sum] = "e29ffabde4e647d494ed4ace88028cb42a42c618bbba8e23a9ee0b063bb3519d"
RPROVIDES:glibc-langpack-an:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-anp = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-anp-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-anp;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-anp}"
SRC_URI[aarch64_glibc-langpack-anp.sha256sum] = "53e6c6a062e22ada9e123392db8c5de739ba0ff3a4720fc0ff1720fe79f359cd"
RPROVIDES:glibc-langpack-anp:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ar = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ar-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ar;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ar}"
SRC_URI[aarch64_glibc-langpack-ar.sha256sum] = "34c8606622ac5cc3a1ebf0a1da84a5c91bbb305d11529b2f60c8e60425a36516"
RPROVIDES:glibc-langpack-ar:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-as = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-as-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-as;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-as}"
SRC_URI[aarch64_glibc-langpack-as.sha256sum] = "675420fcee68f7f24a4eef8a444aa4f19004afc39326c1b10b4889d1459bfb77"
RPROVIDES:glibc-langpack-as:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ast = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ast-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ast;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ast}"
SRC_URI[aarch64_glibc-langpack-ast.sha256sum] = "4f38bb32b9fe2de95b6318adf9ae943f4838bc30b1659ef59c24a4da7dff3104"
RPROVIDES:glibc-langpack-ast:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ayc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ayc-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ayc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ayc}"
SRC_URI[aarch64_glibc-langpack-ayc.sha256sum] = "786612b9cbd19025a065c6cc0f859a380e7aa62953f6d8b772ec2b0fabf1174e"
RPROVIDES:glibc-langpack-ayc:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-az = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-az-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-az;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-az}"
SRC_URI[aarch64_glibc-langpack-az.sha256sum] = "cc73d4894ed79ac532200141b825fc966610b7af561f26b4a83fff7aa3483ec7"
RPROVIDES:glibc-langpack-az:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-be = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-be-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-be;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-be}"
SRC_URI[aarch64_glibc-langpack-be.sha256sum] = "2baf83c64294d5a7fc08d00ecc8a375487ef5118a1ad4e305ae5fb7a78182bdb"
RPROVIDES:glibc-langpack-be:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-bem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bem-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bem;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bem}"
SRC_URI[aarch64_glibc-langpack-bem.sha256sum] = "6ca0eac0e375cd73b0a79aace24e100420cbc6e18694dc079d16586c2f291cf2"
RPROVIDES:glibc-langpack-bem:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ber = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ber-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ber;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ber}"
SRC_URI[aarch64_glibc-langpack-ber.sha256sum] = "c2721bcd9761594231be2352ca3b24e56908e433f9aa5000dc4b7d219debd9d8"
RPROVIDES:glibc-langpack-ber:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-bg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bg-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bg}"
SRC_URI[aarch64_glibc-langpack-bg.sha256sum] = "d5045ff4e253191397d26cbcfe84138143dd7d45cef4a1abe2669ac6a709563c"
RPROVIDES:glibc-langpack-bg:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-bhb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bhb-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bhb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bhb}"
SRC_URI[aarch64_glibc-langpack-bhb.sha256sum] = "c91b9823bcd98a71474ab09cc5ecd3262b3d72fe5183f9054c6ad046f668eb86"
RPROVIDES:glibc-langpack-bhb:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-bho = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bho-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bho;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bho}"
SRC_URI[aarch64_glibc-langpack-bho.sha256sum] = "a55e2e7ab8d4393df4e27fe40e6133a4d0572076086b47e1a867dc49127871a9"
RPROVIDES:glibc-langpack-bho:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-bi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bi-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bi}"
SRC_URI[aarch64_glibc-langpack-bi.sha256sum] = "bedd32f3935bfbab223579bbe781c9bca90d178369893c0d5c0687f95944a78b"
RPROVIDES:glibc-langpack-bi:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-bn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bn-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bn}"
SRC_URI[aarch64_glibc-langpack-bn.sha256sum] = "4f90cac4c5dbdbf559384a6d53a3be4cda50fdafab6ac6beab7f54e305b123b8"
RPROVIDES:glibc-langpack-bn:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-bo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bo-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bo}"
SRC_URI[aarch64_glibc-langpack-bo.sha256sum] = "3fbf443929825d4bf0d5468564fa9101458c4d128021b07284876d669310cc90"
RPROVIDES:glibc-langpack-bo:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-br = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-br-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-br;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-br}"
SRC_URI[aarch64_glibc-langpack-br.sha256sum] = "0521f4349183a8dca621206a0fb4df1594e0984e03f074625030d3419c58a712"
RPROVIDES:glibc-langpack-br:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-brx = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-brx-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-brx;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-brx}"
SRC_URI[aarch64_glibc-langpack-brx.sha256sum] = "3011a5e914f706c569ccd5a277ddb40992de0d6bbbaf23154df80918807b35ed"
RPROVIDES:glibc-langpack-brx:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-bs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bs-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bs}"
SRC_URI[aarch64_glibc-langpack-bs.sha256sum] = "0dfd9091efe567de49b2b2e3b9eff7bdbc56d38949ca8783cdfbe580e7214b92"
RPROVIDES:glibc-langpack-bs:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-byn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-byn-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-byn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-byn}"
SRC_URI[aarch64_glibc-langpack-byn.sha256sum] = "44cd712c30bd7fda85eaae57ecc64f1cb5d21d66f3e9710b0b2e0955219bfab7"
RPROVIDES:glibc-langpack-byn:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ca = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ca-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ca;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ca}"
SRC_URI[aarch64_glibc-langpack-ca.sha256sum] = "1881023bf486cbd1ca0cf1591c91d112066dc1fe29b959c4240cac3b6c2cf8bc"
RPROVIDES:glibc-langpack-ca:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ce = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ce-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ce;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ce}"
SRC_URI[aarch64_glibc-langpack-ce.sha256sum] = "a370f091e7223b64e314566f218af3c29650ec2b7a01426c6d2d9511a1583404"
RPROVIDES:glibc-langpack-ce:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-chr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-chr-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-chr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-chr}"
SRC_URI[aarch64_glibc-langpack-chr.sha256sum] = "7c4cb1f5a9eabbc7e9d9829fe65fea74961f991d59ab187650b090ef4494d99b"
RPROVIDES:glibc-langpack-chr:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ckb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ckb-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ckb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ckb}"
SRC_URI[aarch64_glibc-langpack-ckb.sha256sum] = "14a7256229648c0ae6a1eea4a4ba778f61b792cd5ae5ca076fc1294c67036c15"
RPROVIDES:glibc-langpack-ckb:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-cmn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cmn-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cmn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cmn}"
SRC_URI[aarch64_glibc-langpack-cmn.sha256sum] = "6471f719ab6cc7acb8d2b5a2c49857555f8ba331632de6228c1d0177f0e1d5fb"
RPROVIDES:glibc-langpack-cmn:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-crh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-crh-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-crh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-crh}"
SRC_URI[aarch64_glibc-langpack-crh.sha256sum] = "82e3e544b51acb6b4c115428e9548f1441edc0e9fe01a299ed20672c748bf675"
RPROVIDES:glibc-langpack-crh:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-cs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cs-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cs}"
SRC_URI[aarch64_glibc-langpack-cs.sha256sum] = "60e0bd25ee726497b986ad5582391a7cf2747595bf4a8bb88acfdc5665e3241a"
RPROVIDES:glibc-langpack-cs:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-csb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-csb-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-csb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-csb}"
SRC_URI[aarch64_glibc-langpack-csb.sha256sum] = "93fd2e612a6fa6fbd57f39fbd2126a1a5c7d360c531bd75ff2d17873b3a9dbaa"
RPROVIDES:glibc-langpack-csb:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-cv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cv-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cv}"
SRC_URI[aarch64_glibc-langpack-cv.sha256sum] = "238152c9433ebbfee456915dd472ea328d5b1f58adbf1a7863caa3f718abf169"
RPROVIDES:glibc-langpack-cv:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-cy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cy-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cy}"
SRC_URI[aarch64_glibc-langpack-cy.sha256sum] = "1560e0b5d575fae2e32b6aefc61bed69d8ec566fee9981fe9cc6c1590652d4fc"
RPROVIDES:glibc-langpack-cy:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-da = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-da-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-da;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-da}"
SRC_URI[aarch64_glibc-langpack-da.sha256sum] = "e1ef37737f90e200d5347d30bf0337705be8b33543fcd2bd9b7c2b076b7f861b"
RPROVIDES:glibc-langpack-da:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-de = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-de-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-de;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-de}"
SRC_URI[aarch64_glibc-langpack-de.sha256sum] = "df64071e549c6e168e50954072850bd98f51bcf59862e1d54f8503c0a80f49bc"
RPROVIDES:glibc-langpack-de:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-doi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-doi-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-doi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-doi}"
SRC_URI[aarch64_glibc-langpack-doi.sha256sum] = "b1ab7c67fe7f079ab76f65e1d94a03d76d96bd4fa3e17788c607093b478b31c4"
RPROVIDES:glibc-langpack-doi:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-dsb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-dsb-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-dsb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-dsb}"
SRC_URI[aarch64_glibc-langpack-dsb.sha256sum] = "864a12386caac0d81f966f9316a6aea0a3f03a49d534b6e598e8732a47cf047b"
RPROVIDES:glibc-langpack-dsb:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-dv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-dv-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-dv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-dv}"
SRC_URI[aarch64_glibc-langpack-dv.sha256sum] = "f35c8932c3360d833ac95c869b80339b72c6d15004a9ca83437c3c80e3482b34"
RPROVIDES:glibc-langpack-dv:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-dz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-dz-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-dz;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-dz}"
SRC_URI[aarch64_glibc-langpack-dz.sha256sum] = "08a8e4f6b6b9d92aa2030dacc031a857e85e77305141f9c5dc1640144812d771"
RPROVIDES:glibc-langpack-dz:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-el = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-el-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-el;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-el}"
SRC_URI[aarch64_glibc-langpack-el.sha256sum] = "ed2a55acc792cffe7331decb44ca8421cb49095012b3ffd1f9843b59185128e2"
RPROVIDES:glibc-langpack-el:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-en = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-en-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-en;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-en}"
SRC_URI[aarch64_glibc-langpack-en.sha256sum] = "3ae575fb045a9941e8070ef792f0d42d815c5b655a4ad1843128eca35f530b69"
RPROVIDES:glibc-langpack-en:aarch64 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-eo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-eo-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-eo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-eo}"
SRC_URI[aarch64_glibc-langpack-eo.sha256sum] = "ad4b022402cf93c18b59e8b8a0afbfa3fd8367d86b98456b71c0268c39257b4e"
RPROVIDES:glibc-langpack-eo:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-es = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-es-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-es;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-es}"
SRC_URI[aarch64_glibc-langpack-es.sha256sum] = "e8aa994a25d73995ad84d2193b0128e218fe215615e668568ed00e68d4935ed5"
RPROVIDES:glibc-langpack-es:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-et = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-et-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-et;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-et}"
SRC_URI[aarch64_glibc-langpack-et.sha256sum] = "d94312a17c53af1f9fa3dacd0f65acf8f50edd193ff9cc0c667899a3d386fb08"
RPROVIDES:glibc-langpack-et:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-eu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-eu-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-eu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-eu}"
SRC_URI[aarch64_glibc-langpack-eu.sha256sum] = "d283ada8d9454329aa2ff1fbd69599ddf910c6fb50fe049767012b9d98c34d0c"
RPROVIDES:glibc-langpack-eu:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-fa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fa-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fa}"
SRC_URI[aarch64_glibc-langpack-fa.sha256sum] = "2f72c7837ec219def8073f961830e19e3f07f181be8031eb608799b1d3aff2a2"
RPROVIDES:glibc-langpack-fa:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ff = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ff-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ff;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ff}"
SRC_URI[aarch64_glibc-langpack-ff.sha256sum] = "1a97f0487d961dd557737be599391e8838ae87f5c9cdb68620275555218c9a8f"
RPROVIDES:glibc-langpack-ff:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-fi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fi-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fi}"
SRC_URI[aarch64_glibc-langpack-fi.sha256sum] = "d7cff298f35b5284813c6af6dfb7742411ab1d3181749950f8c4894b3be0f5e9"
RPROVIDES:glibc-langpack-fi:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-fil = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fil-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fil;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fil}"
SRC_URI[aarch64_glibc-langpack-fil.sha256sum] = "7b5191ec478af54a17a0923e69fd9f77dfea40a596bc7504aeae117077999e2f"
RPROVIDES:glibc-langpack-fil:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-fo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fo-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fo}"
SRC_URI[aarch64_glibc-langpack-fo.sha256sum] = "2cc310e0fad8b2ce7cd7a4b492ba3899b473c601d1841f1aaad8127d8aaee769"
RPROVIDES:glibc-langpack-fo:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-fr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fr-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fr}"
SRC_URI[aarch64_glibc-langpack-fr.sha256sum] = "d60424de89e232c5473f1ea05d1e1082c70037ecbe99e1c6ba3d14933ff74f9d"
RPROVIDES:glibc-langpack-fr:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-fur = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fur-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fur;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fur}"
SRC_URI[aarch64_glibc-langpack-fur.sha256sum] = "af1b4ae4bbdfea04c48556dc7948f2feaa609ab25f90fb77eeed9bb8d5c95a63"
RPROVIDES:glibc-langpack-fur:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-fy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fy-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fy}"
SRC_URI[aarch64_glibc-langpack-fy.sha256sum] = "cae4ea79c1828e992ebe063b2196f9568411cd32f2685810f4589cb18b06ce64"
RPROVIDES:glibc-langpack-fy:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ga = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ga-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ga;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ga}"
SRC_URI[aarch64_glibc-langpack-ga.sha256sum] = "504393d76a2b20a471580adeafb9286b590580d369a623302f25bfa1c37d9b02"
RPROVIDES:glibc-langpack-ga:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-gbm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gbm-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gbm;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gbm}"
SRC_URI[aarch64_glibc-langpack-gbm.sha256sum] = "982f01d9d01ff6b0d5a68e5aca898cec87cffb4dd08f427c0bb23fb1eba44e4d"
RPROVIDES:glibc-langpack-gbm:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-gd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gd-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gd;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gd}"
SRC_URI[aarch64_glibc-langpack-gd.sha256sum] = "2c7f0cd478bb491864643dca89f3f785dbae496998baad8aa53ac39d00876cd1"
RPROVIDES:glibc-langpack-gd:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-gez = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gez-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gez;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gez}"
SRC_URI[aarch64_glibc-langpack-gez.sha256sum] = "a5f8b9abbaa49a13e67823d7897220b600328b4e30062ce50ea425ef074e3f37"
RPROVIDES:glibc-langpack-gez:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-gl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gl-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gl}"
SRC_URI[aarch64_glibc-langpack-gl.sha256sum] = "e448f4e1d99b1aa39bac01ba626a91d95d666f641f4eba2410f61563e4cc5e74"
RPROVIDES:glibc-langpack-gl:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-gu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gu-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gu}"
SRC_URI[aarch64_glibc-langpack-gu.sha256sum] = "333282c7c944af495784cd6bec24c49940557a178a382a021282fad542581d30"
RPROVIDES:glibc-langpack-gu:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-gv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gv-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gv}"
SRC_URI[aarch64_glibc-langpack-gv.sha256sum] = "19b40e95bf8d7b61331695512ff01e8dd275b859db82877e437144dd4ae221a0"
RPROVIDES:glibc-langpack-gv:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ha = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ha-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ha;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ha}"
SRC_URI[aarch64_glibc-langpack-ha.sha256sum] = "7bcdcb6557b7de6959dd38519c8a1ba561cdb4be51e80496985ba6e71a3c33d4"
RPROVIDES:glibc-langpack-ha:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-hak = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hak-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hak;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hak}"
SRC_URI[aarch64_glibc-langpack-hak.sha256sum] = "2523d8b3d71ee880bfa9046c10f56395d7e089bb0d7fd09eb7b55a2bf893b3bd"
RPROVIDES:glibc-langpack-hak:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-he = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-he-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-he;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-he}"
SRC_URI[aarch64_glibc-langpack-he.sha256sum] = "7674aaa4a65b17f1eaa6725a9a0eb32b630fc6a2691efa98b45d45e307ef8ed5"
RPROVIDES:glibc-langpack-he:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-hi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hi-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hi}"
SRC_URI[aarch64_glibc-langpack-hi.sha256sum] = "d70ba751de55fbd7c0059936a6858478d80e28f37ce25069e48dc6efcf31560e"
RPROVIDES:glibc-langpack-hi:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-hif = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hif-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hif;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hif}"
SRC_URI[aarch64_glibc-langpack-hif.sha256sum] = "ba9fb79dca4b888cca9c7b3abd1206edcc7467c8ce7cdd4f9a4bb0bd8e9eb404"
RPROVIDES:glibc-langpack-hif:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-hne = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hne-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hne;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hne}"
SRC_URI[aarch64_glibc-langpack-hne.sha256sum] = "70739d939e9263295168d766d211544a903fa4864309e2c74f759671b73b533d"
RPROVIDES:glibc-langpack-hne:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-hr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hr-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hr}"
SRC_URI[aarch64_glibc-langpack-hr.sha256sum] = "925591b31a02d56e9a583e4fd24fd34a6fe7eb2927c71af92a7f70e167ad48b1"
RPROVIDES:glibc-langpack-hr:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-hsb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hsb-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hsb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hsb}"
SRC_URI[aarch64_glibc-langpack-hsb.sha256sum] = "46804b872a4f21150b0a2e034c8146a3bd0611f655eb53e2e912d55546d5d883"
RPROVIDES:glibc-langpack-hsb:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ht = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ht-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ht;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ht}"
SRC_URI[aarch64_glibc-langpack-ht.sha256sum] = "bc86257f682e118068516b7e53477365b785162004af718ea996587f288bf1c7"
RPROVIDES:glibc-langpack-ht:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-hu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hu-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hu}"
SRC_URI[aarch64_glibc-langpack-hu.sha256sum] = "17bd984e5f5926e04c8b1041d46e70d160cf7e28567ed641743b795a898bdd46"
RPROVIDES:glibc-langpack-hu:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-hy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hy-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hy}"
SRC_URI[aarch64_glibc-langpack-hy.sha256sum] = "1e42bcc77d188a8b7a7b0a01b30833fbfd4060396f69f0f724b6ec59788fb0d7"
RPROVIDES:glibc-langpack-hy:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ia = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ia-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ia;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ia}"
SRC_URI[aarch64_glibc-langpack-ia.sha256sum] = "9a3391e403f870003255a01bf8004f6e820b462643ecbe065cbe97d2737dd30e"
RPROVIDES:glibc-langpack-ia:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-id = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-id-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-id;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-id}"
SRC_URI[aarch64_glibc-langpack-id.sha256sum] = "c53a910b5b0a59a385487a0088b15a15a42740485e0004fdb6e1e4c936fbc0f2"
RPROVIDES:glibc-langpack-id:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ig = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ig-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ig;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ig}"
SRC_URI[aarch64_glibc-langpack-ig.sha256sum] = "8bb2c194623d1ddc4cc1d476cc08c3436f2fb1123bb3f09873cc85aeaec071b0"
RPROVIDES:glibc-langpack-ig:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ik = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ik-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ik;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ik}"
SRC_URI[aarch64_glibc-langpack-ik.sha256sum] = "bcbaf2a0e6d7f1780d853e943e994b72420d9d1e37ea0db0e304ca3d89117590"
RPROVIDES:glibc-langpack-ik:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-is = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-is-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-is;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-is}"
SRC_URI[aarch64_glibc-langpack-is.sha256sum] = "cbd83f679655d19a95aa1335e792c94522936ebbe0b8139f45dec025f7c92783"
RPROVIDES:glibc-langpack-is:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-it = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-it-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-it;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-it}"
SRC_URI[aarch64_glibc-langpack-it.sha256sum] = "24f4338da83e92769dc17714f5a9741cf2dd84d1f4a3d0e1289f0344c7b58ac8"
RPROVIDES:glibc-langpack-it:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-iu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-iu-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-iu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-iu}"
SRC_URI[aarch64_glibc-langpack-iu.sha256sum] = "697c5e868bd5140e16b281f4e9e9fe72be81d72161aff78a765fc3afb022fda7"
RPROVIDES:glibc-langpack-iu:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ja = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ja-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ja;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ja}"
SRC_URI[aarch64_glibc-langpack-ja.sha256sum] = "642261dcf4abc8c314e1b42893bb2beebd506b5a878c5523c7868e10924d468b"
RPROVIDES:glibc-langpack-ja:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ka = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ka-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ka;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ka}"
SRC_URI[aarch64_glibc-langpack-ka.sha256sum] = "f337ddaa642b6bd43bd53adb2a970fb2c2df0c121de92950694beb0a43f83ec1"
RPROVIDES:glibc-langpack-ka:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-kab = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kab-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kab;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kab}"
SRC_URI[aarch64_glibc-langpack-kab.sha256sum] = "5de1b80623aebc3e902b281442a7753252d94b5d94fcc946047bb31d1468cd42"
RPROVIDES:glibc-langpack-kab:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-kk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kk-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kk}"
SRC_URI[aarch64_glibc-langpack-kk.sha256sum] = "02b59d53e58132f08cc062c739d81b634ccfa7faa7c786afc928d4e8c61e0fe0"
RPROVIDES:glibc-langpack-kk:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-kl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kl-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kl}"
SRC_URI[aarch64_glibc-langpack-kl.sha256sum] = "c16f606ecf47f9978edc7c4688f13e055ee1f04b932e402802673eeef7af8ea7"
RPROVIDES:glibc-langpack-kl:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-km = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-km-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-km;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-km}"
SRC_URI[aarch64_glibc-langpack-km.sha256sum] = "c10313d1762aa3c2483e896b9b441b18a6f2b2911084145194ef03cced43d9c7"
RPROVIDES:glibc-langpack-km:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-kn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kn-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kn}"
SRC_URI[aarch64_glibc-langpack-kn.sha256sum] = "0022c4fdf31fb29177489dce7a6e23423b2efc08bb45439e80509d095bb9dbb6"
RPROVIDES:glibc-langpack-kn:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ko = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ko-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ko;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ko}"
SRC_URI[aarch64_glibc-langpack-ko.sha256sum] = "d95688dc038b42266a2bb04ef95bb42b26440759638df86008ca401cae5c35b5"
RPROVIDES:glibc-langpack-ko:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-kok = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kok-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kok;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kok}"
SRC_URI[aarch64_glibc-langpack-kok.sha256sum] = "81d9feeacafefc3227c2fe5d7eccf4f603d98c9330e2b0596025a06b7ddaa658"
RPROVIDES:glibc-langpack-kok:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ks = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ks-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ks;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ks}"
SRC_URI[aarch64_glibc-langpack-ks.sha256sum] = "1fd20dcab81febe44927b754c04fcb6f87e7afec60ab96c7bb9d7976bcf97806"
RPROVIDES:glibc-langpack-ks:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ku = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ku-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ku;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ku}"
SRC_URI[aarch64_glibc-langpack-ku.sha256sum] = "9d32dd3baee291b5a044ad45e29f68b918eec142e94a2ed208f67bb84360bf78"
RPROVIDES:glibc-langpack-ku:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-kv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kv-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kv}"
SRC_URI[aarch64_glibc-langpack-kv.sha256sum] = "1bddf4f194d67fa6693fbc351bdaf4a13332d21322a7f8f39fd0b2d8e43e46bf"
RPROVIDES:glibc-langpack-kv:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-kw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kw-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kw}"
SRC_URI[aarch64_glibc-langpack-kw.sha256sum] = "0e2f3fccf39a0d05419dce2978efd31d3af8b0e8e0a66349713e9b6d544e40c0"
RPROVIDES:glibc-langpack-kw:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ky = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ky-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ky;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ky}"
SRC_URI[aarch64_glibc-langpack-ky.sha256sum] = "2842076df9d4dae013e01059cf937311dae5b8d020363a1eb9be34c99c6e4126"
RPROVIDES:glibc-langpack-ky:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-lb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lb-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lb}"
SRC_URI[aarch64_glibc-langpack-lb.sha256sum] = "d3a340271ef23ca8c9188de61178fdffb99fc036e7d424c7d77d6c4a053c5a1f"
RPROVIDES:glibc-langpack-lb:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-lg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lg-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lg}"
SRC_URI[aarch64_glibc-langpack-lg.sha256sum] = "c84647c7cc95567e5d9f9a2cba3987def4c62c513b27bc43988c2738eaad83f8"
RPROVIDES:glibc-langpack-lg:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-li = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-li-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-li;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-li}"
SRC_URI[aarch64_glibc-langpack-li.sha256sum] = "ba28b67425c26bb84e15b680ac65b59b249e19783c378f26e10f7bf2b58c465b"
RPROVIDES:glibc-langpack-li:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-lij = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lij-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lij;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lij}"
SRC_URI[aarch64_glibc-langpack-lij.sha256sum] = "af285dd736131649577f971a34f626017100b6e8182413c7f012f8338740042e"
RPROVIDES:glibc-langpack-lij:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ln = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ln-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ln;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ln}"
SRC_URI[aarch64_glibc-langpack-ln.sha256sum] = "2816f302613959d95596cef6efe48f192c11314e929b0c7a02deb2aa7ae05b91"
RPROVIDES:glibc-langpack-ln:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-lo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lo-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lo}"
SRC_URI[aarch64_glibc-langpack-lo.sha256sum] = "65c748de07449a5fb9414c6e374a1cb607220c1df07cc4e408398d7aefe3f6cd"
RPROVIDES:glibc-langpack-lo:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-lt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lt-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lt}"
SRC_URI[aarch64_glibc-langpack-lt.sha256sum] = "68556ec0edc3850a7cacecc7753ce72d5a3f38c6eb6b530d213fecf4ff7114cc"
RPROVIDES:glibc-langpack-lt:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-lv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lv-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lv}"
SRC_URI[aarch64_glibc-langpack-lv.sha256sum] = "f62521030894d07aa9ea1584acf09f11c20f52960b11216f933214626d111dc5"
RPROVIDES:glibc-langpack-lv:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-lzh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lzh-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lzh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lzh}"
SRC_URI[aarch64_glibc-langpack-lzh.sha256sum] = "08731e507260ffad27b8542393836aad42fa58fa21a73518681fc2b435fb9a2b"
RPROVIDES:glibc-langpack-lzh:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-mag = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mag-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mag;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mag}"
SRC_URI[aarch64_glibc-langpack-mag.sha256sum] = "3c9963ecf802fec38d7ba78a8c0b2be4e7aa35abaccb4449a6a1c6cc330b156a"
RPROVIDES:glibc-langpack-mag:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-mai = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mai-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mai;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mai}"
SRC_URI[aarch64_glibc-langpack-mai.sha256sum] = "89b8039907e61c63ef2e3afc0db2c252fe9d4ab956ef023e884aa5ac33ce7c37"
RPROVIDES:glibc-langpack-mai:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-mfe = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mfe-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mfe;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mfe}"
SRC_URI[aarch64_glibc-langpack-mfe.sha256sum] = "0c94a4b9cc6c5a81c2c59441b65f63f6c7e3f17c2f6dc5543749925ee4dcbf58"
RPROVIDES:glibc-langpack-mfe:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-mg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mg-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mg}"
SRC_URI[aarch64_glibc-langpack-mg.sha256sum] = "8487a997c3f744a7988e1cbcc052b7dea9f04bf66349d77c86e0258ed8a9cff2"
RPROVIDES:glibc-langpack-mg:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-mhr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mhr-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mhr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mhr}"
SRC_URI[aarch64_glibc-langpack-mhr.sha256sum] = "0df60a0ba155302b56edb84182022b978dcfc2161eeb8fb254b2b21c63ad008c"
RPROVIDES:glibc-langpack-mhr:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-mi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mi-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mi}"
SRC_URI[aarch64_glibc-langpack-mi.sha256sum] = "5dc2474890bf41eaad89b50448c28ad6b0eeec915d20b6f8fc460df1535e3b4f"
RPROVIDES:glibc-langpack-mi:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-miq = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-miq-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-miq;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-miq}"
SRC_URI[aarch64_glibc-langpack-miq.sha256sum] = "1c3e3f722b7ef8058f93dafd35e1136c25d149d4df1c67d09aaa4ef6ed48dc7c"
RPROVIDES:glibc-langpack-miq:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-mjw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mjw-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mjw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mjw}"
SRC_URI[aarch64_glibc-langpack-mjw.sha256sum] = "5a5aed40edaac6ce61e1a2e429ef0a3bc780116c611da985116a96f103d3719e"
RPROVIDES:glibc-langpack-mjw:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-mk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mk-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mk}"
SRC_URI[aarch64_glibc-langpack-mk.sha256sum] = "868737976ea937891e874a3fef5e810f059c5b8a96acb1c2589d183d2c6367ae"
RPROVIDES:glibc-langpack-mk:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ml = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ml-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ml;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ml}"
SRC_URI[aarch64_glibc-langpack-ml.sha256sum] = "5f8ae5f706097b80c5337871a50359b42062982d05f13fc6437ab9054637baaf"
RPROVIDES:glibc-langpack-ml:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-mn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mn-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mn}"
SRC_URI[aarch64_glibc-langpack-mn.sha256sum] = "d5dc7c9219f1f23141efd242efff5c47a4d33c1e5f3280ec5b54b59c9772872e"
RPROVIDES:glibc-langpack-mn:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-mni = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mni-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mni;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mni}"
SRC_URI[aarch64_glibc-langpack-mni.sha256sum] = "f1aaa9049f9c9f888d916850584453245660041d7c2c0921bc7bb7192de54670"
RPROVIDES:glibc-langpack-mni:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-mnw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mnw-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mnw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mnw}"
SRC_URI[aarch64_glibc-langpack-mnw.sha256sum] = "88deba03ff5ccc6d9f0affce890e9b51bf10a5ca14b7cb5b2d73eff448103750"
RPROVIDES:glibc-langpack-mnw:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-mr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mr-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mr}"
SRC_URI[aarch64_glibc-langpack-mr.sha256sum] = "df90aad7acc152466c156aaa67882911fce17d197d455cb2a42c34643acb7f9a"
RPROVIDES:glibc-langpack-mr:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ms = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ms-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ms;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ms}"
SRC_URI[aarch64_glibc-langpack-ms.sha256sum] = "d1334213121d14b10cd265d87fd5e5575a14591d8cf44363e5fae1a7e3a12c52"
RPROVIDES:glibc-langpack-ms:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-mt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mt-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mt}"
SRC_URI[aarch64_glibc-langpack-mt.sha256sum] = "2f47d86c34bf0935f22b12b4e39cab77f1b27ae79a7056a3c8c612fbd6979d24"
RPROVIDES:glibc-langpack-mt:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-my = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-my-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-my;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-my}"
SRC_URI[aarch64_glibc-langpack-my.sha256sum] = "488f250cca101b4d958303073b6015c373852ec129f9afadb781fed654282042"
RPROVIDES:glibc-langpack-my:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-nan = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nan-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nan;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nan}"
SRC_URI[aarch64_glibc-langpack-nan.sha256sum] = "311b34897254ea0da5aea498e0226263913bd14589d06383f94462e9d0f8f625"
RPROVIDES:glibc-langpack-nan:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-nb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nb-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nb}"
SRC_URI[aarch64_glibc-langpack-nb.sha256sum] = "3c4c7a3b44513819aba5c25f4d986c0b0214cc0a756ba62a5ac20f2776634ddf"
RPROVIDES:glibc-langpack-nb:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-nds = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nds-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nds;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nds}"
SRC_URI[aarch64_glibc-langpack-nds.sha256sum] = "1d88305817e238f1e898ee2153cb6cad1e21735ab932e6c354670fcbbe3e3a10"
RPROVIDES:glibc-langpack-nds:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ne = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ne-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ne;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ne}"
SRC_URI[aarch64_glibc-langpack-ne.sha256sum] = "9510d51d90f4ad7fa0b28b5ad52708ee6150cd86db4abbeb7a1d84aeb1052c47"
RPROVIDES:glibc-langpack-ne:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-nhn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nhn-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nhn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nhn}"
SRC_URI[aarch64_glibc-langpack-nhn.sha256sum] = "fbb29871b780e5937d3f9113dc92b42a5444954d11ba1f239e7a5e4d52ccd875"
RPROVIDES:glibc-langpack-nhn:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-niu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-niu-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-niu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-niu}"
SRC_URI[aarch64_glibc-langpack-niu.sha256sum] = "f20aca6f9d5bc7bd1eaee098797d3c6fdab93d3897c4a21b3aa8fd4a9c9d84d6"
RPROVIDES:glibc-langpack-niu:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-nl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nl-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nl}"
SRC_URI[aarch64_glibc-langpack-nl.sha256sum] = "cb67dda62e0f8fafcb38eb0d49cccdd2f5af607a2a3a10a60b7a48334c64827b"
RPROVIDES:glibc-langpack-nl:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-nn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nn-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nn}"
SRC_URI[aarch64_glibc-langpack-nn.sha256sum] = "c81b3590bfd44b8c706dd1615c8536d1855f793891665f5c30131f66395b22ea"
RPROVIDES:glibc-langpack-nn:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-nr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nr-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nr}"
SRC_URI[aarch64_glibc-langpack-nr.sha256sum] = "eea48f3210f60435515e4193ae592399449e943c3e96d4b384545ea0f51328bf"
RPROVIDES:glibc-langpack-nr:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-nso = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nso-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nso;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nso}"
SRC_URI[aarch64_glibc-langpack-nso.sha256sum] = "37c1458bc799fa43966b34b9725cda24b279e52d775aa04e5b98719d41450dfa"
RPROVIDES:glibc-langpack-nso:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-oc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-oc-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-oc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-oc}"
SRC_URI[aarch64_glibc-langpack-oc.sha256sum] = "368ead795c6d8fdccb80660400650bca32e6c1df1c70a09a30c3fcc9cd8c42ba"
RPROVIDES:glibc-langpack-oc:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-om = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-om-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-om;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-om}"
SRC_URI[aarch64_glibc-langpack-om.sha256sum] = "62b1320c7e3825c590cb8935a7191cfa5b050ed9b080d7fcfcef2430fb610545"
RPROVIDES:glibc-langpack-om:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-or = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-or-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-or;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-or}"
SRC_URI[aarch64_glibc-langpack-or.sha256sum] = "3f0aa295488b227b724373f9e9f797554f6c60d02e352c9886705bf9a3763db5"
RPROVIDES:glibc-langpack-or:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-os = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-os-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-os;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-os}"
SRC_URI[aarch64_glibc-langpack-os.sha256sum] = "78d8689f306335e4c6da5645d57ed87cb93b455074a0a2ac186ec590d9f0f0ce"
RPROVIDES:glibc-langpack-os:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-pa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pa-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pa}"
SRC_URI[aarch64_glibc-langpack-pa.sha256sum] = "5a05fb0c0e7c34b76b071857f4d2b535f3e1545decea1326988f9804cf7108b7"
RPROVIDES:glibc-langpack-pa:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-pap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pap-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pap;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pap}"
SRC_URI[aarch64_glibc-langpack-pap.sha256sum] = "42664db2d787e139b8cfed93635044ba1eaedd54a5f2ff75c1bcd6ffffb38df7"
RPROVIDES:glibc-langpack-pap:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-pl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pl-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pl}"
SRC_URI[aarch64_glibc-langpack-pl.sha256sum] = "a027214e2d02c746ae700029416b51119fc9aa98a671c95ef2ae1c21f2fd4775"
RPROVIDES:glibc-langpack-pl:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ps = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ps-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ps;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ps}"
SRC_URI[aarch64_glibc-langpack-ps.sha256sum] = "8eef7222b8d4c1b62b58dd55d533fb00724d26217fc7bfa71defbcc433f0f0f5"
RPROVIDES:glibc-langpack-ps:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-pt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pt-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pt}"
SRC_URI[aarch64_glibc-langpack-pt.sha256sum] = "4779445d84f36aa6bde10358bd416076f39cfd197ba2699f622d81bc84f4f617"
RPROVIDES:glibc-langpack-pt:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-quz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-quz-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-quz;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-quz}"
SRC_URI[aarch64_glibc-langpack-quz.sha256sum] = "af3410da6e902f931d0b65ac0e8dc46c41690334b4d3e87151ee6844b6b6112b"
RPROVIDES:glibc-langpack-quz:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-raj = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-raj-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-raj;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-raj}"
SRC_URI[aarch64_glibc-langpack-raj.sha256sum] = "921bb42e32db423828af19542523a2cdd88a8831bc7197b1a479e693c1b813b7"
RPROVIDES:glibc-langpack-raj:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-rif = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-rif-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-rif;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-rif}"
SRC_URI[aarch64_glibc-langpack-rif.sha256sum] = "cdb0fdea70f3f2e82eb89a5455b20f52e5eac1eb29ccdfe4c1e28a09e301d9da"
RPROVIDES:glibc-langpack-rif:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ro = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ro-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ro;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ro}"
SRC_URI[aarch64_glibc-langpack-ro.sha256sum] = "f444671d18fac93a80e1543f0bbac69c790c949cd91b49e8dc6426561b26615c"
RPROVIDES:glibc-langpack-ro:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ru = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ru-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ru;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ru}"
SRC_URI[aarch64_glibc-langpack-ru.sha256sum] = "e121b3e6597a7693bfebb799e9d71e9ea99d73cb70c06609e84e6205a661b743"
RPROVIDES:glibc-langpack-ru:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-rw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-rw-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-rw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-rw}"
SRC_URI[aarch64_glibc-langpack-rw.sha256sum] = "a649e4794b25508b45953fdf1057804c5f57341d493c1d4af654b64ce0d2fe58"
RPROVIDES:glibc-langpack-rw:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-sa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sa-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sa}"
SRC_URI[aarch64_glibc-langpack-sa.sha256sum] = "e1ca1c89c571c438f77b496fdb62050985716f0e2e42e2853d2baa83a2f00eab"
RPROVIDES:glibc-langpack-sa:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-sah = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sah-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sah;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sah}"
SRC_URI[aarch64_glibc-langpack-sah.sha256sum] = "ca32dc121fb5442aea496792e961ff66d32af87029bdfc1a4e49d1c9b06cfe62"
RPROVIDES:glibc-langpack-sah:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-sat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sat-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sat;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sat}"
SRC_URI[aarch64_glibc-langpack-sat.sha256sum] = "0f5c30b31fb26df98c2a9ead3149aa625afbc46498598f9fca9ee52639619b1c"
RPROVIDES:glibc-langpack-sat:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-sc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sc-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sc}"
SRC_URI[aarch64_glibc-langpack-sc.sha256sum] = "2edf6f83db78ba8f85d6428a250627aaaa3b0212ef26d2f7d7dfd3a800c1744e"
RPROVIDES:glibc-langpack-sc:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-sd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sd-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sd;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sd}"
SRC_URI[aarch64_glibc-langpack-sd.sha256sum] = "1905b72ac2d4260ba72ada6750a0f0452716905ba3424d8348edef8b8c8ac68a"
RPROVIDES:glibc-langpack-sd:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-se = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-se-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-se;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-se}"
SRC_URI[aarch64_glibc-langpack-se.sha256sum] = "84bd44a348f0119b2be35ffa3c1250dfa2346db8244b4aa9d7faf89ba4023960"
RPROVIDES:glibc-langpack-se:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-sgs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sgs-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sgs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sgs}"
SRC_URI[aarch64_glibc-langpack-sgs.sha256sum] = "52e41ba940635802ddd1e1abe91b76ebff89b153e2684f6b376e013ca33edc24"
RPROVIDES:glibc-langpack-sgs:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-shn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-shn-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-shn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-shn}"
SRC_URI[aarch64_glibc-langpack-shn.sha256sum] = "e4e575b2386cf91536a83446452426eb8abff7c7d7f64db6dd86ff0dcf02e479"
RPROVIDES:glibc-langpack-shn:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-shs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-shs-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-shs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-shs}"
SRC_URI[aarch64_glibc-langpack-shs.sha256sum] = "13496f4ac9e2deb795cc4fccf910723b950b788f502db086d2ac84f93410ef7d"
RPROVIDES:glibc-langpack-shs:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-si = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-si-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-si;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-si}"
SRC_URI[aarch64_glibc-langpack-si.sha256sum] = "4afd172db2c12149e3c4c9aa9e60551437c1d0f39c4f1cc09dffa860d1646522"
RPROVIDES:glibc-langpack-si:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-sid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sid-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sid;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sid}"
SRC_URI[aarch64_glibc-langpack-sid.sha256sum] = "9ac175ffd5c085f3f10f7c7ae7955b5d22d647c48d8ac0a7781952610d217957"
RPROVIDES:glibc-langpack-sid:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-sk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sk-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sk}"
SRC_URI[aarch64_glibc-langpack-sk.sha256sum] = "202f87f99a109b2585024d809b5349cfa8086e28fd1efb634067920db0dd2a6b"
RPROVIDES:glibc-langpack-sk:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-sl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sl-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sl}"
SRC_URI[aarch64_glibc-langpack-sl.sha256sum] = "06102119d1b63fe0a6f6fabd43d7b5d0431b31e961a3813c7af8dd5c7cd830f7"
RPROVIDES:glibc-langpack-sl:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-sm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sm-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sm;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sm}"
SRC_URI[aarch64_glibc-langpack-sm.sha256sum] = "e56b46cbcdec802d8c5d361da11ef629cf2d0c447b667358f28a927537b559f1"
RPROVIDES:glibc-langpack-sm:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-so = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-so-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-so;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-so}"
SRC_URI[aarch64_glibc-langpack-so.sha256sum] = "e0b5eec967ecbee76835b547ce4936614bc46e43fb25eae01a1714c70cec173c"
RPROVIDES:glibc-langpack-so:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-sq = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sq-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sq;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sq}"
SRC_URI[aarch64_glibc-langpack-sq.sha256sum] = "e15c1b4b5ee917bb9edfa386909af378cf9d42e0365b65e26ca4d0f551fa953e"
RPROVIDES:glibc-langpack-sq:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-sr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sr-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sr}"
SRC_URI[aarch64_glibc-langpack-sr.sha256sum] = "631163dd0cfa72e462c03dbdbd5fc422cb5ec0f55d993bc28a1c696e63f7a908"
RPROVIDES:glibc-langpack-sr:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ss = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ss-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ss;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ss}"
SRC_URI[aarch64_glibc-langpack-ss.sha256sum] = "d13a338c137065323ab36566846f6850e84aa5c45547f83bcd5a9718744edd3e"
RPROVIDES:glibc-langpack-ss:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ssy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ssy-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ssy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ssy}"
SRC_URI[aarch64_glibc-langpack-ssy.sha256sum] = "b541a17c476d4d4774c18b479c088f05e430b7c356c97f64546d8205a9d46390"
RPROVIDES:glibc-langpack-ssy:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-st = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-st-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-st;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-st}"
SRC_URI[aarch64_glibc-langpack-st.sha256sum] = "f4945800290583cada23bbbfb1772e197c01207b8e6f497f4c202a2807c1175a"
RPROVIDES:glibc-langpack-st:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-su = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-su-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-su;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-su}"
SRC_URI[aarch64_glibc-langpack-su.sha256sum] = "6037031da593995d8e298e863ef6ff6314e5bf5e7b5b2a39724cec478793aa44"
RPROVIDES:glibc-langpack-su:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-sv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sv-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sv}"
SRC_URI[aarch64_glibc-langpack-sv.sha256sum] = "41b990f2c6ac1c68086eaef4c89d8e0b036cb71f230a9468280e033fedd7c2e8"
RPROVIDES:glibc-langpack-sv:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-sw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sw-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sw}"
SRC_URI[aarch64_glibc-langpack-sw.sha256sum] = "1f3e2a1c80dae3dba70860990b7bf50545eba4245fa267c25fa4dd71c21f6aa3"
RPROVIDES:glibc-langpack-sw:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-syr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-syr-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-syr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-syr}"
SRC_URI[aarch64_glibc-langpack-syr.sha256sum] = "7379c9ee630618563d118a25e373736ac2198d838a041903f66d40dd8f1fc7fb"
RPROVIDES:glibc-langpack-syr:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-szl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-szl-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-szl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-szl}"
SRC_URI[aarch64_glibc-langpack-szl.sha256sum] = "2104f9c2d6e73f686cacc9c30e1720eb7bd7ec40c68e1a35dd3d176ef76de325"
RPROVIDES:glibc-langpack-szl:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ta = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ta-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ta;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ta}"
SRC_URI[aarch64_glibc-langpack-ta.sha256sum] = "c56c6c761979f70374947b957913f590af0df6160629d84c9008d210d27f2eca"
RPROVIDES:glibc-langpack-ta:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-tcy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tcy-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tcy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tcy}"
SRC_URI[aarch64_glibc-langpack-tcy.sha256sum] = "1dfc844374e1fa4b2e70a23b9abb2c74536040343c4a9f3e2ade4a23bfa5771e"
RPROVIDES:glibc-langpack-tcy:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-te = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-te-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-te;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-te}"
SRC_URI[aarch64_glibc-langpack-te.sha256sum] = "3f528ee528fc03f078472f35d8335a69655e06e6ad67329c3572d48f27f471a1"
RPROVIDES:glibc-langpack-te:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-tg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tg-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tg}"
SRC_URI[aarch64_glibc-langpack-tg.sha256sum] = "e84b813b6d17407645501a8021904d1ce5e6625c57dc01c1d014e77631927a6a"
RPROVIDES:glibc-langpack-tg:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-th = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-th-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-th}"
SRC_URI[aarch64_glibc-langpack-th.sha256sum] = "772e895414399c0195f06039efca51786a2313e89956376b94eb9c289ee96d63"
RPROVIDES:glibc-langpack-th:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-the = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-the-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-the;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-the}"
SRC_URI[aarch64_glibc-langpack-the.sha256sum] = "c80fb4c2f9916a427563af055a013f5a0ea39995ed7843cd8e0c556dd5a79a88"
RPROVIDES:glibc-langpack-the:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ti = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ti-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ti;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ti}"
SRC_URI[aarch64_glibc-langpack-ti.sha256sum] = "7c7517444635cfad79423efaabcab7d0524d8722b5d4bbba5021cf733828d24c"
RPROVIDES:glibc-langpack-ti:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-tig = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tig-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tig;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tig}"
SRC_URI[aarch64_glibc-langpack-tig.sha256sum] = "7e46f14186346b21e6ba7d9e0df48b52a74b66a408991896cabd609b55c65657"
RPROVIDES:glibc-langpack-tig:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-tk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tk-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tk}"
SRC_URI[aarch64_glibc-langpack-tk.sha256sum] = "b918d0281bc5c2cee4ac809af8ec31532148c1a2bcda5d30ead26b876fb07458"
RPROVIDES:glibc-langpack-tk:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-tl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tl-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tl}"
SRC_URI[aarch64_glibc-langpack-tl.sha256sum] = "f4776afeeec5dcae8ea7a4e0a48777d16203b8b8867873886a9b7e654b2d9ead"
RPROVIDES:glibc-langpack-tl:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-tn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tn-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tn}"
SRC_URI[aarch64_glibc-langpack-tn.sha256sum] = "59fe12ffa2297bbf85f519b6049a14bfc651aa55932e23edc0dd1fc3aa605754"
RPROVIDES:glibc-langpack-tn:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-to = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-to-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-to;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-to}"
SRC_URI[aarch64_glibc-langpack-to.sha256sum] = "4b4c30f618f79b03b464b7d15f42fe5273e18df4e55d03a255fd33b1f640c9ab"
RPROVIDES:glibc-langpack-to:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-tok = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tok-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tok;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tok}"
SRC_URI[aarch64_glibc-langpack-tok.sha256sum] = "5da8d581239a3a9b32e6b2af40b762b20619ab81ccdebbff81ce1ec3acb4ecc4"
RPROVIDES:glibc-langpack-tok:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-tpi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tpi-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tpi}"
SRC_URI[aarch64_glibc-langpack-tpi.sha256sum] = "4b36ea23287b7ad903adfec8824a7cabcc3f393fca6be47ef6d23a370a2d0eb8"
RPROVIDES:glibc-langpack-tpi:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-tr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tr-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tr}"
SRC_URI[aarch64_glibc-langpack-tr.sha256sum] = "00e424cd26d3a51b3783cf89d5ca738227501725139fa7f3a0b39cc40d15037f"
RPROVIDES:glibc-langpack-tr:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ts-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ts;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ts}"
SRC_URI[aarch64_glibc-langpack-ts.sha256sum] = "6c010f2520701415d383d1cb7e1e2371e2f15115e4c52a78d5ac44d894c3151d"
RPROVIDES:glibc-langpack-ts:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-tt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tt-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tt}"
SRC_URI[aarch64_glibc-langpack-tt.sha256sum] = "3da913df019d3cea85806fc9d49270649fe4368a028a859cfcadae74ac6f7286"
RPROVIDES:glibc-langpack-tt:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ug = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ug-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ug;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ug}"
SRC_URI[aarch64_glibc-langpack-ug.sha256sum] = "a876fa41e372323e8b422ae8f7a7a3f3ece4741e4883b8acea1b24a39cb88033"
RPROVIDES:glibc-langpack-ug:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-uk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-uk-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-uk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-uk}"
SRC_URI[aarch64_glibc-langpack-uk.sha256sum] = "a27c79329edcc34e2317e6640b0023b29df849d09ab449c973735b74593b0f3c"
RPROVIDES:glibc-langpack-uk:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-unm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-unm-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-unm;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-unm}"
SRC_URI[aarch64_glibc-langpack-unm.sha256sum] = "a0427c839eb55f9cfa1584f548c0238f64169957247f26cd7a8cf6e08ae8a444"
RPROVIDES:glibc-langpack-unm:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ur = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ur-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ur;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ur}"
SRC_URI[aarch64_glibc-langpack-ur.sha256sum] = "9f8dd2f1d53237a20b430343c26e94dd0b23f8137c7ca81096e6544821522117"
RPROVIDES:glibc-langpack-ur:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-uz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-uz-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-uz;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-uz}"
SRC_URI[aarch64_glibc-langpack-uz.sha256sum] = "e9b7df4428c31c971dc1dff93a1350a55f80982148df1ef4ce22c849dffbc102"
RPROVIDES:glibc-langpack-uz:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-ve = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ve-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ve;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ve}"
SRC_URI[aarch64_glibc-langpack-ve.sha256sum] = "67f8365c63b0e3ee369da1134478a4f10cbfff48d14b3d7e6370d68b4eeab4b2"
RPROVIDES:glibc-langpack-ve:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-vi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-vi-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-vi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-vi}"
SRC_URI[aarch64_glibc-langpack-vi.sha256sum] = "f33b047c3fd5026325915bb8d1ee8d46194f8e25f77a9f1c76091f4decd5acc9"
RPROVIDES:glibc-langpack-vi:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-wa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wa-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wa}"
SRC_URI[aarch64_glibc-langpack-wa.sha256sum] = "a515339454c5af064bb3660d20087942a283bdbae9696acfa99d4417920afee1"
RPROVIDES:glibc-langpack-wa:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-wae = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wae-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wae;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wae}"
SRC_URI[aarch64_glibc-langpack-wae.sha256sum] = "27dd92a9ffb5567d44aadf6fa35840bdfcec89af13b0d52e73977f24c319fe05"
RPROVIDES:glibc-langpack-wae:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-wal = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wal-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wal;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wal}"
SRC_URI[aarch64_glibc-langpack-wal.sha256sum] = "a680b85ce868e73d7785c75df9ac09994c91c2ec80c8926ca1cdadbc066fab4a"
RPROVIDES:glibc-langpack-wal:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-wo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wo-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wo}"
SRC_URI[aarch64_glibc-langpack-wo.sha256sum] = "a48124944b222b268bebd717c8cfcb6a7a02d8f2955019e7b3f695855d72148c"
RPROVIDES:glibc-langpack-wo:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-xh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-xh-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-xh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-xh}"
SRC_URI[aarch64_glibc-langpack-xh.sha256sum] = "5098b514059a7df862921f861d3f2ef755b39b34b9d1c4429cc8f2c0a3cc1640"
RPROVIDES:glibc-langpack-xh:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-yi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yi-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yi}"
SRC_URI[aarch64_glibc-langpack-yi.sha256sum] = "8543c43420f2449038e8c92b91cf63e9da49d06906ad8be69f5d7c512bf5b3c0"
RPROVIDES:glibc-langpack-yi:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-yo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yo-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yo}"
SRC_URI[aarch64_glibc-langpack-yo.sha256sum] = "1bcac665b3e2d1efe679d0e39101487802e243fa4ee6f03ff78104cf8555e831"
RPROVIDES:glibc-langpack-yo:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-yue = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yue-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yue;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yue}"
SRC_URI[aarch64_glibc-langpack-yue.sha256sum] = "4e8d395ad997e7ac6c292bd66a8702227c666a41937682ddcb937c172e37f6dc"
RPROVIDES:glibc-langpack-yue:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-yuw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yuw-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yuw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yuw}"
SRC_URI[aarch64_glibc-langpack-yuw.sha256sum] = "f7f0d2762fb5ef521b99164d668d71eb56dccb0e829dbbcc055de345db8c3c6b"
RPROVIDES:glibc-langpack-yuw:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-zgh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-zgh-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-zgh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-zgh}"
SRC_URI[aarch64_glibc-langpack-zgh.sha256sum] = "fda829ebcdf9358380734bb981b481c30fc1a15fe746f29d15aa26947a6553a6"
RPROVIDES:glibc-langpack-zgh:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-zh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-zh-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-zh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-zh}"
SRC_URI[aarch64_glibc-langpack-zh.sha256sum] = "1c91e104dbd456fb770907a219d239ae999195ee9e301d912cac4852a0d6ce19"
RPROVIDES:glibc-langpack-zh:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-langpack-zu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-zu-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-zu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-zu}"
SRC_URI[aarch64_glibc-langpack-zu.sha256sum] = "12030e27d51fbfe9c7eb601005f703a32d15faf7aa6940d78054c2b11bc622d7"
RPROVIDES:glibc-langpack-zu:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-locale-source = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-locale-source-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-locale-source;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-locale-source}"
SRC_URI[aarch64_glibc-locale-source.sha256sum] = "b0c3d69bce65e51630143d39d08bcb6942475c606cf24d04f3a7601e24cb260c"

URI_aarch64_glibc-minimal-langpack = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-minimal-langpack-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-minimal-langpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-minimal-langpack}"
SRC_URI[aarch64_glibc-minimal-langpack.sha256sum] = "681a340858c9577807c24b51d74ff4fb2eb4d30f8347cf9141cd88942960cc5b"
RPROVIDES:glibc-minimal-langpack:aarch64 = "virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

URI_aarch64_glibc-nss-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibc-nss-devel-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-nss-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-nss-devel}"
SRC_URI[aarch64_glibc-nss-devel.sha256sum] = "be6922039451f8cff7009ff021fe005b7fbe5bd08b285e3fd628e05960904bde"

URI_aarch64_glibc-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibc-static-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-static}"
SRC_URI[aarch64_glibc-static.sha256sum] = "3291ab72e93f8ea8466d67b95ec31e8a18a9771203efd1268dd0263c9efbf1bd"

URI_aarch64_glibc-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-utils-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_glibc-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-utils}"
SRC_URI[aarch64_glibc-utils.sha256sum] = "e8c7f87f159c4d512c217dffa2e70112f3f73c5247ad75476a7f45296722cb95"

URI_aarch64_libnsl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnsl-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_libnsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnsl}"
SRC_URI[aarch64_libnsl.sha256sum] = "4105bddb874079a5ad6fd76779aee90c1b8285dfb3260fc0196a7f565e6797ec"

URI_aarch64_nss_db = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nss_db-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_nss_db;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss_db}"
SRC_URI[aarch64_nss_db.sha256sum] = "df8ade428a573a8a2105a058f2a8fc833f8dce2b770567a2ec42ea7050703393"

URI_aarch64_nss_hesiod = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nss_hesiod-2.39-130.el10.alma.1.aarch64.rpm;name=aarch64_nss_hesiod;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss_hesiod}"
SRC_URI[aarch64_nss_hesiod.sha256sum] = "b796038f153e1e686bca37e872c2b136c63688723ede90384f55613680c89649"

RDEPENDS:glibc = " \
 basesystem \
 glibc-common \
 glibc-gconv-extra \
 libgcc \
 virtual/glibc-langpack_eq_2.39-130.el10.alma.1 \
 "
RDEPENDS:glibc-all-langpacks = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-benchtests = " \
 bash \
 glibc \
 python3 \
 "
RDEPENDS:glibc-common = " \
 bash \
 glibc \
 "
RDEPENDS:glibc-devel = " \
 glibc \
 kernel-headers \
 libxcrypt-devel \
 "
RDEPENDS:glibc-doc = " \
 glibc \
 "
RDEPENDS:glibc-gconv-extra = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-aa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-af = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-agr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ak = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-am = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-an = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-anp = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ar = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-as = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ast = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ayc = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-az = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-be = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bem = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ber = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bhb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bho = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-br = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-brx = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-byn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ca = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ce = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-chr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ckb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cmn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-crh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-csb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-da = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-de = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-doi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-dsb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-dv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-dz = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-el = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-en = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-eo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-es = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-et = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-eu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ff = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fil = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fur = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ga = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gbm = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gd = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gez = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ha = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hak = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-he = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hif = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hne = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hsb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ht = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ia = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-id = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ig = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ik = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-is = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-it = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-iu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ja = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ka = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kab = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-km = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ko = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kok = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ks = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ku = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ky = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-li = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lij = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ln = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lzh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mag = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mai = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mfe = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mhr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-miq = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mjw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ml = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mni = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mnw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ms = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-my = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nan = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nds = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ne = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nhn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-niu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nso = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-oc = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-om = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-or = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-os = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pap = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ps = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-quz = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-raj = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-rif = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ro = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ru = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-rw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sah = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sat = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sc = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sd = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-se = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sgs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-shn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-shs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-si = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sid = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sm = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-so = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sq = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ss = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ssy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-st = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-su = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-syr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-szl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ta = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tcy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-te = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-th = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-the = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ti = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tig = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-to = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tok = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tpi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ts = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ug = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-uk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-unm = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ur = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-uz = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ve = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-vi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wae = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wal = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-xh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yue = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yuw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-zgh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-zh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-zu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-locale-source = " \
 glibc \
 glibc-common \
 gzip \
 "
RDEPENDS:glibc-minimal-langpack = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-nss-devel = " \
 glibc \
 nss_db \
 nss_hesiod \
 "
RDEPENDS:glibc-static = " \
 glibc-devel \
 libxcrypt-static \
 "
RDEPENDS:glibc-utils = " \
 bash \
 gd \
 glibc \
 libpng \
 perl-interpreter \
 zlib-ng-compat \
 "
RDEPENDS:libnsl = " \
 glibc \
 "
RDEPENDS:nss_db = " \
 glibc \
 libselinux \
 "
RDEPENDS:nss_hesiod = " \
 glibc \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/glibc-langpack-en_or_glibc-all-langpacks rpm/virtual/glibc-langpack_eq_2.39-130.el10.alma.1"

PROVIDES:append:aarch64 = " rpm/virtual/glibc-langpack-en_or_glibc-all-langpacks rpm/virtual/glibc-langpack_eq_2.39-130.el10.alma.1"
