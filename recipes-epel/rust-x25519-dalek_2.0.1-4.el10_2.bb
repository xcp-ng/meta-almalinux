# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-x25519-dalek"
PV = "2.0.1"
PR = "4.el10_2"
PACKAGES = " \
 rust-x25519-dalek+alloc-devel \
 rust-x25519-dalek+default-devel \
 rust-x25519-dalek+getrandom-devel \
 rust-x25519-dalek+precomputed-tables-devel \
 rust-x25519-dalek+reusable_secrets-devel \
 rust-x25519-dalek+serde-devel \
 rust-x25519-dalek+static_secrets-devel \
 rust-x25519-dalek+zeroize-devel \
 rust-x25519-dalek-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-x25519-dalek-2.0.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f63804f130bf9afa31026398b3139b6cefe09cf5949551b249b697bf27af1aa6"

URI_x86_64_v2_rust-x25519-dalek+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x25519-dalek+alloc-devel-2.0.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x25519-dalek+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x25519-dalek+alloc-devel}"
SRC_URI[x86_64_v2_rust-x25519-dalek+alloc-devel.sha256sum] = "1408bca239c34cf24daa16d03174088c80d599baa2b4c76dc7acceabc7dfd431"

URI_x86_64_v2_rust-x25519-dalek+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x25519-dalek+default-devel-2.0.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x25519-dalek+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x25519-dalek+default-devel}"
SRC_URI[x86_64_v2_rust-x25519-dalek+default-devel.sha256sum] = "f79d5f93887f775ff8d6c872548846e1caa1d203426a9f356a157600a9080c30"

URI_x86_64_v2_rust-x25519-dalek+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x25519-dalek+getrandom-devel-2.0.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x25519-dalek+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x25519-dalek+getrandom-devel}"
SRC_URI[x86_64_v2_rust-x25519-dalek+getrandom-devel.sha256sum] = "12ed4dbe014c23367cb82d77f00308152c63c47ae762bbb009227c7bb6a6d773"

URI_x86_64_v2_rust-x25519-dalek+precomputed-tables-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x25519-dalek+precomputed-tables-devel-2.0.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x25519-dalek+precomputed-tables-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x25519-dalek+precomputed-tables-devel}"
SRC_URI[x86_64_v2_rust-x25519-dalek+precomputed-tables-devel.sha256sum] = "fbdd39bd210c82d3887404ebf6f4b00c4c0b38171117371f9aa8aa3cdbda2180"

URI_x86_64_v2_rust-x25519-dalek+reusable_secrets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x25519-dalek+reusable_secrets-devel-2.0.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x25519-dalek+reusable_secrets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x25519-dalek+reusable_secrets-devel}"
SRC_URI[x86_64_v2_rust-x25519-dalek+reusable_secrets-devel.sha256sum] = "87aaad2607e500e92e0b22853c70fd14a25b0ff8f1e411a2ed42b3cd62a5101d"

URI_x86_64_v2_rust-x25519-dalek+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x25519-dalek+serde-devel-2.0.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x25519-dalek+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x25519-dalek+serde-devel}"
SRC_URI[x86_64_v2_rust-x25519-dalek+serde-devel.sha256sum] = "d7611f820e4c2e1f23963f340a24f796ef64f89e4db9f31c11b1630b2d75bd35"

URI_x86_64_v2_rust-x25519-dalek+static_secrets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x25519-dalek+static_secrets-devel-2.0.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x25519-dalek+static_secrets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x25519-dalek+static_secrets-devel}"
SRC_URI[x86_64_v2_rust-x25519-dalek+static_secrets-devel.sha256sum] = "8d277164ef0caad5c7958ade6cd8eaafd2d31172032a2d92e297f51576d521ac"

URI_x86_64_v2_rust-x25519-dalek+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x25519-dalek+zeroize-devel-2.0.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x25519-dalek+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x25519-dalek+zeroize-devel}"
SRC_URI[x86_64_v2_rust-x25519-dalek+zeroize-devel.sha256sum] = "16b88993188e31692981bf00bc4d5af1172af5f06a4cf87c21640791ab9b7fc8"

URI_x86_64_v2_rust-x25519-dalek-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x25519-dalek-devel-2.0.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x25519-dalek-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x25519-dalek-devel}"
SRC_URI[x86_64_v2_rust-x25519-dalek-devel.sha256sum] = "d6310c2e3df1ae166f058096fd65a36acc4f637a1ced92ff78b6364284d0a73f"

URI_aarch64_rust-x25519-dalek+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x25519-dalek+alloc-devel-2.0.1-4.el10_2.noarch.rpm;name=aarch64_rust-x25519-dalek+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x25519-dalek+alloc-devel}"
SRC_URI[aarch64_rust-x25519-dalek+alloc-devel.sha256sum] = "f8afabf479f3a4d8a4834018eb53e3b17926a970c2d6425e4498653f7ec7f3b0"

URI_aarch64_rust-x25519-dalek+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x25519-dalek+default-devel-2.0.1-4.el10_2.noarch.rpm;name=aarch64_rust-x25519-dalek+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x25519-dalek+default-devel}"
SRC_URI[aarch64_rust-x25519-dalek+default-devel.sha256sum] = "2c3381e8e6d265321a787ce2c556be2a7ea46d7137f7733c056960c9fb0f6c21"

URI_aarch64_rust-x25519-dalek+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x25519-dalek+getrandom-devel-2.0.1-4.el10_2.noarch.rpm;name=aarch64_rust-x25519-dalek+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x25519-dalek+getrandom-devel}"
SRC_URI[aarch64_rust-x25519-dalek+getrandom-devel.sha256sum] = "c8b58233b813b335b59558c3fb047589dc05f1330ece7747752b4ce861c6754b"

URI_aarch64_rust-x25519-dalek+precomputed-tables-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x25519-dalek+precomputed-tables-devel-2.0.1-4.el10_2.noarch.rpm;name=aarch64_rust-x25519-dalek+precomputed-tables-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x25519-dalek+precomputed-tables-devel}"
SRC_URI[aarch64_rust-x25519-dalek+precomputed-tables-devel.sha256sum] = "9e6af8acd1ee415c03b1c2b16d1b49c1b61bcb30f942def3c7906fde6232f233"

URI_aarch64_rust-x25519-dalek+reusable_secrets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x25519-dalek+reusable_secrets-devel-2.0.1-4.el10_2.noarch.rpm;name=aarch64_rust-x25519-dalek+reusable_secrets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x25519-dalek+reusable_secrets-devel}"
SRC_URI[aarch64_rust-x25519-dalek+reusable_secrets-devel.sha256sum] = "64a32a0908c3d9bf6ecd3a47173fea7f95fa4dbabf18b3bd534b3f6ec88c37e5"

URI_aarch64_rust-x25519-dalek+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x25519-dalek+serde-devel-2.0.1-4.el10_2.noarch.rpm;name=aarch64_rust-x25519-dalek+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x25519-dalek+serde-devel}"
SRC_URI[aarch64_rust-x25519-dalek+serde-devel.sha256sum] = "da6b4bce266e1d7b9bf5b7a4bb43e6c5d603520af06b32818070dce42c456fad"

URI_aarch64_rust-x25519-dalek+static_secrets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x25519-dalek+static_secrets-devel-2.0.1-4.el10_2.noarch.rpm;name=aarch64_rust-x25519-dalek+static_secrets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x25519-dalek+static_secrets-devel}"
SRC_URI[aarch64_rust-x25519-dalek+static_secrets-devel.sha256sum] = "fd9d156611c50c18a384d951e6b36ece43855af770a910844d7f5d1f284226fd"

URI_aarch64_rust-x25519-dalek+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x25519-dalek+zeroize-devel-2.0.1-4.el10_2.noarch.rpm;name=aarch64_rust-x25519-dalek+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x25519-dalek+zeroize-devel}"
SRC_URI[aarch64_rust-x25519-dalek+zeroize-devel.sha256sum] = "8143a60832984c500f53c62c19ecba923e82b99275b4e09e41e33d81c489be03"

URI_aarch64_rust-x25519-dalek-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x25519-dalek-devel-2.0.1-4.el10_2.noarch.rpm;name=aarch64_rust-x25519-dalek-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x25519-dalek-devel}"
SRC_URI[aarch64_rust-x25519-dalek-devel.sha256sum] = "2f40febfca40bba89ce1d6ce18a04ce3b6f770255f86d59f739a58da3fc16600"

RDEPENDS:rust-x25519-dalek+alloc-devel = " \
 cargo \
 rust-curve25519-dalek+alloc-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-x25519-dalek-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize+zeroize_derive-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-x25519-dalek+default-devel = " \
 cargo \
 rust-x25519-dalek+alloc-devel \
 rust-x25519-dalek+precomputed-tables-devel \
 rust-x25519-dalek+zeroize-devel \
 rust-x25519-dalek-devel \
 "
RDEPENDS:rust-x25519-dalek+getrandom-devel = " \
 cargo \
 rust-rand_core0.6+getrandom-devel \
 rust-x25519-dalek-devel \
 "
RDEPENDS:rust-x25519-dalek+precomputed-tables-devel = " \
 cargo \
 rust-curve25519-dalek+precomputed-tables-devel \
 rust-x25519-dalek-devel \
 "
RDEPENDS:rust-x25519-dalek+reusable_secrets-devel = " \
 cargo \
 rust-x25519-dalek-devel \
 "
RDEPENDS:rust-x25519-dalek+serde-devel = " \
 cargo \
 rust-curve25519-dalek+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-x25519-dalek-devel \
 "
RDEPENDS:rust-x25519-dalek+static_secrets-devel = " \
 cargo \
 rust-x25519-dalek-devel \
 "
RDEPENDS:rust-x25519-dalek+zeroize-devel = " \
 cargo \
 rust-curve25519-dalek+zeroize-devel \
 rust-x25519-dalek-devel \
 rust-zeroize+zeroize_derive-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-x25519-dalek-devel = " \
 cargo \
 rust \
 rust-curve25519-dalek-devel \
 rust-rand_core0.6-devel \
 "
