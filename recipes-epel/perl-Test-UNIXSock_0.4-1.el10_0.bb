# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-UNIXSock"
PV = "0.4"
PR = "1.el10_0"
PACKAGES = " \
 perl-Test-UNIXSock \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-UNIXSock-0.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "519c0a85ac7318fddb5b736d93e2bc01ebe579c6cedf49fd6fa5b1e31a4b5efa"

URI_x86_64_v2_perl-Test-UNIXSock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-UNIXSock-0.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-UNIXSock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-UNIXSock}"
SRC_URI[x86_64_v2_perl-Test-UNIXSock.sha256sum] = "6993782f3115c095af7e02c722e35775098469924908f9a53ebeed9599acd4af"

URI_aarch64_perl-Test-UNIXSock = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-UNIXSock-0.4-1.el10_0.noarch.rpm;name=aarch64_perl-Test-UNIXSock;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-UNIXSock}"
SRC_URI[aarch64_perl-Test-UNIXSock.sha256sum] = "2bc70c68cf0dfcb1eb634e716ed6efeb565fd614a67170c134f5a3bc6909c0ea"

RDEPENDS:perl-Test-UNIXSock = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Temp \
 perl-IO \
 perl-POSIX \
 perl-Test-SharedFork \
 perl-Test-Simple \
 perl-Test-TCP \
 perl-Time-HiRes \
 perl-base \
 perl-libs \
 "
