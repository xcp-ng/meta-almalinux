# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-time-macros"
PV = "0.2.22"
PR = "1.el10_1"
PACKAGES = " \
 rust-time-macros+default-devel \
 rust-time-macros+formatting-devel \
 rust-time-macros+large-dates-devel \
 rust-time-macros+parsing-devel \
 rust-time-macros+serde-devel \
 rust-time-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-time-macros-0.2.22-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5de62b567b58bd41830ce17ef57384d01dddd96daee32f268273d5c9f57975bf"

URI_x86_64_v2_rust-time-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros+default-devel-0.2.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros+default-devel}"
SRC_URI[x86_64_v2_rust-time-macros+default-devel.sha256sum] = "d9b15ace04d813237f234bab3654e484473915db4b2b83b973bb7d22ae33d944"

URI_x86_64_v2_rust-time-macros+formatting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros+formatting-devel-0.2.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros+formatting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros+formatting-devel}"
SRC_URI[x86_64_v2_rust-time-macros+formatting-devel.sha256sum] = "2f15d71f05dc369d8165e5333b1fc4f32725231477524884ce4d334c8f8c8b10"

URI_x86_64_v2_rust-time-macros+large-dates-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros+large-dates-devel-0.2.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros+large-dates-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros+large-dates-devel}"
SRC_URI[x86_64_v2_rust-time-macros+large-dates-devel.sha256sum] = "fbe3fcb6dbdfe09bb651a486d78e0c2ea25c9a7d0090d177ad202af15b91d831"

URI_x86_64_v2_rust-time-macros+parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros+parsing-devel-0.2.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros+parsing-devel}"
SRC_URI[x86_64_v2_rust-time-macros+parsing-devel.sha256sum] = "3f0337d64e484e46d2a834dd8bb241dafcaa5c1a1082857fe2ada6917b04b87e"

URI_x86_64_v2_rust-time-macros+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros+serde-devel-0.2.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros+serde-devel}"
SRC_URI[x86_64_v2_rust-time-macros+serde-devel.sha256sum] = "1d3b064207ec3e7e8a8689814c475c4cad5cd904ce9b157a2ca15f3aafea1fb9"

URI_x86_64_v2_rust-time-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros-devel-0.2.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros-devel}"
SRC_URI[x86_64_v2_rust-time-macros-devel.sha256sum] = "24fcb5bc24c9b4c2acd9de6acf184053c9897a3720e869e08e3ec13338bec68a"

URI_aarch64_rust-time-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros+default-devel-0.2.22-1.el10_1.noarch.rpm;name=aarch64_rust-time-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros+default-devel}"
SRC_URI[aarch64_rust-time-macros+default-devel.sha256sum] = "98d16c24cf15792438a531ff6403380bc5aebb503af01bf213605fd486489ed9"

URI_aarch64_rust-time-macros+formatting-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros+formatting-devel-0.2.22-1.el10_1.noarch.rpm;name=aarch64_rust-time-macros+formatting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros+formatting-devel}"
SRC_URI[aarch64_rust-time-macros+formatting-devel.sha256sum] = "a0720fae79f8408e9e22d8b5a00f9378c26cc49c125b21d9fabb4206810e8d9d"

URI_aarch64_rust-time-macros+large-dates-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros+large-dates-devel-0.2.22-1.el10_1.noarch.rpm;name=aarch64_rust-time-macros+large-dates-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros+large-dates-devel}"
SRC_URI[aarch64_rust-time-macros+large-dates-devel.sha256sum] = "13aed83cfedbd878a106e8cd4a5f95b544cd644540c0e35c2ee412fc1b7b1610"

URI_aarch64_rust-time-macros+parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros+parsing-devel-0.2.22-1.el10_1.noarch.rpm;name=aarch64_rust-time-macros+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros+parsing-devel}"
SRC_URI[aarch64_rust-time-macros+parsing-devel.sha256sum] = "c02a4c1cd23b50191bb2be0dcf1eb368a1b516dc860aa6ef6c9486f2a16803f0"

URI_aarch64_rust-time-macros+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros+serde-devel-0.2.22-1.el10_1.noarch.rpm;name=aarch64_rust-time-macros+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros+serde-devel}"
SRC_URI[aarch64_rust-time-macros+serde-devel.sha256sum] = "e4e503a08e5e0fac8bf7a1e326b7e064bfcb5f00d84567a0d3db19a4bdb5e150"

URI_aarch64_rust-time-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros-devel-0.2.22-1.el10_1.noarch.rpm;name=aarch64_rust-time-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros-devel}"
SRC_URI[aarch64_rust-time-macros-devel.sha256sum] = "7321142b7b9a56dd2b63486d1808ff5571d5b8f4786a6f98e5f0337c4c460b61"

RDEPENDS:rust-time-macros+default-devel = " \
 cargo \
 rust-time-macros-devel \
 "
RDEPENDS:rust-time-macros+formatting-devel = " \
 cargo \
 rust-time-macros-devel \
 "
RDEPENDS:rust-time-macros+large-dates-devel = " \
 cargo \
 rust-time-macros-devel \
 "
RDEPENDS:rust-time-macros+parsing-devel = " \
 cargo \
 rust-time-macros-devel \
 "
RDEPENDS:rust-time-macros+serde-devel = " \
 cargo \
 rust-time-macros-devel \
 "
RDEPENDS:rust-time-macros-devel = " \
 cargo \
 rust \
 rust-num-conv+default-devel \
 rust-time-core+default-devel \
 "
