# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xorg-x11-xinit"
PV = "1.4.3"
PR = "1.el10_1"
PACKAGES = " \
 xorg-x11-xinit \
 xorg-x11-xinit-session \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xorg-x11-xinit-1.4.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a991b9ba79138861f00468ade44f914a7e17403135dde1a0e86ef65369aa5a9d"

URI_x86_64_v2_xorg-x11-xinit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xorg-x11-xinit-1.4.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xorg-x11-xinit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-xinit}"
SRC_URI[x86_64_v2_xorg-x11-xinit.sha256sum] = "8aa0094ad4f89b7a0dc312c522fe659260e2e41cfb613efa34d4adbb910e1ec8"

URI_x86_64_v2_xorg-x11-xinit-session = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xorg-x11-xinit-session-1.4.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xorg-x11-xinit-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-xinit-session}"
SRC_URI[x86_64_v2_xorg-x11-xinit-session.sha256sum] = "e9a42b538c44d4256f895b1162e53d0e5447021c988f55811a3fd0abc5665587"

URI_aarch64_xorg-x11-xinit = "${EPEL_MIRROR}/aarch64/Packages/x/xorg-x11-xinit-1.4.3-1.el10_1.aarch64.rpm;name=aarch64_xorg-x11-xinit;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-xinit}"
SRC_URI[aarch64_xorg-x11-xinit.sha256sum] = "7d90689327eb8cc5c4c909db3d60ca6e0c0b9990c6e0728e7f2544a47d0b6398"

URI_aarch64_xorg-x11-xinit-session = "${EPEL_MIRROR}/aarch64/Packages/x/xorg-x11-xinit-session-1.4.3-1.el10_1.aarch64.rpm;name=aarch64_xorg-x11-xinit-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-xinit-session}"
SRC_URI[aarch64_xorg-x11-xinit-session.sha256sum] = "e62262c74c165cff323e4348947f4998ac3638119e21b7077b1511e76688be8c"

RDEPENDS:xorg-x11-xinit = " \
 bash \
 glibc \
 libX11 \
 setxkbmap \
 virtual/coreutils \
 xhost \
 xmodmap \
 xorg-x11-xauth \
 xrdb \
 "
RDEPENDS:xorg-x11-xinit-session = " \
 bash \
 "
