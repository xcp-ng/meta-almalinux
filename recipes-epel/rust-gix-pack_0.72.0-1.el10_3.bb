# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-pack"
PV = "0.72.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-pack+default-devel \
 rust-gix-pack+document-features-devel \
 rust-gix-pack+generate-devel \
 rust-gix-pack+object-cache-dynamic-devel \
 rust-gix-pack+pack-cache-lru-dynamic-devel \
 rust-gix-pack+pack-cache-lru-static-devel \
 rust-gix-pack+parallel-devel \
 rust-gix-pack+serde-devel \
 rust-gix-pack+sha1-devel \
 rust-gix-pack+sha256-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-pack-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-pack-0.72.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20a3cfe0c92d76b7d0b459600ebb454096cd2e02adcce228d498ffc3b385392e"

URI_x86_64_v2_rust-gix-pack+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+default-devel-0.72.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+default-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+default-devel.sha256sum] = "adeec4a35ad818180b2392f260d6284fd763247cc7d30b6dd6c3ae57074ad212"

URI_x86_64_v2_rust-gix-pack+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+document-features-devel-0.72.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+document-features-devel.sha256sum] = "01390473d382ec261ca4f5d456f8197a4f2d90aa6e4537de7d1480cbb36ac820"

URI_x86_64_v2_rust-gix-pack+generate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+generate-devel-0.72.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+generate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+generate-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+generate-devel.sha256sum] = "9383a5d3072a000e56fdd247f7cb45048667ee3182ec84d99ee4702613be8906"

URI_x86_64_v2_rust-gix-pack+object-cache-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+object-cache-dynamic-devel-0.72.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+object-cache-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+object-cache-dynamic-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+object-cache-dynamic-devel.sha256sum] = "ff240afea9662d55a3b97f98cad2b74a5986118eaac9cc0957076a08b2a08457"

URI_x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+pack-cache-lru-dynamic-devel-0.72.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel.sha256sum] = "677f1eb54f5fdd04f9b49b96b67094f36842c4be75f102b474afb53c8b7440d9"

URI_x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+pack-cache-lru-static-devel-0.72.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel.sha256sum] = "9f00210b3fc3292fe1685bf01c7f1f4e31975e796294323489f3477752befa5a"

URI_x86_64_v2_rust-gix-pack+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+parallel-devel-0.72.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+parallel-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+parallel-devel.sha256sum] = "1a8db2e92aa01fee709caf837f9a1fab91dc3c606d22375feac0e564b36a45d9"

URI_x86_64_v2_rust-gix-pack+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+serde-devel-0.72.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+serde-devel.sha256sum] = "48e85b666119524f3e9d0df54acbe98151b9c419342d2cb756f0879323e4772d"

URI_x86_64_v2_rust-gix-pack+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+sha1-devel-0.72.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+sha1-devel.sha256sum] = "157034e6853ad8b2b914368eb90d82850544d573ee77126a1edbaf26d70d87e6"

URI_x86_64_v2_rust-gix-pack+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+sha256-devel-0.72.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+sha256-devel.sha256sum] = "49233e80ef439b7dbf8b27336121f525feccff633a457b3341686496e672b33f"

URI_x86_64_v2_rust-gix-pack+streaming-input-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+streaming-input-devel-0.72.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+streaming-input-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+streaming-input-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+streaming-input-devel.sha256sum] = "20a6fa7807dcb8849aa8c7a2139be97cb77c7ea4db7f95950b5f88cc28e30e5c"

URI_x86_64_v2_rust-gix-pack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack-devel-0.72.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack-devel}"
SRC_URI[x86_64_v2_rust-gix-pack-devel.sha256sum] = "eda7dace593ebebee1786a4f9d6c6a04947b20ada5e112b17a72f04261480429"

URI_aarch64_rust-gix-pack+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+default-devel-0.72.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-pack+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+default-devel}"
SRC_URI[aarch64_rust-gix-pack+default-devel.sha256sum] = "ca4749c0b1082824522c8b820beba138ba8ceb3cb47b6966e26d1db36ef9c2d6"

URI_aarch64_rust-gix-pack+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+document-features-devel-0.72.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-pack+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+document-features-devel}"
SRC_URI[aarch64_rust-gix-pack+document-features-devel.sha256sum] = "512e79422298e4fba0cfd94cc0914861cb9aed03beb5458ca38dd77fa3c6a1b1"

URI_aarch64_rust-gix-pack+generate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+generate-devel-0.72.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-pack+generate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+generate-devel}"
SRC_URI[aarch64_rust-gix-pack+generate-devel.sha256sum] = "82b6d4f971f6955c20f4cfbb3b756a97062b8e607d1b4ba60bf07bec77de5c82"

URI_aarch64_rust-gix-pack+object-cache-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+object-cache-dynamic-devel-0.72.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-pack+object-cache-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+object-cache-dynamic-devel}"
SRC_URI[aarch64_rust-gix-pack+object-cache-dynamic-devel.sha256sum] = "77e8cdf4d76b62622effdd3fcd0dc19441f526e500b57044dd2d0f89cc7b29fa"

URI_aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+pack-cache-lru-dynamic-devel-0.72.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel}"
SRC_URI[aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel.sha256sum] = "cdaa5e48e442599479e84a258537d186e429107ad7a787d4eced4e3c404b7467"

URI_aarch64_rust-gix-pack+pack-cache-lru-static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+pack-cache-lru-static-devel-0.72.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-pack+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+pack-cache-lru-static-devel}"
SRC_URI[aarch64_rust-gix-pack+pack-cache-lru-static-devel.sha256sum] = "85d33d194ba83f769bd7728c67b552d7ffe22af5495798b2c35e26a6395c39ea"

URI_aarch64_rust-gix-pack+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+parallel-devel-0.72.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-pack+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+parallel-devel}"
SRC_URI[aarch64_rust-gix-pack+parallel-devel.sha256sum] = "14fe7cd8508d845a02c79b42ad786f41fadd45c9a498d0de7eb437c5e839545c"

URI_aarch64_rust-gix-pack+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+serde-devel-0.72.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-pack+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+serde-devel}"
SRC_URI[aarch64_rust-gix-pack+serde-devel.sha256sum] = "29dd2aeeaf91eec252eb9dcf840445a44b9665e09047f75692639dbd4e068012"

URI_aarch64_rust-gix-pack+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+sha1-devel-0.72.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-pack+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+sha1-devel}"
SRC_URI[aarch64_rust-gix-pack+sha1-devel.sha256sum] = "f15ecc91c73dd69e64a709e6cbc3e3f04796056959b3c33ee9674319a7603986"

URI_aarch64_rust-gix-pack+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+sha256-devel-0.72.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-pack+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+sha256-devel}"
SRC_URI[aarch64_rust-gix-pack+sha256-devel.sha256sum] = "0bca9fb908758bd21175f2be0e5682b241490832803bde8d389a2bdcf21f9368"

URI_aarch64_rust-gix-pack+streaming-input-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+streaming-input-devel-0.72.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-pack+streaming-input-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+streaming-input-devel}"
SRC_URI[aarch64_rust-gix-pack+streaming-input-devel.sha256sum] = "d8a3f869d0bfb1a00b0415d21e9d3c28c6662ae466902474510f3b3ea36886a8"

URI_aarch64_rust-gix-pack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack-devel-0.72.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-pack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack-devel}"
SRC_URI[aarch64_rust-gix-pack-devel.sha256sum] = "4f9fd57f63e18f48abf3d81679e3c992b92f83094253e7f614b7a67ea7038477"

RDEPENDS:rust-gix-pack+default-devel = " \
 cargo \
 rust-gix-pack+generate-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+generate-devel = " \
 cargo \
 rust-gix-diff-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-pack-devel \
 rust-gix-traverse+default-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-gix-pack+object-cache-dynamic-devel = " \
 cargo \
 rust-clru+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+pack-cache-lru-dynamic-devel = " \
 cargo \
 rust-clru+default-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+pack-cache-lru-static-devel = " \
 cargo \
 rust-gix-pack-devel \
 rust-uluru+default-devel \
 "
RDEPENDS:rust-gix-pack+parallel-devel = " \
 cargo \
 rust-gix-features+parallel-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+serde-devel = " \
 cargo \
 rust-gix-object+serde-devel \
 rust-gix-pack-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-pack+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+streaming-input-devel = " \
 cargo \
 rust-gix-pack-devel \
 rust-gix-tempfile-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-gix-pack-devel = " \
 cargo \
 rust \
 rust-gix-chunk+default-devel \
 rust-gix-error+default-devel \
 rust-gix-features+crc32-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-features+zlib-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-memmap2+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
