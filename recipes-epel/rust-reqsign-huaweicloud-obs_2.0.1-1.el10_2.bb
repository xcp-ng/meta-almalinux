# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-huaweicloud-obs"
PV = "2.0.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqsign-huaweicloud-obs+default-devel \
 rust-reqsign-huaweicloud-obs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-huaweicloud-obs-2.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "870ac3d0953459a6c0d90639f2e44b9c34690fbb7a6efadc7b86e572d0059ed2"

URI_x86_64_v2_rust-reqsign-huaweicloud-obs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-huaweicloud-obs+default-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-huaweicloud-obs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-huaweicloud-obs+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-huaweicloud-obs+default-devel.sha256sum] = "8e44184b6d3bd12f4d4f79e759f0aacdab3e0b350832c5bd004615b5f4d2373d"

URI_x86_64_v2_rust-reqsign-huaweicloud-obs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-huaweicloud-obs-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-huaweicloud-obs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-huaweicloud-obs-devel}"
SRC_URI[x86_64_v2_rust-reqsign-huaweicloud-obs-devel.sha256sum] = "be122213a1f9abf6d00af2427afcdba29bbc4cce7034f6c34ec3f01d0a568789"

URI_aarch64_rust-reqsign-huaweicloud-obs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-huaweicloud-obs+default-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-huaweicloud-obs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-huaweicloud-obs+default-devel}"
SRC_URI[aarch64_rust-reqsign-huaweicloud-obs+default-devel.sha256sum] = "241bd6840616fc8c727e5b2642e1cb9c1449361cb564260300f15fddee390285"

URI_aarch64_rust-reqsign-huaweicloud-obs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-huaweicloud-obs-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-huaweicloud-obs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-huaweicloud-obs-devel}"
SRC_URI[aarch64_rust-reqsign-huaweicloud-obs-devel.sha256sum] = "13f42b086251840f50ca646e73bc027d7a50496f1e27f4469809e79974507eda"

RDEPENDS:rust-reqsign-huaweicloud-obs+default-devel = " \
 cargo \
 rust-reqsign-huaweicloud-obs-devel \
 "
RDEPENDS:rust-reqsign-huaweicloud-obs-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 "
