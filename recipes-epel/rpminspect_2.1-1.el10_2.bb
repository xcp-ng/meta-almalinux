# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpminspect"
PV = "2.1"
PR = "1.el10_2"
PACKAGES = " \
 librpminspect \
 librpminspect-devel \
 rpminspect \
 rpminspect-data-generic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rpminspect-2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50d9bae107c2145e5625ff9489d30768beb3917b93ddca21ae3988227443e1b6"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - librpminspect: libcap.so.2()(64bit)

URI_x86_64_v2_librpminspect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librpminspect-2.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librpminspect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librpminspect}"
SRC_URI[x86_64_v2_librpminspect.sha256sum] = "3edb4a1fc568ce5d7966c67872a0fdcd07bf8e75e2495cafe943065874a85eb8"

URI_x86_64_v2_librpminspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librpminspect-devel-2.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librpminspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librpminspect-devel}"
SRC_URI[x86_64_v2_librpminspect-devel.sha256sum] = "7a59662cc5522b699067f6a8d5ed552f1094e73dbd3afb59a2a0ab7030bf6f4f"

URI_x86_64_v2_rpminspect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpminspect-2.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rpminspect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpminspect}"
SRC_URI[x86_64_v2_rpminspect.sha256sum] = "3a14c109cc871f5021e5d7ac6563d1692b11b2626600bc4a90ff8483955f8ec0"

URI_x86_64_v2_rpminspect-data-generic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpminspect-data-generic-2.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rpminspect-data-generic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpminspect-data-generic}"
SRC_URI[x86_64_v2_rpminspect-data-generic.sha256sum] = "5398d802d42d184ee7e008775062a517bf9741c99d40ff96623ec51ec32aeba0"

URI_aarch64_librpminspect = "${EPEL_MIRROR}/aarch64/Packages/l/librpminspect-2.1-1.el10_2.aarch64.rpm;name=aarch64_librpminspect;unpack=0"
SRC_URI:append = " ${URI_aarch64_librpminspect}"
SRC_URI[aarch64_librpminspect.sha256sum] = "f39945c2e4f4f81686cacac3fa618a16915db0ac329e04c30d8d3daba2986aa3"

URI_aarch64_librpminspect-devel = "${EPEL_MIRROR}/aarch64/Packages/l/librpminspect-devel-2.1-1.el10_2.aarch64.rpm;name=aarch64_librpminspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librpminspect-devel}"
SRC_URI[aarch64_librpminspect-devel.sha256sum] = "303101391bdc3469d54a45e5b8751d3bafa8ccc3bf0726ee11a58befd69b107a"

URI_aarch64_rpminspect = "${EPEL_MIRROR}/aarch64/Packages/r/rpminspect-2.1-1.el10_2.aarch64.rpm;name=aarch64_rpminspect;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpminspect}"
SRC_URI[aarch64_rpminspect.sha256sum] = "2eb415700175b14fae1d1b8c6454e59ce18bbd660f294a3bfd2d22ec6e00a1cd"

URI_aarch64_rpminspect-data-generic = "${EPEL_MIRROR}/aarch64/Packages/r/rpminspect-data-generic-2.1-1.el10_2.aarch64.rpm;name=aarch64_rpminspect-data-generic;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpminspect-data-generic}"
SRC_URI[aarch64_rpminspect-data-generic.sha256sum] = "d86d0bb1cb5918b721df272e56a43e9143ea5d0abb17b9c180f8d614f5e67db2"

RDEPENDS:librpminspect:x86_64_v2 = " \
 clamav-lib \
 desktop-file-utils \
 elfutils-libelf \
 file-libs \
 gettext \
 glibc \
 json-c \
 kmod-libs \
 libarchive \
 libcap \
 libcdson \
 libicu \
 libxml2 \
 libyaml \
 openssl-libs \
 rpm-build-libs \
 rpm-libs \
 virtual/libcurl.so.4___64bit_ \
 xmlrpc-c \
 xmlrpc-c-client \
 zlib-ng-compat \
"
RDEPENDS:librpminspect:aarch64 = " \
 clamav-lib \
 desktop-file-utils \
 elfutils-libelf \
 file-libs \
 gettext \
 glibc \
 json-c \
 kmod-libs \
 libarchive \
 libcdson \
 libicu \
 libxml2 \
 libyaml \
 openssl-libs \
 rpm-build-libs \
 rpm-libs \
 virtual/libcurl.so.4___64bit_ \
 xmlrpc-c \
 xmlrpc-c-client \
 zlib-ng-compat \
"
RDEPENDS:librpminspect-devel = " \
 librpminspect \
 "
RDEPENDS:rpminspect = " \
 glibc \
 librpminspect \
 rpm-libs \
 "
RDEPENDS:rpminspect-data-generic = " \
 "
