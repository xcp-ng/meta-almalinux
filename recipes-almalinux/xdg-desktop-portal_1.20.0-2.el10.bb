# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-desktop-portal"
PV = "1.20.0"
PR = "2.el10"
PACKAGES = " \
 xdg-desktop-portal \
 xdg-desktop-portal-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xdg-desktop-portal-1.20.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7e258c2ea654d97eb9ae6e547cb40e989bf7930a850a4f8a1bdaf7b5afe9406"

URI_x86_64_v2_xdg-desktop-portal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xdg-desktop-portal-1.20.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_xdg-desktop-portal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-desktop-portal}"
SRC_URI[x86_64_v2_xdg-desktop-portal.sha256sum] = "77ce12ed213e63a1da518a1399e6bd63176b308c229acb9246442927771d4707"

URI_x86_64_v2_xdg-desktop-portal-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xdg-desktop-portal-devel-1.20.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_xdg-desktop-portal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-desktop-portal-devel}"
SRC_URI[x86_64_v2_xdg-desktop-portal-devel.sha256sum] = "62c224f07830388fc61bcecee8b03695e1dcaf739ce948e97a7152fc6955eb61"

URI_aarch64_xdg-desktop-portal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xdg-desktop-portal-1.20.0-2.el10.aarch64.rpm;name=aarch64_xdg-desktop-portal;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-desktop-portal}"
SRC_URI[aarch64_xdg-desktop-portal.sha256sum] = "a435704d4c56b8388eb8842282100129729053c82d32d7219851efd12a657a23"

URI_aarch64_xdg-desktop-portal-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xdg-desktop-portal-devel-1.20.0-2.el10.aarch64.rpm;name=aarch64_xdg-desktop-portal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-desktop-portal-devel}"
SRC_URI[aarch64_xdg-desktop-portal-devel.sha256sum] = "b4b3ebabf5769bdacc22d0b4b23085e9a60f9fc93e6e065fd9698b00d81b8ec6"

RDEPENDS:xdg-desktop-portal = " \
 bash \
 dbus \
 fuse3 \
 fuse3-libs \
 gdk-pixbuf2 \
 geoclue2 \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 json-glib \
 libdex \
 libgcc \
 libgudev \
 libportal \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:xdg-desktop-portal-devel = " \
 pkgconf-pkg-config \
 xdg-desktop-portal \
 "
