# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plymouth-kcm"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plymouth-kcm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plymouth-kcm-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9fc74ece4b136334ad000b4a1072290232842ca8a4c294904f0491fe2fdd9dd"

URI_x86_64_v2_plymouth-kcm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plymouth-kcm-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plymouth-kcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-kcm}"
SRC_URI[x86_64_v2_plymouth-kcm.sha256sum] = "61f2a9c57554d2c1daa69121d1a89c6b1e7fd6ca73216af83eef1ab4c51d4430"

URI_aarch64_plymouth-kcm = "${EPEL_MIRROR}/aarch64/Packages/p/plymouth-kcm-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plymouth-kcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-kcm}"
SRC_URI[aarch64_plymouth-kcm.sha256sum] = "ce74243eb0dd12cddea64a47f3b1876dcf12b1bc83cc1df7fa0410481a42ed9a"

RDEPENDS:plymouth-kcm = " \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-knewstuff \
 libstdc++ \
 plymouth \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
