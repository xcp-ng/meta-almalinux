# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "f43-backgrounds"
PV = "43.0.1"
PR = "2.el10_1"
PACKAGES = " \
 f43-backgrounds \
 f43-backgrounds-base \
 f43-backgrounds-budgie \
 f43-backgrounds-gnome \
 f43-backgrounds-kde \
 f43-backgrounds-mate \
 f43-backgrounds-xfce \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/f43-backgrounds-43.0.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88937a46de32d1f17e8b319fc1d8006d765a0c4da846178df7f92b00372ac08f"

URI_x86_64_v2_f43-backgrounds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f43-backgrounds-43.0.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_f43-backgrounds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f43-backgrounds}"
SRC_URI[x86_64_v2_f43-backgrounds.sha256sum] = "846109d79d765dd451ccad0628aad4eb88e7c041135fafe09f3915dd81006ba4"

URI_x86_64_v2_f43-backgrounds-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f43-backgrounds-base-43.0.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_f43-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f43-backgrounds-base}"
SRC_URI[x86_64_v2_f43-backgrounds-base.sha256sum] = "fff5d23e29ec0e330b89d44a445b175d5070f1429680b82560cef5280d1135a8"

URI_x86_64_v2_f43-backgrounds-budgie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f43-backgrounds-budgie-43.0.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_f43-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f43-backgrounds-budgie}"
SRC_URI[x86_64_v2_f43-backgrounds-budgie.sha256sum] = "8d1d0e86581b3e5f5c42ad75fb2e2e5f2237311504a478f85e0480abca05c939"

URI_x86_64_v2_f43-backgrounds-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f43-backgrounds-gnome-43.0.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_f43-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f43-backgrounds-gnome}"
SRC_URI[x86_64_v2_f43-backgrounds-gnome.sha256sum] = "cb0849035f8c26c779b936fd325fa13ff5f415e44d5ae05bd55e2ec05e89fb51"

URI_x86_64_v2_f43-backgrounds-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f43-backgrounds-kde-43.0.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_f43-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f43-backgrounds-kde}"
SRC_URI[x86_64_v2_f43-backgrounds-kde.sha256sum] = "5244310473d133b76a0eda8865739da7f19cf47683064726a9be5e869c6cd0b5"

URI_x86_64_v2_f43-backgrounds-mate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f43-backgrounds-mate-43.0.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_f43-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f43-backgrounds-mate}"
SRC_URI[x86_64_v2_f43-backgrounds-mate.sha256sum] = "90beab94cf4909f620435e367aa804ac6a0236120b7c7b84b36cd915e23e15a3"

URI_x86_64_v2_f43-backgrounds-xfce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f43-backgrounds-xfce-43.0.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_f43-backgrounds-xfce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f43-backgrounds-xfce}"
SRC_URI[x86_64_v2_f43-backgrounds-xfce.sha256sum] = "fc2b4f80c4c1dfd625953f2dfd781c7874757092a1a6f5fc99c672ed82acf6e2"

URI_aarch64_f43-backgrounds = "${EPEL_MIRROR}/aarch64/Packages/f/f43-backgrounds-43.0.1-2.el10_1.noarch.rpm;name=aarch64_f43-backgrounds;unpack=0"
SRC_URI:append = " ${URI_aarch64_f43-backgrounds}"
SRC_URI[aarch64_f43-backgrounds.sha256sum] = "2fec3fe4b174ffdf6cc77a48b70314871aedf31d3466affe81d3fe5f8ad22ee5"

URI_aarch64_f43-backgrounds-base = "${EPEL_MIRROR}/aarch64/Packages/f/f43-backgrounds-base-43.0.1-2.el10_1.noarch.rpm;name=aarch64_f43-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_f43-backgrounds-base}"
SRC_URI[aarch64_f43-backgrounds-base.sha256sum] = "a05d96809b217819b35b9687a4578e74590401322d4ff631bca42ebf2fc1bc21"

URI_aarch64_f43-backgrounds-budgie = "${EPEL_MIRROR}/aarch64/Packages/f/f43-backgrounds-budgie-43.0.1-2.el10_1.noarch.rpm;name=aarch64_f43-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_aarch64_f43-backgrounds-budgie}"
SRC_URI[aarch64_f43-backgrounds-budgie.sha256sum] = "5790ad309531de78f8cfb52f2f89b1ee7abdf7fc1e56e71145283db559dcbd8b"

URI_aarch64_f43-backgrounds-gnome = "${EPEL_MIRROR}/aarch64/Packages/f/f43-backgrounds-gnome-43.0.1-2.el10_1.noarch.rpm;name=aarch64_f43-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_f43-backgrounds-gnome}"
SRC_URI[aarch64_f43-backgrounds-gnome.sha256sum] = "70c09085184f583cad2c592fca56b4fa2caa0578ca543a3ecb25050907c098d9"

URI_aarch64_f43-backgrounds-kde = "${EPEL_MIRROR}/aarch64/Packages/f/f43-backgrounds-kde-43.0.1-2.el10_1.noarch.rpm;name=aarch64_f43-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_f43-backgrounds-kde}"
SRC_URI[aarch64_f43-backgrounds-kde.sha256sum] = "f1f147cfcf87bd8f2a2e35e2ef04fc713baf770e89e7ed8d29ceddf3ae0100ca"

URI_aarch64_f43-backgrounds-mate = "${EPEL_MIRROR}/aarch64/Packages/f/f43-backgrounds-mate-43.0.1-2.el10_1.noarch.rpm;name=aarch64_f43-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_aarch64_f43-backgrounds-mate}"
SRC_URI[aarch64_f43-backgrounds-mate.sha256sum] = "21642676548825ef6e00f552cef7e079397a28df82af502ad8494a75a3ef4888"

URI_aarch64_f43-backgrounds-xfce = "${EPEL_MIRROR}/aarch64/Packages/f/f43-backgrounds-xfce-43.0.1-2.el10_1.noarch.rpm;name=aarch64_f43-backgrounds-xfce;unpack=0"
SRC_URI:append = " ${URI_aarch64_f43-backgrounds-xfce}"
SRC_URI[aarch64_f43-backgrounds-xfce.sha256sum] = "fffba05121b342570a45564b7811ad2f3125befb3f9f89bed09416438bc98e88"

RDEPENDS:f43-backgrounds = " \
 f43-backgrounds-budgie \
 f43-backgrounds-gnome \
 f43-backgrounds-kde \
 f43-backgrounds-mate \
 f43-backgrounds-xfce \
 "
RDEPENDS:f43-backgrounds-base = " \
 jxl-pixbuf-loader \
 kf6-kimageformats \
 "
RDEPENDS:f43-backgrounds-budgie = " \
 f43-backgrounds-base \
 "
RDEPENDS:f43-backgrounds-gnome = " \
 f43-backgrounds-base \
 "
RDEPENDS:f43-backgrounds-kde = " \
 f43-backgrounds-base \
 kde-filesystem \
 "
RDEPENDS:f43-backgrounds-mate = " \
 f43-backgrounds-base \
 "
RDEPENDS:f43-backgrounds-xfce = " \
 f43-backgrounds-base \
 "
