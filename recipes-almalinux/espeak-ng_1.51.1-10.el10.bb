# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "espeak-ng"
PV = "1.51.1"
PR = "10.el10"
PACKAGES = " \
 espeak-ng \
 espeak-ng-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/espeak-ng-1.51.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3c9c77e407cfffddd3c267682cb400ddb67921e65f5e0d55f816e8b3fd1eb8d"

URI_x86_64_v2_espeak-ng = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/espeak-ng-1.51.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_espeak-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_espeak-ng}"
SRC_URI[x86_64_v2_espeak-ng.sha256sum] = "ec21f6ca495e3c28ebf078f95068c4304fc2950ed4c560cbd05b0eecef7ad992"

URI_x86_64_v2_espeak-ng-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/espeak-ng-devel-1.51.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_espeak-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_espeak-ng-devel}"
SRC_URI[x86_64_v2_espeak-ng-devel.sha256sum] = "565fa28bc7d41857bfc2dce9a5ffba57a5d246af285fc73663a0ae679b790765"

URI_aarch64_espeak-ng = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/espeak-ng-1.51.1-10.el10.aarch64.rpm;name=aarch64_espeak-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_espeak-ng}"
SRC_URI[aarch64_espeak-ng.sha256sum] = "c43551688e7115a297e6341ca712f176e680305803d3be300b59c5f58e3cb483"

URI_aarch64_espeak-ng-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/espeak-ng-devel-1.51.1-10.el10.aarch64.rpm;name=aarch64_espeak-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_espeak-ng-devel}"
SRC_URI[aarch64_espeak-ng-devel.sha256sum] = "0e936999c42655e9fbc76b1b3b665eb68e08298f494c70d5472d3e7ac67a86ff"

RDEPENDS:espeak-ng = " \
 glibc \
 libgcc \
 libstdc++ \
 pcaudiolib \
 "
RDEPENDS:espeak-ng-devel = " \
 espeak-ng \
 pkgconf-pkg-config \
 "
