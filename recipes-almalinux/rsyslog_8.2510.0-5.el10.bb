# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rsyslog"
PV = "8.2510.0"
PR = "5.el10"
PACKAGES = " \
 rsyslog \
 rsyslog-crypto \
 rsyslog-doc \
 rsyslog-elasticsearch \
 rsyslog-gnutls \
 rsyslog-gssapi \
 rsyslog-kafka \
 rsyslog-mmaudit \
 rsyslog-mmfields \
 rsyslog-mmjsonparse \
 rsyslog-mmkubernetes \
 rsyslog-mmnormalize \
 rsyslog-mmsnmptrapd \
 rsyslog-mysql \
 rsyslog-omamqp1 \
 rsyslog-openssl \
 rsyslog-pgsql \
 rsyslog-relp \
 rsyslog-snmp \
 rsyslog-udpspoof \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rsyslog-8.2510.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48b83245e750b3442ac43d739dd49b33d392c0d94de03e7e8008e11a04e0a5d2"

URI_x86_64_v2_rsyslog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog}"
SRC_URI[x86_64_v2_rsyslog.sha256sum] = "66687e9f0d631ed87cee1dfa8718c36f6b7c7060143ae1ba0f9ef26fb918a8b6"
RPROVIDES:rsyslog:x86_64_v2 = "virtual/syslog"

URI_x86_64_v2_rsyslog-crypto = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-crypto-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-crypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-crypto}"
SRC_URI[x86_64_v2_rsyslog-crypto.sha256sum] = "df7b7ed62cf9cf6260cd4b89c12621336125b2c090a9c9d49a3568e61f20bf34"

URI_x86_64_v2_rsyslog-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-doc-8.2510.0-5.el10.noarch.rpm;name=x86_64_v2_rsyslog-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-doc}"
SRC_URI[x86_64_v2_rsyslog-doc.sha256sum] = "f3abc09b36255c0c44a682e8e8994856b8ee10d883dab2e49280da2076823fda"

URI_x86_64_v2_rsyslog-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-elasticsearch-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-elasticsearch}"
SRC_URI[x86_64_v2_rsyslog-elasticsearch.sha256sum] = "3a26c1ddf02300fe4365ac2888a450f8937c8adb4744c9e800de07242eef5619"

URI_x86_64_v2_rsyslog-gnutls = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-gnutls-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-gnutls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-gnutls}"
SRC_URI[x86_64_v2_rsyslog-gnutls.sha256sum] = "4be1691f53f1aa5690ef3676d2fd8b83b3d454d2bc5a332a1e2088b9d8a03cf3"

URI_x86_64_v2_rsyslog-gssapi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-gssapi-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-gssapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-gssapi}"
SRC_URI[x86_64_v2_rsyslog-gssapi.sha256sum] = "e4aa53b4cb63ec73af64b7482e572bd0a33f3ea69505ecc866b86f3d6551aebf"

URI_x86_64_v2_rsyslog-kafka = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-kafka-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-kafka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-kafka}"
SRC_URI[x86_64_v2_rsyslog-kafka.sha256sum] = "dac7c5c5337040ae74e25bc2aa6f71ec2e8f33bd5bdb52c7fa6bc7ca685795c8"

URI_x86_64_v2_rsyslog-mmaudit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmaudit-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmaudit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmaudit}"
SRC_URI[x86_64_v2_rsyslog-mmaudit.sha256sum] = "9d63869b50afe49e29275e7713abc83e977f1b0231e531ce2153cf4c28100da1"

URI_x86_64_v2_rsyslog-mmfields = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmfields-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmfields;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmfields}"
SRC_URI[x86_64_v2_rsyslog-mmfields.sha256sum] = "95ead7f764e314b4251d12e41d94c1b27dd12420311776f77c90be40a2e2d42c"

URI_x86_64_v2_rsyslog-mmjsonparse = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmjsonparse-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmjsonparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmjsonparse}"
SRC_URI[x86_64_v2_rsyslog-mmjsonparse.sha256sum] = "193bd59141a25ae7a1c60148ed49882ffbcb3e83a8015b8e583cf17003ef4f68"

URI_x86_64_v2_rsyslog-mmkubernetes = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmkubernetes-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmkubernetes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmkubernetes}"
SRC_URI[x86_64_v2_rsyslog-mmkubernetes.sha256sum] = "35e88d92bf4ebbaa535bb6b0ac3f52646e6ebc7ea0ed295cdd9887c003978520"

URI_x86_64_v2_rsyslog-mmnormalize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmnormalize-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmnormalize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmnormalize}"
SRC_URI[x86_64_v2_rsyslog-mmnormalize.sha256sum] = "f54a5ea6d4d4ad5476704bc23d72513ca3508c9537ef0bf06ebb312cf21f93f5"

URI_x86_64_v2_rsyslog-mmsnmptrapd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmsnmptrapd-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmsnmptrapd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmsnmptrapd}"
SRC_URI[x86_64_v2_rsyslog-mmsnmptrapd.sha256sum] = "69ca4dcde04bf610eede4c29f9f14d620854393cd1f52eef629c488fe09fc10f"

URI_x86_64_v2_rsyslog-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mysql-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mysql}"
SRC_URI[x86_64_v2_rsyslog-mysql.sha256sum] = "d3e2ac93e57d6a9ab0596d657d5b3aeeae55c21463b1e9680bed9bf241e462aa"

URI_x86_64_v2_rsyslog-omamqp1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-omamqp1-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-omamqp1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-omamqp1}"
SRC_URI[x86_64_v2_rsyslog-omamqp1.sha256sum] = "ea6737838e11c5487b93d0c954a838bbd453704ee8d3c26c749c0952428f10fc"

URI_x86_64_v2_rsyslog-openssl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-openssl-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-openssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-openssl}"
SRC_URI[x86_64_v2_rsyslog-openssl.sha256sum] = "7609faf8b53824a2ed06130b427199477e30249ec0d0c51f6de1190ec203ec83"

URI_x86_64_v2_rsyslog-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-pgsql-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-pgsql}"
SRC_URI[x86_64_v2_rsyslog-pgsql.sha256sum] = "259a6fb963154a06191a6c843e1cca8cfcfa899ee2449b6e31657a9ac1e90381"

URI_x86_64_v2_rsyslog-relp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-relp-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-relp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-relp}"
SRC_URI[x86_64_v2_rsyslog-relp.sha256sum] = "b7d2159db58e1f2180aa6610f26cd34b0b7500faf1f452661a031a14a5c3c196"

URI_x86_64_v2_rsyslog-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-snmp-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-snmp}"
SRC_URI[x86_64_v2_rsyslog-snmp.sha256sum] = "de4b17167e7a4971fb8c529146bf45387df0ddea4a77ad5c1719280575e572f6"

URI_x86_64_v2_rsyslog-udpspoof = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-udpspoof-8.2510.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-udpspoof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-udpspoof}"
SRC_URI[x86_64_v2_rsyslog-udpspoof.sha256sum] = "0b1315f2261675b26a7ed72a9c134950b378d508b831b9eea5de9173fef68ae7"

URI_aarch64_rsyslog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog}"
SRC_URI[aarch64_rsyslog.sha256sum] = "49ac461298737fa87b473bb6b87945cce0cbc5a83f685d5042d85ec0ab8e245b"
RPROVIDES:rsyslog:aarch64 = "virtual/syslog"

URI_aarch64_rsyslog-crypto = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-crypto-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-crypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-crypto}"
SRC_URI[aarch64_rsyslog-crypto.sha256sum] = "483e61af5554f32d5e633515607326856da1e36dbace33fa301c379d0d2b70f5"

URI_aarch64_rsyslog-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-doc-8.2510.0-5.el10.noarch.rpm;name=aarch64_rsyslog-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-doc}"
SRC_URI[aarch64_rsyslog-doc.sha256sum] = "f3abc09b36255c0c44a682e8e8994856b8ee10d883dab2e49280da2076823fda"

URI_aarch64_rsyslog-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-elasticsearch-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-elasticsearch}"
SRC_URI[aarch64_rsyslog-elasticsearch.sha256sum] = "f56f16d645c78455dc17c9037727d08273880511f0582f05ce1536eb0f6e6913"

URI_aarch64_rsyslog-gnutls = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-gnutls-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-gnutls;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-gnutls}"
SRC_URI[aarch64_rsyslog-gnutls.sha256sum] = "00e3c414e893bf03594291dca36595f53f2ac2bb7d842bc0cc410fe064bb5326"

URI_aarch64_rsyslog-gssapi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-gssapi-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-gssapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-gssapi}"
SRC_URI[aarch64_rsyslog-gssapi.sha256sum] = "01ea81e4a6a19af413f443f19be39563b50e8ec1df4d5ec283904719be02e100"

URI_aarch64_rsyslog-kafka = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-kafka-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-kafka;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-kafka}"
SRC_URI[aarch64_rsyslog-kafka.sha256sum] = "d1f3b8731eb1442dfbc5df53050a1d6c4c2ad0bc6ff78847b7bc64f7999c8c89"

URI_aarch64_rsyslog-mmaudit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmaudit-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-mmaudit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmaudit}"
SRC_URI[aarch64_rsyslog-mmaudit.sha256sum] = "18c6bff1913290752b59f16cf4e5a1bdab810db8bc3841105a3e547c270d54e5"

URI_aarch64_rsyslog-mmfields = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmfields-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-mmfields;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmfields}"
SRC_URI[aarch64_rsyslog-mmfields.sha256sum] = "6cdde361199ae760e065ffa59b7292954012e494739b62910316febf851fa53f"

URI_aarch64_rsyslog-mmjsonparse = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmjsonparse-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-mmjsonparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmjsonparse}"
SRC_URI[aarch64_rsyslog-mmjsonparse.sha256sum] = "add6d580d4d075899349daa91e8498bece4ff58a20d2bd74502732927938904f"

URI_aarch64_rsyslog-mmkubernetes = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmkubernetes-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-mmkubernetes;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmkubernetes}"
SRC_URI[aarch64_rsyslog-mmkubernetes.sha256sum] = "1f7283d77a8f4902c06f2fbb162ce1460056af4d7565258787767a5435fc82ce"

URI_aarch64_rsyslog-mmnormalize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmnormalize-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-mmnormalize;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmnormalize}"
SRC_URI[aarch64_rsyslog-mmnormalize.sha256sum] = "ea04395b5c4819d3bbc57cdc8a06f4207199012c211cfa6d3135063ae2ccb5d4"

URI_aarch64_rsyslog-mmsnmptrapd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmsnmptrapd-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-mmsnmptrapd;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmsnmptrapd}"
SRC_URI[aarch64_rsyslog-mmsnmptrapd.sha256sum] = "85ca3b2a1efba3b676fcf8231e9c30c75eec0019670ac90af20413491fbac199"

URI_aarch64_rsyslog-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mysql-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mysql}"
SRC_URI[aarch64_rsyslog-mysql.sha256sum] = "31b68eae9b4d1e03c25043a045501f7dbac03936dc114c1ab1ac94df6f094a7e"

URI_aarch64_rsyslog-omamqp1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-omamqp1-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-omamqp1;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-omamqp1}"
SRC_URI[aarch64_rsyslog-omamqp1.sha256sum] = "ccdfdc8d0f7d140955c9829ca6563b0e4a1fe80232b513d386380d0aa379b2b1"

URI_aarch64_rsyslog-openssl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-openssl-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-openssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-openssl}"
SRC_URI[aarch64_rsyslog-openssl.sha256sum] = "ea8714883211c46d0710844c13bf400af24a886e5fba865c0a0a625d5652c8e6"

URI_aarch64_rsyslog-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-pgsql-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-pgsql}"
SRC_URI[aarch64_rsyslog-pgsql.sha256sum] = "1f3a9f182f5239db476cfce420914d84ef69678996988259a441df553000bb2d"

URI_aarch64_rsyslog-relp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-relp-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-relp;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-relp}"
SRC_URI[aarch64_rsyslog-relp.sha256sum] = "a95c5a9525cf85b8307c3cec226fa7805802fb45299d978e304e019f819cd40c"

URI_aarch64_rsyslog-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-snmp-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-snmp}"
SRC_URI[aarch64_rsyslog-snmp.sha256sum] = "7c883c0b27e914a35a017b444573c194d181bfc6110ab385a6c4a634db2c41c9"

URI_aarch64_rsyslog-udpspoof = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-udpspoof-8.2510.0-5.el10.aarch64.rpm;name=aarch64_rsyslog-udpspoof;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-udpspoof}"
SRC_URI[aarch64_rsyslog-udpspoof.sha256sum] = "be4cb0558421ffb0bffc6f01c39952df43ec80c9fc01706be9032385c2553cbc"

RDEPENDS:rsyslog = " \
 bash \
 glibc \
 libcap-ng \
 libestr \
 libfastjson \
 libgcc \
 libuuid \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:rsyslog-crypto = " \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-doc = " \
 "
RDEPENDS:rsyslog-elasticsearch = " \
 glibc \
 libcap-ng \
 rsyslog \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:rsyslog-gnutls = " \
 glibc \
 gnutls \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-gssapi = " \
 glibc \
 krb5-libs \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-kafka = " \
 glibc \
 libcap-ng \
 librdkafka \
 rsyslog \
 "
RDEPENDS:rsyslog-mmaudit = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mmfields = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mmjsonparse = " \
 glibc \
 libcap-ng \
 libfastjson \
 rsyslog \
 "
RDEPENDS:rsyslog-mmkubernetes = " \
 glibc \
 libcap-ng \
 libfastjson \
 liblognorm \
 rsyslog \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:rsyslog-mmnormalize = " \
 glibc \
 libcap-ng \
 libfastjson \
 liblognorm \
 rsyslog \
 "
RDEPENDS:rsyslog-mmsnmptrapd = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mysql = " \
 glibc \
 mariadb-connector-c \
 rsyslog \
 "
RDEPENDS:rsyslog-omamqp1 = " \
 cyrus-sasl-lib \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-openssl = " \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-pgsql = " \
 glibc \
 libcap-ng \
 libpq \
 rsyslog \
 "
RDEPENDS:rsyslog-relp = " \
 glibc \
 libcap-ng \
 librelp \
 rsyslog \
 "
RDEPENDS:rsyslog-snmp = " \
 glibc \
 libcap-ng \
 net-snmp-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-udpspoof = " \
 glibc \
 libcap-ng \
 libnet \
 rsyslog \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/syslog"

PROVIDES:append:aarch64 = " rpm/virtual/syslog"
