# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fnv"
PV = "1.0.7"
PR = "12.el10_0"
PACKAGES = " \
 rust-fnv+default-devel \
 rust-fnv+std-devel \
 rust-fnv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fnv-1.0.7-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec290effd17540d9f58c5675a6751efdba542146dd4256c2bf7db9b1a09181e2"

URI_x86_64_v2_rust-fnv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fnv+default-devel-1.0.7-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fnv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fnv+default-devel}"
SRC_URI[x86_64_v2_rust-fnv+default-devel.sha256sum] = "95795c87e86a7ff8ba48182b47e1cf988cea4c3f22ae85bddb217ce24243e84a"

URI_x86_64_v2_rust-fnv+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fnv+std-devel-1.0.7-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fnv+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fnv+std-devel}"
SRC_URI[x86_64_v2_rust-fnv+std-devel.sha256sum] = "91eb69684509991ddece38d56be238308e4271cc73cf7d36a69742cd89cff919"

URI_x86_64_v2_rust-fnv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fnv-devel-1.0.7-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fnv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fnv-devel}"
SRC_URI[x86_64_v2_rust-fnv-devel.sha256sum] = "f6869bac647b92ef296c51a0c089184d1e9aca07c353b9dc47cbfca7dcb1fe27"

URI_aarch64_rust-fnv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fnv+default-devel-1.0.7-12.el10_0.noarch.rpm;name=aarch64_rust-fnv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fnv+default-devel}"
SRC_URI[aarch64_rust-fnv+default-devel.sha256sum] = "aa7ed6a1e44f47a5cc6f8f956551440d8e39b97bd4480e30bbeaf71f3b871c4e"

URI_aarch64_rust-fnv+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fnv+std-devel-1.0.7-12.el10_0.noarch.rpm;name=aarch64_rust-fnv+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fnv+std-devel}"
SRC_URI[aarch64_rust-fnv+std-devel.sha256sum] = "6ce986c8818e64c139420d2ff22a085ad8aada3b3e8547cc5928c890cffbc518"

URI_aarch64_rust-fnv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fnv-devel-1.0.7-12.el10_0.noarch.rpm;name=aarch64_rust-fnv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fnv-devel}"
SRC_URI[aarch64_rust-fnv-devel.sha256sum] = "9d244ace69522a2a49faaff35d26cb5abf65708e7eccf334b1073c95bfe30fdb"

RDEPENDS:rust-fnv+default-devel = " \
 cargo \
 rust-fnv+std-devel \
 rust-fnv-devel \
 "
RDEPENDS:rust-fnv+std-devel = " \
 cargo \
 rust-fnv-devel \
 "
RDEPENDS:rust-fnv-devel = " \
 cargo \
 "
