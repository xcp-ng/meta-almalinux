# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kpeople"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kpeople \
 kf6-kpeople-devel \
 kf6-kpeople-doc \
 kf6-kpeople-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kpeople-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8bc3f82b8689f8bf823c05362d57a51c1b716401b47553174234cbb965bd96c"

URI_x86_64_v2_kf6-kpeople = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpeople;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpeople}"
SRC_URI[x86_64_v2_kf6-kpeople.sha256sum] = "3826a8439ab188abe29edc1daac8e47b465c4577b85194047581460c21b190e9"

URI_x86_64_v2_kf6-kpeople-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpeople-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpeople-devel}"
SRC_URI[x86_64_v2_kf6-kpeople-devel.sha256sum] = "df5d1505fcfc9103a06a2355e090ef2d8a323463f24698d3bb7bc11e0828041f"

URI_x86_64_v2_kf6-kpeople-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpeople-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpeople-doc}"
SRC_URI[x86_64_v2_kf6-kpeople-doc.sha256sum] = "a97f119fa8e002ec91546ee705199088e494268f3dc34dd271acbbe564d99ce0"

URI_x86_64_v2_kf6-kpeople-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpeople-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpeople-html}"
SRC_URI[x86_64_v2_kf6-kpeople-html.sha256sum] = "8272eb37db587602af10a25f18b6bdc085ebf5a5306183d864c4ffdc84ccf769"

URI_aarch64_kf6-kpeople = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kpeople;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpeople}"
SRC_URI[aarch64_kf6-kpeople.sha256sum] = "1ea032d75fb4f9e58e5ffd54d777e8e211182b5484c6a3f56137165692806ee3"

URI_aarch64_kf6-kpeople-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kpeople-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpeople-devel}"
SRC_URI[aarch64_kf6-kpeople-devel.sha256sum] = "61f11264ae1741701e234670191125ed54633f3b7a00684609f626ef7ddf02bd"

URI_aarch64_kf6-kpeople-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kpeople-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpeople-doc}"
SRC_URI[aarch64_kf6-kpeople-doc.sha256sum] = "a91bfa10e109472663bc036c92a9912178420467feb7c6d24a465895f24ae000"

URI_aarch64_kf6-kpeople-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kpeople-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpeople-html}"
SRC_URI[aarch64_kf6-kpeople-html.sha256sum] = "63ff964bd46cd8351cad9493b638c3a0c9769b7dae3031ceb1792b97fd69c0a3"

RDEPENDS:kf6-kpeople = " \
 glibc \
 kf6-filesystem \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kpeople-devel = " \
 cmake-filesystem \
 kf6-kpeople \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kpeople-doc = " \
 "
RDEPENDS:kf6-kpeople-html = " \
 "
