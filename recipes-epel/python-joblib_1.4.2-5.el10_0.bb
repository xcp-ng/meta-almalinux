# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-joblib"
PV = "1.4.2"
PR = "5.el10_0"
PACKAGES = " \
 python3-joblib \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-joblib-1.4.2-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "24113a318068e2bdd5a32415f98df991b0b2bc3e89e8653c149f73c1dec31e59"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-joblib-1.4.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-joblib;unpack=0"
SRC_URI[x86_64_v2_python3-joblib.sha256sum] = "fe4898836a3c73e58476f321ea777f9f4c8d01e4d51b99f15cb048df0e208142"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-joblib-1.4.2-5.el10_0.noarch.rpm;name=aarch64_python3-joblib;unpack=0"
SRC_URI[aarch64_python3-joblib.sha256sum] = "88101c6bb6760285f399d05388b26cd7d081f75bbdf861be2f78636280894288"

RDEPENDS:python3-joblib = " \
 python3 \
 python3-cloudpickle \
 "
