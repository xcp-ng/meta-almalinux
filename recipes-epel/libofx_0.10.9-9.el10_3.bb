# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libofx"
PV = "0.10.9"
PR = "9.el10_3"
PACKAGES = " \
 libofx \
 libofx-devel \
 ofx \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libofx-0.10.9-9.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f29d2d028b1d2af1fd9d734c96880e313991496ff1f05d46dfd75c7549ed8b7f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libofx-0.10.9-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libofx;unpack=0"
SRC_URI[x86_64_v2_libofx.sha256sum] = "892775ba15d7cb5c172ad2f1f6781c2627a35dafa80d9032668e1e252193a69e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libofx-devel-0.10.9-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libofx-devel;unpack=0"
SRC_URI[x86_64_v2_libofx-devel.sha256sum] = "1b580caabf1b326165bbb9b386d0cb54dc8dccb3cad75a5ee5e0d69818ade7a5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofx-0.10.9-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofx;unpack=0"
SRC_URI[x86_64_v2_ofx.sha256sum] = "19d40a78b629563aaeda295178c874d1e98e4c641aae6af185be86957afe743d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libofx-0.10.9-9.el10_3.aarch64.rpm;name=aarch64_libofx;unpack=0"
SRC_URI[aarch64_libofx.sha256sum] = "181dfc24c70609d5f422c127a6acfe9e931110920018a5bbca6611af8c9af45d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libofx-devel-0.10.9-9.el10_3.aarch64.rpm;name=aarch64_libofx-devel;unpack=0"
SRC_URI[aarch64_libofx-devel.sha256sum] = "79b2856c676348989e3420bdda9bfcdd5c147a0d0d11c6df0b9f81ceeb1ee040"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/ofx-0.10.9-9.el10_3.aarch64.rpm;name=aarch64_ofx;unpack=0"
SRC_URI[aarch64_ofx.sha256sum] = "d1d25d39d872290b8e2c4d87a543a101bb99b95846c8e481f94a0ea2b63830db"

RDEPENDS:libofx = " \
 glibc \
 libgcc \
 libstdc++ \
 opensp \
 "
RDEPENDS:libofx-devel = " \
 cmake-filesystem \
 libofx \
 pkgconf-pkg-config \
 "
RDEPENDS:ofx = " \
 glibc \
 glibmm2.4 \
 libgcc \
 libofx \
 libstdc++ \
 libxml++ \
 virtual/libcurl.so.4___64bit_ \
 "
