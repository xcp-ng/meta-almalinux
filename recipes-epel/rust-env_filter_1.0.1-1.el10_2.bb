# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_filter"
PV = "1.0.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-env_filter+default-devel \
 rust-env_filter+regex-devel \
 rust-env_filter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_filter-1.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1028c97ecc36bf3d71bf5af9530a3ad6b5a54d41ef9efebbff658afb51eacb25"

URI_x86_64_v2_rust-env_filter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_filter+default-devel-1.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_filter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_filter+default-devel}"
SRC_URI[x86_64_v2_rust-env_filter+default-devel.sha256sum] = "567cf04bbb2a5a2cdc0913e031d4a447eb66ac714c064ef5736f1da4a43adfb9"

URI_x86_64_v2_rust-env_filter+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_filter+regex-devel-1.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_filter+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_filter+regex-devel}"
SRC_URI[x86_64_v2_rust-env_filter+regex-devel.sha256sum] = "6d05454dae5352fb5f2a2eb531b9b4ec0ea304d17ded4b9a76bd2752d33bb6cd"

URI_x86_64_v2_rust-env_filter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_filter-devel-1.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_filter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_filter-devel}"
SRC_URI[x86_64_v2_rust-env_filter-devel.sha256sum] = "d0142d9bad0b58d45fa0bdabc8e9a4836bd959fcfa57c232983739c0705b70ab"

URI_aarch64_rust-env_filter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_filter+default-devel-1.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-env_filter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_filter+default-devel}"
SRC_URI[aarch64_rust-env_filter+default-devel.sha256sum] = "6ad991a6cd49ab5d8225aba3ba97666f6fe12bd5e6accd0014c5f0ddda7df9c3"

URI_aarch64_rust-env_filter+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_filter+regex-devel-1.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-env_filter+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_filter+regex-devel}"
SRC_URI[aarch64_rust-env_filter+regex-devel.sha256sum] = "1c6068e8f2dd1f001f14580e9f99b06812d9de47c6904c377e96ea2e73e79e5d"

URI_aarch64_rust-env_filter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_filter-devel-1.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-env_filter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_filter-devel}"
SRC_URI[aarch64_rust-env_filter-devel.sha256sum] = "0e1fc887320fd81a89836abfd7f69f6ed7b6d8bc33ba1c108a4610cfd9a61d5d"

RDEPENDS:rust-env_filter+default-devel = " \
 cargo \
 rust-env_filter+regex-devel \
 rust-env_filter-devel \
 "
RDEPENDS:rust-env_filter+regex-devel = " \
 cargo \
 rust-env_filter-devel \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-env_filter-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-log+std-devel \
 "
