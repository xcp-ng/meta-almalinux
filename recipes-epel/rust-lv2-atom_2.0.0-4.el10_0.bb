# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lv2-atom"
PV = "2.0.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-lv2-atom+default-devel \
 rust-lv2-atom+lv2-core-devel \
 rust-lv2-atom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lv2-atom-2.0.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c45681605934c4ca7eb6285e9b3d41b1c7dbe4555ec57eda85bc87a000244d0b"

URI_x86_64_v2_rust-lv2-atom+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-atom+default-devel-2.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-atom+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-atom+default-devel}"
SRC_URI[x86_64_v2_rust-lv2-atom+default-devel.sha256sum] = "a221f4ca2a972d34d6498deb4530e5c60704412f4e1cfcd0b12934e3adda2d91"

URI_x86_64_v2_rust-lv2-atom+lv2-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-atom+lv2-core-devel-2.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-atom+lv2-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-atom+lv2-core-devel}"
SRC_URI[x86_64_v2_rust-lv2-atom+lv2-core-devel.sha256sum] = "de2b31f3117abbb7ecf77fd36b3396e45075825b5449fd2fba7b82ca7b4ef3a6"

URI_x86_64_v2_rust-lv2-atom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-atom-devel-2.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-atom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-atom-devel}"
SRC_URI[x86_64_v2_rust-lv2-atom-devel.sha256sum] = "f3d6261a3b87bdd7e8d57039b8c2cba1fe30e1f30c52907cc230cd498f37af2f"

URI_aarch64_rust-lv2-atom+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-atom+default-devel-2.0.0-4.el10_0.noarch.rpm;name=aarch64_rust-lv2-atom+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-atom+default-devel}"
SRC_URI[aarch64_rust-lv2-atom+default-devel.sha256sum] = "cdf59c8a33d1fd6a2bb3b297752c099ba824aedba87142097e17ad1a470abbff"

URI_aarch64_rust-lv2-atom+lv2-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-atom+lv2-core-devel-2.0.0-4.el10_0.noarch.rpm;name=aarch64_rust-lv2-atom+lv2-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-atom+lv2-core-devel}"
SRC_URI[aarch64_rust-lv2-atom+lv2-core-devel.sha256sum] = "f200ff72cc541d910a926b72a1d0a54efbbb5194021f0d4774f7ea9687d0f6e4"

URI_aarch64_rust-lv2-atom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-atom-devel-2.0.0-4.el10_0.noarch.rpm;name=aarch64_rust-lv2-atom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-atom-devel}"
SRC_URI[aarch64_rust-lv2-atom-devel.sha256sum] = "29836c49a05dc6142ac713e5e53d78d81a7c2fd8de9a153812cc6a8a6af58d08"

RDEPENDS:rust-lv2-atom+default-devel = " \
 cargo \
 rust-lv2-atom+lv2-core-devel \
 rust-lv2-atom-devel \
 "
RDEPENDS:rust-lv2-atom+lv2-core-devel = " \
 cargo \
 rust-lv2-atom-devel \
 rust-lv2-core+default-devel \
 "
RDEPENDS:rust-lv2-atom-devel = " \
 cargo \
 rust-lv2-sys+default-devel \
 rust-lv2-units+default-devel \
 rust-urid+default-devel \
 "
