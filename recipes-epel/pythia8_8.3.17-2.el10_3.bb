# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pythia8"
PV = "8.3.17"
PR = "2.el10_3"
PACKAGES = " \
 pythia8 \
 pythia8-data \
 pythia8-devel \
 pythia8-doc \
 pythia8-examples \
 pythia8-hepmc3 \
 pythia8-lhapdf \
 python3-pythia8 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pythia8-8.3.17-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c068ec59e908f7ebdb93cbca18d21a84329a0077d70342031652af24a077a43"

URI_x86_64_v2_pythia8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-8.3.17-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pythia8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8}"
SRC_URI[x86_64_v2_pythia8.sha256sum] = "0cec1436ec5a945ec85584d865db8dc51fc6f28137b555a012a3b8e65fa63c2b"

URI_x86_64_v2_pythia8-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-data-8.3.17-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pythia8-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-data}"
SRC_URI[x86_64_v2_pythia8-data.sha256sum] = "0213f706918beff1a80c530455001496e930b61cd40e3e4aa049737cee6ea952"

URI_x86_64_v2_pythia8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-devel-8.3.17-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pythia8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-devel}"
SRC_URI[x86_64_v2_pythia8-devel.sha256sum] = "4ce8e8ded91267d526e0e55f14a0fee31c4b8757f4da399551e2668881494d23"

URI_x86_64_v2_pythia8-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-doc-8.3.17-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pythia8-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-doc}"
SRC_URI[x86_64_v2_pythia8-doc.sha256sum] = "00bfb5c26d37d84afbe6c7e0513a55b6b9d9c4533dbe37db851ba549a16c1fee"

URI_x86_64_v2_pythia8-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-examples-8.3.17-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pythia8-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-examples}"
SRC_URI[x86_64_v2_pythia8-examples.sha256sum] = "c4ebd8de9401940b41a9a85ae22b91902c61270c6dfd79c4cca4e510b1dc862a"

URI_x86_64_v2_pythia8-hepmc3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-hepmc3-8.3.17-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pythia8-hepmc3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-hepmc3}"
SRC_URI[x86_64_v2_pythia8-hepmc3.sha256sum] = "a82e9210cd319e91d27da657fef56343f750833e10d341af7324cbd50838d096"

URI_x86_64_v2_pythia8-lhapdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-lhapdf-8.3.17-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pythia8-lhapdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-lhapdf}"
SRC_URI[x86_64_v2_pythia8-lhapdf.sha256sum] = "09afc156b23b2e94316494f1714558095616f04ca8f54b313a0883fee5f269ed"

URI_x86_64_v2_python3-pythia8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pythia8-8.3.17-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pythia8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pythia8}"
SRC_URI[x86_64_v2_python3-pythia8.sha256sum] = "0fca13b58440089009d3366f3eb2503228cf3bf2a17c3990543f7752e5fe0450"

URI_aarch64_pythia8 = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-8.3.17-2.el10_3.aarch64.rpm;name=aarch64_pythia8;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8}"
SRC_URI[aarch64_pythia8.sha256sum] = "d5128108a8d21ac058f37e65f437f23d1f978071e26b82cfd04d3d8889178c13"

URI_aarch64_pythia8-data = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-data-8.3.17-2.el10_3.noarch.rpm;name=aarch64_pythia8-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-data}"
SRC_URI[aarch64_pythia8-data.sha256sum] = "55507473df36dd741ae6b3c32fd513504b782de1af032608e8a0b1b5e313a471"

URI_aarch64_pythia8-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-devel-8.3.17-2.el10_3.aarch64.rpm;name=aarch64_pythia8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-devel}"
SRC_URI[aarch64_pythia8-devel.sha256sum] = "1a340b22471bca863b7109b6319cb87e1704dda25f66e5198d998d25917f4be2"

URI_aarch64_pythia8-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-doc-8.3.17-2.el10_3.noarch.rpm;name=aarch64_pythia8-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-doc}"
SRC_URI[aarch64_pythia8-doc.sha256sum] = "2de63bd5be4a6d92e08097dad868bc0840eaba49fa528a0c43f41d742873c709"

URI_aarch64_pythia8-examples = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-examples-8.3.17-2.el10_3.noarch.rpm;name=aarch64_pythia8-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-examples}"
SRC_URI[aarch64_pythia8-examples.sha256sum] = "6eb22dca4b715a1dd62796ffaa6ae9e3ab9c717513d077e8670b4cbc10a96347"

URI_aarch64_pythia8-hepmc3 = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-hepmc3-8.3.17-2.el10_3.aarch64.rpm;name=aarch64_pythia8-hepmc3;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-hepmc3}"
SRC_URI[aarch64_pythia8-hepmc3.sha256sum] = "32a340cadaccb9f883ff4c41f732da84d432b01e69a8378575cf6f87c1ce71d6"

URI_aarch64_pythia8-lhapdf = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-lhapdf-8.3.17-2.el10_3.aarch64.rpm;name=aarch64_pythia8-lhapdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-lhapdf}"
SRC_URI[aarch64_pythia8-lhapdf.sha256sum] = "9471e5496acec02526aaf05b132a6144e4eca78c8ea432614467b84985c451d0"

URI_aarch64_python3-pythia8 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pythia8-8.3.17-2.el10_3.aarch64.rpm;name=aarch64_python3-pythia8;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pythia8}"
SRC_URI[aarch64_python3-pythia8.sha256sum] = "067c71e17f1682f413de9f61a5ea9bbd1f95f449207d24ed15777d9af246feef"

RDEPENDS:pythia8 = " \
 glibc \
 libgcc \
 libstdc++ \
 pythia8-data \
 zlib-ng-compat \
 "
RDEPENDS:pythia8-data = " \
 "
RDEPENDS:pythia8-devel = " \
 pythia8 \
 "
RDEPENDS:pythia8-doc = " \
 "
RDEPENDS:pythia8-examples = " \
 "
RDEPENDS:pythia8-hepmc3 = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 pythia8 \
 "
RDEPENDS:pythia8-lhapdf = " \
 glibc \
 lhapdf \
 libgcc \
 libstdc++ \
 pythia8 \
 "
RDEPENDS:python3-pythia8 = " \
 glibc \
 libgcc \
 libstdc++ \
 pythia8 \
 python3 \
 "
