# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libssh2-sys"
PV = "0.3.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-libssh2-sys+default-devel \
 rust-libssh2-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libssh2-sys-0.3.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "382ac9002d129b81b79a77ab037cff11e5e12f35d86a2b3ed365d6d3c5b3f22a"

URI_x86_64_v2_rust-libssh2-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libssh2-sys+default-devel-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libssh2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libssh2-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libssh2-sys+default-devel.sha256sum] = "d69b3c98937a1b898359905aeb7198e755eda6f063b1c808788651bcb8c6c8ea"

URI_x86_64_v2_rust-libssh2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libssh2-sys-devel-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libssh2-sys-devel}"
SRC_URI[x86_64_v2_rust-libssh2-sys-devel.sha256sum] = "8dc811ef32ad05c990126c52bfc67e02c0cfa61ad0131ccf5608a6bac5b928ed"

URI_aarch64_rust-libssh2-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libssh2-sys+default-devel-0.3.2-1.el10_3.noarch.rpm;name=aarch64_rust-libssh2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libssh2-sys+default-devel}"
SRC_URI[aarch64_rust-libssh2-sys+default-devel.sha256sum] = "f502065f0df777bdd339a50bd67c96897921ea6dd497c6b18717ef30ff96f7c0"

URI_aarch64_rust-libssh2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libssh2-sys-devel-0.3.2-1.el10_3.noarch.rpm;name=aarch64_rust-libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libssh2-sys-devel}"
SRC_URI[aarch64_rust-libssh2-sys-devel.sha256sum] = "b3b463dd20cd53103d5778fe913f88ca666e7c164a24991482e7ab9f228e1b80"

RDEPENDS:rust-libssh2-sys+default-devel = " \
 cargo \
 rust-libssh2-sys-devel \
 "
RDEPENDS:rust-libssh2-sys-devel = " \
 cargo \
 libssh2-devel \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys-devel \
 rust-openssl-sys+default-devel \
 rust-pkg-config+default-devel \
 "
