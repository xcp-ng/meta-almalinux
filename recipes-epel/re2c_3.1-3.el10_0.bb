# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "re2c"
PV = "3.1"
PR = "3.el10_0"
PACKAGES = " \
 re2c \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/re2c-3.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17bb1067423b986c0cb9bdbc26331cf6e7447e78d1dda991ed78f6e49a7743d5"

URI_x86_64_v2_re2c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/re2c-3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_re2c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_re2c}"
SRC_URI[x86_64_v2_re2c.sha256sum] = "775bfd472bad70797cf9e491491f8be01012cf4999e7785b3403499d36a47bed"

URI_aarch64_re2c = "${EPEL_MIRROR}/aarch64/Packages/r/re2c-3.1-3.el10_0.aarch64.rpm;name=aarch64_re2c;unpack=0"
SRC_URI:append = " ${URI_aarch64_re2c}"
SRC_URI[aarch64_re2c.sha256sum] = "897a77875bca6cbe1a37f1aacb36453487dba7993e4b1831cf826567e59987b3"

RDEPENDS:re2c = " \
 glibc \
 libgcc \
 libstdc++ \
 "
