# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CGI-Fast"
PV = "2.17"
PR = "4.el10_0"
PACKAGES = " \
 perl-CGI-Fast \
 perl-CGI-Fast-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-CGI-Fast-2.17-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b55710588b1e45f8028dccc80033bb337bc6cffbe15e9989bbfe9eb3586cfa6"

URI_x86_64_v2_perl-CGI-Fast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CGI-Fast-2.17-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CGI-Fast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CGI-Fast}"
SRC_URI[x86_64_v2_perl-CGI-Fast.sha256sum] = "bb7b4c6a55d66f435c2be1052e7e6157e02f93685239fe1f15c1043553d4c161"

URI_x86_64_v2_perl-CGI-Fast-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CGI-Fast-tests-2.17-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CGI-Fast-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CGI-Fast-tests}"
SRC_URI[x86_64_v2_perl-CGI-Fast-tests.sha256sum] = "b5d01055ce75ea4fde4deb34fad0778f26055ea17ec31b56edd8896e4a848f45"

URI_aarch64_perl-CGI-Fast = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CGI-Fast-2.17-4.el10_0.noarch.rpm;name=aarch64_perl-CGI-Fast;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CGI-Fast}"
SRC_URI[aarch64_perl-CGI-Fast.sha256sum] = "e93a5d32bc0364e9e59223026b31aef252c714766d0635c14fbf183b7065d63c"

URI_aarch64_perl-CGI-Fast-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CGI-Fast-tests-2.17-4.el10_0.noarch.rpm;name=aarch64_perl-CGI-Fast-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CGI-Fast-tests}"
SRC_URI[aarch64_perl-CGI-Fast-tests.sha256sum] = "2a52e9a11410626a6384c18e84ad0b1a150aa39607c2b006c58655beba036691"

RDEPENDS:perl-CGI-Fast = " \
 perl-CGI \
 perl-FCGI \
 perl-deprecate \
 perl-if \
 perl-libs \
 "
RDEPENDS:perl-CGI-Fast-tests = " \
 bash \
 perl-CGI-Fast \
 perl-File-Temp \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
