# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-latest-openjdk"
PE = "1"
PV = "27.0.0.0.35"
PR = "0.0.1.0.ea.el10_3"
PACKAGES = " \
 java-latest-openjdk \
 java-latest-openjdk-crypto-adapter \
 java-latest-openjdk-crypto-adapter-fastdebug \
 java-latest-openjdk-crypto-adapter-slowdebug \
 java-latest-openjdk-demo \
 java-latest-openjdk-demo-fastdebug \
 java-latest-openjdk-demo-slowdebug \
 java-latest-openjdk-devel \
 java-latest-openjdk-devel-fastdebug \
 java-latest-openjdk-devel-slowdebug \
 java-latest-openjdk-fastdebug \
 java-latest-openjdk-headless \
 java-latest-openjdk-headless-fastdebug \
 java-latest-openjdk-headless-slowdebug \
 java-latest-openjdk-javadoc \
 java-latest-openjdk-javadoc-zip \
 java-latest-openjdk-jmods \
 java-latest-openjdk-jmods-fastdebug \
 java-latest-openjdk-jmods-slowdebug \
 java-latest-openjdk-slowdebug \
 java-latest-openjdk-src \
 java-latest-openjdk-src-fastdebug \
 java-latest-openjdk-src-slowdebug \
 java-latest-openjdk-static-libs \
 java-latest-openjdk-static-libs-fastdebug \
 java-latest-openjdk-static-libs-slowdebug \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/java-latest-openjdk-27.0.0.0.35-0.0.1.0.ea.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8ececbf0906d9e778a525aa62c18dc823eb77305fd38881fc17439e823a01d3c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk.sha256sum] = "b63d4f4493c048776f65e2082812eb0b3276ea696427a4f2f060fecae55843e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-crypto-adapter-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-crypto-adapter;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-crypto-adapter.sha256sum] = "94c1d210f40185e95e15bfeabe28fb52c5633bbce884f58827eddcf90021133b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-crypto-adapter-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug.sha256sum] = "a73ef71f82b3c4618ac52f307976ea489569d873a8c4001e180ad53412eaa4f5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-crypto-adapter-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug.sha256sum] = "2084e16c5153e48402df56e26ad7369ab52c48737cb3e560a6ab398f6b5a64f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-demo.sha256sum] = "a48d97d266b459b5574eff892a99c6204d146d9c16949aa04b2627f1e66c61a9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-demo-fastdebug.sha256sum] = "4e58643a6e80d284b1ab3964ed8f2b390761d14ad363f4ab6ca7d675a97cba7c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-demo-slowdebug.sha256sum] = "80dd5865558995dfe987563200e27bd5b9f1def75cfc713e18a2eb5e5ba4530b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-devel.sha256sum] = "a92934c7b8309531bd7bec97a66ba512e306e5411e30fb9d077d0cb46505a7ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-devel-fastdebug.sha256sum] = "10d9eae4b0fb58e24adf9123f36b149dde7e454072381a5faf37b3a1d4a000b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-devel-slowdebug.sha256sum] = "28d9abd46354decd34bdd5dc25e216cda3e26b6d1ff2506e9e78f9cd50f13634"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-fastdebug.sha256sum] = "e6afa7ac8c4697806b314e9a0e79299795464157759ddcab48f170b627e9da13"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-headless.sha256sum] = "cdd34e3e7aee703872c1abcd948c410d260c79d71282ffc27b5e423c7cbbede5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-headless-fastdebug.sha256sum] = "0737bbdafa411e5128fffdd8e4ce1859a716460c1d3b7af635e0bc48c916d060"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-headless-slowdebug.sha256sum] = "ee820a550ed83d545824ef41dc9169957ee8ae836a1b93bb2ca5c78b70e4a894"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-javadoc-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-javadoc;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-javadoc.sha256sum] = "0ebf4a655824e3c05ce9df5898445cdf8c4fcff093da30a32eb9d50369fa55b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-javadoc-zip-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-javadoc-zip;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-javadoc-zip.sha256sum] = "6344ca0b41e2bcb3439d9c3e851682e8dfb86777a6001400959b8be7390ddb49"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods.sha256sum] = "7c0b005e4b8e11ba7b67f634c5d9a3e5a088128ccca172c6e805481e47039006"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods-fastdebug.sha256sum] = "758e77f162888397105e0682666bb8aadfd499d3eead38de49dc2a7f52705ec5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods-slowdebug.sha256sum] = "f0ffa3e6774c5c9144cfcc53bfa0d76c4445498292b211ea761614a922b4699c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-slowdebug.sha256sum] = "d80f71621f29c05c3877f8ce064cb91b25468eb2f8093837010d9cf5633431fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-src.sha256sum] = "9fa9563668cc26adf3cf0e746ac47286f9a6781fbfc3fe3ec08e98ba0034d6bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-src-fastdebug.sha256sum] = "40729159e7f95b3d46e23417750f45ab1ed40beb5cf5628b22cdfea72c090c15"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-src-slowdebug.sha256sum] = "2da17dbafd1fabc2957bc4e11aaf3f73af6128f1a6f306606daf1bd62a6e7266"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs.sha256sum] = "7eac423cfb5ca95b690fe200f039da141a06575dbc59973884a44d99e97cacc3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs-fastdebug.sha256sum] = "1f6aaef7389e97e6a6640b91223b4c22861e1ab139c7fa77cef286ffe676f320"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs-slowdebug.sha256sum] = "6aa25ca065c4e93731159badea8d87a48e1913710dfbc52237f86f44330b90a2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk;unpack=0"
SRC_URI[aarch64_java-latest-openjdk.sha256sum] = "5492c25776d58bd039eb6513029706c99809286e0da892bcf96e442cbac449ab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-crypto-adapter-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-crypto-adapter;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-crypto-adapter.sha256sum] = "7d523150ed00b7ca6566ab613c8c6ab7cfe40e5f44fa2d3d04640934acfe2bf1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-crypto-adapter-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-crypto-adapter-fastdebug.sha256sum] = "18ac71e54ccc68d01fd35f3d18d480aa5ab3ed1f0180b285d06c71d3a9026f80"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-crypto-adapter-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-crypto-adapter-slowdebug.sha256sum] = "f7ce43bbed3f5beb2c5a6de4a1287576d8f8c6c16a6feb6ee30c04c94600db6d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-demo;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-demo.sha256sum] = "0532348f09bd6374925451ec83f45264acee69af610f742585a298d9e4d27123"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-demo-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-demo-fastdebug.sha256sum] = "07af90d9e58731f08352a9b0813ccd3f851d29e18df8810df0d34e0b1bf7c3c4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-demo-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-demo-slowdebug.sha256sum] = "54cb567a6cca517786ea47b568143cf50fcfd8681c5c5a4e292f9480df18c20f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-devel;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-devel.sha256sum] = "9804d12a7fe61f5bee171503dce50fe663507d2a0eecce47ab3807c9accc4563"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-devel-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-devel-fastdebug.sha256sum] = "1a0fc7defe739c77e5d9a030d2ad71bff0722cfaa52c926f7e84a4943aa01d9a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-devel-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-devel-slowdebug.sha256sum] = "b9e74851d5ea20aaca95e8173278d56ec92b6b202daffc720565fa7c366d01a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-fastdebug.sha256sum] = "c7cbb12ef0a0279c6fcbc00d96398d113b3c9601b0df1d81934bcb0178793d7a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-headless;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-headless.sha256sum] = "e6d38187e3c05e2c56e04dc949ea445e26fc171c9086a76acf65d0706c134f82"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-headless-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-headless-fastdebug.sha256sum] = "9bbad46ece653f847e295bea036b115178357882056f011b9b8dbe25797acbbb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-headless-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-headless-slowdebug.sha256sum] = "75a758a52a150b67e0a62c4cc23497b2f0d5f98289a2c75703a55a400fda177b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-javadoc-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-javadoc;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-javadoc.sha256sum] = "eeb59a2f1aa41662ece85040a4f3f5717846541fae3b6a803f3aec5f7e009714"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-javadoc-zip-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-javadoc-zip;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-javadoc-zip.sha256sum] = "dcf2f3e7b621787256d2adf77ba12bda2696ab402d50cb9b12197d17f2bd1194"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-jmods.sha256sum] = "eaf169a2f069303fdfb690f34696ff20be694972b4580a311b49e5bf7119075f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-jmods-fastdebug.sha256sum] = "db5aec86609a49cb20c644cdee382c3b77b2f77b749211eb4c3a6299d6ca5d7f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-jmods-slowdebug.sha256sum] = "7157eac358c228a62fd4b19c01b5595bcb2eeb362cee6fab4c86af1862e19dbd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-slowdebug.sha256sum] = "3e6218636cd52f0a66d9269e08c937d9fa85083ff0747e812582beffad4772c1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-src;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-src.sha256sum] = "54d6f52eb2d581141b8b8bf99aa3ee0ec8266afc9d723d55f63bc86ef66d1849"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-src-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-src-fastdebug.sha256sum] = "38bf66bc7965ec517a249a024ad95e1f3e27f35ea07ed9dd1e72d07edc2c2206"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-src-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-src-slowdebug.sha256sum] = "e7d24216135dd744fd41ea41b5d11a3d6193cec015abdb456e495345297be403"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-static-libs.sha256sum] = "7df2efc2b8c1dd89280c8c33e37a996658ee3247e8c9ba8e41dacf9e74f11661"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-fastdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-static-libs-fastdebug.sha256sum] = "807fe73d4f8cf70283d5edca74059942b6a4524b854c50d3bd49a5ef7647b05b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-slowdebug-27.0.0.0.35-0.0.1.0.ea.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-static-libs-slowdebug.sha256sum] = "5945a528c67c3ec5b156659b1e51e68746d96e04ac59c5ea91a934a5ecba5952"

RDEPENDS:java-latest-openjdk = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-crypto-adapter = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-latest-openjdk-crypto-adapter-fastdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-latest-openjdk-crypto-adapter-slowdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-latest-openjdk-demo = " \
 java-latest-openjdk \
 "
RDEPENDS:java-latest-openjdk-demo-fastdebug = " \
 java-latest-openjdk-fastdebug \
 "
RDEPENDS:java-latest-openjdk-demo-slowdebug = " \
 java-latest-openjdk-slowdebug \
 "
RDEPENDS:java-latest-openjdk-devel = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk \
 "
RDEPENDS:java-latest-openjdk-devel-fastdebug = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk-fastdebug \
 "
RDEPENDS:java-latest-openjdk-devel-slowdebug = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk-slowdebug \
 "
RDEPENDS:java-latest-openjdk-fastdebug = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless-fastdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-headless = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-latest-openjdk-crypto-adapter \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-headless-fastdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-latest-openjdk-crypto-adapter-fastdebug \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-headless-slowdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-latest-openjdk-crypto-adapter-slowdebug \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-javadoc = " \
 alternatives \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:java-latest-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:java-latest-openjdk-jmods = " \
 java-latest-openjdk-devel \
 "
RDEPENDS:java-latest-openjdk-jmods-fastdebug = " \
 java-latest-openjdk-devel-fastdebug \
 "
RDEPENDS:java-latest-openjdk-jmods-slowdebug = " \
 java-latest-openjdk-devel-slowdebug \
 "
RDEPENDS:java-latest-openjdk-slowdebug = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless-slowdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-src = " \
 java-latest-openjdk-headless \
 "
RDEPENDS:java-latest-openjdk-src-fastdebug = " \
 java-latest-openjdk-headless-fastdebug \
 "
RDEPENDS:java-latest-openjdk-src-slowdebug = " \
 java-latest-openjdk-headless-slowdebug \
 "
RDEPENDS:java-latest-openjdk-static-libs = " \
 java-latest-openjdk-devel \
 "
RDEPENDS:java-latest-openjdk-static-libs-fastdebug = " \
 java-latest-openjdk-devel-fastdebug \
 "
RDEPENDS:java-latest-openjdk-static-libs-slowdebug = " \
 java-latest-openjdk-devel-slowdebug \
 "
