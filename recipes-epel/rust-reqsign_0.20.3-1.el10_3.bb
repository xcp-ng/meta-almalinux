# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign"
PV = "0.20.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign+aliyun-devel \
 rust-reqsign+aws-devel \
 rust-reqsign+azure-devel \
 rust-reqsign+default-context-devel \
 rust-reqsign+default-devel \
 rust-reqsign+full-devel \
 rust-reqsign+google-devel \
 rust-reqsign+huaweicloud-devel \
 rust-reqsign+oracle-devel \
 rust-reqsign+tencent-devel \
 rust-reqsign+volcengine-devel \
 rust-reqsign-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-0.20.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "986c51a096cdf1154c9673febdb704f080b60689068c3d892aab9bbacd1d5ce1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+aliyun-devel-0.20.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+aliyun-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign+aliyun-devel.sha256sum] = "e4c031f7331a1a897bc10f4c359203e6d46bccaee056f121e1ee468ed774f353"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+aws-devel-0.20.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+aws-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign+aws-devel.sha256sum] = "ecf47a185af048e2c7dc36e6831a26be15ae0a52952d2b37df6b2b59b914b81f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+azure-devel-0.20.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+azure-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign+azure-devel.sha256sum] = "1a02ec7f40ed63f2ca7bd48181a2c5506f33abe6bda2ffb221a1a615cef30e9a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+default-context-devel-0.20.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+default-context-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign+default-context-devel.sha256sum] = "4cb698caba1e5b7410d38c0b5c5e09f8f133d319d82b5b3a25583cedc4024c66"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+default-devel-0.20.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign+default-devel.sha256sum] = "70a788d33b94174ce8f47f10158d83155e06d854805800e0c91e2b0231640337"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+full-devel-0.20.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+full-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign+full-devel.sha256sum] = "3b1559ff890e4310256199216ce73cb6e59b7a9226ec076e248a598b590147b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+google-devel-0.20.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+google-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign+google-devel.sha256sum] = "90775ac65f9b4167264c3598c85319833330dcd8e7dbda627172d638b918f388"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+huaweicloud-devel-0.20.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+huaweicloud-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign+huaweicloud-devel.sha256sum] = "4d75762c9e07eef19507e3f5af427fb088c8c6e319c7c1ca5cfdf395c15f43e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+oracle-devel-0.20.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+oracle-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign+oracle-devel.sha256sum] = "c02f97ced40a27ab0931f0b5984be8c4321bff1f59c983b744b50394b609c4b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+tencent-devel-0.20.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+tencent-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign+tencent-devel.sha256sum] = "53869056070c6ff504230ec1643e569d5bf492a78aaf43ed503764dad86f7b0e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+volcengine-devel-0.20.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+volcengine-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign+volcengine-devel.sha256sum] = "9592eb39eab9ba383bd1891c178dfd4e2123339c1bfe485292db31b1b231fe72"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-devel-0.20.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-devel.sha256sum] = "933efc4e2982875100889081eb2c9f8e8ed24d6fcfe65bb26180154fc0d333fe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+aliyun-devel-0.20.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+aliyun-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign+aliyun-devel.sha256sum] = "43baed9daf9146f12179fd47e519a4e655bc3a8164229b08d4edbd7a4b7a80f1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+aws-devel-0.20.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+aws-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign+aws-devel.sha256sum] = "100664f864bab544573359ed0eade80b32da65a5e5ff2a4a98034caa3a820bd5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+azure-devel-0.20.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+azure-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign+azure-devel.sha256sum] = "dd44f8f7d784044a6c038065befa7cb9869c60ad7baf81e59eb34f9259ae8041"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+default-context-devel-0.20.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+default-context-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign+default-context-devel.sha256sum] = "07d389969277f9e5489a7f035baedbfc452be3214c8db699bfbcba5353db4baa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+default-devel-0.20.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+default-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign+default-devel.sha256sum] = "f2652bde90db688422c7173f7a4fba41aecadde0d06a8147626d4ded179cb8e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+full-devel-0.20.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+full-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign+full-devel.sha256sum] = "f411d020fc2d352ee4ba628381e7060378935f3b6f10a7120b91b8c30b7644f8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+google-devel-0.20.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+google-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign+google-devel.sha256sum] = "b861df719391cd2f9355ca7396022b760b9d65ea46d1efcd31b06d421b8a123e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+huaweicloud-devel-0.20.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+huaweicloud-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign+huaweicloud-devel.sha256sum] = "a4b8e12dc976c4013ec5e6a5716132be239c3f2dc10fa468722d7656fccfbdc2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+oracle-devel-0.20.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+oracle-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign+oracle-devel.sha256sum] = "3882d8e4e944a0388156ebd415d5d6abacc680e6f8e6385f6992803edf48cb4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+tencent-devel-0.20.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+tencent-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign+tencent-devel.sha256sum] = "2ce8e2da45135740a14ac15ef80285a61a4a51a85f45abcb1e77d3e68c06b99f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+volcengine-devel-0.20.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign+volcengine-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign+volcengine-devel.sha256sum] = "12406fd9c45dcfa8be87d719e775a3c21bcfb4820bacbd8a0279bf36510c5e14"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-devel-0.20.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-devel.sha256sum] = "71fafeaa70a58920185c10111b5ba73ad09a8970afb571b4b6d2ded19169d6ec"

RDEPENDS:rust-reqsign+aliyun-devel = " \
 cargo \
 rust-reqsign-aliyun-oss+default-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+aws-devel = " \
 cargo \
 rust-reqsign-aws-v4+default-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+azure-devel = " \
 cargo \
 rust-reqsign-azure-storage+default-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+default-context-devel = " \
 cargo \
 rust-reqsign-command-execute-tokio+default-devel \
 rust-reqsign-devel \
 rust-reqsign-file-read-tokio+default-devel \
 rust-reqsign-http-send-reqwest+default-devel \
 "
RDEPENDS:rust-reqsign+default-devel = " \
 cargo \
 rust-reqsign+default-context-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+full-devel = " \
 cargo \
 rust-reqsign+aliyun-devel \
 rust-reqsign+aws-devel \
 rust-reqsign+azure-devel \
 rust-reqsign+google-devel \
 rust-reqsign+huaweicloud-devel \
 rust-reqsign+oracle-devel \
 rust-reqsign+tencent-devel \
 rust-reqsign+volcengine-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+google-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-google+default-devel \
 "
RDEPENDS:rust-reqsign+huaweicloud-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-huaweicloud-obs+default-devel \
 "
RDEPENDS:rust-reqsign+oracle-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-oracle+default-devel \
 "
RDEPENDS:rust-reqsign+tencent-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-tencent-cos+default-devel \
 "
RDEPENDS:rust-reqsign+volcengine-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-volcengine-tos+default-devel \
 "
RDEPENDS:rust-reqsign-devel = " \
 cargo \
 rust \
 rust-reqsign-core+default-devel \
 "
