# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aesfix"
PV = "1.0.1"
PR = "6.el10_0"
PACKAGES = " \
 aesfix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aesfix-1.0.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b48a5a92c148fd91578c6d3277167eac61157630f20221007e61cb09592aaea"

URI_x86_64_v2_aesfix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aesfix-1.0.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aesfix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aesfix}"
SRC_URI[x86_64_v2_aesfix.sha256sum] = "f1623941370d33ba030ceb7cd814fe7c8f13ac108fe2fad5a032a377c2235898"

URI_aarch64_aesfix = "${EPEL_MIRROR}/aarch64/Packages/a/aesfix-1.0.1-6.el10_0.aarch64.rpm;name=aarch64_aesfix;unpack=0"
SRC_URI:append = " ${URI_aarch64_aesfix}"
SRC_URI[aarch64_aesfix.sha256sum] = "da61b41b81f42e78701cf64ddb62b21dfc568fb19fc2b17e00ef1c7d6dab9634"

RDEPENDS:aesfix = " \
 glibc \
 libgcc \
 libstdc++ \
 "
