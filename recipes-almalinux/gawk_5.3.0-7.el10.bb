# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gawk"
PV = "5.3.0"
PR = "7.el10"
PACKAGES = " \
 gawk \
 gawk-all-langpacks \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gawk-5.3.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0d42f76a11d5c9a0d54e673532ce1d1d50901929a1c0632eccbf0833df5be202"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gawk-5.3.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_gawk;unpack=0"
SRC_URI[x86_64_v2_gawk.sha256sum] = "17ee5f21c78259ba919793c7a05e571990a13a093f39e050f1a7c71f6fbdf6a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gawk-all-langpacks-5.3.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_gawk-all-langpacks;unpack=0"
SRC_URI[x86_64_v2_gawk-all-langpacks.sha256sum] = "b9033a2122d42b36e614ff41749dee5f3b4e5add6388595ede9e5637bb92c61f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gawk-5.3.0-7.el10.aarch64.rpm;name=aarch64_gawk;unpack=0"
SRC_URI[aarch64_gawk.sha256sum] = "2220a1d2b6ac22e0fb8db2e93bc84df73865acc61612d5804ca56057c42ab506"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gawk-all-langpacks-5.3.0-7.el10.aarch64.rpm;name=aarch64_gawk-all-langpacks;unpack=0"
SRC_URI[aarch64_gawk-all-langpacks.sha256sum] = "07af786183e72dcbac9cf2502d25af021f9d6616b896f0412ca456fcbda2cd04"

RDEPENDS:gawk = " \
 bash \
 filesystem \
 glibc \
 gmp \
 mpfr \
 readline \
 "
RDEPENDS:gawk-all-langpacks = " \
 "
