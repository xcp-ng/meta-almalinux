# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-email-validator"
PV = "2.3.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-email-validator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-email-validator-2.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d31af2342a1fa6814de89e039488a3fc4c4b6c05eeba48d5ee8c25ced4dbeb57"

URI_x86_64_v2_python3-email-validator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-email-validator-2.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-email-validator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-email-validator}"
SRC_URI[x86_64_v2_python3-email-validator.sha256sum] = "b8cda233859e7d25cbea7dbe17760dd303deb05cf00fe7bc0ce35e55aeb7b5ed"

URI_aarch64_python3-email-validator = "${EPEL_MIRROR}/aarch64/Packages/p/python3-email-validator-2.3.0-1.el10_0.noarch.rpm;name=aarch64_python3-email-validator;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-email-validator}"
SRC_URI[aarch64_python3-email-validator.sha256sum] = "01f4c518b0837af0730d649134e9b6aee0c78f83fb00a6af6a85e0d98c9145ed"

RDEPENDS:python3-email-validator = " \
 python3 \
 python3-dns \
 python3-idna \
 "
