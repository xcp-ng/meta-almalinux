# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rmp-serde"
PV = "1.3.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-rmp-serde+default-devel \
 rust-rmp-serde-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rmp-serde-1.3.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7200c031d8589229ac535f6945076544219dde9fbacd7acd4311efcb5d901aa8"

URI_x86_64_v2_rust-rmp-serde+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmp-serde+default-devel-1.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmp-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmp-serde+default-devel}"
SRC_URI[x86_64_v2_rust-rmp-serde+default-devel.sha256sum] = "6dca3a4eab5c3f552392a7dbc19f85da6c692834070ad46a5d475c2fafd753dd"

URI_x86_64_v2_rust-rmp-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmp-serde-devel-1.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmp-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmp-serde-devel}"
SRC_URI[x86_64_v2_rust-rmp-serde-devel.sha256sum] = "fbcb055164741b2c2f4fb7479b83d0368efbd7368c8a53645781a74f1e52ecd8"

URI_aarch64_rust-rmp-serde+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmp-serde+default-devel-1.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-rmp-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmp-serde+default-devel}"
SRC_URI[aarch64_rust-rmp-serde+default-devel.sha256sum] = "4245773a8c20324edbe70c635b3f9203a771cbf92e2a38a25e213b553d2e65eb"

URI_aarch64_rust-rmp-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmp-serde-devel-1.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-rmp-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmp-serde-devel}"
SRC_URI[aarch64_rust-rmp-serde-devel.sha256sum] = "6f620684c0665c017cb0d6fcb54a8f1f413f0abd443e40333214b2e42daa421c"

RDEPENDS:rust-rmp-serde+default-devel = " \
 cargo \
 rust-rmp-serde-devel \
 "
RDEPENDS:rust-rmp-serde-devel = " \
 cargo \
 rust \
 rust-rmp+default-devel \
 rust-serde+default-devel \
 "
