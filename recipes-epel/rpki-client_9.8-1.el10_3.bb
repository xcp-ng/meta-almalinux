# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpki-client"
PV = "9.8"
PR = "1.el10_3"
PACKAGES = " \
 rpki-client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rpki-client-9.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68b2b8a1993a534660b7897755c66f742eb7b2d64dd85ac72d66be2b2cd6414f"

URI_x86_64_v2_rpki-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpki-client-9.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rpki-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpki-client}"
SRC_URI[x86_64_v2_rpki-client.sha256sum] = "d18cbbac38180b01b0f721bc9d7e5cecfd03dfc344d1b99dfc4e163c177e3cff"

URI_aarch64_rpki-client = "${EPEL_MIRROR}/aarch64/Packages/r/rpki-client-9.8-1.el10_3.aarch64.rpm;name=aarch64_rpki-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpki-client}"
SRC_URI[aarch64_rpki-client.sha256sum] = "3d356416a8745f737d622fdfbfe6d5f052a4d669acc883982ded131a7fbf4930"

RDEPENDS:rpki-client = " \
 bash \
 expat \
 glibc \
 libretls \
 openssl-libs \
 rsync \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
