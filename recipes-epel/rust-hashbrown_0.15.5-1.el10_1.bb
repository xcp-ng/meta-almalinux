# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashbrown"
PV = "0.15.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-hashbrown+allocator-api2-devel \
 rust-hashbrown+default-devel \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+equivalent-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown+raw-entry-devel \
 rust-hashbrown+rayon-devel \
 rust-hashbrown+serde-devel \
 rust-hashbrown-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hashbrown-0.15.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "744d71b213895d69828bbcfede27238cb10a4652b8e79957c0fb3247f17873a1"

URI_x86_64_v2_rust-hashbrown+allocator-api2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+allocator-api2-devel-0.15.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+allocator-api2-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+allocator-api2-devel.sha256sum] = "23aa689ac57369b49bf95f68b250dbc4441f2be85ac6ea1ca02eb180234d9515"

URI_x86_64_v2_rust-hashbrown+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+default-devel-0.15.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+default-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+default-devel.sha256sum] = "d53bb4091e8a5921a1b2bcda33bb5148f60711947a85f6c1296faa3419523b53"
RPROVIDES:rust-hashbrown+default-devel:x86_64_v2 = "virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~"

URI_x86_64_v2_rust-hashbrown+default-hasher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+default-hasher-devel-0.15.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+default-hasher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+default-hasher-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+default-hasher-devel.sha256sum] = "e8047e0bcb7b9c45fa97143ea9e4d7c69ba64743e707d2494310695cbd780e33"

URI_x86_64_v2_rust-hashbrown+equivalent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+equivalent-devel-0.15.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+equivalent-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+equivalent-devel.sha256sum] = "8951f6dc13d967aaffca9294e25915c6ec732256f6ff363bc64185b1c8b88e56"

URI_x86_64_v2_rust-hashbrown+inline-more-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+inline-more-devel-0.15.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+inline-more-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+inline-more-devel.sha256sum] = "a4a5e02a2ac76bf230f5c04c6e64841655a06da6e0ffe302bc97b70695cdd207"

URI_x86_64_v2_rust-hashbrown+raw-entry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+raw-entry-devel-0.15.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+raw-entry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+raw-entry-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+raw-entry-devel.sha256sum] = "dc43fe3df3750eb9d2631bd73610b730c068cf8b59fc1eff08a0dc7da519b0f2"

URI_x86_64_v2_rust-hashbrown+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+rayon-devel-0.15.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+rayon-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+rayon-devel.sha256sum] = "db84e202998f6bae1d0502ca2e9f84ca1568e35081f78a0ea489aa2948feadca"

URI_x86_64_v2_rust-hashbrown+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+serde-devel-0.15.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+serde-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+serde-devel.sha256sum] = "5e9f0955b408394aa649361bea7421b5b5d7ea4c9ad4c42c1c0918c119d478e2"

URI_x86_64_v2_rust-hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown-devel-0.15.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown-devel}"
SRC_URI[x86_64_v2_rust-hashbrown-devel.sha256sum] = "01f2412a89b467ea0ce6c413f75eb93bec253811aed95249241c98b515d867fa"

URI_aarch64_rust-hashbrown+allocator-api2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+allocator-api2-devel-0.15.5-1.el10_1.noarch.rpm;name=aarch64_rust-hashbrown+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+allocator-api2-devel}"
SRC_URI[aarch64_rust-hashbrown+allocator-api2-devel.sha256sum] = "b41ba1c8a1cac5268cc7f7cfcd172c31277e7d4de797d5b81c1ef093b5e440eb"

URI_aarch64_rust-hashbrown+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+default-devel-0.15.5-1.el10_1.noarch.rpm;name=aarch64_rust-hashbrown+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+default-devel}"
SRC_URI[aarch64_rust-hashbrown+default-devel.sha256sum] = "b65ed47f1b86305d96345ce08c58f3e7045f7c45583045378bd7f89f94ca101e"
RPROVIDES:rust-hashbrown+default-devel:aarch64 = "virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~"

URI_aarch64_rust-hashbrown+default-hasher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+default-hasher-devel-0.15.5-1.el10_1.noarch.rpm;name=aarch64_rust-hashbrown+default-hasher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+default-hasher-devel}"
SRC_URI[aarch64_rust-hashbrown+default-hasher-devel.sha256sum] = "d4f7c635d1910c1e9fcf1471527e3f4e082ffe0b714f825b774ed57e1aae7e44"

URI_aarch64_rust-hashbrown+equivalent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+equivalent-devel-0.15.5-1.el10_1.noarch.rpm;name=aarch64_rust-hashbrown+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+equivalent-devel}"
SRC_URI[aarch64_rust-hashbrown+equivalent-devel.sha256sum] = "2d3cbebc13ffb34aae2a2eb1e0e6787ac80178cc791bbbc90c2c02f4787d2d01"

URI_aarch64_rust-hashbrown+inline-more-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+inline-more-devel-0.15.5-1.el10_1.noarch.rpm;name=aarch64_rust-hashbrown+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+inline-more-devel}"
SRC_URI[aarch64_rust-hashbrown+inline-more-devel.sha256sum] = "86587a62e19a7496b2c3d6a986bf23aeba9f5e50d7143ed376a8dea841023f5b"

URI_aarch64_rust-hashbrown+raw-entry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+raw-entry-devel-0.15.5-1.el10_1.noarch.rpm;name=aarch64_rust-hashbrown+raw-entry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+raw-entry-devel}"
SRC_URI[aarch64_rust-hashbrown+raw-entry-devel.sha256sum] = "bbdcaa27c3cfc69a7a04029c9f76ba923b243f1d7e4602ffdcd70378bbf603ce"

URI_aarch64_rust-hashbrown+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+rayon-devel-0.15.5-1.el10_1.noarch.rpm;name=aarch64_rust-hashbrown+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+rayon-devel}"
SRC_URI[aarch64_rust-hashbrown+rayon-devel.sha256sum] = "888d890b1b7d15c68239874377e7a8b4a6cf78c552c786ee24715512513a9f51"

URI_aarch64_rust-hashbrown+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+serde-devel-0.15.5-1.el10_1.noarch.rpm;name=aarch64_rust-hashbrown+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+serde-devel}"
SRC_URI[aarch64_rust-hashbrown+serde-devel.sha256sum] = "f0218a5f9def6809befc1d7b15271caf09a951ccbffbc81e2ebb6e5beb6be3cb"

URI_aarch64_rust-hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown-devel-0.15.5-1.el10_1.noarch.rpm;name=aarch64_rust-hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown-devel}"
SRC_URI[aarch64_rust-hashbrown-devel.sha256sum] = "55f870a3aa64ee8eaa68e285a3b8f78bc611624239f85a3587173ea20c51a964"

RDEPENDS:rust-hashbrown+allocator-api2-devel = " \
 cargo \
 rust-allocator-api2+alloc-devel \
 rust-allocator-api2-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+default-devel = " \
 cargo \
 rust-hashbrown+allocator-api2-devel \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+equivalent-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown+raw-entry-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+default-hasher-devel = " \
 cargo \
 rust-foldhash0.1-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+equivalent-devel = " \
 cargo \
 rust-equivalent-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+inline-more-devel = " \
 cargo \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+raw-entry-devel = " \
 cargo \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+rayon-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-hashbrown+serde-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-hashbrown-devel = " \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~"
