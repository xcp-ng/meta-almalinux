# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cryptoki"
PV = "0.12.0"
PR = "3.el10_3"
PACKAGES = " \
 rust-cryptoki+default-devel \
 rust-cryptoki+generate-bindings-devel \
 rust-cryptoki+serde-devel \
 rust-cryptoki-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cryptoki-0.12.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78ddd2560f7ca23c5cb2e2743ce7ede11bb08e0e04d50af854b1fe32c6bc9a5b"

URI_x86_64_v2_rust-cryptoki+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki+default-devel-0.12.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cryptoki+default-devel}"
SRC_URI[x86_64_v2_rust-cryptoki+default-devel.sha256sum] = "d65ff7a42db9f142fcdf881d06ef9b583c10883a09a451f46d4367087f72051e"

URI_x86_64_v2_rust-cryptoki+generate-bindings-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki+generate-bindings-devel-0.12.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki+generate-bindings-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cryptoki+generate-bindings-devel}"
SRC_URI[x86_64_v2_rust-cryptoki+generate-bindings-devel.sha256sum] = "1c922c90c135e459b7724bb25c044f9da3b2f30902f200a06069a43e3bfc880a"

URI_x86_64_v2_rust-cryptoki+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki+serde-devel-0.12.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cryptoki+serde-devel}"
SRC_URI[x86_64_v2_rust-cryptoki+serde-devel.sha256sum] = "417c3b71cf6d326cfdd04fa7322902d7a1fe7501849bbe84283f7cd7ca5e396c"

URI_x86_64_v2_rust-cryptoki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki-devel-0.12.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cryptoki-devel}"
SRC_URI[x86_64_v2_rust-cryptoki-devel.sha256sum] = "d45f6c5366465680c628b496ab39483949a0a139087d2f45b7aead234d710508"

URI_aarch64_rust-cryptoki+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki+default-devel-0.12.0-3.el10_3.noarch.rpm;name=aarch64_rust-cryptoki+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cryptoki+default-devel}"
SRC_URI[aarch64_rust-cryptoki+default-devel.sha256sum] = "fd59981686321df7832094c8038e816f31a32bc590b87593a3909b9d4afb3dc7"

URI_aarch64_rust-cryptoki+generate-bindings-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki+generate-bindings-devel-0.12.0-3.el10_3.noarch.rpm;name=aarch64_rust-cryptoki+generate-bindings-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cryptoki+generate-bindings-devel}"
SRC_URI[aarch64_rust-cryptoki+generate-bindings-devel.sha256sum] = "e932e4416ec15c3c5290c7d73ee585f8a80267e60ee3b50a1fe82a9f7a13c0af"

URI_aarch64_rust-cryptoki+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki+serde-devel-0.12.0-3.el10_3.noarch.rpm;name=aarch64_rust-cryptoki+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cryptoki+serde-devel}"
SRC_URI[aarch64_rust-cryptoki+serde-devel.sha256sum] = "3109c7fd52e48098fcb9d716fd0a80c6766d636972095fc4a70b72c9b032b333"

URI_aarch64_rust-cryptoki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki-devel-0.12.0-3.el10_3.noarch.rpm;name=aarch64_rust-cryptoki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cryptoki-devel}"
SRC_URI[aarch64_rust-cryptoki-devel.sha256sum] = "34f9e5b3ac392aec785f18370888d59c582d4d48e4570753f727ab0beffa42dd"

RDEPENDS:rust-cryptoki+default-devel = " \
 cargo \
 rust-cryptoki-devel \
 "
RDEPENDS:rust-cryptoki+generate-bindings-devel = " \
 cargo \
 rust-cryptoki-devel \
 rust-cryptoki-sys+generate-bindings-devel \
 "
RDEPENDS:rust-cryptoki+serde-devel = " \
 cargo \
 rust-cryptoki-devel \
 rust-secrecy+serde-devel \
 "
RDEPENDS:rust-cryptoki-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cryptoki-sys+default-devel \
 rust-libloading0.8+default-devel \
 rust-log+default-devel \
 rust-secrecy+default-devel \
 "
