# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ssdeep"
PV = "2.14.1"
PR = "19.el10_0"
PACKAGES = " \
 ssdeep \
 ssdeep-devel \
 ssdeep-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/ssdeep-2.14.1-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9460a94d57827f7e8226f6581b14061c7a84f56e67b52572c853929bb0f1df1"

URI_x86_64_v2_ssdeep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ssdeep-2.14.1-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ssdeep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ssdeep}"
SRC_URI[x86_64_v2_ssdeep.sha256sum] = "44a8ebfa3134a28ba0d01ddc0d06fbce9284525a89915f25df7283aa879155e6"

URI_x86_64_v2_ssdeep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ssdeep-devel-2.14.1-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ssdeep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ssdeep-devel}"
SRC_URI[x86_64_v2_ssdeep-devel.sha256sum] = "e378c7d7b46d4d21a1d2e3faa0899f7bcf4be7adee0ce3de4a0ede488c17c260"

URI_x86_64_v2_ssdeep-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ssdeep-libs-2.14.1-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ssdeep-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ssdeep-libs}"
SRC_URI[x86_64_v2_ssdeep-libs.sha256sum] = "e44afac574b2e559c1515b68356f6b35e6b90695bf01ad032ae435a671771ef1"

URI_aarch64_ssdeep = "${EPEL_MIRROR}/aarch64/Packages/s/ssdeep-2.14.1-19.el10_0.aarch64.rpm;name=aarch64_ssdeep;unpack=0"
SRC_URI:append = " ${URI_aarch64_ssdeep}"
SRC_URI[aarch64_ssdeep.sha256sum] = "45ab3294a766b20dc755cf5f75fe47698beb2f164be82be312bb61e7039567d7"

URI_aarch64_ssdeep-devel = "${EPEL_MIRROR}/aarch64/Packages/s/ssdeep-devel-2.14.1-19.el10_0.aarch64.rpm;name=aarch64_ssdeep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ssdeep-devel}"
SRC_URI[aarch64_ssdeep-devel.sha256sum] = "4bb7280483c6ae4c2c7ec95fec99f732b2f0970974bf635317f30ec89470c69b"

URI_aarch64_ssdeep-libs = "${EPEL_MIRROR}/aarch64/Packages/s/ssdeep-libs-2.14.1-19.el10_0.aarch64.rpm;name=aarch64_ssdeep-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ssdeep-libs}"
SRC_URI[aarch64_ssdeep-libs.sha256sum] = "065468f1d290337975fef6182221c1009751957711deb636bd0de473851b6727"

RDEPENDS:ssdeep = " \
 glibc \
 libgcc \
 libstdc++ \
 ssdeep-libs \
 "
RDEPENDS:ssdeep-devel = " \
 ssdeep-libs \
 "
RDEPENDS:ssdeep-libs = " \
 glibc \
 "
