# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "poly2tri"
PV = "0.0^20130501hg26242d0aa7b8"
PR = "3.el10_2"
PACKAGES = " \
 poly2tri \
 poly2tri-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/poly2tri-0.0^20130501hg26242d0aa7b8-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "13c077cbfaab0443a62c2a0ccbc8111ea33f0132ece8fd4d6e919876fb2e30f7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/poly2tri-0.0^20130501hg26242d0aa7b8-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_poly2tri;unpack=0"
SRC_URI[x86_64_v2_poly2tri.sha256sum] = "0d7dfee7869e0ab6bc2deac48e76a0e36b80fad4dabf0e69f3c7a48f8b42bcae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/poly2tri-devel-0.0^20130501hg26242d0aa7b8-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_poly2tri-devel;unpack=0"
SRC_URI[x86_64_v2_poly2tri-devel.sha256sum] = "049c43bc135b07458cb5f38c1b6904d41c5c1200737d6aac1f68662c8ff60a8a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/poly2tri-0.0^20130501hg26242d0aa7b8-3.el10_2.aarch64.rpm;name=aarch64_poly2tri;unpack=0"
SRC_URI[aarch64_poly2tri.sha256sum] = "dfaf3fea8fd069eed951588625c2a5424b0f78b1c0d2f4eecd90c3200264e44f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/poly2tri-devel-0.0^20130501hg26242d0aa7b8-3.el10_2.aarch64.rpm;name=aarch64_poly2tri-devel;unpack=0"
SRC_URI[aarch64_poly2tri-devel.sha256sum] = "3b96a6a8e9c69917d40141f55abd4e4e69738a723a1c38338ea3e1659a2c8852"

RDEPENDS:poly2tri = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:poly2tri-devel = " \
 poly2tri \
 "
