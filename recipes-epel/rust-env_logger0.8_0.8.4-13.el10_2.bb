# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_logger0.8"
PV = "0.8.4"
PR = "13.el10_2"
PACKAGES = " \
 rust-env_logger0.8+atty-devel \
 rust-env_logger0.8+default-devel \
 rust-env_logger0.8+humantime-devel \
 rust-env_logger0.8+regex-devel \
 rust-env_logger0.8+termcolor-devel \
 rust-env_logger0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_logger0.8-0.8.4-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad5f04a95e854184104683f3c4478e25b455855db7878b1f95d902113a1343d5"

URI_x86_64_v2_rust-env_logger0.8+atty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+atty-devel-0.8.4-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+atty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+atty-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+atty-devel.sha256sum] = "46510664c6a240f9f50d1b1c92f9912b8a8a842ab61b03c31452620d95c1f845"

URI_x86_64_v2_rust-env_logger0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+default-devel-0.8.4-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+default-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+default-devel.sha256sum] = "1621370600913f401b58cebf70d0523d89eb722824c252a38471137be5f65ab3"

URI_x86_64_v2_rust-env_logger0.8+humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+humantime-devel-0.8.4-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+humantime-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+humantime-devel.sha256sum] = "dfb55f2c97a326478d9f10a263eb77308c4b15d6769589648bfc40b7ec4c3269"

URI_x86_64_v2_rust-env_logger0.8+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+regex-devel-0.8.4-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+regex-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+regex-devel.sha256sum] = "bb2d5713460bbc4e12713b45b9d3376eda153915f8f267f3631c205f571bed4b"

URI_x86_64_v2_rust-env_logger0.8+termcolor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+termcolor-devel-0.8.4-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+termcolor-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+termcolor-devel.sha256sum] = "bd3873de2b3f097325ac977ff149bd76b44bd98efee74b5c13150bef02e34dc6"

URI_x86_64_v2_rust-env_logger0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8-devel-0.8.4-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8-devel.sha256sum] = "cb9e56f1b28ca743b0b538b84c001faf207a4a5c660e62e441f4f473af0b703b"
RPROVIDES:rust-env_logger0.8-devel:x86_64_v2 = "virtual/crate_env_logger__ge_0.6.1"

URI_aarch64_rust-env_logger0.8+atty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+atty-devel-0.8.4-13.el10_2.noarch.rpm;name=aarch64_rust-env_logger0.8+atty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+atty-devel}"
SRC_URI[aarch64_rust-env_logger0.8+atty-devel.sha256sum] = "9f601ec2caa7b0cfb09b6ed7ece7ca4ae32699c14821af3f2bf90c6f87184215"

URI_aarch64_rust-env_logger0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+default-devel-0.8.4-13.el10_2.noarch.rpm;name=aarch64_rust-env_logger0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+default-devel}"
SRC_URI[aarch64_rust-env_logger0.8+default-devel.sha256sum] = "29d066b3f8d8288e95c2c4fef214848e3da57e372f18732f1219788188e3f303"

URI_aarch64_rust-env_logger0.8+humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+humantime-devel-0.8.4-13.el10_2.noarch.rpm;name=aarch64_rust-env_logger0.8+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+humantime-devel}"
SRC_URI[aarch64_rust-env_logger0.8+humantime-devel.sha256sum] = "97589a3c554422fa149d66ac341d24e2295c186c7ccce56c1adf3a782a830b8c"

URI_aarch64_rust-env_logger0.8+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+regex-devel-0.8.4-13.el10_2.noarch.rpm;name=aarch64_rust-env_logger0.8+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+regex-devel}"
SRC_URI[aarch64_rust-env_logger0.8+regex-devel.sha256sum] = "ff1c0f03b48f91933be5be728db9a8ad0719b454ce109fdbc4dd6768579bdc05"

URI_aarch64_rust-env_logger0.8+termcolor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+termcolor-devel-0.8.4-13.el10_2.noarch.rpm;name=aarch64_rust-env_logger0.8+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+termcolor-devel}"
SRC_URI[aarch64_rust-env_logger0.8+termcolor-devel.sha256sum] = "0c566291098ee4658d6c03ac60b637917d1918d01f183a0f8cc726353d8e7dbb"

URI_aarch64_rust-env_logger0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8-devel-0.8.4-13.el10_2.noarch.rpm;name=aarch64_rust-env_logger0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8-devel}"
SRC_URI[aarch64_rust-env_logger0.8-devel.sha256sum] = "7b500737df75948010ad270229d43be863cf1f3e5c22c5010de5b2d4d834ac49"
RPROVIDES:rust-env_logger0.8-devel:aarch64 = "virtual/crate_env_logger__ge_0.6.1"

RDEPENDS:rust-env_logger0.8+atty-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 "
RDEPENDS:rust-env_logger0.8+default-devel = " \
 cargo \
 rust-env_logger0.8+atty-devel \
 rust-env_logger0.8+humantime-devel \
 rust-env_logger0.8+regex-devel \
 rust-env_logger0.8+termcolor-devel \
 rust-env_logger0.8-devel \
 "
RDEPENDS:rust-env_logger0.8+humantime-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 rust-humantime+default-devel \
 "
RDEPENDS:rust-env_logger0.8+regex-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-env_logger0.8+termcolor-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 rust-termcolor+default-devel \
 "
RDEPENDS:rust-env_logger0.8-devel = " \
 cargo \
 rust-log+default-devel \
 rust-log+std-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_env_logger__ge_0.6.1"

PROVIDES:append:aarch64 = " rpm/virtual/crate_env_logger__ge_0.6.1"
