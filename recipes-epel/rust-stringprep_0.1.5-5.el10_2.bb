# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-stringprep"
PV = "0.1.5"
PR = "5.el10_2"
PACKAGES = " \
 rust-stringprep+default-devel \
 rust-stringprep-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-stringprep-0.1.5-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e18d526c9a7d8cfa02821bc1fac70cec6030dff454a8c977e077b21e67adb2fb"

URI_x86_64_v2_rust-stringprep+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stringprep+default-devel-0.1.5-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stringprep+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stringprep+default-devel}"
SRC_URI[x86_64_v2_rust-stringprep+default-devel.sha256sum] = "80fbfdc8a85da13dff5b196a981d6f63d05455f5fe1001cc8c0093dd527fe77e"

URI_x86_64_v2_rust-stringprep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stringprep-devel-0.1.5-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stringprep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stringprep-devel}"
SRC_URI[x86_64_v2_rust-stringprep-devel.sha256sum] = "f4c99316f571aa38cd09d8e37722a594ad91b396fffee3b19ccdc7a570da1326"

URI_aarch64_rust-stringprep+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stringprep+default-devel-0.1.5-5.el10_2.noarch.rpm;name=aarch64_rust-stringprep+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stringprep+default-devel}"
SRC_URI[aarch64_rust-stringprep+default-devel.sha256sum] = "f29e8edcc500c2576cee1512f249c3f6791d1d97858508de201f366942f96334"

URI_aarch64_rust-stringprep-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stringprep-devel-0.1.5-5.el10_2.noarch.rpm;name=aarch64_rust-stringprep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stringprep-devel}"
SRC_URI[aarch64_rust-stringprep-devel.sha256sum] = "13ad0efde359e0cdaf44c66e9f4b32143a19468b20d0032f962a4cea57e4e431"

RDEPENDS:rust-stringprep+default-devel = " \
 cargo \
 rust-stringprep-devel \
 "
RDEPENDS:rust-stringprep-devel = " \
 cargo \
 rust-unicode-bidi+default-devel \
 rust-unicode-normalization+default-devel \
 rust-unicode-properties+default-devel \
 "
