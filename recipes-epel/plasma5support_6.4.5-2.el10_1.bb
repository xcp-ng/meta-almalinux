# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma5support"
PV = "6.4.5"
PR = "2.el10_1"
PACKAGES = " \
 plasma5support \
 plasma5support-devel \
 plasma5support-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma5support-6.4.5-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43c7a5974dfadf01d0ec5aeffdeebd7735971366fb48fbe09eb1a955d7fe759a"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - plasma5support: libgps.so.30()(64bit)

URI_x86_64_v2_plasma5support = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma5support-6.4.5-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma5support;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma5support}"
SRC_URI[x86_64_v2_plasma5support.sha256sum] = "dff9d997c3b10c9494dd16410a6fa5918dfb5fe5eec775d8bbada54b5b442050"

URI_x86_64_v2_plasma5support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma5support-devel-6.4.5-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma5support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma5support-devel}"
SRC_URI[x86_64_v2_plasma5support-devel.sha256sum] = "478d9007beb57359b34ea9bed45b414c2cad708e4f5b30a09ec7dd9a871c605a"

URI_x86_64_v2_plasma5support-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma5support-doc-6.4.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_plasma5support-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma5support-doc}"
SRC_URI[x86_64_v2_plasma5support-doc.sha256sum] = "255ca1ccd0b11bcf70f7d399112890e4956167ed5b268185a7713b73d38355ab"

URI_aarch64_plasma5support = "${EPEL_MIRROR}/aarch64/Packages/p/plasma5support-6.4.5-2.el10_1.aarch64.rpm;name=aarch64_plasma5support;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma5support}"
SRC_URI[aarch64_plasma5support.sha256sum] = "e0bb019677938081f9090f5e62532369024bfbcac043876f28449558b2f2f3ca"

URI_aarch64_plasma5support-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma5support-devel-6.4.5-2.el10_1.aarch64.rpm;name=aarch64_plasma5support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma5support-devel}"
SRC_URI[aarch64_plasma5support-devel.sha256sum] = "2a05f4ef3e287f2b4f8e4e1fb917102ea6acb7c6a611f58e9b108504f21cd9dc"

URI_aarch64_plasma5support-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma5support-doc-6.4.5-2.el10_1.noarch.rpm;name=aarch64_plasma5support-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma5support-doc}"
SRC_URI[aarch64_plasma5support-doc.sha256sum] = "c3cd6923ff13193a0c7172b147b2d9ddde906d46e884666b261985c289449734"

RDEPENDS:plasma5support:x86_64_v2 = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-networkmanager-qt \
 kf6-solid \
 libX11 \
 libXfixes \
 libksysguard \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
"
RDEPENDS:plasma5support:aarch64 = " \
 glibc \
 gpsd-libs \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-networkmanager-qt \
 kf6-solid \
 libX11 \
 libXfixes \
 libksysguard \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
"
RDEPENDS:plasma5support-devel = " \
 cmake-filesystem \
 plasma5support \
 qt6-qtbase-devel \
 "
RDEPENDS:plasma5support-doc = " \
 "
