# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "exiv2"
PV = "0.28.9"
PR = "1.el10"
PACKAGES = " \
 exiv2 \
 exiv2-devel \
 exiv2-doc \
 exiv2-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/exiv2-0.28.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7ee1feffde6027cb1cb5295e2b4ae0e37cfd27195fc6933d7e05769a7556c8e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/exiv2-0.28.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_exiv2;unpack=0"
SRC_URI[x86_64_v2_exiv2.sha256sum] = "b62522c957c7ca8cf71f18ec99e97b2b0bd4d33219f05e6133c16fa507345003"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/exiv2-devel-0.28.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_exiv2-devel;unpack=0"
SRC_URI[x86_64_v2_exiv2-devel.sha256sum] = "608f1564beaed55a9c7561c2877d3d5e42b74ea4d841321b28d847e99523acf2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/exiv2-doc-0.28.9-1.el10.noarch.rpm;name=x86_64_v2_exiv2-doc;unpack=0"
SRC_URI[x86_64_v2_exiv2-doc.sha256sum] = "216f8a10c85c45dbefd73d4cac5daab66e651851a860df406fbbc8469b81495f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/exiv2-libs-0.28.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_exiv2-libs;unpack=0"
SRC_URI[x86_64_v2_exiv2-libs.sha256sum] = "efd7dbdaf2c72f68a68a938869f680874ddd4d592dcd41f856af6d3a49335ade"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/exiv2-0.28.9-1.el10.aarch64.rpm;name=aarch64_exiv2;unpack=0"
SRC_URI[aarch64_exiv2.sha256sum] = "c9d4e453f8a3a6b4238b1d2a1fa37c7f920d818a1815038d778f1d8de1a833c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/exiv2-devel-0.28.9-1.el10.aarch64.rpm;name=aarch64_exiv2-devel;unpack=0"
SRC_URI[aarch64_exiv2-devel.sha256sum] = "ca5ad0796e29f55f941158fbd0eb65e0a780324a8dd8612c0a4bf07079ebf142"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/exiv2-doc-0.28.9-1.el10.noarch.rpm;name=aarch64_exiv2-doc;unpack=0"
SRC_URI[aarch64_exiv2-doc.sha256sum] = "216f8a10c85c45dbefd73d4cac5daab66e651851a860df406fbbc8469b81495f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/exiv2-libs-0.28.9-1.el10.aarch64.rpm;name=aarch64_exiv2-libs;unpack=0"
SRC_URI[aarch64_exiv2-libs.sha256sum] = "6ffd3082210fce4283afaad472b03a980dcad5e3320492eff4bceb53cd90904d"

RDEPENDS:exiv2 = " \
 exiv2-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:exiv2-devel = " \
 brotli-devel \
 cmake-filesystem \
 exiv2-libs \
 expat-devel \
 inih-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:exiv2-doc = " \
 "
RDEPENDS:exiv2-libs = " \
 expat \
 glibc \
 inih-cpp \
 libbrotli \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
