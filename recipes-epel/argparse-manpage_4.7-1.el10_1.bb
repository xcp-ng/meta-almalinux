# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "argparse-manpage"
PV = "4.7"
PR = "1.el10_1"
PACKAGES = " \
 argparse-manpage \
 python3-argparse-manpage \
 python3-argparse-manpage+setuptools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/argparse-manpage-4.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bc4932f4fbd1154b3e4844cf924357fdfa6298c82b9aca641084bba4a6d44d7"

URI_x86_64_v2_argparse-manpage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/argparse-manpage-4.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_argparse-manpage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_argparse-manpage}"
SRC_URI[x86_64_v2_argparse-manpage.sha256sum] = "444c396a90cfe6797dcb1064e03d160759bf430f90e46576eb5d0009a65d8cc9"

URI_x86_64_v2_python3-argparse-manpage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-argparse-manpage-4.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-argparse-manpage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-argparse-manpage}"
SRC_URI[x86_64_v2_python3-argparse-manpage.sha256sum] = "31b5f0b84046d7f2489888ff31478b3c5cf5872fdaa82bc1e9935c98b5a741ec"

URI_x86_64_v2_python3-argparse-manpage+setuptools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-argparse-manpage+setuptools-4.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-argparse-manpage+setuptools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-argparse-manpage+setuptools}"
SRC_URI[x86_64_v2_python3-argparse-manpage+setuptools.sha256sum] = "f5dd3e6828aad0cf9b868b145e0555bbee8145079e5ade76dda3c4a83dd429cc"

URI_aarch64_argparse-manpage = "${EPEL_MIRROR}/aarch64/Packages/a/argparse-manpage-4.7-1.el10_1.noarch.rpm;name=aarch64_argparse-manpage;unpack=0"
SRC_URI:append = " ${URI_aarch64_argparse-manpage}"
SRC_URI[aarch64_argparse-manpage.sha256sum] = "3aeb3d6355f2739c2aff024c205f4596329c0369a2642ae72e2586abd1a4c8a7"

URI_aarch64_python3-argparse-manpage = "${EPEL_MIRROR}/aarch64/Packages/p/python3-argparse-manpage-4.7-1.el10_1.noarch.rpm;name=aarch64_python3-argparse-manpage;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-argparse-manpage}"
SRC_URI[aarch64_python3-argparse-manpage.sha256sum] = "3136b6a12a2ecd7b461201360f6cd7bbba1d2ab0d7f9df280b46e01e4ea99910"

URI_aarch64_python3-argparse-manpage+setuptools = "${EPEL_MIRROR}/aarch64/Packages/p/python3-argparse-manpage+setuptools-4.7-1.el10_1.noarch.rpm;name=aarch64_python3-argparse-manpage+setuptools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-argparse-manpage+setuptools}"
SRC_URI[aarch64_python3-argparse-manpage+setuptools.sha256sum] = "e2debceccbe4e80bd3d4690f2781996114c51f413acc83bc465f9d85b2ed6650"

RDEPENDS:argparse-manpage = " \
 python3 \
 python3-argparse-manpage \
 "
RDEPENDS:python3-argparse-manpage = " \
 python3 \
 "
RDEPENDS:python3-argparse-manpage+setuptools = " \
 python3 \
 python3-argparse-manpage \
 python3-setuptools \
 "
