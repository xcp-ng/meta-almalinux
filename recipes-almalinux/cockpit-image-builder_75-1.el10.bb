# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-image-builder"
PV = "75"
PR = "1.el10"
PACKAGES = " \
 cockpit-image-builder \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-image-builder-75-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7089796ca674223463872e5ca9ce3ead9e115bbf98414254f36d3953ee6ada28"

URI_x86_64_v2_cockpit-image-builder = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-image-builder-75-1.el10.noarch.rpm;name=x86_64_v2_cockpit-image-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-image-builder}"
SRC_URI[x86_64_v2_cockpit-image-builder.sha256sum] = "448f37d559a38a77b527eb0f43e651181f5c0058f199d413e9aa9f49e741d0c9"

URI_aarch64_cockpit-image-builder = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-image-builder-75-1.el10.noarch.rpm;name=aarch64_cockpit-image-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-image-builder}"
SRC_URI[aarch64_cockpit-image-builder.sha256sum] = "448f37d559a38a77b527eb0f43e651181f5c0058f199d413e9aa9f49e741d0c9"

RDEPENDS:cockpit-image-builder = " \
 cockpit \
 cockpit-files \
 osbuild-composer \
 "
