# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tendril"
PV = "0.5.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-tendril+default-devel \
 rust-tendril+encoding_rs-devel \
 rust-tendril-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tendril-0.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2218798c905efbb66009a1b23eae7c7525c5af15bebe3ae7e49626f7d459c905"

URI_x86_64_v2_rust-tendril+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tendril+default-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tendril+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tendril+default-devel}"
SRC_URI[x86_64_v2_rust-tendril+default-devel.sha256sum] = "5269b388f89009d7cf4c468f60bd31873e8d0eff1a24ea107bed2f13dbe6c9e5"

URI_x86_64_v2_rust-tendril+encoding_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tendril+encoding_rs-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tendril+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tendril+encoding_rs-devel}"
SRC_URI[x86_64_v2_rust-tendril+encoding_rs-devel.sha256sum] = "b41171eab0dfe601efbd880adff6e32e93fe7683fa73a1cddc7c5ac7171a873b"

URI_x86_64_v2_rust-tendril-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tendril-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tendril-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tendril-devel}"
SRC_URI[x86_64_v2_rust-tendril-devel.sha256sum] = "17f0af16782a1360602e212e017f27c9089d0d4176ebe1f95cdc21e5dca4c5ae"

URI_aarch64_rust-tendril+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tendril+default-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-tendril+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tendril+default-devel}"
SRC_URI[aarch64_rust-tendril+default-devel.sha256sum] = "2edb58736eae28a89db9e96d5e8579e9daabe75fa2b5d2e0e99da2df551fbb6f"

URI_aarch64_rust-tendril+encoding_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tendril+encoding_rs-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-tendril+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tendril+encoding_rs-devel}"
SRC_URI[aarch64_rust-tendril+encoding_rs-devel.sha256sum] = "023e039139ed3aeb2c19b30cf5320762659ea94751dfd7863ba23a6268d893c8"

URI_aarch64_rust-tendril-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tendril-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-tendril-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tendril-devel}"
SRC_URI[aarch64_rust-tendril-devel.sha256sum] = "ea8be735c249df503e4ca0800afcfeca7f254bb7b172ab35ea3b9cc1bced0b38"

RDEPENDS:rust-tendril+default-devel = " \
 cargo \
 rust-tendril-devel \
 "
RDEPENDS:rust-tendril+encoding_rs-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-tendril-devel \
 "
RDEPENDS:rust-tendril-devel = " \
 cargo \
 rust \
 rust-new_debug_unreachable+default-devel \
 "
