# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grafana-pcp"
PV = "5.3.0"
PR = "4.el10_1"
PACKAGES = " \
 grafana-pcp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/grafana-pcp-5.3.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87591e450f9422182f477f0c2ccbe4f15fa9dc54ea9668fbd9e3792bb7c6b036"

URI_x86_64_v2_grafana-pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-pcp-5.3.0-4.el10_1.x86_64_v2.rpm;name=x86_64_v2_grafana-pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grafana-pcp}"
SRC_URI[x86_64_v2_grafana-pcp.sha256sum] = "6515231eb88b06666d32ea37547cb97fc5479cffd363f7128c949bcfeb117763"

URI_aarch64_grafana-pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-pcp-5.3.0-4.el10_1.aarch64.rpm;name=aarch64_grafana-pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_grafana-pcp}"
SRC_URI[aarch64_grafana-pcp.sha256sum] = "31219a8702e99e8e1b910b463ce5338aa29da7b722f0209f23c9104c972ecd1c"

RDEPENDS:grafana-pcp = " \
 bash \
 glibc \
 grafana \
 systemd \
 "
