# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kunitconversion"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kunitconversion \
 kf6-kunitconversion-devel \
 kf6-kunitconversion-doc \
 kf6-kunitconversion-html \
 python3-kf6-kunitconversion \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kunitconversion-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bac511a990327e06908f39a951ff726eec4ffda5b877269d75b7afc52276ee7"

URI_x86_64_v2_kf6-kunitconversion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kunitconversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kunitconversion}"
SRC_URI[x86_64_v2_kf6-kunitconversion.sha256sum] = "5977560283a3c300613411a4e0919bf385ff3d7658b8076dfc98677a7fbeeb02"

URI_x86_64_v2_kf6-kunitconversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kunitconversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kunitconversion-devel}"
SRC_URI[x86_64_v2_kf6-kunitconversion-devel.sha256sum] = "6ff124d108aaf0a70a7cb26e24cf15ff5e99e3ddf1f1716b0043496cd1d86637"

URI_x86_64_v2_kf6-kunitconversion-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kunitconversion-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kunitconversion-doc}"
SRC_URI[x86_64_v2_kf6-kunitconversion-doc.sha256sum] = "c3e1325f100865e880a7142481497caa3f7385ea00de21988681313d8491c430"

URI_x86_64_v2_kf6-kunitconversion-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kunitconversion-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kunitconversion-html}"
SRC_URI[x86_64_v2_kf6-kunitconversion-html.sha256sum] = "8b9113990340121ede26ed7ef68003d7df356e6fec35258ab26ee2b39e768d3e"

URI_x86_64_v2_python3-kf6-kunitconversion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kunitconversion-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kunitconversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kunitconversion}"
SRC_URI[x86_64_v2_python3-kf6-kunitconversion.sha256sum] = "e6274f70204f8665c14f61665ddfd122a1b9cf15c4a7f76d96cded8aaeafb921"

URI_aarch64_kf6-kunitconversion = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kunitconversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kunitconversion}"
SRC_URI[aarch64_kf6-kunitconversion.sha256sum] = "e69fb2e7427c52064979f4d1af6e32740a528f194ed2f2150b585cfe5478e272"

URI_aarch64_kf6-kunitconversion-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kunitconversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kunitconversion-devel}"
SRC_URI[aarch64_kf6-kunitconversion-devel.sha256sum] = "1ad81ea26c5b263c7c0cc5f69e2e56fb3a62e4a64122522ffaa77e2adc4031dd"

URI_aarch64_kf6-kunitconversion-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kunitconversion-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kunitconversion-doc}"
SRC_URI[aarch64_kf6-kunitconversion-doc.sha256sum] = "c2e89ec49dc89af8f54ce2985f4c0a0c2aee5b1da6c8be358a25e98504fbd3c3"

URI_aarch64_kf6-kunitconversion-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kunitconversion-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kunitconversion-html}"
SRC_URI[aarch64_kf6-kunitconversion-html.sha256sum] = "fdbc80c274189f4d45fdced61fcfed44a019c773f4d444e1f82ddd635dd53797"

URI_aarch64_python3-kf6-kunitconversion = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kunitconversion-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_python3-kf6-kunitconversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kunitconversion}"
SRC_URI[aarch64_python3-kf6-kunitconversion.sha256sum] = "0819d0ddd01919f6bd96d1e90381821d1e7fd60f087e1fda8eba7cd9f67769ab"

RDEPENDS:kf6-kunitconversion = " \
 glibc \
 kf6-filesystem \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kunitconversion-devel = " \
 cmake-filesystem \
 kf6-kunitconversion \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kunitconversion-doc = " \
 "
RDEPENDS:kf6-kunitconversion-html = " \
 "
RDEPENDS:python3-kf6-kunitconversion = " \
 glibc \
 kf6-kunitconversion \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 "
