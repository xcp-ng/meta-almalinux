# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-patsy"
PV = "1.0.2"
PR = "1.el10_2"
PACKAGES = " \
 python3-patsy \
 python3-patsy-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-patsy-1.0.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d27918ec1064145bea869755ed518c07ec702d489b2a5357dd69faa45c6c467"

URI_x86_64_v2_python3-patsy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-patsy-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-patsy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-patsy}"
SRC_URI[x86_64_v2_python3-patsy.sha256sum] = "1452e445f1f31930b4e8092cdc4e8852e7b165b2c5ab6155e19d67d85a605376"

URI_x86_64_v2_python3-patsy-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-patsy-doc-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-patsy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-patsy-doc}"
SRC_URI[x86_64_v2_python3-patsy-doc.sha256sum] = "4f7752adec084afe361e6d168f4fbe4524a25b2a68433d1a5f10ae3205241e26"

URI_aarch64_python3-patsy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-patsy-1.0.2-1.el10_2.noarch.rpm;name=aarch64_python3-patsy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-patsy}"
SRC_URI[aarch64_python3-patsy.sha256sum] = "853c69fc0ac1b7690128bc38a0180c3e70e6aa55d8b55698562d235d45bf63e2"

URI_aarch64_python3-patsy-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-patsy-doc-1.0.2-1.el10_2.noarch.rpm;name=aarch64_python3-patsy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-patsy-doc}"
SRC_URI[aarch64_python3-patsy-doc.sha256sum] = "7cda3886f08e9d57cfff480be63745673f5d5a3f155ada68ac59f73b1a27bb1c"

RDEPENDS:python3-patsy = " \
 python3 \
 python3-numpy \
 "
RDEPENDS:python3-patsy-doc = " \
 "
