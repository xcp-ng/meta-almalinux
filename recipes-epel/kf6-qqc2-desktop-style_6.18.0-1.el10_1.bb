# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-qqc2-desktop-style"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-qqc2-desktop-style \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-qqc2-desktop-style-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a0ebd1dcc0c25c4cf934beb625724a99bc954b51c65dda6cab7268046996e18"

URI_x86_64_v2_kf6-qqc2-desktop-style = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-qqc2-desktop-style-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-qqc2-desktop-style;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-qqc2-desktop-style}"
SRC_URI[x86_64_v2_kf6-qqc2-desktop-style.sha256sum] = "ab02ce9b7f89b60fac0fb7d89567b72d23968e8c22dcc3f7c175af27445f64b3"

URI_aarch64_kf6-qqc2-desktop-style = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-qqc2-desktop-style-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-qqc2-desktop-style;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-qqc2-desktop-style}"
SRC_URI[aarch64_kf6-qqc2-desktop-style.sha256sum] = "98ab416c7e3511fd72a6f48287087a6d45abd1a4082409f9ac567e30b78fcc42"

RDEPENDS:kf6-qqc2-desktop-style = " \
 cmake-filesystem \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
