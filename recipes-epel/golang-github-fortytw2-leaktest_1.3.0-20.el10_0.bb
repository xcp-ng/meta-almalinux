# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-fortytw2-leaktest"
PV = "1.3.0"
PR = "20.el10_0"
PACKAGES = " \
 golang-github-fortytw2-leaktest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-fortytw2-leaktest-1.3.0-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f237c0801ff332efa117746ad273e05026183033d412aef43c11bb8810380d7b"

URI_x86_64_v2_golang-github-fortytw2-leaktest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-fortytw2-leaktest-devel-1.3.0-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-fortytw2-leaktest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-fortytw2-leaktest-devel}"
SRC_URI[x86_64_v2_golang-github-fortytw2-leaktest-devel.sha256sum] = "ccb6b3bdd1a69c4eb938c9255d648c4c4a65a89beddbd04246f7a2d6845a7596"

URI_aarch64_golang-github-fortytw2-leaktest-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-fortytw2-leaktest-devel-1.3.0-20.el10_0.noarch.rpm;name=aarch64_golang-github-fortytw2-leaktest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-fortytw2-leaktest-devel}"
SRC_URI[aarch64_golang-github-fortytw2-leaktest-devel.sha256sum] = "a7c79acd2d1835e1291977a7d9b831df88363a7a7ea67cd66487f7bc39e600e8"

RDEPENDS:golang-github-fortytw2-leaktest-devel = " \
 go-filesystem \
 "
