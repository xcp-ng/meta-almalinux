# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "torque"
PV = "6.1.3"
PR = "16.el10"
PACKAGES = " \
 torque-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/torque-6.1.3-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab332fe0b1cabef6fe08bd6d19afb28df313bfc62190640d042101d9e4ebfe93"

URI_x86_64_v2_torque-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/torque-libs-6.1.3-16.el10.x86_64_v2.rpm;name=x86_64_v2_torque-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_torque-libs}"
SRC_URI[x86_64_v2_torque-libs.sha256sum] = "c800bda1d7e714c1702788e329c847429fbea09feb15cf4da90a0995700f0863"

URI_aarch64_torque-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/torque-libs-6.1.3-16.el10.aarch64.rpm;name=aarch64_torque-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_torque-libs}"
SRC_URI[aarch64_torque-libs.sha256sum] = "6a1b6dde0e83d19d276fc0d38a21edcd6f174ea1971e69b91e1ef50481e0ceed"

RDEPENDS:torque-libs = " \
 glibc \
 hwloc-libs \
 jsoncpp \
 libgcc \
 libstdc++ \
 libxml2 \
 munge \
 munge-libs \
 zlib-ng-compat \
 "
