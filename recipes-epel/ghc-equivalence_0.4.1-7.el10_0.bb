# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-equivalence"
PV = "0.4.1"
PR = "7.el10_0"
PACKAGES = " \
 ghc-equivalence \
 ghc-equivalence-devel \
 ghc-equivalence-doc \
 ghc-equivalence-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-equivalence-0.4.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bcdfa282103ee0f0846b7de545f58a2814816fa767b3def65977944533a82a5"

URI_x86_64_v2_ghc-equivalence = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-equivalence-0.4.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-equivalence;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-equivalence}"
SRC_URI[x86_64_v2_ghc-equivalence.sha256sum] = "5b9571dbc63fba083534ac50c1d58486eb68a9177c0480f9e41f1dc85d917741"

URI_x86_64_v2_ghc-equivalence-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-equivalence-devel-0.4.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-equivalence-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-equivalence-devel}"
SRC_URI[x86_64_v2_ghc-equivalence-devel.sha256sum] = "151e046fecf5fee8a9168bbfb146280866e5ca27e5ed80039a447c00af67fb0c"

URI_x86_64_v2_ghc-equivalence-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-equivalence-doc-0.4.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-equivalence-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-equivalence-doc}"
SRC_URI[x86_64_v2_ghc-equivalence-doc.sha256sum] = "72c2bf1b3d83e48667cad6a95761d6fda99796e4c87ba5bb388e2b07836a7da8"

URI_x86_64_v2_ghc-equivalence-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-equivalence-prof-0.4.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-equivalence-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-equivalence-prof}"
SRC_URI[x86_64_v2_ghc-equivalence-prof.sha256sum] = "5d4c5d2e9510fc09addd98c04e80534eb8cbe856097753b1f365f2d72128f00a"

URI_aarch64_ghc-equivalence = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-equivalence-0.4.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-equivalence;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-equivalence}"
SRC_URI[aarch64_ghc-equivalence.sha256sum] = "d2e2375381aa089cfcf9c14343e89af066f683ffd2ced90fedc17c907881efb6"

URI_aarch64_ghc-equivalence-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-equivalence-devel-0.4.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-equivalence-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-equivalence-devel}"
SRC_URI[aarch64_ghc-equivalence-devel.sha256sum] = "79a00bdb7dc5f270d76d5f0925e976ad182ff1679d05b931847f8966c3dfb038"

URI_aarch64_ghc-equivalence-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-equivalence-doc-0.4.1-7.el10_0.noarch.rpm;name=aarch64_ghc-equivalence-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-equivalence-doc}"
SRC_URI[aarch64_ghc-equivalence-doc.sha256sum] = "03397c59e322124827119661acd700f4d962e539609703acddd0fbc0454fb348"

URI_aarch64_ghc-equivalence-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-equivalence-prof-0.4.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-equivalence-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-equivalence-prof}"
SRC_URI[aarch64_ghc-equivalence-prof.sha256sum] = "99b1ce602eaa7fbea0d839cf39061f5494645e0086f01da5d755f7c897de18b0"

RDEPENDS:ghc-equivalence = " \
 ghc-STMonadTrans \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-template-haskell \
 ghc-transformers \
 ghc-transformers-compat \
 glibc \
 gmp \
 "
RDEPENDS:ghc-equivalence-devel = " \
 ghc-STMonadTrans-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-equivalence \
 ghc-mtl-devel \
 ghc-transformers-compat-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-equivalence-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-equivalence-prof = " \
 ghc-STMonadTrans-prof \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-equivalence-devel \
 ghc-mtl-prof \
 ghc-transformers-compat-prof \
 ghc-transformers-prof \
 "
