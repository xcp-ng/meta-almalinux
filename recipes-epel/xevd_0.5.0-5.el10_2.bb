# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xevd"
PV = "0.5.0"
PR = "5.el10_2"
PACKAGES = " \
 xevd \
 xevd-devel \
 xevd-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xevd-0.5.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e6b2680a0d80883d71a37e348b288ac36e5ad9d9b89c4b75464f2b2fa48b136"

URI_x86_64_v2_xevd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xevd-0.5.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xevd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xevd}"
SRC_URI[x86_64_v2_xevd.sha256sum] = "adbf4545b3d0b38f2bb20badac6b37ecbc00544542355a8e7a69015d785628a6"

URI_x86_64_v2_xevd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xevd-devel-0.5.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xevd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xevd-devel}"
SRC_URI[x86_64_v2_xevd-devel.sha256sum] = "371c931acb14fb95e60f4553d6e4f8a510e3feb50d56c9f622cde4aa3ae9659d"

URI_x86_64_v2_xevd-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xevd-libs-0.5.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xevd-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xevd-libs}"
SRC_URI[x86_64_v2_xevd-libs.sha256sum] = "9964471efc2fbc894ad7d6dd0727fb820344af23a6f62d9356320551839f2484"

URI_aarch64_xevd = "${EPEL_MIRROR}/aarch64/Packages/x/xevd-0.5.0-5.el10_2.aarch64.rpm;name=aarch64_xevd;unpack=0"
SRC_URI:append = " ${URI_aarch64_xevd}"
SRC_URI[aarch64_xevd.sha256sum] = "db4a3e6f84a7255763b4545901e992348f303621f9e37548f7aae04bd14566ce"

URI_aarch64_xevd-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xevd-devel-0.5.0-5.el10_2.aarch64.rpm;name=aarch64_xevd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xevd-devel}"
SRC_URI[aarch64_xevd-devel.sha256sum] = "d6e59219a1b3aaeb9e0de6ee794076c6fbe739e26a78e17ec8dc7d4cf6df8468"

URI_aarch64_xevd-libs = "${EPEL_MIRROR}/aarch64/Packages/x/xevd-libs-0.5.0-5.el10_2.aarch64.rpm;name=aarch64_xevd-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xevd-libs}"
SRC_URI[aarch64_xevd-libs.sha256sum] = "abb119c9f9dbc890eeefaec86f37aa92cfa23bc58d904c0fdf1769ae83c4338f"

RDEPENDS:xevd = " \
 glibc \
 xevd-libs \
 "
RDEPENDS:xevd-devel = " \
 pkgconf-pkg-config \
 xevd-libs \
 "
RDEPENDS:xevd-libs = " \
 glibc \
 "
