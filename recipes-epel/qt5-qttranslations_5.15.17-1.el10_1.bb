# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qttranslations"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qttranslations \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qttranslations-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69000d655393f49be275851a9cec05650afcdd0707d8ec358d3baf56f9d73476"

URI_x86_64_v2_qt5-qttranslations = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttranslations-5.15.17-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qttranslations;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttranslations}"
SRC_URI[x86_64_v2_qt5-qttranslations.sha256sum] = "1e436fa8fb4ca33792b4075d15b308abbf0529b5ebf7cb85f8e218894452ae4c"

URI_aarch64_qt5-qttranslations = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttranslations-5.15.17-1.el10_1.noarch.rpm;name=aarch64_qt5-qttranslations;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttranslations}"
SRC_URI[aarch64_qt5-qttranslations.sha256sum] = "938eca1e25ef14a98fbea4ada4bbbd8bdf294df29b6f20ca1c93c89ad58f4024"

RDEPENDS:qt5-qttranslations = " \
 "
