# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "imagej"
PV = "1.54r"
PR = "1.el10_2"
PACKAGES = " \
 imagej \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/imagej-1.54r-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f032b0c555ad1358dfe1322a378a5b4e3c63db66dcd1f4e1f7a3a900a1e5c292"

URI_x86_64_v2_imagej = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/imagej-1.54r-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_imagej;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_imagej}"
SRC_URI[x86_64_v2_imagej.sha256sum] = "df8a331bbab9ec3f7c92d9aee2090f92a89cb612f4b6aabb4ceb8d14f2e57334"

URI_aarch64_imagej = "${EPEL_MIRROR}/aarch64/Packages/i/imagej-1.54r-1.el10_2.noarch.rpm;name=aarch64_imagej;unpack=0"
SRC_URI:append = " ${URI_aarch64_imagej}"
SRC_URI[aarch64_imagej.sha256sum] = "f84782b3340094da5b3ae3efa322ba7013c10e936ee2a0f7a7c43e67e20bdc72"

RDEPENDS:imagej = " \
 bash \
 java-21-openjdk-devel \
 javapackages-tools \
 "
