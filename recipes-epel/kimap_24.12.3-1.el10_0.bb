# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kimap"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kimap \
 kimap-devel \
 kimap-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kimap-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7a15c4323b6e907f77489602d33e837b394e165c4030720b889286d35f1194f"

URI_x86_64_v2_kimap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimap-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kimap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimap}"
SRC_URI[x86_64_v2_kimap.sha256sum] = "aad849ecc72840c722485d649b40d0e191bb6770f30276dd4b5205e67ea4837b"

URI_x86_64_v2_kimap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimap-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kimap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimap-devel}"
SRC_URI[x86_64_v2_kimap-devel.sha256sum] = "84513be299ee9935014006bc1a5843652496ed93be5603fef6763cd4034afadb"

URI_x86_64_v2_kimap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimap-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kimap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimap-doc}"
SRC_URI[x86_64_v2_kimap-doc.sha256sum] = "75e975b6edafc42a7c7a08aa3f6896085b212b504b3b7c2c583e8aaefc93059c"

URI_aarch64_kimap = "${EPEL_MIRROR}/aarch64/Packages/k/kimap-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kimap;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimap}"
SRC_URI[aarch64_kimap.sha256sum] = "73f05ca075b6c6f947e199c6e476e12b3ccf65c83af9925ae5aa7d5917a7da8b"

URI_aarch64_kimap-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kimap-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kimap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimap-devel}"
SRC_URI[aarch64_kimap-devel.sha256sum] = "91a5f56a9d9810bd7503c5178333f539b2cebb24d8cfe3d1826b72616dc0feb0"

URI_aarch64_kimap-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kimap-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kimap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimap-doc}"
SRC_URI[aarch64_kimap-doc.sha256sum] = "d70519606af3040149c888690fa2381f551cfaf99316c4e1a011462377982634"

RDEPENDS:kimap = " \
 cyrus-sasl-lib \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kimap-devel = " \
 boost-devel \
 cmake-filesystem \
 cyrus-sasl-devel \
 kf6-kcoreaddons-devel \
 kimap \
 "
RDEPENDS:kimap-doc = " \
 "
