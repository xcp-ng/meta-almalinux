# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trycmd0.15"
PV = "0.15.11"
PR = "1.el10_2"
PACKAGES = " \
 rust-trycmd0.15+color-auto-devel \
 rust-trycmd0.15+color-devel \
 rust-trycmd0.15+debug-devel \
 rust-trycmd0.15+default-devel \
 rust-trycmd0.15+diff-devel \
 rust-trycmd0.15+escargot-devel \
 rust-trycmd0.15+examples-devel \
 rust-trycmd0.15+filesystem-devel \
 rust-trycmd0.15+schema-devel \
 rust-trycmd0.15-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-trycmd0.15-0.15.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43bb3ba276113ffaa2b3e51610b2436b42aa1ef391cab4585a6652e0965f5cf8"

URI_x86_64_v2_rust-trycmd0.15+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd0.15+color-auto-devel-0.15.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd0.15+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd0.15+color-auto-devel}"
SRC_URI[x86_64_v2_rust-trycmd0.15+color-auto-devel.sha256sum] = "ae0290f169125e5560e7a6c6e2bf4110039c4847be498435d12c253e70530267"

URI_x86_64_v2_rust-trycmd0.15+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd0.15+color-devel-0.15.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd0.15+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd0.15+color-devel}"
SRC_URI[x86_64_v2_rust-trycmd0.15+color-devel.sha256sum] = "ceaffddb1a7d4107686dbebb41d5f72e785f9f249a306c5a8bb4af652082cc37"

URI_x86_64_v2_rust-trycmd0.15+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd0.15+debug-devel-0.15.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd0.15+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd0.15+debug-devel}"
SRC_URI[x86_64_v2_rust-trycmd0.15+debug-devel.sha256sum] = "d2fb581231e0da1db84fd8401e0be1f846bdb89c9047df85d171f5a9b5c2e1d4"

URI_x86_64_v2_rust-trycmd0.15+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd0.15+default-devel-0.15.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd0.15+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd0.15+default-devel}"
SRC_URI[x86_64_v2_rust-trycmd0.15+default-devel.sha256sum] = "fbbed9feca42c65d0f4d0e24c30dec5cac4d682762ca8f748e9d232fc3a5031b"

URI_x86_64_v2_rust-trycmd0.15+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd0.15+diff-devel-0.15.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd0.15+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd0.15+diff-devel}"
SRC_URI[x86_64_v2_rust-trycmd0.15+diff-devel.sha256sum] = "2b0f2e0e360fc0c55b4cbff7e54cca651fac7ae90b513bcf9a946d007dc6b71d"

URI_x86_64_v2_rust-trycmd0.15+escargot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd0.15+escargot-devel-0.15.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd0.15+escargot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd0.15+escargot-devel}"
SRC_URI[x86_64_v2_rust-trycmd0.15+escargot-devel.sha256sum] = "e007f0c0a0684082fa0b55750b1aa1cbed029ac3371f630c03deae8b646bc851"

URI_x86_64_v2_rust-trycmd0.15+examples-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd0.15+examples-devel-0.15.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd0.15+examples-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd0.15+examples-devel}"
SRC_URI[x86_64_v2_rust-trycmd0.15+examples-devel.sha256sum] = "d07a35531dd79740fc61d5de00f7c307fe27e496fa687b495f5e555bf7c5e71b"

URI_x86_64_v2_rust-trycmd0.15+filesystem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd0.15+filesystem-devel-0.15.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd0.15+filesystem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd0.15+filesystem-devel}"
SRC_URI[x86_64_v2_rust-trycmd0.15+filesystem-devel.sha256sum] = "210be5d28c3be43148bea9f465b2867d7c789e66205b1bdb78298302aa6b289c"

URI_x86_64_v2_rust-trycmd0.15+schema-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd0.15+schema-devel-0.15.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd0.15+schema-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd0.15+schema-devel}"
SRC_URI[x86_64_v2_rust-trycmd0.15+schema-devel.sha256sum] = "49098c64e19d833347d692cac6579779bed54faf63a16ca4bcf0214073c2f954"

URI_x86_64_v2_rust-trycmd0.15-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd0.15-devel-0.15.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd0.15-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd0.15-devel}"
SRC_URI[x86_64_v2_rust-trycmd0.15-devel.sha256sum] = "2ac429629f0d0cbd34e40b66a3e047c5a9fde717d52f57d790515d07e0b4d6f1"

URI_aarch64_rust-trycmd0.15+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd0.15+color-auto-devel-0.15.11-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd0.15+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd0.15+color-auto-devel}"
SRC_URI[aarch64_rust-trycmd0.15+color-auto-devel.sha256sum] = "0f60153be51131abb33c057f7c3616924650196f5f55ed7f45166e62c5dd538c"

URI_aarch64_rust-trycmd0.15+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd0.15+color-devel-0.15.11-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd0.15+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd0.15+color-devel}"
SRC_URI[aarch64_rust-trycmd0.15+color-devel.sha256sum] = "00b0d2203e42ddf2b4c7f4479b5efa0dff00a5a814e58ad93ef08445ce08e4fe"

URI_aarch64_rust-trycmd0.15+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd0.15+debug-devel-0.15.11-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd0.15+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd0.15+debug-devel}"
SRC_URI[aarch64_rust-trycmd0.15+debug-devel.sha256sum] = "fc63c03702e7e7c005429539f6e87e58390ede1a2362b14163b05e2c1d020c0c"

URI_aarch64_rust-trycmd0.15+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd0.15+default-devel-0.15.11-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd0.15+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd0.15+default-devel}"
SRC_URI[aarch64_rust-trycmd0.15+default-devel.sha256sum] = "0f3fae057c2535bf0053be4082e955b49c2d2dc942498d2397b353dc9cbc0a10"

URI_aarch64_rust-trycmd0.15+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd0.15+diff-devel-0.15.11-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd0.15+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd0.15+diff-devel}"
SRC_URI[aarch64_rust-trycmd0.15+diff-devel.sha256sum] = "8f7720d34b4f10c2fc3d0285f240acc92ec8b1591457feb282cf6759b020afe6"

URI_aarch64_rust-trycmd0.15+escargot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd0.15+escargot-devel-0.15.11-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd0.15+escargot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd0.15+escargot-devel}"
SRC_URI[aarch64_rust-trycmd0.15+escargot-devel.sha256sum] = "b68d7b68f9a4ec168b6999cae2839fb9740ef73e15408637a1ad0ba7ba2733be"

URI_aarch64_rust-trycmd0.15+examples-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd0.15+examples-devel-0.15.11-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd0.15+examples-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd0.15+examples-devel}"
SRC_URI[aarch64_rust-trycmd0.15+examples-devel.sha256sum] = "e4efc16fd1db914ee5261d5e7ca9784049500806449f8592a60e718cc8e6dae6"

URI_aarch64_rust-trycmd0.15+filesystem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd0.15+filesystem-devel-0.15.11-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd0.15+filesystem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd0.15+filesystem-devel}"
SRC_URI[aarch64_rust-trycmd0.15+filesystem-devel.sha256sum] = "18ed0fbae051bae1a59746e61d43b545cf70b7046f993c9a239972ca46c16c7e"

URI_aarch64_rust-trycmd0.15+schema-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd0.15+schema-devel-0.15.11-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd0.15+schema-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd0.15+schema-devel}"
SRC_URI[aarch64_rust-trycmd0.15+schema-devel.sha256sum] = "1ca488ae5aa75c1f8b7bd0dc4d552c859786ab2683dd10a418cd154702cc09c7"

URI_aarch64_rust-trycmd0.15-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd0.15-devel-0.15.11-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd0.15-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd0.15-devel}"
SRC_URI[aarch64_rust-trycmd0.15-devel.sha256sum] = "353801ccf9c0f24460c7b4efb7e7ab940c008bed408ded7fc1f9045eb0fbd643"

RDEPENDS:rust-trycmd0.15+color-auto-devel = " \
 cargo \
 rust-snapbox0.6+color-auto-devel \
 rust-trycmd0.15+color-devel \
 rust-trycmd0.15-devel \
 "
RDEPENDS:rust-trycmd0.15+color-devel = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-snapbox0.6+color-devel \
 rust-trycmd0.15-devel \
 "
RDEPENDS:rust-trycmd0.15+debug-devel = " \
 cargo \
 rust-snapbox0.6+debug-devel \
 rust-trycmd0.15-devel \
 "
RDEPENDS:rust-trycmd0.15+default-devel = " \
 cargo \
 rust-trycmd0.15+color-auto-devel \
 rust-trycmd0.15+diff-devel \
 rust-trycmd0.15+filesystem-devel \
 rust-trycmd0.15-devel \
 "
RDEPENDS:rust-trycmd0.15+diff-devel = " \
 cargo \
 rust-snapbox0.6+diff-devel \
 rust-trycmd0.15-devel \
 "
RDEPENDS:rust-trycmd0.15+escargot-devel = " \
 cargo \
 rust-escargot+default-devel \
 rust-trycmd0.15-devel \
 "
RDEPENDS:rust-trycmd0.15+examples-devel = " \
 cargo \
 rust-snapbox0.6+examples-devel \
 rust-trycmd0.15-devel \
 "
RDEPENDS:rust-trycmd0.15+filesystem-devel = " \
 cargo \
 rust-snapbox0.6+dir-devel \
 rust-trycmd0.15-devel \
 "
RDEPENDS:rust-trycmd0.15+schema-devel = " \
 cargo \
 rust-schemars0.8+default-devel \
 rust-schemars0.8+preserve_order-devel \
 rust-serde_json+default-devel \
 rust-trycmd0.15-devel \
 "
RDEPENDS:rust-trycmd0.15-devel = " \
 cargo \
 rust \
 rust-automod+default-devel \
 rust-glob+default-devel \
 rust-humantime+default-devel \
 rust-humantime-serde+default-devel \
 rust-rayon+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-shlex+default-devel \
 rust-snapbox0.6+cmd-devel \
 rust-snapbox0.6-devel \
 virtual/crate_toml_edit/default__ge_0.23.5_with_crate_toml_edit/default__lt_0.25.0~ \
 virtual/crate_toml_edit/serde__ge_0.23.5_with_crate_toml_edit/serde__lt_0.25.0~ \
 "
