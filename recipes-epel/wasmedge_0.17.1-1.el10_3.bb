# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wasmedge"
PV = "0.17.1"
PR = "1.el10_3"
PACKAGES = " \
 wasmedge \
 wasmedge-devel \
 wasmedge-rt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wasmedge-0.17.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0382b0fa1055ffcaa169aab3ce997e195056ddca7b032ab9861d4d3e228153ee"

URI_x86_64_v2_wasmedge = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wasmedge-0.17.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wasmedge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wasmedge}"
SRC_URI[x86_64_v2_wasmedge.sha256sum] = "f9fd5a6162b886e8dfed24e3f74d773570bb0d93e210a1c3c7f88cef0e0f15c2"
RPROVIDES:wasmedge:x86_64_v2 = "virtual/libwasmedge.so.0___64bit_"

URI_x86_64_v2_wasmedge-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wasmedge-devel-0.17.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wasmedge-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wasmedge-devel}"
SRC_URI[x86_64_v2_wasmedge-devel.sha256sum] = "46ba9ad0e7e6852bf58f85e9ce3d0ce83900f1a937f0a421ebf2328adef39997"

URI_x86_64_v2_wasmedge-rt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wasmedge-rt-0.17.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wasmedge-rt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wasmedge-rt}"
SRC_URI[x86_64_v2_wasmedge-rt.sha256sum] = "142fa4208fe19a250d9fe7a5f8deb35f5bfbc61e1f281a780cd387c20402aa3c"
RPROVIDES:wasmedge-rt:x86_64_v2 = "virtual/libwasmedge.so.0___64bit_"

URI_aarch64_wasmedge = "${EPEL_MIRROR}/aarch64/Packages/w/wasmedge-0.17.1-1.el10_3.aarch64.rpm;name=aarch64_wasmedge;unpack=0"
SRC_URI:append = " ${URI_aarch64_wasmedge}"
SRC_URI[aarch64_wasmedge.sha256sum] = "7c9ec0612270fd5d5a651a5a179c5275e9e9eac45bcf14ecb8b45b45e7212463"
RPROVIDES:wasmedge:aarch64 = "virtual/libwasmedge.so.0___64bit_"

URI_aarch64_wasmedge-devel = "${EPEL_MIRROR}/aarch64/Packages/w/wasmedge-devel-0.17.1-1.el10_3.aarch64.rpm;name=aarch64_wasmedge-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wasmedge-devel}"
SRC_URI[aarch64_wasmedge-devel.sha256sum] = "1b6f4a424172f06a853d7db8e4cfc7bea09a1ba9aee5812ed9979b8543af3292"

URI_aarch64_wasmedge-rt = "${EPEL_MIRROR}/aarch64/Packages/w/wasmedge-rt-0.17.1-1.el10_3.aarch64.rpm;name=aarch64_wasmedge-rt;unpack=0"
SRC_URI:append = " ${URI_aarch64_wasmedge-rt}"
SRC_URI[aarch64_wasmedge-rt.sha256sum] = "b38976d17892785bdedb758232cd677717e7ccf633c698011e1889142029e76c"
RPROVIDES:wasmedge-rt:aarch64 = "virtual/libwasmedge.so.0___64bit_"

RDEPENDS:wasmedge = " \
 fmt \
 glibc \
 libgcc \
 libstdc++ \
 lld19 \
 lld19-libs \
 llvm19 \
 llvm19-libs \
 spdlog \
 "
RDEPENDS:wasmedge-devel = " \
 virtual/libwasmedge.so.0___64bit_ \
 wasmedge \
 "
RDEPENDS:wasmedge-rt = " \
 fmt \
 glibc \
 libgcc \
 libstdc++ \
 lld19-libs \
 llvm19-libs \
 spdlog \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libwasmedge.so.0___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libwasmedge.so.0___64bit_"
