# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-feature-classification"
PV = "2.1.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-sphinx-feature-classification \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-feature-classification-2.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18c19b70582645face04f123b3ad597439f99dbff22597b299b0ed243625a2bb"

URI_x86_64_v2_python3-sphinx-feature-classification = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-feature-classification-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-feature-classification;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-feature-classification}"
SRC_URI[x86_64_v2_python3-sphinx-feature-classification.sha256sum] = "b556d6475e19499c5070899a4092738d0497f90a7c23dbbf18270c760dce6ffa"

URI_aarch64_python3-sphinx-feature-classification = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-feature-classification-2.1.0-1.el10_2.noarch.rpm;name=aarch64_python3-sphinx-feature-classification;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-feature-classification}"
SRC_URI[aarch64_python3-sphinx-feature-classification.sha256sum] = "38067c0afc8e7c0178c62206333a0391cd7fdb39e69f1affee8915e80963d6c5"

RDEPENDS:python3-sphinx-feature-classification = " \
 python3 \
 python3-docutils \
 python3-pbr \
 "
