# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-persistent"
PV = "2.14.6.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-lift-type \
 ghc-lift-type-devel \
 ghc-lift-type-doc \
 ghc-lift-type-prof \
 ghc-persistent \
 ghc-persistent-devel \
 ghc-persistent-doc \
 ghc-persistent-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-persistent-2.14.6.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aaaa0f55b785d7135ac3b0c20cb36dd378c3e06d47e5fa87d7b897c432a1af9e"

URI_x86_64_v2_ghc-lift-type = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lift-type-0.1.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-lift-type;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lift-type}"
SRC_URI[x86_64_v2_ghc-lift-type.sha256sum] = "fc3db9ffa1aa4a50d07561dc38ecc7d6a52ed5de70e5120754d9af714a0354b1"

URI_x86_64_v2_ghc-lift-type-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lift-type-devel-0.1.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-lift-type-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lift-type-devel}"
SRC_URI[x86_64_v2_ghc-lift-type-devel.sha256sum] = "57210bb8569bc9a8e0a4f6289f77ee2f2a5477d449e9b6b7f66b20eedddb24c2"

URI_x86_64_v2_ghc-lift-type-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lift-type-doc-0.1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-lift-type-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lift-type-doc}"
SRC_URI[x86_64_v2_ghc-lift-type-doc.sha256sum] = "483086f6ec07dfc0a1a78d5e3bc10b987b077124299537f3040a9f353179f076"

URI_x86_64_v2_ghc-lift-type-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lift-type-prof-0.1.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-lift-type-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lift-type-prof}"
SRC_URI[x86_64_v2_ghc-lift-type-prof.sha256sum] = "9d07c0a59ab4a6cbb64070586a2553f8e75ee59ae41d061911060040e76bf782"

URI_x86_64_v2_ghc-persistent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-persistent-2.14.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-persistent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-persistent}"
SRC_URI[x86_64_v2_ghc-persistent.sha256sum] = "1daac082c8ccfeff8f9afb37d99ef8c1feb37f17750aeec09806b41615b7d417"

URI_x86_64_v2_ghc-persistent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-persistent-devel-2.14.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-persistent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-persistent-devel}"
SRC_URI[x86_64_v2_ghc-persistent-devel.sha256sum] = "a2e30292e61317aa07c69215e9d3248502f4362703bcebae5762cabe41daa658"

URI_x86_64_v2_ghc-persistent-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-persistent-doc-2.14.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-persistent-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-persistent-doc}"
SRC_URI[x86_64_v2_ghc-persistent-doc.sha256sum] = "cca94fa99ddd8764bca670cfcafb5376b69a4b81d6d3823974ebc5721842e405"

URI_x86_64_v2_ghc-persistent-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-persistent-prof-2.14.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-persistent-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-persistent-prof}"
SRC_URI[x86_64_v2_ghc-persistent-prof.sha256sum] = "222f71e44ecd7b8be767042e83447971e6276dd248b5dff416bee015df349994"

URI_aarch64_ghc-lift-type = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lift-type-0.1.2.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-lift-type;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lift-type}"
SRC_URI[aarch64_ghc-lift-type.sha256sum] = "8f52214d739629ed362fe3ff9ed2caf8fcd78bb057826ee70ecf4b851eff8f51"

URI_aarch64_ghc-lift-type-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lift-type-devel-0.1.2.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-lift-type-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lift-type-devel}"
SRC_URI[aarch64_ghc-lift-type-devel.sha256sum] = "e7d071bfda2ff1c1b7486012326df8ed2b23b38e644b72188b37d904ba4e0cb9"

URI_aarch64_ghc-lift-type-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lift-type-doc-0.1.2.0-1.el10_0.noarch.rpm;name=aarch64_ghc-lift-type-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lift-type-doc}"
SRC_URI[aarch64_ghc-lift-type-doc.sha256sum] = "1ae136872ba292e7e9258e7fc91a02a17d9e36f40f3e87d3710c0d2e01572925"

URI_aarch64_ghc-lift-type-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lift-type-prof-0.1.2.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-lift-type-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lift-type-prof}"
SRC_URI[aarch64_ghc-lift-type-prof.sha256sum] = "e2794d9cd18f26c1a1978dcf84b14b6e5259da687e2b3412d57100e5dcfdaa30"

URI_aarch64_ghc-persistent = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-persistent-2.14.6.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-persistent;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-persistent}"
SRC_URI[aarch64_ghc-persistent.sha256sum] = "2a1b8ab8bb15a382b3ddebc3dd6aac9b859b98acf332a8d1d76ec8aebba89eb0"

URI_aarch64_ghc-persistent-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-persistent-devel-2.14.6.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-persistent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-persistent-devel}"
SRC_URI[aarch64_ghc-persistent-devel.sha256sum] = "dcb020ab45638c0c72ee99bb8ad8d33daba0871b883e321bdb5576f2df556a90"

URI_aarch64_ghc-persistent-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-persistent-doc-2.14.6.1-1.el10_0.noarch.rpm;name=aarch64_ghc-persistent-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-persistent-doc}"
SRC_URI[aarch64_ghc-persistent-doc.sha256sum] = "64f80505dfc823611426e7947c2d495fb3caa01a20007b0fb8f3dbb36b18ecbd"

URI_aarch64_ghc-persistent-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-persistent-prof-2.14.6.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-persistent-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-persistent-prof}"
SRC_URI[aarch64_ghc-persistent-prof.sha256sum] = "43c3c91e1a59caae3a6c79f812147ee66e7a2b1c94f35e097abec347a902dcac"

RDEPENDS:ghc-lift-type = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-lift-type-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-lift-type \
 ghc-template-haskell-devel \
 "
RDEPENDS:ghc-lift-type-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-lift-type-prof = " \
 ghc-base-prof \
 ghc-lift-type-devel \
 ghc-template-haskell-prof \
 "
RDEPENDS:ghc-persistent = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-attoparsec-iso8601 \
 ghc-auto-update \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-easy-file \
 ghc-exceptions \
 ghc-fast-logger \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-http-api-data \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-conversion \
 ghc-integer-logarithms \
 ghc-lift-type \
 ghc-lifted-base \
 ghc-monad-control \
 ghc-monad-logger \
 ghc-monad-loops \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-path-pieces \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resource-pool \
 ghc-resourcet \
 ghc-safe-exceptions \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-silently \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-stm-chans \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 ghc-unliftio \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vault \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-persistent-devel = " \
 ghc-aeson-devel \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-base64-bytestring-devel \
 ghc-blaze-html-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-conduit-devel \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-fast-logger-devel \
 ghc-http-api-data-devel \
 ghc-lift-type-devel \
 ghc-monad-logger-devel \
 ghc-mtl-devel \
 ghc-path-pieces-devel \
 ghc-persistent \
 ghc-resource-pool-devel \
 ghc-resourcet-devel \
 ghc-scientific-devel \
 ghc-silently-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-th-lift-instances-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unliftio-core-devel \
 ghc-unliftio-devel \
 ghc-unordered-containers-devel \
 ghc-vault-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-persistent-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-persistent-prof = " \
 ghc-aeson-prof \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-base64-bytestring-prof \
 ghc-blaze-html-prof \
 ghc-bytestring-prof \
 ghc-conduit-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-fast-logger-prof \
 ghc-http-api-data-prof \
 ghc-lift-type-prof \
 ghc-monad-logger-prof \
 ghc-mtl-prof \
 ghc-path-pieces-prof \
 ghc-persistent-devel \
 ghc-resource-pool-prof \
 ghc-resourcet-prof \
 ghc-scientific-prof \
 ghc-silently-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-th-lift-instances-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unliftio-core-prof \
 ghc-unliftio-prof \
 ghc-unordered-containers-prof \
 ghc-vault-prof \
 ghc-vector-prof \
 "
