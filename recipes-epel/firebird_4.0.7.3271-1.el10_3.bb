# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firebird"
PV = "4.0.7.3271"
PR = "1.el10_3"
PACKAGES = " \
 firebird \
 firebird-devel \
 firebird-doc \
 firebird-examples \
 firebird-utils \
 libfbclient2 \
 libfbclient2-devel \
 libib-util \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/firebird-4.0.7.3271-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce773927b08abcdb61ffbaa29a521b0ee129b0362193b40d80f62d2258823a7d"

URI_x86_64_v2_firebird = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/firebird-4.0.7.3271-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_firebird;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firebird}"
SRC_URI[x86_64_v2_firebird.sha256sum] = "c2d3c812b7859ac1381b858b80580a82949414ae89d459cb06efb3203709d9a4"

URI_x86_64_v2_firebird-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/firebird-devel-4.0.7.3271-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_firebird-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firebird-devel}"
SRC_URI[x86_64_v2_firebird-devel.sha256sum] = "0de626efd073d425a7027612c2a10081ad4156ab30fe36f90ceaa4193c801b20"

URI_x86_64_v2_firebird-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/firebird-doc-4.0.7.3271-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_firebird-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firebird-doc}"
SRC_URI[x86_64_v2_firebird-doc.sha256sum] = "39a4a3ab65f6be71d28bbdf6cdfb142b5c9ca49d17c68234be726427ebf5a5ff"

URI_x86_64_v2_firebird-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/firebird-examples-4.0.7.3271-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_firebird-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firebird-examples}"
SRC_URI[x86_64_v2_firebird-examples.sha256sum] = "a657591e4e5559f2f6983cbdad91b927a0f1c4576943678744613e25da3d9319"

URI_x86_64_v2_firebird-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/firebird-utils-4.0.7.3271-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_firebird-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firebird-utils}"
SRC_URI[x86_64_v2_firebird-utils.sha256sum] = "ca56fe8fb334b9a1b1d89385af2d6cb8a4974edac377295b80ca2fed7fba2def"

URI_x86_64_v2_libfbclient2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfbclient2-4.0.7.3271-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libfbclient2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfbclient2}"
SRC_URI[x86_64_v2_libfbclient2.sha256sum] = "244dae87a505cad5859349327d69ba94720492ce9153cfc2c4282779d4d2a06d"

URI_x86_64_v2_libfbclient2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfbclient2-devel-4.0.7.3271-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libfbclient2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfbclient2-devel}"
SRC_URI[x86_64_v2_libfbclient2-devel.sha256sum] = "b1ca9352491427cb4c726dfec77fbc6c196696220b9a73fcf48f0fb8f74fab4d"

URI_x86_64_v2_libib-util = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libib-util-4.0.7.3271-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libib-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libib-util}"
SRC_URI[x86_64_v2_libib-util.sha256sum] = "5c2127366dbd419d65d18d6d6032151165ef626c3be41bd31f9a507f72231cf4"

URI_aarch64_firebird = "${EPEL_MIRROR}/aarch64/Packages/f/firebird-4.0.7.3271-1.el10_3.aarch64.rpm;name=aarch64_firebird;unpack=0"
SRC_URI:append = " ${URI_aarch64_firebird}"
SRC_URI[aarch64_firebird.sha256sum] = "44927796898bc29221da8a72908796f9f1c94ea2a0dce8817d948290bd5b8f28"

URI_aarch64_firebird-devel = "${EPEL_MIRROR}/aarch64/Packages/f/firebird-devel-4.0.7.3271-1.el10_3.aarch64.rpm;name=aarch64_firebird-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_firebird-devel}"
SRC_URI[aarch64_firebird-devel.sha256sum] = "cf3c4e9c91afd00523b090ca07a1811f61bff8f062a458ec4f9e0ba9224b0176"

URI_aarch64_firebird-doc = "${EPEL_MIRROR}/aarch64/Packages/f/firebird-doc-4.0.7.3271-1.el10_3.noarch.rpm;name=aarch64_firebird-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_firebird-doc}"
SRC_URI[aarch64_firebird-doc.sha256sum] = "10e2f863b79dbd65ba54d2c4a038730be2a274fefd5a5da2d88a5f26f7847385"

URI_aarch64_firebird-examples = "${EPEL_MIRROR}/aarch64/Packages/f/firebird-examples-4.0.7.3271-1.el10_3.noarch.rpm;name=aarch64_firebird-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_firebird-examples}"
SRC_URI[aarch64_firebird-examples.sha256sum] = "5d090fb14507d376c8bfd7f67c1086aa0bf232f41ffdff4b0166db9c56c95a05"

URI_aarch64_firebird-utils = "${EPEL_MIRROR}/aarch64/Packages/f/firebird-utils-4.0.7.3271-1.el10_3.aarch64.rpm;name=aarch64_firebird-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_firebird-utils}"
SRC_URI[aarch64_firebird-utils.sha256sum] = "b99c71d5b06d1db6f901b830dfa09872349be6d863bf562f02d3a5675001d44e"

URI_aarch64_libfbclient2 = "${EPEL_MIRROR}/aarch64/Packages/l/libfbclient2-4.0.7.3271-1.el10_3.aarch64.rpm;name=aarch64_libfbclient2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfbclient2}"
SRC_URI[aarch64_libfbclient2.sha256sum] = "4fdd7d4520d93a0b77e8a93f9868538ba3abce1cc8211a51d4cb9a5b03a004aa"

URI_aarch64_libfbclient2-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libfbclient2-devel-4.0.7.3271-1.el10_3.aarch64.rpm;name=aarch64_libfbclient2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfbclient2-devel}"
SRC_URI[aarch64_libfbclient2-devel.sha256sum] = "fe4b448c9b219077089e19a9ba40f4df33b6e536c3b50786336ab17e20c3af5b"

URI_aarch64_libib-util = "${EPEL_MIRROR}/aarch64/Packages/l/libib-util-4.0.7.3271-1.el10_3.aarch64.rpm;name=aarch64_libib-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_libib-util}"
SRC_URI[aarch64_libib-util.sha256sum] = "2c5d2ac930edea3d78ccbe66e74be5be6a3b36c1c0d0d4472a6aedfd91246bea"

RDEPENDS:firebird = " \
 bash \
 firebird-utils \
 glibc \
 libfbclient2 \
 libgcc \
 libib-util \
 libtomcrypt \
 libtommath \
 shadow-utils \
 "
RDEPENDS:firebird-devel = " \
 bash \
 firebird \
 libfbclient2-devel \
 "
RDEPENDS:firebird-doc = " \
 firebird \
 "
RDEPENDS:firebird-examples = " \
 firebird-doc \
 "
RDEPENDS:firebird-utils = " \
 glibc \
 libedit \
 libfbclient2 \
 libgcc \
 "
RDEPENDS:libfbclient2 = " \
 glibc \
 libgcc \
 libtommath \
 "
RDEPENDS:libfbclient2-devel = " \
 firebird-devel \
 libfbclient2 \
 pkgconf-pkg-config \
 "
RDEPENDS:libib-util = " \
 glibc \
 "
