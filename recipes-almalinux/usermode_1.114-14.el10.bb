# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "usermode"
PV = "1.114"
PR = "14.el10"
PACKAGES = " \
 usermode \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/usermode-1.114-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c885b3888e06792670ab7c9a08e9ee85d183b423f64339392b97d1a4267aa1b9"

URI_x86_64_v2_usermode = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/usermode-1.114-14.el10.x86_64_v2.rpm;name=x86_64_v2_usermode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_usermode}"
SRC_URI[x86_64_v2_usermode.sha256sum] = "41b0ef80e8b145fac74831f30665652275d193aac32eedec1d03ecfd7904ea7c"

URI_aarch64_usermode = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/usermode-1.114-14.el10.aarch64.rpm;name=aarch64_usermode;unpack=0"
SRC_URI:append = " ${URI_aarch64_usermode}"
SRC_URI[aarch64_usermode.sha256sum] = "bde9a22b03eae6e810ccfc4e5d013f792b12305b9fddf014b7ddccff01024f27"

RDEPENDS:usermode = " \
 glib2 \
 glibc \
 libselinux \
 libuser \
 pam \
 pam-libs \
 shadow-utils \
 util-linux \
 "
