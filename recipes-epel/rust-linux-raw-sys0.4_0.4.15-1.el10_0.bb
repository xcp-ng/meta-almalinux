# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-linux-raw-sys0.4"
PV = "0.4.15"
PR = "1.el10_0"
PACKAGES = " \
 rust-linux-raw-sys0.4+bootparam-devel \
 rust-linux-raw-sys0.4+btrfs-devel \
 rust-linux-raw-sys0.4+default-devel \
 rust-linux-raw-sys0.4+elf-devel \
 rust-linux-raw-sys0.4+elf_uapi-devel \
 rust-linux-raw-sys0.4+errno-devel \
 rust-linux-raw-sys0.4+general-devel \
 rust-linux-raw-sys0.4+if_arp-devel \
 rust-linux-raw-sys0.4+if_ether-devel \
 rust-linux-raw-sys0.4+if_packet-devel \
 rust-linux-raw-sys0.4+io_uring-devel \
 rust-linux-raw-sys0.4+ioctl-devel \
 rust-linux-raw-sys0.4+landlock-devel \
 rust-linux-raw-sys0.4+loop_device-devel \
 rust-linux-raw-sys0.4+mempolicy-devel \
 rust-linux-raw-sys0.4+net-devel \
 rust-linux-raw-sys0.4+netlink-devel \
 rust-linux-raw-sys0.4+no_std-devel \
 rust-linux-raw-sys0.4+prctl-devel \
 rust-linux-raw-sys0.4+ptrace-devel \
 rust-linux-raw-sys0.4+std-devel \
 rust-linux-raw-sys0.4+system-devel \
 rust-linux-raw-sys0.4+xdp-devel \
 rust-linux-raw-sys0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-linux-raw-sys0.4-0.4.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "690a3888113eeba081465ccb4afd2748f072163a21e521ba5decc18f66b2e088"

URI_x86_64_v2_rust-linux-raw-sys0.4+bootparam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+bootparam-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+bootparam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+bootparam-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+bootparam-devel.sha256sum] = "5d8b29382835e634f3994cc8f069b9df1b243966ec438ce9020ab09f3e19b26a"

URI_x86_64_v2_rust-linux-raw-sys0.4+btrfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+btrfs-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+btrfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+btrfs-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+btrfs-devel.sha256sum] = "e8b4e32e46eb6cd3002487d6a2bf7d5a79493cd07e6457f7d2499c3d9986668c"

URI_x86_64_v2_rust-linux-raw-sys0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+default-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+default-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+default-devel.sha256sum] = "da1437ad8f5987a6e5d9bcff3b733a51ab00bc958cc40822adcc4ada397877ed"

URI_x86_64_v2_rust-linux-raw-sys0.4+elf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+elf-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+elf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+elf-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+elf-devel.sha256sum] = "1b66c60dfc663ab9712ea6f96004f7cc43bcafaf24c134946da45a13e520bbe5"

URI_x86_64_v2_rust-linux-raw-sys0.4+elf_uapi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+elf_uapi-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+elf_uapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+elf_uapi-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+elf_uapi-devel.sha256sum] = "36157972621145140ff0f5fc38225255ae3d584a2368c6061687876ac4b10bb9"

URI_x86_64_v2_rust-linux-raw-sys0.4+errno-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+errno-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+errno-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+errno-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+errno-devel.sha256sum] = "5c168429c2bf6242b8637934b59c1768f41702cbbee4ffadf1e089ad07a9faf7"

URI_x86_64_v2_rust-linux-raw-sys0.4+general-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+general-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+general-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+general-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+general-devel.sha256sum] = "8855364dc1489439b54b60cb8605a3686f45d7ccd4d45f6b2ef4f192b08cc5f8"

URI_x86_64_v2_rust-linux-raw-sys0.4+if_arp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+if_arp-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+if_arp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+if_arp-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+if_arp-devel.sha256sum] = "b6fc5cadba93f0487a759911bd5a3edf237cbb03e84b390029e726a918666dd1"

URI_x86_64_v2_rust-linux-raw-sys0.4+if_ether-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+if_ether-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+if_ether-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+if_ether-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+if_ether-devel.sha256sum] = "d6d71d052a6b04502d478e81303ff389c9fb52599b1b9bf5d5f8f8c6069fb5f6"

URI_x86_64_v2_rust-linux-raw-sys0.4+if_packet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+if_packet-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+if_packet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+if_packet-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+if_packet-devel.sha256sum] = "c9ec8d9a15f042604e862460553531ac22dffbe0dddc74d4420763573b6ee972"

URI_x86_64_v2_rust-linux-raw-sys0.4+io_uring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+io_uring-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+io_uring-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+io_uring-devel.sha256sum] = "ebf69d181071233e8ae4c06b77c7517fd93f4ed3005f5c7d1fd64c7591f25241"

URI_x86_64_v2_rust-linux-raw-sys0.4+ioctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+ioctl-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+ioctl-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+ioctl-devel.sha256sum] = "3972d038530117bf0b4ebd61a3ceb1596d5c12719372ee75d679a21df452f990"

URI_x86_64_v2_rust-linux-raw-sys0.4+landlock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+landlock-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+landlock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+landlock-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+landlock-devel.sha256sum] = "ae11cb6712b7c3db203989df10caca43a4502730171d4ca2dbe3c17faab0137f"

URI_x86_64_v2_rust-linux-raw-sys0.4+loop_device-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+loop_device-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+loop_device-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+loop_device-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+loop_device-devel.sha256sum] = "c203845ce1043f7f6733dc33ec6c17b316b1530845087f1a1fd74b574f3e54b8"

URI_x86_64_v2_rust-linux-raw-sys0.4+mempolicy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+mempolicy-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+mempolicy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+mempolicy-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+mempolicy-devel.sha256sum] = "b1270926922b89167846cccd274e2f21ed1ee34da6ecee701f72bd570247e672"

URI_x86_64_v2_rust-linux-raw-sys0.4+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+net-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+net-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+net-devel.sha256sum] = "ccc9c622fb2def33086fbd2ffec2af8c08f3604ea11b6ddd57f7795454cbd681"

URI_x86_64_v2_rust-linux-raw-sys0.4+netlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+netlink-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+netlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+netlink-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+netlink-devel.sha256sum] = "b9ea3a7df794e38272b21b5c1aaf6e3758d516006cbf006dde93001b24534c32"

URI_x86_64_v2_rust-linux-raw-sys0.4+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+no_std-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+no_std-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+no_std-devel.sha256sum] = "9edc3bf0e5c6634153d17eb4a98b18de2ffd3828a1a36518e6f7aed0cf26eb9b"

URI_x86_64_v2_rust-linux-raw-sys0.4+prctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+prctl-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+prctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+prctl-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+prctl-devel.sha256sum] = "3c9bbb809402892199736036185aa9dbc423b92c7b3518e4cacec109407d3016"

URI_x86_64_v2_rust-linux-raw-sys0.4+ptrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+ptrace-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+ptrace-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+ptrace-devel.sha256sum] = "2b17d94a7ade0c8d2868116e6f530c5af2136f5f6f1d5a229543aadc16800f1c"

URI_x86_64_v2_rust-linux-raw-sys0.4+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+std-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+std-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+std-devel.sha256sum] = "172ac5436edb109a7280b579f0d739bbb78e17baae9eff47e8b3eb6884e71c27"

URI_x86_64_v2_rust-linux-raw-sys0.4+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+system-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+system-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+system-devel.sha256sum] = "d3b68c621f5506d41a26c9316e83f13693a2fec91fc68b2db72582bd38cf0bb9"

URI_x86_64_v2_rust-linux-raw-sys0.4+xdp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4+xdp-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4+xdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4+xdp-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4+xdp-devel.sha256sum] = "0c3b39487565b06c4be5f67e5bdab6bc33f05112ddce7080098340c58b908ed1"

URI_x86_64_v2_rust-linux-raw-sys0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys0.4-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys0.4-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys0.4-devel.sha256sum] = "48a9f33c63f15c3e2baee8aab6b4fede41d7c04c1a2a723b9f3440243c634bf2"

URI_aarch64_rust-linux-raw-sys0.4+bootparam-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+bootparam-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+bootparam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+bootparam-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+bootparam-devel.sha256sum] = "55934cf7e74f4d5b673bf0cf0aece0b8b5098b38a091cf15de2199951bbf1ddf"

URI_aarch64_rust-linux-raw-sys0.4+btrfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+btrfs-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+btrfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+btrfs-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+btrfs-devel.sha256sum] = "56ea94f84a2589c02771494a5a1045605606ba011df8b2a195fb03fc34d33d07"

URI_aarch64_rust-linux-raw-sys0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+default-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+default-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+default-devel.sha256sum] = "9a75380ed74418a441a7a05148181b1ddb73a602a9000c4c758c2efc8f8740b2"

URI_aarch64_rust-linux-raw-sys0.4+elf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+elf-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+elf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+elf-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+elf-devel.sha256sum] = "f8251500013e4f37e839a0b23e8d8b05f733aa2b16f6af9a2313f27ef0ad52aa"

URI_aarch64_rust-linux-raw-sys0.4+elf_uapi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+elf_uapi-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+elf_uapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+elf_uapi-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+elf_uapi-devel.sha256sum] = "153506b5dc0ca57ce63b38e7298aa388338fce68165edb79aa9f5ed1200d264c"

URI_aarch64_rust-linux-raw-sys0.4+errno-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+errno-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+errno-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+errno-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+errno-devel.sha256sum] = "2f08579a3a6aa5d232eddaee29d9695305dc60002f71ae00c5340459838061c4"

URI_aarch64_rust-linux-raw-sys0.4+general-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+general-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+general-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+general-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+general-devel.sha256sum] = "b5c4c8db26f9d0ddafe404d54093a82413360609883c3c15c8fb5277f0170b5e"

URI_aarch64_rust-linux-raw-sys0.4+if_arp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+if_arp-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+if_arp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+if_arp-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+if_arp-devel.sha256sum] = "3e04bd439af2b56f254c07b23cc7d6fe5b791773439d06e7bb0f56a855a762bf"

URI_aarch64_rust-linux-raw-sys0.4+if_ether-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+if_ether-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+if_ether-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+if_ether-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+if_ether-devel.sha256sum] = "28b84722680650616a687aae95499783fa50289d79bfc95dd67d059b701044b0"

URI_aarch64_rust-linux-raw-sys0.4+if_packet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+if_packet-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+if_packet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+if_packet-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+if_packet-devel.sha256sum] = "ce6283d9876a3a8f60eb40111a1926ae3a3509b96efbfe74fe269214d5e45189"

URI_aarch64_rust-linux-raw-sys0.4+io_uring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+io_uring-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+io_uring-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+io_uring-devel.sha256sum] = "04041adc9a08df86e956b5f0b2581f33b473fdff4add93e24128ab621a1be97c"

URI_aarch64_rust-linux-raw-sys0.4+ioctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+ioctl-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+ioctl-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+ioctl-devel.sha256sum] = "275d9e9a6fed49b91ea67d39e5edddb6c471f1e240070949b63d5d96021febbc"

URI_aarch64_rust-linux-raw-sys0.4+landlock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+landlock-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+landlock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+landlock-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+landlock-devel.sha256sum] = "0beb58ab8ceea7d50fddb1ac90018565bdfdbe5d61fbea37da2e8375a0515aaf"

URI_aarch64_rust-linux-raw-sys0.4+loop_device-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+loop_device-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+loop_device-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+loop_device-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+loop_device-devel.sha256sum] = "04c9916a9c38ff1b6054bb5627d00324731350879f123fe77553cf0024645997"

URI_aarch64_rust-linux-raw-sys0.4+mempolicy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+mempolicy-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+mempolicy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+mempolicy-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+mempolicy-devel.sha256sum] = "9ecbe83308028dfa0aece10da89c013a6703ae87a27b4a5566c74e408439c012"

URI_aarch64_rust-linux-raw-sys0.4+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+net-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+net-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+net-devel.sha256sum] = "305da7b9810c60b62b1799146f1037f4ccab8eabf2aab1b5596b4fd6be4788e5"

URI_aarch64_rust-linux-raw-sys0.4+netlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+netlink-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+netlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+netlink-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+netlink-devel.sha256sum] = "2bcb0c9cdff08c45ab24eb77a4cca9f753a4a871efc95948dc7590dd97a08a4b"

URI_aarch64_rust-linux-raw-sys0.4+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+no_std-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+no_std-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+no_std-devel.sha256sum] = "e0d24c8513b1c65a5b58797d13030f18846ba0d218f250cd79f727d5741b963c"

URI_aarch64_rust-linux-raw-sys0.4+prctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+prctl-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+prctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+prctl-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+prctl-devel.sha256sum] = "319c8f50e5ce822b3825adc61cc662412a4172070bbb3cd22aafe391c6d92559"

URI_aarch64_rust-linux-raw-sys0.4+ptrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+ptrace-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+ptrace-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+ptrace-devel.sha256sum] = "83814a63d59ed84032e13c95966434da50e66465beb972cfa18d6e1eeb5f3294"

URI_aarch64_rust-linux-raw-sys0.4+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+std-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+std-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+std-devel.sha256sum] = "cb7781b0f8d2c609be2795651d7cb442d515b87e7c64058c29663275826e0b17"

URI_aarch64_rust-linux-raw-sys0.4+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+system-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+system-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+system-devel.sha256sum] = "335334d573ae375bcae383e9b34289ef44ed4d3d1240706d64aff36f1620a5a1"

URI_aarch64_rust-linux-raw-sys0.4+xdp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4+xdp-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4+xdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4+xdp-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4+xdp-devel.sha256sum] = "dde1dd4cb5cfdb0aff482a99cd8b58bfa279ae7a1541999c1f08f9518a30312d"

URI_aarch64_rust-linux-raw-sys0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys0.4-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-linux-raw-sys0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys0.4-devel}"
SRC_URI[aarch64_rust-linux-raw-sys0.4-devel.sha256sum] = "f925d89c8760d086432e290566960c7d302734dda1c937f7038f262c79cc4e93"

RDEPENDS:rust-linux-raw-sys0.4+bootparam-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+btrfs-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+default-devel = " \
 cargo \
 rust-linux-raw-sys0.4+errno-devel \
 rust-linux-raw-sys0.4+general-devel \
 rust-linux-raw-sys0.4+std-devel \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+elf-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+elf_uapi-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+errno-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+general-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+if_arp-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+if_ether-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+if_packet-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+io_uring-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+ioctl-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+landlock-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+loop_device-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+mempolicy-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+net-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+netlink-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+no_std-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+prctl-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+ptrace-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+std-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+system-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4+xdp-devel = " \
 cargo \
 rust-linux-raw-sys0.4-devel \
 "
RDEPENDS:rust-linux-raw-sys0.4-devel = " \
 cargo \
 rust \
 "
