# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shake"
PV = "0.19.8"
PR = "30.el10_0"
PACKAGES = " \
 ghc-heaps \
 ghc-heaps-devel \
 ghc-heaps-doc \
 ghc-heaps-prof \
 ghc-js-dgtable \
 ghc-js-dgtable-devel \
 ghc-js-dgtable-doc \
 ghc-js-dgtable-prof \
 ghc-shake \
 ghc-shake-devel \
 ghc-shake-doc \
 ghc-shake-prof \
 shake \
 shake-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/shake-0.19.8-30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b831e4f09e7f6f75cb230f319be07e2fa6d1aa8f289eaf2dd971ebf1b967f60"

URI_x86_64_v2_ghc-heaps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-heaps-0.4-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-heaps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-heaps}"
SRC_URI[x86_64_v2_ghc-heaps.sha256sum] = "eebcf84f1e1eb9e8462744efa14928234931f6a6f7a4ec04b5aa5b21e6b2339a"

URI_x86_64_v2_ghc-heaps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-heaps-devel-0.4-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-heaps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-heaps-devel}"
SRC_URI[x86_64_v2_ghc-heaps-devel.sha256sum] = "31e15637a93a45de82b21c0cf7b78f55808a67ae2549276ba0703c595bcb819f"

URI_x86_64_v2_ghc-heaps-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-heaps-doc-0.4-30.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-heaps-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-heaps-doc}"
SRC_URI[x86_64_v2_ghc-heaps-doc.sha256sum] = "3a2b0133713994d4a616919a78797a077c746423bc7e6d8a5f9912cadc094538"

URI_x86_64_v2_ghc-heaps-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-heaps-prof-0.4-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-heaps-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-heaps-prof}"
SRC_URI[x86_64_v2_ghc-heaps-prof.sha256sum] = "6b0ad6a1305155d92bf05552d000e5ceb6f100e1d8e7d6b4f4c8971816bb6b4d"

URI_x86_64_v2_ghc-js-dgtable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-dgtable-0.5.2-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-js-dgtable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-js-dgtable}"
SRC_URI[x86_64_v2_ghc-js-dgtable.sha256sum] = "a0416bac8c002783d9fae3a1aa072584154e35e4970310f8fbf00b7dacfb011f"

URI_x86_64_v2_ghc-js-dgtable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-dgtable-devel-0.5.2-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-js-dgtable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-js-dgtable-devel}"
SRC_URI[x86_64_v2_ghc-js-dgtable-devel.sha256sum] = "f640d22c0de5b85951f22a2665c3529a850d9fcf6da489ad345d53621986b1ee"

URI_x86_64_v2_ghc-js-dgtable-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-dgtable-doc-0.5.2-30.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-js-dgtable-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-js-dgtable-doc}"
SRC_URI[x86_64_v2_ghc-js-dgtable-doc.sha256sum] = "da2de319253247207c8f6c54077c4d1f39b2af2346dc44485bc0d86c502b2f48"

URI_x86_64_v2_ghc-js-dgtable-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-dgtable-prof-0.5.2-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-js-dgtable-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-js-dgtable-prof}"
SRC_URI[x86_64_v2_ghc-js-dgtable-prof.sha256sum] = "f3c893e8f904067b4f391cd9369e968961d65cbc7284bfae620795666baeb701"

URI_x86_64_v2_ghc-shake = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-shake-0.19.8-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-shake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-shake}"
SRC_URI[x86_64_v2_ghc-shake.sha256sum] = "d42e97626f4cd20574d5858a11b5b6cb39537f806f688219cce01a31aaa6e3af"

URI_x86_64_v2_ghc-shake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-shake-devel-0.19.8-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-shake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-shake-devel}"
SRC_URI[x86_64_v2_ghc-shake-devel.sha256sum] = "9ef2b7eb074fe7c97f8a5a257ffb52e0583bc26a1ef781806723d98e7aa52f0e"

URI_x86_64_v2_ghc-shake-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-shake-doc-0.19.8-30.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-shake-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-shake-doc}"
SRC_URI[x86_64_v2_ghc-shake-doc.sha256sum] = "cc795c4669bc8a7150fb5e644472b7b4da07c3044c5484121a253e35fec3be7d"

URI_x86_64_v2_ghc-shake-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-shake-prof-0.19.8-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-shake-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-shake-prof}"
SRC_URI[x86_64_v2_ghc-shake-prof.sha256sum] = "bb1baa4e4ef8d853bccb2a8daa8b16a0b18ea93a975e2a4a99f9311e6a63adbe"

URI_x86_64_v2_shake = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/shake-0.19.8-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_shake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shake}"
SRC_URI[x86_64_v2_shake.sha256sum] = "42cbf015fe9854cf3ae7a3fd756a9176c304607999b1ff69cc4cbae7ffb987cb"

URI_x86_64_v2_shake-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/shake-common-0.19.8-30.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_shake-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shake-common}"
SRC_URI[x86_64_v2_shake-common.sha256sum] = "b2037784a4f61c517cdb2783b3d1eccbf00eb52b875a1a813a92aec3718c1f55"

URI_aarch64_ghc-heaps = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-heaps-0.4-30.el10_0.aarch64.rpm;name=aarch64_ghc-heaps;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-heaps}"
SRC_URI[aarch64_ghc-heaps.sha256sum] = "d6f6bb77a6331be77abe852dd538c995c04d92c2e5cd764a247985f7cf53ccbc"

URI_aarch64_ghc-heaps-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-heaps-devel-0.4-30.el10_0.aarch64.rpm;name=aarch64_ghc-heaps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-heaps-devel}"
SRC_URI[aarch64_ghc-heaps-devel.sha256sum] = "1f34b5c6b14d016f0fa906e264958329e89153d5ff58be92cf8b8643e887a06a"

URI_aarch64_ghc-heaps-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-heaps-doc-0.4-30.el10_0.noarch.rpm;name=aarch64_ghc-heaps-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-heaps-doc}"
SRC_URI[aarch64_ghc-heaps-doc.sha256sum] = "609c0fb3ab2bfe4dd5740a07e973f4dcae50f458bbb4057269a58f51eb355be3"

URI_aarch64_ghc-heaps-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-heaps-prof-0.4-30.el10_0.aarch64.rpm;name=aarch64_ghc-heaps-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-heaps-prof}"
SRC_URI[aarch64_ghc-heaps-prof.sha256sum] = "4bb5f8b54a64a7453a616a70e679cad9c111c5ea44d829aee0f04f4ec2ccc40f"

URI_aarch64_ghc-js-dgtable = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-dgtable-0.5.2-30.el10_0.aarch64.rpm;name=aarch64_ghc-js-dgtable;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-js-dgtable}"
SRC_URI[aarch64_ghc-js-dgtable.sha256sum] = "fca153e06be2a130e192223dd4f73294bedfab3485c8eb9a9b7c1a660df6eabd"

URI_aarch64_ghc-js-dgtable-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-dgtable-devel-0.5.2-30.el10_0.aarch64.rpm;name=aarch64_ghc-js-dgtable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-js-dgtable-devel}"
SRC_URI[aarch64_ghc-js-dgtable-devel.sha256sum] = "1ee099dd0e5979c6124cd0cb21171d3f39863757268d2b7f097a1df66472fb62"

URI_aarch64_ghc-js-dgtable-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-dgtable-doc-0.5.2-30.el10_0.noarch.rpm;name=aarch64_ghc-js-dgtable-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-js-dgtable-doc}"
SRC_URI[aarch64_ghc-js-dgtable-doc.sha256sum] = "c2203af167b4c7573703f90d7c5a1c980524fbfc1382011fc9326ac3726f3f33"

URI_aarch64_ghc-js-dgtable-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-dgtable-prof-0.5.2-30.el10_0.aarch64.rpm;name=aarch64_ghc-js-dgtable-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-js-dgtable-prof}"
SRC_URI[aarch64_ghc-js-dgtable-prof.sha256sum] = "eafc059c7aace634971c29c5616d7d6627b6a6ac0db6eab06889c4330939b1b7"

URI_aarch64_ghc-shake = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-shake-0.19.8-30.el10_0.aarch64.rpm;name=aarch64_ghc-shake;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-shake}"
SRC_URI[aarch64_ghc-shake.sha256sum] = "7f2e11bbd56eea4d28c63292ce35fc2428b201d46fe57405d1e6a21722d8b92e"

URI_aarch64_ghc-shake-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-shake-devel-0.19.8-30.el10_0.aarch64.rpm;name=aarch64_ghc-shake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-shake-devel}"
SRC_URI[aarch64_ghc-shake-devel.sha256sum] = "13309d2c013e2ea43ba320f0ee7e027fe41a454ba01c0849a3e0cbfb8c61d27a"

URI_aarch64_ghc-shake-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-shake-doc-0.19.8-30.el10_0.noarch.rpm;name=aarch64_ghc-shake-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-shake-doc}"
SRC_URI[aarch64_ghc-shake-doc.sha256sum] = "fc6e2df36af56a8d3630c223f55ebb44b118d1f6cff6181214d1304758484cb4"

URI_aarch64_ghc-shake-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-shake-prof-0.19.8-30.el10_0.aarch64.rpm;name=aarch64_ghc-shake-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-shake-prof}"
SRC_URI[aarch64_ghc-shake-prof.sha256sum] = "5fd5ff558775aad3ad42eca46b57aa4b6e3c94898feda2c5f23cb21ad7327895"

URI_aarch64_shake = "${EPEL_MIRROR}/aarch64/Packages/s/shake-0.19.8-30.el10_0.aarch64.rpm;name=aarch64_shake;unpack=0"
SRC_URI:append = " ${URI_aarch64_shake}"
SRC_URI[aarch64_shake.sha256sum] = "c01c37592cd4052d959f536154a172f935071abfb9fd06bf474e7e60297c37e9"

URI_aarch64_shake-common = "${EPEL_MIRROR}/aarch64/Packages/s/shake-common-0.19.8-30.el10_0.noarch.rpm;name=aarch64_shake-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_shake-common}"
SRC_URI[aarch64_shake-common.sha256sum] = "fc5d0ec96eed15cf6532f7aabdc1dbd8eb7369966f3b4dd526f0290d60749dca"

RDEPENDS:ghc-heaps = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-heaps-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-heaps \
 "
RDEPENDS:ghc-heaps-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-heaps-prof = " \
 ghc-base-prof \
 ghc-heaps-devel \
 "
RDEPENDS:ghc-js-dgtable = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-js-dgtable-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-js-dgtable \
 "
RDEPENDS:ghc-js-dgtable-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-js-dgtable-prof = " \
 ghc-base-prof \
 ghc-js-dgtable-devel \
 "
RDEPENDS:ghc-shake = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-clock \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-extra \
 ghc-filepath \
 ghc-filepattern \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-heaps \
 ghc-js-dgtable \
 ghc-js-flot \
 ghc-js-jquery \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-splitmix \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-unordered-containers \
 ghc-utf8-string \
 glibc \
 gmp \
 shake-common \
 "
RDEPENDS:ghc-shake-devel = " \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-extra-devel \
 ghc-filepath-devel \
 ghc-filepattern-devel \
 ghc-hashable-devel \
 ghc-heaps-devel \
 ghc-js-dgtable-devel \
 ghc-js-flot-devel \
 ghc-js-jquery-devel \
 ghc-primitive-devel \
 ghc-process-devel \
 ghc-random-devel \
 ghc-shake \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unix-devel \
 ghc-unordered-containers-devel \
 ghc-utf8-string-devel \
 "
RDEPENDS:ghc-shake-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-shake-prof = " \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-extra-prof \
 ghc-filepath-prof \
 ghc-filepattern-prof \
 ghc-hashable-prof \
 ghc-heaps-prof \
 ghc-js-dgtable-prof \
 ghc-js-flot-prof \
 ghc-js-jquery-prof \
 ghc-primitive-prof \
 ghc-process-prof \
 ghc-random-prof \
 ghc-shake-devel \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unix-prof \
 ghc-unordered-containers-prof \
 ghc-utf8-string-prof \
 "
RDEPENDS:shake = " \
 glibc \
 gmp \
 libffi \
 shake-common \
 "
RDEPENDS:shake-common = " \
 "
