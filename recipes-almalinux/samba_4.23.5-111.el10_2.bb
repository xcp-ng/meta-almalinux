# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "samba"
PV = "4.23.5"
PR = "111.el10_2"
PACKAGES:x86_64_v2 = " \
 ldb-tools \
 libldb \
 libldb-devel \
 libnetapi \
 libnetapi-devel \
 libsmbclient \
 libsmbclient-devel \
 libwbclient \
 libwbclient-devel \
 python3-ldb \
 python3-samba \
 python3-samba-dc \
 python3-samba-test \
 samba \
 samba-client \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dc-libs \
 samba-dcerpc \
 samba-devel \
 samba-gpupdate \
 samba-krb5-printing \
 samba-ldb-ldap-modules \
 samba-libs \
 samba-pidl \
 samba-test \
 samba-test-libs \
 samba-tools \
 samba-usershares \
 samba-vfs-iouring \
 samba-winbind \
 samba-winbind-clients \
 samba-winbind-krb5-locator \
 samba-winbind-modules \
 samba-winexe \
"
PACKAGES:aarch64 = " \
 ldb-tools \
 libldb \
 libldb-devel \
 libnetapi \
 libnetapi-devel \
 libsmbclient \
 libsmbclient-devel \
 libwbclient \
 libwbclient-devel \
 python3-ldb \
 python3-samba \
 python3-samba-dc \
 python3-samba-test \
 samba \
 samba-client \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dc-libs \
 samba-dcerpc \
 samba-devel \
 samba-gpupdate \
 samba-krb5-printing \
 samba-ldb-ldap-modules \
 samba-libs \
 samba-pidl \
 samba-test \
 samba-test-libs \
 samba-tools \
 samba-usershares \
 samba-vfs-iouring \
 samba-winbind \
 samba-winbind-clients \
 samba-winbind-krb5-locator \
 samba-winbind-modules \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/samba-4.23.5-111.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e535f00d8b0a09d38e08837ccd9cb3dc7a6f1c4e0aae68f93c6ae805888b6bcc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ldb-tools-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_ldb-tools;unpack=0"
SRC_URI[x86_64_v2_ldb-tools.sha256sum] = "e87522be593e0a332cb5ae5976ae3f1d5fe50d662e744ab6c5fe13bc82079d67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libldb-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_libldb;unpack=0"
SRC_URI[x86_64_v2_libldb.sha256sum] = "02947e38c332fc647dd9dfbc877d7282114e003a79c65106927ef1d0a0e784fc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libldb-devel-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_libldb-devel;unpack=0"
SRC_URI[x86_64_v2_libldb-devel.sha256sum] = "b5003876a8b174eb08f493cb2ed8ba979b6dd5f24676b2a99fc3d66905771438"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnetapi-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_libnetapi;unpack=0"
SRC_URI[x86_64_v2_libnetapi.sha256sum] = "4eb0f7c6a59c727e0292b29091565ffc331bc041fe914eece42f119f95173a7c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnetapi-devel-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_libnetapi-devel;unpack=0"
SRC_URI[x86_64_v2_libnetapi-devel.sha256sum] = "55519d78f595a3f99b486ee011f3a5e3a0e437e669aa447c88bb202050e13a49"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsmbclient-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_libsmbclient;unpack=0"
SRC_URI[x86_64_v2_libsmbclient.sha256sum] = "7c93e50d5cc1776253879dbf6313a6c0fc31987f83f0118cee02d756d0c8f62c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsmbclient-devel-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_libsmbclient-devel;unpack=0"
SRC_URI[x86_64_v2_libsmbclient-devel.sha256sum] = "40a0d231884a7f9c99cc65097ab832abc0feee675ec28ad14197030cd52ec9b8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libwbclient-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_libwbclient;unpack=0"
SRC_URI[x86_64_v2_libwbclient.sha256sum] = "b0db44a017b45c4762188a38ce569ddc1d4b92f96ffe14ce251f92008a9ac6bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwbclient-devel-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_libwbclient-devel;unpack=0"
SRC_URI[x86_64_v2_libwbclient-devel.sha256sum] = "01dad402a29a83d260ddd65d9ea6811c8aa6eba760d452eb8fcdac7a6b7275ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-ldb-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-ldb;unpack=0"
SRC_URI[x86_64_v2_python3-ldb.sha256sum] = "47152aac2d292332c379f4f58c510a63c0e0034f2e3655fe9571310aa3a39b18"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-samba-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-samba;unpack=0"
SRC_URI[x86_64_v2_python3-samba.sha256sum] = "2b20eebe05cc4a56948b5a77d01123dfe8bff064d89d957a9a73e87441366d36"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-samba-dc-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-samba-dc;unpack=0"
SRC_URI[x86_64_v2_python3-samba-dc.sha256sum] = "8a4a35a703e7f9193579f48dd9ba5265c480a629e6f3d570738b3c87e52f242d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-samba-test-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-samba-test;unpack=0"
SRC_URI[x86_64_v2_python3-samba-test.sha256sum] = "acf501912042e52765b1e80edc93ace33841b197c3479081398da680998af3bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba;unpack=0"
SRC_URI[x86_64_v2_samba.sha256sum] = "f6de9dc0f93d81ecd01525e4e6255fb4c7381daa9409449403376af0fed68622"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-client-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-client;unpack=0"
SRC_URI[x86_64_v2_samba-client.sha256sum] = "ed9336f36a688619c673ac78a81dad1d6f9e4bf8b5a02497fd2f551290851086"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-client-libs-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-client-libs;unpack=0"
SRC_URI[x86_64_v2_samba-client-libs.sha256sum] = "251afd0b2f19458f86ad5b1668f62cbffd66d2ceaee9bd0eccb57af437279923"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-4.23.5-111.el10_2.noarch.rpm;name=x86_64_v2_samba-common;unpack=0"
SRC_URI[x86_64_v2_samba-common.sha256sum] = "4d61bf1d63516c7fd48fef3b3d379d5265da9a1d6f15cfcb555ea85620ebeca4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-libs-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-common-libs;unpack=0"
SRC_URI[x86_64_v2_samba-common-libs.sha256sum] = "29f9fb2425df7a0276d7c997adbbf0e0ec84368068312ae8de9878c5f9abb31c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-tools-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-common-tools;unpack=0"
SRC_URI[x86_64_v2_samba-common-tools.sha256sum] = "d2121d5d83ccd25c2652ef8fb0f580f073d7de26e94fda35637e9094d8b5e08b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-dc-libs-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-dc-libs;unpack=0"
SRC_URI[x86_64_v2_samba-dc-libs.sha256sum] = "28bdeb897ae54ccecf4bfbb2794d42faaa4487a6129591fe77f2a580d73f6c32"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-dcerpc-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-dcerpc;unpack=0"
SRC_URI[x86_64_v2_samba-dcerpc.sha256sum] = "2ae21eddb97581289a6490af0d5ee74271589694270903c26f6ae2bb655b9a2d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-devel-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-devel;unpack=0"
SRC_URI[x86_64_v2_samba-devel.sha256sum] = "bbe5342b6fea1cc62b6eddd148a28922a1da1758eadc1a844a20e8b6b6909f1f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-gpupdate-4.23.5-111.el10_2.noarch.rpm;name=x86_64_v2_samba-gpupdate;unpack=0"
SRC_URI[x86_64_v2_samba-gpupdate.sha256sum] = "a40b9170fcf4b68f678dc8f99965e135a4346db33358e6cf9e9b03d1b51cc714"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-krb5-printing-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-krb5-printing;unpack=0"
SRC_URI[x86_64_v2_samba-krb5-printing.sha256sum] = "2122d716b67ccd3e9b0576aef03965e8f7aeda27e44119a3b6154dcea36b9e73"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-ldb-ldap-modules-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-ldb-ldap-modules;unpack=0"
SRC_URI[x86_64_v2_samba-ldb-ldap-modules.sha256sum] = "ce575282eb1863f227ff2ed6d96ab7e9a9d65397b0aa8f05757d62f0cd5bacb2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-libs-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-libs;unpack=0"
SRC_URI[x86_64_v2_samba-libs.sha256sum] = "4e329a19e87c803f003bcc5534eb1e807e383c4d5554c0fdc132afaed72a0318"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-pidl-4.23.5-111.el10_2.noarch.rpm;name=x86_64_v2_samba-pidl;unpack=0"
SRC_URI[x86_64_v2_samba-pidl.sha256sum] = "71aaee8f556da7c875e57abd6e75456744b30cd4cfc933b0f9b5f55bdc6fa62b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-test-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-test;unpack=0"
SRC_URI[x86_64_v2_samba-test.sha256sum] = "f977efd9a4593fd9870c174312001913bd22624587a2c357676476f412875e7f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-test-libs-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-test-libs;unpack=0"
SRC_URI[x86_64_v2_samba-test-libs.sha256sum] = "ca6f7a767d71b0f9da8b3da5b6d486a57a608fabb24b7c7f6c44bbb610b085e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-tools-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-tools;unpack=0"
SRC_URI[x86_64_v2_samba-tools.sha256sum] = "95496dbedc803eac098d29fe5b3d1633912069386ea7daf34486064bb61c1ded"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-usershares-4.23.5-111.el10_2.noarch.rpm;name=x86_64_v2_samba-usershares;unpack=0"
SRC_URI[x86_64_v2_samba-usershares.sha256sum] = "005d27aa46324b2295ad8b28470210f8e64255f79a4c4d7cc58dd27927d50fea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-vfs-iouring-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-vfs-iouring;unpack=0"
SRC_URI[x86_64_v2_samba-vfs-iouring.sha256sum] = "1b0e6581a7392ceb72635a33526584c38b22831211700d111e6bf100c5f1c16e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-winbind-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-winbind;unpack=0"
SRC_URI[x86_64_v2_samba-winbind.sha256sum] = "c2a5684ad113fcb74b84d40ef78a6fbc0fc592e360fc8d611b0bf6e327dd5cdb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winbind-clients-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-clients;unpack=0"
SRC_URI[x86_64_v2_samba-winbind-clients.sha256sum] = "ae6c6ea4c0e60de3624ed5f33168ea8153296c35bb4ef99e5fcaa7193d65ee01"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winbind-krb5-locator-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-krb5-locator;unpack=0"
SRC_URI[x86_64_v2_samba-winbind-krb5-locator.sha256sum] = "86298d7ee56e6e866dfd1ac3d224f1d44ae719f8c5168636e596bca7075028d4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-winbind-modules-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-modules;unpack=0"
SRC_URI[x86_64_v2_samba-winbind-modules.sha256sum] = "cb99d769b692f3675c5f520144c8357973ba8288b78ebdd8c6b3686820b8b005"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winexe-4.23.5-111.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-winexe;unpack=0"
SRC_URI[x86_64_v2_samba-winexe.sha256sum] = "97686000e38751ca19716ba533de84dee5c2a5627c5b2cf8dd62aaf1e5e298c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ldb-tools-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_ldb-tools;unpack=0"
SRC_URI[aarch64_ldb-tools.sha256sum] = "9d3d246776e6f6b49b7b6cb659f7c8a60c30a42f9cf3d0be587bbf6471d3f6b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libldb-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_libldb;unpack=0"
SRC_URI[aarch64_libldb.sha256sum] = "2f970add6c4f608f45828c70ec8be266f0c69bb638a63cc6766908c8464fe701"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libldb-devel-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_libldb-devel;unpack=0"
SRC_URI[aarch64_libldb-devel.sha256sum] = "a2160d7d7d889266600a83dfa66424c11ac9f32ef1b73c39a0a8f994e8c90f44"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnetapi-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_libnetapi;unpack=0"
SRC_URI[aarch64_libnetapi.sha256sum] = "6caafd06da4c3b0b5c78f4b4c2cdc55edab9f40ef272bfcebe3671e8a6ea2870"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnetapi-devel-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_libnetapi-devel;unpack=0"
SRC_URI[aarch64_libnetapi-devel.sha256sum] = "573b7fe4707a4c2a5158f111fa7c4815b75ca338955e684e3d869900a0584bda"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsmbclient-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_libsmbclient;unpack=0"
SRC_URI[aarch64_libsmbclient.sha256sum] = "eb17cc6e852246cc228cea46c82673bfa4cd6d3624e382fa47d610882cf44280"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsmbclient-devel-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_libsmbclient-devel;unpack=0"
SRC_URI[aarch64_libsmbclient-devel.sha256sum] = "9a0766ee88960d142c81302c80d659dc83b21f3845966d20f290a6feb0fe249b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libwbclient-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_libwbclient;unpack=0"
SRC_URI[aarch64_libwbclient.sha256sum] = "7cd11297238ed1e857926708afad7846e7c5a9e3e8757d948392b97a5a778454"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwbclient-devel-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_libwbclient-devel;unpack=0"
SRC_URI[aarch64_libwbclient-devel.sha256sum] = "82a5fba397d055ce851fbbfe08ed3479e1cdfb2b56a401e0ee3d61ec6b1892f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-ldb-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_python3-ldb;unpack=0"
SRC_URI[aarch64_python3-ldb.sha256sum] = "881b8d2985a78e801ac97a5ab741369fe3ed2d3cfc729311d18b5b9e346f7492"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-samba-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_python3-samba;unpack=0"
SRC_URI[aarch64_python3-samba.sha256sum] = "05a0814cdf9d09c10ce4ea339ef3c56288a9dc4289a273aec1d8560389445065"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-samba-dc-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_python3-samba-dc;unpack=0"
SRC_URI[aarch64_python3-samba-dc.sha256sum] = "1577fdfe07766b80c9cf94462b3b1b8e25e38607913b6a1237ec0c94ee534f4a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-samba-test-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_python3-samba-test;unpack=0"
SRC_URI[aarch64_python3-samba-test.sha256sum] = "35e13be8ddf9a4c1cb2c5767b508590f8bde4bfad4c6f8a83f436c8d27792070"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba;unpack=0"
SRC_URI[aarch64_samba.sha256sum] = "9f4961e78c5a52077ea103e9aa46b85e752e8416a2efc7959fe5159f6b74d4d6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-client-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-client;unpack=0"
SRC_URI[aarch64_samba-client.sha256sum] = "b6c0669896379b5927c8304fba9ef08b608b61c2715ef153765023429f513335"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-client-libs-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-client-libs;unpack=0"
SRC_URI[aarch64_samba-client-libs.sha256sum] = "12378847920d03d1ffbd94c30799d84534f716aab504233957c05a87a77a8107"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-4.23.5-111.el10_2.noarch.rpm;name=aarch64_samba-common;unpack=0"
SRC_URI[aarch64_samba-common.sha256sum] = "4d61bf1d63516c7fd48fef3b3d379d5265da9a1d6f15cfcb555ea85620ebeca4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-libs-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-common-libs;unpack=0"
SRC_URI[aarch64_samba-common-libs.sha256sum] = "763822000a381c2ea819ea7d4117b76c19c61577aeb914eeb6c23debdead6beb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-tools-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-common-tools;unpack=0"
SRC_URI[aarch64_samba-common-tools.sha256sum] = "93223228ea51e835844407a7513eaa58ac9ef7a467f01d9ec5e09cafe845f781"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-dc-libs-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-dc-libs;unpack=0"
SRC_URI[aarch64_samba-dc-libs.sha256sum] = "59102e55f9c65498c8f4b15035c1011b71da2edf35b6134b60d1b7ea0d5ea593"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-dcerpc-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-dcerpc;unpack=0"
SRC_URI[aarch64_samba-dcerpc.sha256sum] = "1b7cfeea17d44919b276ac69eb87553ab0ec491b7e57ebe3291dea3c3c18ab74"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-devel-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-devel;unpack=0"
SRC_URI[aarch64_samba-devel.sha256sum] = "305806243c52a1e366a24fb77a1c584210360b2711c6f6468d92996db9be02c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-gpupdate-4.23.5-111.el10_2.noarch.rpm;name=aarch64_samba-gpupdate;unpack=0"
SRC_URI[aarch64_samba-gpupdate.sha256sum] = "a40b9170fcf4b68f678dc8f99965e135a4346db33358e6cf9e9b03d1b51cc714"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-krb5-printing-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-krb5-printing;unpack=0"
SRC_URI[aarch64_samba-krb5-printing.sha256sum] = "5beab6e3b4c3289d9c1b57fc46ffe178e8d2ccb8c364c3c3cbc55568f4f7db9c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-ldb-ldap-modules-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-ldb-ldap-modules;unpack=0"
SRC_URI[aarch64_samba-ldb-ldap-modules.sha256sum] = "022482b66f864f5fed71456bc0e051a3978e22e01ef3c296d682bc5f487b21e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-libs-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-libs;unpack=0"
SRC_URI[aarch64_samba-libs.sha256sum] = "8e902db6f195518e6328981af78cd17e256b0312783b9016c931276a37eb2cc4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-pidl-4.23.5-111.el10_2.noarch.rpm;name=aarch64_samba-pidl;unpack=0"
SRC_URI[aarch64_samba-pidl.sha256sum] = "71aaee8f556da7c875e57abd6e75456744b30cd4cfc933b0f9b5f55bdc6fa62b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-test-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-test;unpack=0"
SRC_URI[aarch64_samba-test.sha256sum] = "518134452d43423e3b92de13766b90ccf8a3482d67fc1d67c30f799aac442051"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-test-libs-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-test-libs;unpack=0"
SRC_URI[aarch64_samba-test-libs.sha256sum] = "a31a6385a5fe6596f7def0cfa4716efea8905ed895907e66d6e5bbb3a7dbe28e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-tools-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-tools;unpack=0"
SRC_URI[aarch64_samba-tools.sha256sum] = "cb8db72b6e7d3a7c30c285fd8a60c8a9de8c1d34168a6cac36051d7d1ade68f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-usershares-4.23.5-111.el10_2.noarch.rpm;name=aarch64_samba-usershares;unpack=0"
SRC_URI[aarch64_samba-usershares.sha256sum] = "005d27aa46324b2295ad8b28470210f8e64255f79a4c4d7cc58dd27927d50fea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-vfs-iouring-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-vfs-iouring;unpack=0"
SRC_URI[aarch64_samba-vfs-iouring.sha256sum] = "841e570dc2b3d2c24813e42798cc33f6ebb2256cc723e230078378473cf7d103"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-winbind-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-winbind;unpack=0"
SRC_URI[aarch64_samba-winbind.sha256sum] = "01b0c478e1c71d6c68094c71859d019fb84b8fc8c104987308ff81a91f72a70a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-winbind-clients-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-winbind-clients;unpack=0"
SRC_URI[aarch64_samba-winbind-clients.sha256sum] = "978d6303d3935e7cddd72269a843e6d2e8416a4f75dac7f3125fea6f5e8b3b11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-winbind-krb5-locator-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-winbind-krb5-locator;unpack=0"
SRC_URI[aarch64_samba-winbind-krb5-locator.sha256sum] = "f97685927d709168b6ec2ba7da6cb568b4c2173ed9f55e75f7ef7f8aeec412b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-winbind-modules-4.23.5-111.el10_2.aarch64.rpm;name=aarch64_samba-winbind-modules;unpack=0"
SRC_URI[aarch64_samba-winbind-modules.sha256sum] = "ff532253196b69ca1404005e6c4fa1e8a314715269ae6a1b72b02c2c52ec71fb"

RDEPENDS:ldb-tools = " \
 glibc \
 libldb \
 libtalloc \
 popt \
 "
RDEPENDS:libldb = " \
 glibc \
 libtalloc \
 libtdb \
 libtevent \
 lmdb-libs \
 "
RDEPENDS:libldb-devel = " \
 libldb \
 libtalloc-devel \
 libtdb-devel \
 libtevent-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libnetapi = " \
 glibc \
 gnutls \
 libgcc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 "
RDEPENDS:libnetapi-devel = " \
 libnetapi \
 pkgconf-pkg-config \
 "
RDEPENDS:libsmbclient = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 "
RDEPENDS:libsmbclient-devel = " \
 libsmbclient \
 pkgconf-pkg-config \
 "
RDEPENDS:libwbclient = " \
 bash \
 glibc \
 samba-client-libs \
 "
RDEPENDS:libwbclient-devel = " \
 libwbclient \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-ldb = " \
 glibc \
 libldb \
 libtalloc \
 python3 \
 python3-libs \
 python3-tdb \
 samba-client-libs \
 samba-common-libs \
 "
RDEPENDS:python3-samba = " \
 glibc \
 gnutls \
 krb5-libs \
 libgcc \
 libldb \
 libsmbclient \
 libtalloc \
 libtevent \
 libwbclient \
 python3 \
 python3-cryptography \
 python3-dns \
 python3-ldb \
 python3-libs \
 python3-requests \
 python3-talloc \
 python3-tdb \
 python3-tevent \
 samba-client-libs \
 samba-common-libs \
 samba-dc-libs \
 samba-libs \
 "
RDEPENDS:python3-samba-dc = " \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 python3 \
 python3-libs \
 python3-markdown \
 python3-samba \
 python3-talloc \
 samba-client-libs \
 samba-dc-libs \
 "
RDEPENDS:python3-samba-test = " \
 python3 \
 python3-samba \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba = " \
 bash \
 cups-libs \
 dbus-libs \
 glibc \
 gnutls \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 pam \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dcerpc \
 samba-libs \
 "
RDEPENDS:samba-client = " \
 alternatives \
 bash \
 glibc \
 gnutls \
 krb5-libs \
 libarchive \
 libcom_err \
 libldb \
 libsmbclient \
 libtalloc \
 libtevent \
 libwbclient \
 ncurses-libs \
 popt \
 readline \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 "
RDEPENDS:samba-client-libs = " \
 avahi-libs \
 glibc \
 glibc-gconv-extra \
 gnutls \
 jansson \
 krb5-libs \
 libacl \
 libcap \
 libcom_err \
 libgcc \
 libicu \
 libldb \
 libtalloc \
 libtasn1 \
 libtdb \
 libtevent \
 libtirpc \
 libwbclient \
 libxcrypt \
 openldap \
 pam-libs \
 popt \
 samba-common \
 samba-common-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:samba-common = " \
 bash \
 systemd \
 "
RDEPENDS:samba-common-libs = " \
 glibc \
 libldb \
 libtalloc \
 libtdb \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-common \
 "
RDEPENDS:samba-common-tools = " \
 glibc \
 gnutls \
 jansson \
 krb5-libs \
 libcom_err \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 python3 \
 readline \
 samba-client-libs \
 samba-common-libs \
 samba-ldb-ldap-modules \
 samba-libs \
 "
RDEPENDS:samba-dc-libs = " \
 glibc \
 gnutls \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 samba-client-libs \
 samba-common-libs \
 samba-libs \
 "
RDEPENDS:samba-dcerpc = " \
 cups-libs \
 glibc \
 gnutls \
 jansson \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-common-libs \
 samba-libs \
 "
RDEPENDS:samba-devel = " \
 libldb-devel \
 libnetapi \
 libtalloc-devel \
 libtevent-devel \
 pkgconf-pkg-config \
 samba-client-libs \
 samba-dc-libs \
 samba-devel \
 samba-libs \
 "
RDEPENDS:samba-gpupdate = " \
 cepces-certmonger \
 certmonger \
 python3 \
 python3-samba \
 python3-samba-dc \
 samba-ldb-ldap-modules \
 "
RDEPENDS:samba-krb5-printing = " \
 alternatives \
 bash \
 glibc \
 krb5-libs \
 samba-client \
 samba-client-libs \
 "
RDEPENDS:samba-ldb-ldap-modules = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 openldap \
 samba-client-libs \
 samba-common-libs \
 "
RDEPENDS:samba-libs = " \
 glibc \
 libldb \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-common-libs \
 "
RDEPENDS:samba-pidl = " \
 perl-Exporter \
 perl-File-Basename \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Parse-Yapp \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-parent \
 perl-vars \
 samba-pidl \
 "
RDEPENDS:samba-test = " \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libnetapi \
 libsmbclient \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 perl-Archive-Tar \
 popt \
 python3-samba \
 readline \
 samba \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-dc-libs \
 samba-libs \
 samba-test-libs \
 samba-winbind \
 "
RDEPENDS:samba-test-libs = " \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-common-libs \
 samba-libs \
 "
RDEPENDS:samba-tools = " \
 python3 \
 python3-samba \
 python3-samba-dc \
 "
RDEPENDS:samba-usershares = " \
 bash \
 samba \
 samba-common-tools \
 "
RDEPENDS:samba-vfs-iouring = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 liburing \
 libwbclient \
 samba \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba-winbind = " \
 bash \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dcerpc \
 samba-libs \
 samba-winbind-modules \
 "
RDEPENDS:samba-winbind-clients = " \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-libs \
 samba-winbind \
 "
RDEPENDS:samba-winbind-krb5-locator = " \
 alternatives \
 bash \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-winbind \
 "
RDEPENDS:samba-winbind-modules = " \
 glibc \
 libtalloc \
 libwbclient \
 pam \
 pam-libs \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba-winexe = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-common-libs \
 "
