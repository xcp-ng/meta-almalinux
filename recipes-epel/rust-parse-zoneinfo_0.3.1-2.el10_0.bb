# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-parse-zoneinfo"
PV = "0.3.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-parse-zoneinfo+default-devel \
 rust-parse-zoneinfo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-parse-zoneinfo-0.3.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23e45fa9606fc40f21bc94dff765ee828ab74c259212493a8b6adf88992d2a31"

URI_x86_64_v2_rust-parse-zoneinfo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parse-zoneinfo+default-devel-0.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parse-zoneinfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parse-zoneinfo+default-devel}"
SRC_URI[x86_64_v2_rust-parse-zoneinfo+default-devel.sha256sum] = "9fc58ccda2e9dcd0166129977da6cc32334f44348ffe22a0a48a4afef199ec2d"

URI_x86_64_v2_rust-parse-zoneinfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parse-zoneinfo-devel-0.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parse-zoneinfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parse-zoneinfo-devel}"
SRC_URI[x86_64_v2_rust-parse-zoneinfo-devel.sha256sum] = "672c8ae598562cffcf6af9f9625502646a3b498475bd47c1f6418aa339605433"

URI_aarch64_rust-parse-zoneinfo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parse-zoneinfo+default-devel-0.3.1-2.el10_0.noarch.rpm;name=aarch64_rust-parse-zoneinfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parse-zoneinfo+default-devel}"
SRC_URI[aarch64_rust-parse-zoneinfo+default-devel.sha256sum] = "0669dfb09a1c705b6a779bcba9524937f4f248e3452e5acdd6f1b15bc584cbfb"

URI_aarch64_rust-parse-zoneinfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parse-zoneinfo-devel-0.3.1-2.el10_0.noarch.rpm;name=aarch64_rust-parse-zoneinfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parse-zoneinfo-devel}"
SRC_URI[aarch64_rust-parse-zoneinfo-devel.sha256sum] = "6fd2165100f581b87d8dc2a99ba247f9e142ecf497be7945ac83f4369e4fdc82"

RDEPENDS:rust-parse-zoneinfo+default-devel = " \
 cargo \
 rust-parse-zoneinfo-devel \
 "
RDEPENDS:rust-parse-zoneinfo-devel = " \
 cargo \
 rust \
 rust-regex+std-devel \
 rust-regex+unicode-perl-devel \
 rust-regex-devel \
 "
