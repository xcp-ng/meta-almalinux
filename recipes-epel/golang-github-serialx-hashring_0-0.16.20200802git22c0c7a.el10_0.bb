# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-serialx-hashring"
PV = "0"
PR = "0.16.20200802git22c0c7a.el10_0"
PACKAGES = " \
 golang-github-serialx-hashring-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-serialx-hashring-0-0.16.20200802git22c0c7a.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d97a1e586be086cda12f0743873b285cb2197f3f756b7db6bf52b98910e5da6"

URI_aarch64_golang-github-serialx-hashring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-serialx-hashring-devel-0-0.16.20200802git22c0c7a.el10_0.noarch.rpm;name=aarch64_golang-github-serialx-hashring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-serialx-hashring-devel}"
SRC_URI[aarch64_golang-github-serialx-hashring-devel.sha256sum] = "980898848536390f6a23d6a959cb9743ab53277986e70dd8c33e0d5d0a6ef554"

RDEPENDS:golang-github-serialx-hashring-devel = " \
 go-filesystem \
 "
