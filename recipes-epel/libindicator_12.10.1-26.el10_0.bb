# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libindicator"
PV = "12.10.1"
PR = "26.el10_0"
PACKAGES = " \
 libindicator \
 libindicator-devel \
 libindicator-gtk3 \
 libindicator-gtk3-devel \
 libindicator-gtk3-tools \
 libindicator-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libindicator-12.10.1-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e529fa5776f3a690060174aef77199e7586cf4a642f647a4f0a164e0979fedb"

URI_x86_64_v2_libindicator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libindicator-12.10.1-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libindicator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libindicator}"
SRC_URI[x86_64_v2_libindicator.sha256sum] = "810698548e1f5df80af7acf29f8cdaf6e4fea911265c1b8f27a11b7f22217138"

URI_x86_64_v2_libindicator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libindicator-devel-12.10.1-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libindicator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libindicator-devel}"
SRC_URI[x86_64_v2_libindicator-devel.sha256sum] = "ab9b5a3c03e0727c1c11d539d9a20b021a1ba96dd43f92328faa092f2f51f23e"

URI_x86_64_v2_libindicator-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libindicator-gtk3-12.10.1-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libindicator-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libindicator-gtk3}"
SRC_URI[x86_64_v2_libindicator-gtk3.sha256sum] = "153634b6895520f48d6cc1b15c10f4d5f7c7cec7e6b40dfc33800bcb2c0f470b"

URI_x86_64_v2_libindicator-gtk3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libindicator-gtk3-devel-12.10.1-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libindicator-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libindicator-gtk3-devel}"
SRC_URI[x86_64_v2_libindicator-gtk3-devel.sha256sum] = "8e2fdb045046a3521ad6194d7f35a1a3254fe80a44bbcfbbaab216f65c6eab9f"

URI_x86_64_v2_libindicator-gtk3-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libindicator-gtk3-tools-12.10.1-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libindicator-gtk3-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libindicator-gtk3-tools}"
SRC_URI[x86_64_v2_libindicator-gtk3-tools.sha256sum] = "d58417e6c8fe908be4e0e342879e727c6406713612a8063f085aef1419e55731"

URI_x86_64_v2_libindicator-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libindicator-tools-12.10.1-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libindicator-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libindicator-tools}"
SRC_URI[x86_64_v2_libindicator-tools.sha256sum] = "147399f264df3a9eef52a84d04f668476d5da7cc814fa246b335425d785eedd4"

URI_aarch64_libindicator = "${EPEL_MIRROR}/aarch64/Packages/l/libindicator-12.10.1-26.el10_0.aarch64.rpm;name=aarch64_libindicator;unpack=0"
SRC_URI:append = " ${URI_aarch64_libindicator}"
SRC_URI[aarch64_libindicator.sha256sum] = "73cc257482b2d65d4f4c87a35b19ffb9d7c42b2793566d221c6d3bbea56e6268"

URI_aarch64_libindicator-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libindicator-devel-12.10.1-26.el10_0.aarch64.rpm;name=aarch64_libindicator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libindicator-devel}"
SRC_URI[aarch64_libindicator-devel.sha256sum] = "5345d6730890f5fcb7ba5977b40dba1bafdd81dc2fe4b002bdb52027860191b0"

URI_aarch64_libindicator-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/l/libindicator-gtk3-12.10.1-26.el10_0.aarch64.rpm;name=aarch64_libindicator-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libindicator-gtk3}"
SRC_URI[aarch64_libindicator-gtk3.sha256sum] = "6986aed0e57b97c906cf44eb480db80de092dd1a2cbdd435522081bb1ebf051c"

URI_aarch64_libindicator-gtk3-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libindicator-gtk3-devel-12.10.1-26.el10_0.aarch64.rpm;name=aarch64_libindicator-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libindicator-gtk3-devel}"
SRC_URI[aarch64_libindicator-gtk3-devel.sha256sum] = "2854ecdab3629fd669b43cbc3f51468b6d13f4001aa80c7aa567116d909b5b8d"

URI_aarch64_libindicator-gtk3-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libindicator-gtk3-tools-12.10.1-26.el10_0.aarch64.rpm;name=aarch64_libindicator-gtk3-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libindicator-gtk3-tools}"
SRC_URI[aarch64_libindicator-gtk3-tools.sha256sum] = "740b7947a730ec3c030d3b6dba68c07c2efd6b356cdb922f20f7115d02937687"

URI_aarch64_libindicator-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libindicator-tools-12.10.1-26.el10_0.aarch64.rpm;name=aarch64_libindicator-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libindicator-tools}"
SRC_URI[aarch64_libindicator-tools.sha256sum] = "83e312cc4511bd1f0e885ce3ee0ed274aa14df37160c190ff82a0e0bba63e981"

RDEPENDS:libindicator = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 "
RDEPENDS:libindicator-devel = " \
 gtk2-devel \
 libindicator \
 pkgconf-pkg-config \
 "
RDEPENDS:libindicator-gtk3 = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 "
RDEPENDS:libindicator-gtk3-devel = " \
 gtk3-devel \
 libindicator-gtk3 \
 pkgconf-pkg-config \
 "
RDEPENDS:libindicator-gtk3-tools = " \
 glib2 \
 glibc \
 gtk3 \
 libindicator-gtk3 \
 pkgconf-pkg-config \
 "
RDEPENDS:libindicator-tools = " \
 glib2 \
 glibc \
 gtk2 \
 libindicator \
 pkgconf-pkg-config \
 "
