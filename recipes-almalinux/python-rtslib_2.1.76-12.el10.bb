# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rtslib"
PV = "2.1.76"
PR = "12.el10"
PACKAGES = " \
 python3-rtslib \
 target-restore \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-rtslib-2.1.76-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "703a3a888c5767f95d7f0a648ad2ee5100b151813cb598d5eef134b00f4a013d"

URI_x86_64_v2_python3-rtslib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-rtslib-2.1.76-12.el10.noarch.rpm;name=x86_64_v2_python3-rtslib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rtslib}"
SRC_URI[x86_64_v2_python3-rtslib.sha256sum] = "0f149a9599cea34d5b664410ea4fc1c8f9f966d202160588680808460fed7de4"

URI_x86_64_v2_target-restore = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/target-restore-2.1.76-12.el10.noarch.rpm;name=x86_64_v2_target-restore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_target-restore}"
SRC_URI[x86_64_v2_target-restore.sha256sum] = "9417275655be4309a4bb98cffd336949452aa32301c1c85deed3645f28e07f12"

URI_aarch64_python3-rtslib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-rtslib-2.1.76-12.el10.noarch.rpm;name=aarch64_python3-rtslib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rtslib}"
SRC_URI[aarch64_python3-rtslib.sha256sum] = "0f149a9599cea34d5b664410ea4fc1c8f9f966d202160588680808460fed7de4"

URI_aarch64_target-restore = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/target-restore-2.1.76-12.el10.noarch.rpm;name=aarch64_target-restore;unpack=0"
SRC_URI:append = " ${URI_aarch64_target-restore}"
SRC_URI[aarch64_target-restore.sha256sum] = "9417275655be4309a4bb98cffd336949452aa32301c1c85deed3645f28e07f12"

RDEPENDS:python3-rtslib = " \
 python3 \
 python3-kmod \
 python3-pyudev \
 python3-six \
 "
RDEPENDS:target-restore = " \
 bash \
 python3 \
 python3-rtslib \
 systemd \
 "
