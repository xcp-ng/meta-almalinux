# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cty"
PV = "0.2.2"
PR = "10.el10_1"
PACKAGES = " \
 rust-cty+default-devel \
 rust-cty-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cty-0.2.2-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94d849e024685de20fdee30a8a942b212484860d3aefa35506f13955d536127a"

URI_x86_64_v2_rust-cty+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cty+default-devel-0.2.2-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cty+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cty+default-devel}"
SRC_URI[x86_64_v2_rust-cty+default-devel.sha256sum] = "2c257b2023576500ef5338d9ca461c6202c5ea8e00faeb6825e2f268a71b97a1"

URI_x86_64_v2_rust-cty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cty-devel-0.2.2-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cty-devel}"
SRC_URI[x86_64_v2_rust-cty-devel.sha256sum] = "6b5a363fa17b0a6a96107c4f9aad9809ac8f72c00eb447156f9cb5a82992f0f9"

URI_aarch64_rust-cty+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cty+default-devel-0.2.2-10.el10_1.noarch.rpm;name=aarch64_rust-cty+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cty+default-devel}"
SRC_URI[aarch64_rust-cty+default-devel.sha256sum] = "493c9ed7aa7ecb719c3eb12fc8902546d4d5cb554a1a00035dec5402d2bb7c9e"

URI_aarch64_rust-cty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cty-devel-0.2.2-10.el10_1.noarch.rpm;name=aarch64_rust-cty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cty-devel}"
SRC_URI[aarch64_rust-cty-devel.sha256sum] = "26ffa5f5f56607b94f5cd088ae6e7ace855feb046c055172baff323113d7a08c"

RDEPENDS:rust-cty+default-devel = " \
 cargo \
 rust-cty-devel \
 "
RDEPENDS:rust-cty-devel = " \
 cargo \
 "
