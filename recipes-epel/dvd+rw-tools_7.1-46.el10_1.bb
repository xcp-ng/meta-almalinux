# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dvd+rw-tools"
PV = "7.1"
PR = "46.el10_1"
PACKAGES = " \
 dvd+rw-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dvd+rw-tools-7.1-46.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0129ec236b325257c436f38f43a15deb410ce58b3a3fecd707dffffe0a8c0119"

URI_x86_64_v2_dvd+rw-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dvd+rw-tools-7.1-46.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dvd+rw-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dvd+rw-tools}"
SRC_URI[x86_64_v2_dvd+rw-tools.sha256sum] = "0bdfcfe211974fed5657752b72353b75d85ca74c3a85005d5215d4e9cfa519de"

URI_aarch64_dvd+rw-tools = "${EPEL_MIRROR}/aarch64/Packages/d/dvd+rw-tools-7.1-46.el10_1.aarch64.rpm;name=aarch64_dvd+rw-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_dvd+rw-tools}"
SRC_URI[aarch64_dvd+rw-tools.sha256sum] = "367ccd5c77cca6cfb030e18e11521bd3d677142a328ef70413437e8705595ae8"

RDEPENDS:dvd+rw-tools = " \
 genisoimage \
 glibc \
 libstdc++ \
 "
