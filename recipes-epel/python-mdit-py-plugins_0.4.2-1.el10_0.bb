# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mdit-py-plugins"
PV = "0.4.2"
PR = "1.el10_0"
PACKAGES = " \
 python3-mdit-py-plugins \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mdit-py-plugins-0.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d77bce5331cd44d775f17f1245d17551dfd621fa2dad2bd0352e3126cc6b6c94"

URI_x86_64_v2_python3-mdit-py-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mdit-py-plugins-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mdit-py-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mdit-py-plugins}"
SRC_URI[x86_64_v2_python3-mdit-py-plugins.sha256sum] = "b37439a2c8b68b32a3f4bb60ea6a09d2e5c85b981d95507c1e9779ef08779f82"

URI_aarch64_python3-mdit-py-plugins = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mdit-py-plugins-0.4.2-1.el10_0.noarch.rpm;name=aarch64_python3-mdit-py-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mdit-py-plugins}"
SRC_URI[aarch64_python3-mdit-py-plugins.sha256sum] = "a278ffa04cc1bd1d90e6eb3aa13dfe6f81d2f04ff353400aa6c70f40e21ca542"

RDEPENDS:python3-mdit-py-plugins = " \
 python3 \
 python3-markdown-it-py \
 "
