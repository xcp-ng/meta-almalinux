# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpm"
PV = "4.19.1.1"
PR = "25.el10.alma.1"
PACKAGES = " \
 python3-rpm \
 rpm \
 rpm-apidocs \
 rpm-build \
 rpm-build-libs \
 rpm-cron \
 rpm-devel \
 rpm-libs \
 rpm-plugin-audit \
 rpm-plugin-dbus-announce \
 rpm-plugin-fapolicyd \
 rpm-plugin-ima \
 rpm-plugin-selinux \
 rpm-plugin-syslog \
 rpm-plugin-systemd-inhibit \
 rpm-sign \
 rpm-sign-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rpm-4.19.1.1-25.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f7f96d40c9e4e7f562a8ecee5173d8eb894a24ed0ca7f2bc68cb33e8534eb6b"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - rpm-build-libs: libcap.so.2()(64bit)
# - rpm-libs: libcap.so.2()(64bit)

URI_x86_64_v2_python3-rpm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-rpm-4.19.1.1-25.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpm}"
SRC_URI[x86_64_v2_python3-rpm.sha256sum] = "0b674c7f252ec5918d7a19c0017d04933de8b737ef356a62b2d3cb77acc72cb8"

URI_x86_64_v2_rpm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-4.19.1.1-25.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm}"
SRC_URI[x86_64_v2_rpm.sha256sum] = "78e9760053f8fd2e4da633209cd1b383a86997ab66c1071040dce43ae9b8a97e"

URI_x86_64_v2_rpm-apidocs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-apidocs-4.19.1.1-25.el10.alma.1.noarch.rpm;name=x86_64_v2_rpm-apidocs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-apidocs}"
SRC_URI[x86_64_v2_rpm-apidocs.sha256sum] = "2c453c962922680863e5104d90cc1d3d31a3393fdb2694c9c0ca8766baeb3cda"

URI_x86_64_v2_rpm-build = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-build-4.19.1.1-25.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-build;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-build}"
SRC_URI[x86_64_v2_rpm-build.sha256sum] = "7b3a68db290176aa6f00a60aa318c73104c5558edfb0ab4b54f0f9bd068641ea"

URI_x86_64_v2_rpm-build-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-build-libs-4.19.1.1-25.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-build-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-build-libs}"
SRC_URI[x86_64_v2_rpm-build-libs.sha256sum] = "75e02216b54f6d7721d2f14451bbc346627848b00a065bf65986ae4f9aef8c9a"

URI_x86_64_v2_rpm-cron = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-cron-4.19.1.1-25.el10.alma.1.noarch.rpm;name=x86_64_v2_rpm-cron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-cron}"
SRC_URI[x86_64_v2_rpm-cron.sha256sum] = "97b4bd9984de4cc64d600b88043b4825e6bcfdfb397a7d6c84e86415e123df49"

URI_x86_64_v2_rpm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-devel-4.19.1.1-25.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-devel}"
SRC_URI[x86_64_v2_rpm-devel.sha256sum] = "af818bdd72c8714f8f1b88666a411c6bbac412b7f6a7af3bcedcb225f57437ec"

URI_x86_64_v2_rpm-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-libs-4.19.1.1-25.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-libs}"
SRC_URI[x86_64_v2_rpm-libs.sha256sum] = "3caf6892e2bd8cf704e57f3e01118a4ac5751cb099b60481d301fabd5c1bdd2c"

URI_x86_64_v2_rpm-plugin-audit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-plugin-audit-4.19.1.1-25.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-audit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-audit}"
SRC_URI[x86_64_v2_rpm-plugin-audit.sha256sum] = "78fe4073a4ea5de9a2756b12b13a78d2f18aaaf5d96e97a9a1318a1c4419b786"

URI_x86_64_v2_rpm-plugin-dbus-announce = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-dbus-announce-4.19.1.1-25.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-dbus-announce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-dbus-announce}"
SRC_URI[x86_64_v2_rpm-plugin-dbus-announce.sha256sum] = "54fa161c30f6f2258d0e400e8af15eec14ae1a63777374d2562547577046dcce"

URI_x86_64_v2_rpm-plugin-fapolicyd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-fapolicyd-4.19.1.1-25.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-fapolicyd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-fapolicyd}"
SRC_URI[x86_64_v2_rpm-plugin-fapolicyd.sha256sum] = "28c69b0c42cd9f4bfd312e235e5b7ad69901cada36b3d00a427421784fda7b3e"

URI_x86_64_v2_rpm-plugin-ima = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-ima-4.19.1.1-25.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-ima;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-ima}"
SRC_URI[x86_64_v2_rpm-plugin-ima.sha256sum] = "34364d286ecd2242484f6f2a9e97b4a4e4066414ec805581413361289d38a0c4"

URI_x86_64_v2_rpm-plugin-selinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-plugin-selinux-4.19.1.1-25.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-selinux}"
SRC_URI[x86_64_v2_rpm-plugin-selinux.sha256sum] = "42dac6f349f6c3aedc5d9e8e138248102fa6d57fdb7e0d8cad6a733bccbc7fd1"

URI_x86_64_v2_rpm-plugin-syslog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-syslog-4.19.1.1-25.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-syslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-syslog}"
SRC_URI[x86_64_v2_rpm-plugin-syslog.sha256sum] = "9e21a4e07bb4effd539591af366c10d497c2373e5cff8a03318e8d5fcf797ee4"

URI_x86_64_v2_rpm-plugin-systemd-inhibit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-systemd-inhibit-4.19.1.1-25.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-systemd-inhibit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-systemd-inhibit}"
SRC_URI[x86_64_v2_rpm-plugin-systemd-inhibit.sha256sum] = "fdcc727d63fe51832e37bd1839f4c0911bd5571bfea9a7370103c22419401d61"

URI_x86_64_v2_rpm-sign = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-sign-4.19.1.1-25.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-sign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-sign}"
SRC_URI[x86_64_v2_rpm-sign.sha256sum] = "8fadd65bc4a12bc0963e59b042b9b35420f031ffdefee7592d9cbcdd807b510f"

URI_x86_64_v2_rpm-sign-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-sign-libs-4.19.1.1-25.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-sign-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-sign-libs}"
SRC_URI[x86_64_v2_rpm-sign-libs.sha256sum] = "d536c455212b4db0cefbc90795d475e8cd5d54fb75c477c245999ace43185df8"

URI_aarch64_python3-rpm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-rpm-4.19.1.1-25.el10.alma.1.aarch64.rpm;name=aarch64_python3-rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpm}"
SRC_URI[aarch64_python3-rpm.sha256sum] = "b35a45e78d6f899f1ea83ff91e35afd6eb883c9dc94dd3ae92f1628d4842260e"

URI_aarch64_rpm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-4.19.1.1-25.el10.alma.1.aarch64.rpm;name=aarch64_rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm}"
SRC_URI[aarch64_rpm.sha256sum] = "1fd6f3319e654d490ee4dfe9e80978a4784b285ea5650badc069bae09ad7b3cc"

URI_aarch64_rpm-apidocs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-apidocs-4.19.1.1-25.el10.alma.1.noarch.rpm;name=aarch64_rpm-apidocs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-apidocs}"
SRC_URI[aarch64_rpm-apidocs.sha256sum] = "2c453c962922680863e5104d90cc1d3d31a3393fdb2694c9c0ca8766baeb3cda"

URI_aarch64_rpm-build = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-build-4.19.1.1-25.el10.alma.1.aarch64.rpm;name=aarch64_rpm-build;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-build}"
SRC_URI[aarch64_rpm-build.sha256sum] = "a57a305fc4839bd92d0b171d0055655900799c089f77f350cf261b1e87ae6d79"

URI_aarch64_rpm-build-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-build-libs-4.19.1.1-25.el10.alma.1.aarch64.rpm;name=aarch64_rpm-build-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-build-libs}"
SRC_URI[aarch64_rpm-build-libs.sha256sum] = "339b30367066389f1ece131090527afe66a66f1a1a3cfd135f10ab6867715aed"

URI_aarch64_rpm-cron = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-cron-4.19.1.1-25.el10.alma.1.noarch.rpm;name=aarch64_rpm-cron;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-cron}"
SRC_URI[aarch64_rpm-cron.sha256sum] = "97b4bd9984de4cc64d600b88043b4825e6bcfdfb397a7d6c84e86415e123df49"

URI_aarch64_rpm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-devel-4.19.1.1-25.el10.alma.1.aarch64.rpm;name=aarch64_rpm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-devel}"
SRC_URI[aarch64_rpm-devel.sha256sum] = "53060325f1d22dd86fc958e6ae19969009b812a8fbcba6a798839518012dc118"

URI_aarch64_rpm-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-libs-4.19.1.1-25.el10.alma.1.aarch64.rpm;name=aarch64_rpm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-libs}"
SRC_URI[aarch64_rpm-libs.sha256sum] = "4bbb84cd21e59299a8914a7484137ee0061acabd11fce6d190215ad48448b213"

URI_aarch64_rpm-plugin-audit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-plugin-audit-4.19.1.1-25.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-audit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-audit}"
SRC_URI[aarch64_rpm-plugin-audit.sha256sum] = "c6d0543e95c7976bfac625a6a1577762cdc4cd692c4b51a3737d5630ec394e20"

URI_aarch64_rpm-plugin-dbus-announce = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-dbus-announce-4.19.1.1-25.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-dbus-announce;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-dbus-announce}"
SRC_URI[aarch64_rpm-plugin-dbus-announce.sha256sum] = "276a82e77d961e96f7bc2e1a495d71181f7addd69f0e398aa56a6bdca1efab50"

URI_aarch64_rpm-plugin-fapolicyd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-fapolicyd-4.19.1.1-25.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-fapolicyd;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-fapolicyd}"
SRC_URI[aarch64_rpm-plugin-fapolicyd.sha256sum] = "69b60fecce91ba3f3cdb425e90f44b92174f3ab0b4c7d0c6f4ffdb695b511d45"

URI_aarch64_rpm-plugin-ima = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-ima-4.19.1.1-25.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-ima;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-ima}"
SRC_URI[aarch64_rpm-plugin-ima.sha256sum] = "b8b5ee471abc40b03c6be0eba751a93eb6d2d77d48306b39b4ed0ddb15e64cef"

URI_aarch64_rpm-plugin-selinux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-plugin-selinux-4.19.1.1-25.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-selinux}"
SRC_URI[aarch64_rpm-plugin-selinux.sha256sum] = "1b2823eca6062cc93de9dfef6583d34e1ffb690e645bc2441c2c3d86dd1f89bf"

URI_aarch64_rpm-plugin-syslog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-syslog-4.19.1.1-25.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-syslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-syslog}"
SRC_URI[aarch64_rpm-plugin-syslog.sha256sum] = "52dfd14c9132d07ec01b68e3bc30c60d112400c39782337ab0422b6a7e339595"

URI_aarch64_rpm-plugin-systemd-inhibit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-systemd-inhibit-4.19.1.1-25.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-systemd-inhibit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-systemd-inhibit}"
SRC_URI[aarch64_rpm-plugin-systemd-inhibit.sha256sum] = "d27398ee9d0eea544631e118d9f201dd9d4ae5058c4d55d18c2754ab171d2f55"

URI_aarch64_rpm-sign = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-sign-4.19.1.1-25.el10.alma.1.aarch64.rpm;name=aarch64_rpm-sign;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-sign}"
SRC_URI[aarch64_rpm-sign.sha256sum] = "12b1f8dc0c21e97113d0bbcd8ef6bd03682d7c06cc9d95220c158bc08ca8b2ab"

URI_aarch64_rpm-sign-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-sign-libs-4.19.1.1-25.el10.alma.1.aarch64.rpm;name=aarch64_rpm-sign-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-sign-libs}"
SRC_URI[aarch64_rpm-sign-libs.sha256sum] = "535d8c0bc1073f6a7c49019beda8a801d55b022b1fa98ce40bd54c470f1d1eff"

RDEPENDS:python3-rpm = " \
 glibc \
 python3 \
 rpm-build-libs \
 rpm-libs \
 rpm-sign-libs \
 "
RDEPENDS:rpm = " \
 bash \
 curl \
 findutils \
 glibc \
 libarchive \
 popt \
 rpm-libs \
 sed \
 virtual/coreutils \
 "
RDEPENDS:rpm-apidocs = " \
 "
RDEPENDS:rpm-build = " \
 bash \
 binutils \
 bzip2 \
 cpio \
 debugedit \
 diffutils \
 elfutils \
 elfutils-libelf \
 file \
 findutils \
 gawk \
 glibc \
 grep \
 gzip \
 libarchive \
 patch \
 pkgconf-pkg-config \
 popt \
 readline \
 redhat-rpm-config \
 rpm \
 rpm-build-libs \
 rpm-libs \
 sed \
 tar \
 unzip \
 virtual//usr/bin/gdb-add-index \
 xz \
 zstd \
 "
RDEPENDS:rpm-build-libs:x86_64_v2 = " \
 elfutils-libelf \
 elfutils-libs \
 file-libs \
 glibc \
 libcap \
 libgcc \
 libgomp \
 lua-libs \
 popt \
 rpm-libs \
"
RDEPENDS:rpm-build-libs:aarch64 = " \
 elfutils-libelf \
 elfutils-libs \
 file-libs \
 glibc \
 libgcc \
 libgomp \
 lua-libs \
 popt \
 rpm-libs \
"
RDEPENDS:rpm-cron = " \
 bash \
 crontabs \
 logrotate \
 rpm \
 "
RDEPENDS:rpm-devel = " \
 cmake-filesystem \
 glibc \
 pkgconf-pkg-config \
 popt \
 popt-devel \
 rpm \
 rpm-build-libs \
 rpm-libs \
 rpm-sign-libs \
 "
RDEPENDS:rpm-libs:x86_64_v2 = " \
 bzip2-libs \
 glibc \
 libacl \
 libcap \
 libzstd \
 lua-libs \
 popt \
 rpm \
 rpm-plugin-audit \
 rpm-plugin-syslog \
 rpm-sequoia \
 sqlite-libs \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:rpm-libs:aarch64 = " \
 bzip2-libs \
 glibc \
 libacl \
 libzstd \
 lua-libs \
 popt \
 rpm \
 rpm-plugin-audit \
 rpm-plugin-syslog \
 rpm-sequoia \
 sqlite-libs \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:rpm-plugin-audit = " \
 audit-libs \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-dbus-announce = " \
 dbus-libs \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-fapolicyd = " \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-ima = " \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-selinux = " \
 glibc \
 libselinux \
 rpm-libs \
 selinux-policy \
 "
RDEPENDS:rpm-plugin-syslog = " \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-systemd-inhibit = " \
 dbus-libs \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-sign = " \
 glibc \
 popt \
 rpm-libs \
 rpm-sign-libs \
 "
RDEPENDS:rpm-sign-libs = " \
 glibc \
 ima-evm-utils \
 popt \
 rpm-libs \
 "
