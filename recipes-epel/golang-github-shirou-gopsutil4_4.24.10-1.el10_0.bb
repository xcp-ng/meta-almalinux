# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-shirou-gopsutil4"
PV = "4.24.10"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-shirou-gopsutil4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-shirou-gopsutil4-4.24.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "776493e81477a384278c52c13aa68ab50b49c42dcba4aba4b72350d849dc1f79"

URI_x86_64_v2_golang-github-shirou-gopsutil4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-shirou-gopsutil4-devel-4.24.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-shirou-gopsutil4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-shirou-gopsutil4-devel}"
SRC_URI[x86_64_v2_golang-github-shirou-gopsutil4-devel.sha256sum] = "f9b8364a0fbc2b9b929900b34226f915eaafda1b9e02d7b88b229d15ad211583"

URI_aarch64_golang-github-shirou-gopsutil4-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-shirou-gopsutil4-devel-4.24.10-1.el10_0.noarch.rpm;name=aarch64_golang-github-shirou-gopsutil4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-shirou-gopsutil4-devel}"
SRC_URI[aarch64_golang-github-shirou-gopsutil4-devel.sha256sum] = "e24ff460f3ec5e6b1922392c79bb05b95363940e4ea8814e3e7dcb74e7808e1e"

RDEPENDS:golang-github-shirou-gopsutil4-devel = " \
 go-filesystem \
 golang-github-tklauser-sysconf-devel \
 golang-x-sys-devel \
 "
