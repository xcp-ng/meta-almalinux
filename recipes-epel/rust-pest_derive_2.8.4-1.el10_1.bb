# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest_derive"
PV = "2.8.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-pest_derive+default-devel \
 rust-pest_derive+grammar-extras-devel \
 rust-pest_derive+std-devel \
 rust-pest_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest_derive-2.8.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f55cdf856913293f9674a1ac3fea73d55648bc783292a9f7e8d7338b4ad95796"

URI_x86_64_v2_rust-pest_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive+default-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive+default-devel}"
SRC_URI[x86_64_v2_rust-pest_derive+default-devel.sha256sum] = "4440fd9a6fde75e7773a97af86492af57adc0a023b0dd88db086a7cd4ad8711b"

URI_x86_64_v2_rust-pest_derive+grammar-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive+grammar-extras-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive+grammar-extras-devel}"
SRC_URI[x86_64_v2_rust-pest_derive+grammar-extras-devel.sha256sum] = "c0670578fbd3af0c7113e838feedaebe135c860681e8491d2333a9daddec95a6"

URI_x86_64_v2_rust-pest_derive+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive+std-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive+std-devel}"
SRC_URI[x86_64_v2_rust-pest_derive+std-devel.sha256sum] = "158d90252522b04e1fa3af45443f26724986fd19aab40067e1837e557699de5d"

URI_x86_64_v2_rust-pest_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive-devel}"
SRC_URI[x86_64_v2_rust-pest_derive-devel.sha256sum] = "d500f909e953db8ca1f61883b3dc061e7958be3aeeeb3a05a3058ad14c14e048"

URI_aarch64_rust-pest_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive+default-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive+default-devel}"
SRC_URI[aarch64_rust-pest_derive+default-devel.sha256sum] = "e9b12e5d1949be454eb368a2170b8ba87e3264d7862a30e943399da034eac112"

URI_aarch64_rust-pest_derive+grammar-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive+grammar-extras-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest_derive+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive+grammar-extras-devel}"
SRC_URI[aarch64_rust-pest_derive+grammar-extras-devel.sha256sum] = "0545b9496efcc86ef18eb262a23335745a74f2d848b5496287d3e666b0129ae7"

URI_aarch64_rust-pest_derive+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive+std-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest_derive+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive+std-devel}"
SRC_URI[aarch64_rust-pest_derive+std-devel.sha256sum] = "f66a1dca01798d18a9a3bc0e391f60824bff012d6bc695d51eb025cb3dd0fa15"

URI_aarch64_rust-pest_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive-devel}"
SRC_URI[aarch64_rust-pest_derive-devel.sha256sum] = "9c6e740a4261e85be92a5892d7744ae822f0ffbf1a21fb5f61c85a96dadacbfd"

RDEPENDS:rust-pest_derive+default-devel = " \
 cargo \
 rust-pest_derive+std-devel \
 rust-pest_derive-devel \
 "
RDEPENDS:rust-pest_derive+grammar-extras-devel = " \
 cargo \
 rust-pest_derive-devel \
 rust-pest_generator+grammar-extras-devel \
 "
RDEPENDS:rust-pest_derive+std-devel = " \
 cargo \
 rust-pest+std-devel \
 rust-pest_derive-devel \
 rust-pest_generator+std-devel \
 "
RDEPENDS:rust-pest_derive-devel = " \
 cargo \
 rust \
 rust-pest-devel \
 rust-pest_generator-devel \
 "
