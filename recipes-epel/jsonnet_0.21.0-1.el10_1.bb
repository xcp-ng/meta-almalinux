# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jsonnet"
PV = "0.21.0"
PR = "1.el10_1"
PACKAGES = " \
 jsonnet \
 jsonnet-devel \
 jsonnet-doc \
 jsonnet-libs \
 python3-jsonnet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jsonnet-0.21.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4328c360f633fa606c86524394f1281b3722c721b73e76bb7fc72f8978970bad"

URI_x86_64_v2_jsonnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jsonnet-0.21.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jsonnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsonnet}"
SRC_URI[x86_64_v2_jsonnet.sha256sum] = "341fc3e0618590699a889083b8353895c2f9c78a124f3b8e8a5da7b8ac56454e"

URI_x86_64_v2_jsonnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jsonnet-devel-0.21.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jsonnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsonnet-devel}"
SRC_URI[x86_64_v2_jsonnet-devel.sha256sum] = "6818d471d9a95584eeaac40108c1e5dbc0306a17d65fdd1d28ee3024956c213b"

URI_x86_64_v2_jsonnet-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jsonnet-doc-0.21.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_jsonnet-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsonnet-doc}"
SRC_URI[x86_64_v2_jsonnet-doc.sha256sum] = "363f446ff8539fd7d7ef476d6265084533ab68c01f9e57057dd8c8e47e864580"

URI_x86_64_v2_jsonnet-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jsonnet-libs-0.21.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jsonnet-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsonnet-libs}"
SRC_URI[x86_64_v2_jsonnet-libs.sha256sum] = "8fcb23791a2cca8573b7cf3fa8280a34eb411359cc195e07be988d2e5c652eed"

URI_x86_64_v2_python3-jsonnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jsonnet-0.21.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-jsonnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jsonnet}"
SRC_URI[x86_64_v2_python3-jsonnet.sha256sum] = "e97aea9f567799841a8d0c2b2183745a535b5362a6df1dad5812b5ab8fe639a6"

URI_aarch64_jsonnet = "${EPEL_MIRROR}/aarch64/Packages/j/jsonnet-0.21.0-1.el10_1.aarch64.rpm;name=aarch64_jsonnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsonnet}"
SRC_URI[aarch64_jsonnet.sha256sum] = "7d89a63ff42320032048436318c2bc33e8b283d4036fec5a54da7d008ea823da"

URI_aarch64_jsonnet-devel = "${EPEL_MIRROR}/aarch64/Packages/j/jsonnet-devel-0.21.0-1.el10_1.aarch64.rpm;name=aarch64_jsonnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsonnet-devel}"
SRC_URI[aarch64_jsonnet-devel.sha256sum] = "6b717ff655a544660f27be0d9b1092b98ce77f96da1878fcb4564e786b1cd47a"

URI_aarch64_jsonnet-doc = "${EPEL_MIRROR}/aarch64/Packages/j/jsonnet-doc-0.21.0-1.el10_1.noarch.rpm;name=aarch64_jsonnet-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsonnet-doc}"
SRC_URI[aarch64_jsonnet-doc.sha256sum] = "858da56b435112d11ab766701f7556195221df5ff806efa8f4521d1f91caab85"

URI_aarch64_jsonnet-libs = "${EPEL_MIRROR}/aarch64/Packages/j/jsonnet-libs-0.21.0-1.el10_1.aarch64.rpm;name=aarch64_jsonnet-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsonnet-libs}"
SRC_URI[aarch64_jsonnet-libs.sha256sum] = "3ea97320aca84cdde7178a59577439ed1eada0d4956110fca08b7935fb6a24b0"

URI_aarch64_python3-jsonnet = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jsonnet-0.21.0-1.el10_1.aarch64.rpm;name=aarch64_python3-jsonnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jsonnet}"
SRC_URI[aarch64_python3-jsonnet.sha256sum] = "17331238698c684f7b90756003b4795738b31dbc1e4a1e0414dd2891f277d9a6"

RDEPENDS:jsonnet = " \
 glibc \
 jsonnet-libs \
 libgcc \
 libstdc++ \
 "
RDEPENDS:jsonnet-devel = " \
 jsonnet-libs \
 "
RDEPENDS:jsonnet-doc = " \
 "
RDEPENDS:jsonnet-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 rapidyaml \
 "
RDEPENDS:python3-jsonnet = " \
 glibc \
 jsonnet-libs \
 python3 \
 "
