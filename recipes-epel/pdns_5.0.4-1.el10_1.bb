# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pdns"
PV = "5.0.4"
PR = "1.el10_1"
PACKAGES = " \
 pdns \
 pdns-backend-ldap \
 pdns-backend-lmdb \
 pdns-backend-lua2 \
 pdns-backend-mysql \
 pdns-backend-pipe \
 pdns-backend-postgresql \
 pdns-backend-remote \
 pdns-backend-sqlite \
 pdns-backend-tinydns \
 pdns-ixfrdist \
 pdns-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pdns-5.0.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95e14fb5a2839df909ae2003e8c683cadcfd53622132ea674d66ee36315198a3"

URI_x86_64_v2_pdns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-5.0.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns}"
SRC_URI[x86_64_v2_pdns.sha256sum] = "c2d58d910dea55a47cec77041f1018fa9a96a3b86eb1ca0febd413868810920e"

URI_x86_64_v2_pdns-backend-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-ldap-5.0.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-ldap}"
SRC_URI[x86_64_v2_pdns-backend-ldap.sha256sum] = "ecd360bdf889f6e51d6ef79a2d3a77579bacc907a7aa99afd84e74572f9d3d43"

URI_x86_64_v2_pdns-backend-lmdb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-lmdb-5.0.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-lmdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-lmdb}"
SRC_URI[x86_64_v2_pdns-backend-lmdb.sha256sum] = "1053eb5142fda445faece6b808c1b1b8dfad70f6edc72efe5438ba07dc4b07a0"

URI_x86_64_v2_pdns-backend-lua2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-lua2-5.0.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-lua2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-lua2}"
SRC_URI[x86_64_v2_pdns-backend-lua2.sha256sum] = "bdc605263f89c3ba5a3689535cfa269489807a417c741f30d26f71fbbce59a87"

URI_x86_64_v2_pdns-backend-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-mysql-5.0.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-mysql}"
SRC_URI[x86_64_v2_pdns-backend-mysql.sha256sum] = "8ebda2bda0bdd4fc2992eb875a8dbbc120120069cb0d1521f14f6926c1d8c912"

URI_x86_64_v2_pdns-backend-pipe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-pipe-5.0.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-pipe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-pipe}"
SRC_URI[x86_64_v2_pdns-backend-pipe.sha256sum] = "b8a78fe195fe4f063a5dc6cf40fe23e729df345eb12c85eb16d411b289de5d46"

URI_x86_64_v2_pdns-backend-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-postgresql-5.0.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-postgresql}"
SRC_URI[x86_64_v2_pdns-backend-postgresql.sha256sum] = "af606940709509f1a1324c02bcd172d4421490d0e035cc1ecb9eb95c7e5cf8e8"

URI_x86_64_v2_pdns-backend-remote = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-remote-5.0.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-remote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-remote}"
SRC_URI[x86_64_v2_pdns-backend-remote.sha256sum] = "1064b6533096dfce5db1947c205b36ba42d850d62b30af000ca862e0cf061ded"

URI_x86_64_v2_pdns-backend-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-sqlite-5.0.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-sqlite}"
SRC_URI[x86_64_v2_pdns-backend-sqlite.sha256sum] = "a9788905afd3985b92b935769c8d1fc4c4031bcfb84bf4eaca4a7b068ce9ca2f"

URI_x86_64_v2_pdns-backend-tinydns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-tinydns-5.0.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-tinydns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-tinydns}"
SRC_URI[x86_64_v2_pdns-backend-tinydns.sha256sum] = "1d96d1352144106b0565592a0de634cc6c2fcadf5682574dc6397a89b407be52"

URI_x86_64_v2_pdns-ixfrdist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-ixfrdist-5.0.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-ixfrdist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-ixfrdist}"
SRC_URI[x86_64_v2_pdns-ixfrdist.sha256sum] = "7fc73c32c1715d326bd47fed96f19c100c4843d4b0750a342780b0bbccb471c1"

URI_x86_64_v2_pdns-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-tools-5.0.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-tools}"
SRC_URI[x86_64_v2_pdns-tools.sha256sum] = "8ac6ca40e88e6ec689892a770c6f324c4a02b49de8608c7259fed19c5cc1a641"

URI_aarch64_pdns = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-5.0.4-1.el10_1.aarch64.rpm;name=aarch64_pdns;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns}"
SRC_URI[aarch64_pdns.sha256sum] = "cb6a93226e3d9f12e1048382cad5dd7f497ed71a555a388c353d6a42d7455ec4"

URI_aarch64_pdns-backend-ldap = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-ldap-5.0.4-1.el10_1.aarch64.rpm;name=aarch64_pdns-backend-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-ldap}"
SRC_URI[aarch64_pdns-backend-ldap.sha256sum] = "953bc4c817d4632e4bc6c4ca1413bb4b5cf31921269105d30ce567a7d6b47bdb"

URI_aarch64_pdns-backend-lmdb = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-lmdb-5.0.4-1.el10_1.aarch64.rpm;name=aarch64_pdns-backend-lmdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-lmdb}"
SRC_URI[aarch64_pdns-backend-lmdb.sha256sum] = "54e9f8606ea83f26477df9f8d48d72d14d1a9f4cea8d92f02ef1dfae5a1511bd"

URI_aarch64_pdns-backend-lua2 = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-lua2-5.0.4-1.el10_1.aarch64.rpm;name=aarch64_pdns-backend-lua2;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-lua2}"
SRC_URI[aarch64_pdns-backend-lua2.sha256sum] = "b7de76e349159e324072262f8dee4e97a41954544218225f2dcef2a6cade0ae0"

URI_aarch64_pdns-backend-mysql = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-mysql-5.0.4-1.el10_1.aarch64.rpm;name=aarch64_pdns-backend-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-mysql}"
SRC_URI[aarch64_pdns-backend-mysql.sha256sum] = "a85ab71bd76dcb8b88377131bc48cd234ba3bc3d12c037e49b8d5aeab5d1c156"

URI_aarch64_pdns-backend-pipe = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-pipe-5.0.4-1.el10_1.aarch64.rpm;name=aarch64_pdns-backend-pipe;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-pipe}"
SRC_URI[aarch64_pdns-backend-pipe.sha256sum] = "1a6e497a438b54b098c3968c9f71feec5cdc6028e80acdc5daf9aaef6e377cae"

URI_aarch64_pdns-backend-postgresql = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-postgresql-5.0.4-1.el10_1.aarch64.rpm;name=aarch64_pdns-backend-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-postgresql}"
SRC_URI[aarch64_pdns-backend-postgresql.sha256sum] = "6be0bfb3b7eee54aa653539fef07caa04b8725965769ee2f9daaf2236afaa663"

URI_aarch64_pdns-backend-remote = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-remote-5.0.4-1.el10_1.aarch64.rpm;name=aarch64_pdns-backend-remote;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-remote}"
SRC_URI[aarch64_pdns-backend-remote.sha256sum] = "f60205257107817938b5d5fd02af44564154fdbb32a41f474d3d21cee4d2df6d"

URI_aarch64_pdns-backend-sqlite = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-sqlite-5.0.4-1.el10_1.aarch64.rpm;name=aarch64_pdns-backend-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-sqlite}"
SRC_URI[aarch64_pdns-backend-sqlite.sha256sum] = "dc5adedb8d434fdb43fb4b7a79350104d7ae713a034f2e614fea516dbf5ca612"

URI_aarch64_pdns-backend-tinydns = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-tinydns-5.0.4-1.el10_1.aarch64.rpm;name=aarch64_pdns-backend-tinydns;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-tinydns}"
SRC_URI[aarch64_pdns-backend-tinydns.sha256sum] = "32b74b640ce94f6fc23cffc717339e6061d790ba01d6feb5b6c2d82d2ed973c0"

URI_aarch64_pdns-ixfrdist = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-ixfrdist-5.0.4-1.el10_1.aarch64.rpm;name=aarch64_pdns-ixfrdist;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-ixfrdist}"
SRC_URI[aarch64_pdns-ixfrdist.sha256sum] = "5004575e838e5c9be0a3296a73c9a14ca4ebdb2bf4fdbd0386f12f0842326e59"

URI_aarch64_pdns-tools = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-tools-5.0.4-1.el10_1.aarch64.rpm;name=aarch64_pdns-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-tools}"
SRC_URI[aarch64_pdns-tools.sha256sum] = "0788350d7c891f3454a235925c82587aed74bbf3d859cb25d526091a346b58f7"

RDEPENDS:pdns = " \
 bash \
 boost-program-options \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 luajit \
 openssl-libs \
 p11-kit \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:pdns-backend-ldap = " \
 glibc \
 krb5-libs \
 libgcc \
 libstdc++ \
 openldap \
 pdns \
 "
RDEPENDS:pdns-backend-lmdb = " \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 lmdb-libs \
 pdns \
 systemd-libs \
 "
RDEPENDS:pdns-backend-lua2 = " \
 glibc \
 libgcc \
 libstdc++ \
 luajit \
 pdns \
 "
RDEPENDS:pdns-backend-mysql = " \
 glibc \
 libgcc \
 libstdc++ \
 mariadb-connector-c \
 pdns \
 "
RDEPENDS:pdns-backend-pipe = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-postgresql = " \
 glibc \
 libgcc \
 libpq \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-remote = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-sqlite = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-tinydns = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 tinycdb \
 "
RDEPENDS:pdns-ixfrdist = " \
 boost-program-options \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 openssl-libs \
 p11-kit \
 yaml-cpp \
 "
RDEPENDS:pdns-tools = " \
 boost-program-options \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 openssl-libs \
 p11-kit \
 virtual/libcurl.so.4___64bit_ \
 "
