# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-calendar-tools"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 akonadi-calendar-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-calendar-tools-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf92893f404bbb1fcc9756f34760fc26bcebce05b4bb5e26edb36c6822dedfa6"

URI_x86_64_v2_akonadi-calendar-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-tools-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-calendar-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar-tools}"
SRC_URI[x86_64_v2_akonadi-calendar-tools.sha256sum] = "592b96fd610b9b70b9493e11d21737be248dff55ad94f8ff9dfa2904a5e7d130"

URI_aarch64_akonadi-calendar-tools = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-tools-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-calendar-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar-tools}"
SRC_URI[aarch64_akonadi-calendar-tools.sha256sum] = "38c85ef3ca25090875601cb5236a5f5f7ef6e542b3bd11d16b14851ec7d91088"

RDEPENDS:akonadi-calendar-tools = " \
 akonadi-calendar \
 akonadi-server \
 calendarsupport \
 glibc \
 kf6-kcalendarcore \
 kf6-kcoreaddons \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
