# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jupyter-server-terminals"
PV = "0.5.3"
PR = "5.el10_1"
PACKAGES = " \
 python3-jupyter-server-terminals \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-jupyter-server-terminals-0.5.3-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "09d6082597141234b66e22753001086434ce66d14a8fce89b4928d732053fa9d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jupyter-server-terminals-0.5.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jupyter-server-terminals;unpack=0"
SRC_URI[x86_64_v2_python3-jupyter-server-terminals.sha256sum] = "a5860bd169d64ec80ca368cc5f6ae4a18befdd3d253d0a54b349f21f4a526945"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-jupyter-server-terminals-0.5.3-5.el10_1.noarch.rpm;name=aarch64_python3-jupyter-server-terminals;unpack=0"
SRC_URI[aarch64_python3-jupyter-server-terminals.sha256sum] = "640d7f6d6f86a296a3acc2e065f87b778566d87924df457c6de6351f0b0cad99"

RDEPENDS:python3-jupyter-server-terminals = " \
 python-jupyter-filesystem \
 python3 \
 python3-terminado \
 "
