# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tin"
PV = "2.6.6"
PR = "1.el10_3"
PACKAGES = " \
 tin \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tin-2.6.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3fbb9a0b456b958577f9efd1addf495af8a5ca7e37f9cd39e6676c462f4c6a3b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tin-2.6.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tin;unpack=0"
SRC_URI[x86_64_v2_tin.sha256sum] = "0b37ffe56d951a9a819c52a6a45513a7c7ba0ff9d891c24c0d8d49ede73d9c85"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tin-2.6.6-1.el10_3.aarch64.rpm;name=aarch64_tin;unpack=0"
SRC_URI[aarch64_tin.sha256sum] = "5ebbeb855a0cd48b32dab8aee819041426c0fb26c047336d7e4ac5197a10e8d8"

RDEPENDS:tin = " \
 bash \
 glibc \
 libcanlock \
 libgsasl \
 libicu \
 ncurses-libs \
 openssl-libs \
 pcre2 \
 perl-Getopt-Long \
 perl-IO \
 perl-Pod-Usage \
 perl-Sys-Hostname \
 perl-Term-ReadLine \
 perl-Time-Local \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 zlib-ng-compat \
 "
