# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-RUnit"
PV = "0.4.33.1"
PR = "2.el10_2"
PACKAGES = " \
 R-RUnit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-RUnit-0.4.33.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42daf43d02c126d88a770e14b9b3cc9eeee3c5184ca4d61c605c54c3b13c2a4f"

URI_x86_64_v2_R-RUnit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-RUnit-0.4.33.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_R-RUnit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-RUnit}"
SRC_URI[x86_64_v2_R-RUnit.sha256sum] = "737ad3bbf4013cd5767681ab56b95bc7c61bc7a4a4871ca3d590065db81f023e"

URI_aarch64_R-RUnit = "${EPEL_MIRROR}/aarch64/Packages/r/R-RUnit-0.4.33.1-2.el10_2.noarch.rpm;name=aarch64_R-RUnit;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-RUnit}"
SRC_URI[aarch64_R-RUnit.sha256sum] = "5c74e8dc36da2e3e94056c44362c716969200e34878d220f80b7314cdfeb9dc8"

RDEPENDS:R-RUnit = " \
 R-core \
 "
