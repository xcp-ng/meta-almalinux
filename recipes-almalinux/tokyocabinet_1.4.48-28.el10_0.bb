# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tokyocabinet"
PV = "1.4.48"
PR = "28.el10_0"
PACKAGES = " \
 tokyocabinet \
 tokyocabinet-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tokyocabinet-1.4.48-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96bc920d8ff68ed172db18946d89f284a0020cc26f3a3259c19a0d5f9c0dbc9d"

URI_x86_64_v2_tokyocabinet = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tokyocabinet-1.4.48-28.el10_0.x86_64_v2.rpm;name=x86_64_v2_tokyocabinet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tokyocabinet}"
SRC_URI[x86_64_v2_tokyocabinet.sha256sum] = "c0729ff8f54189aeaea9317a60b1c413e769db266641dc8827efaf60354740c5"

URI_x86_64_v2_tokyocabinet-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/tokyocabinet-devel-1.4.48-28.el10_0.x86_64_v2.rpm;name=x86_64_v2_tokyocabinet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tokyocabinet-devel}"
SRC_URI[x86_64_v2_tokyocabinet-devel.sha256sum] = "670117f26528c91e72d55fd95006337851d6869f4211d0af3971d94126c94b03"

URI_aarch64_tokyocabinet = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tokyocabinet-1.4.48-28.el10_0.aarch64.rpm;name=aarch64_tokyocabinet;unpack=0"
SRC_URI:append = " ${URI_aarch64_tokyocabinet}"
SRC_URI[aarch64_tokyocabinet.sha256sum] = "803b867ce7abc2ee5ce10130c407699d6cd9edd21649377bc85daa1e41ead8a0"

URI_aarch64_tokyocabinet-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/tokyocabinet-devel-1.4.48-28.el10_0.aarch64.rpm;name=aarch64_tokyocabinet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tokyocabinet-devel}"
SRC_URI[aarch64_tokyocabinet-devel.sha256sum] = "888a80380ac5a9891d9667a252ed27920caeb76fcf865aaf130d25e85f18126f"

RDEPENDS:tokyocabinet = " \
 bzip2-libs \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:tokyocabinet-devel = " \
 pkgconf-pkg-config \
 tokyocabinet \
 "
