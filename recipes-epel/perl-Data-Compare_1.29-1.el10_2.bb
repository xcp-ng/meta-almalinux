# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Compare"
PV = "1.29"
PR = "1.el10_2"
PACKAGES = " \
 perl-Data-Compare \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Compare-1.29-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71013f52602fd77791d15781ef65d5eb49b6ce1286987e86655e01d17e2ee4b2"

URI_x86_64_v2_perl-Data-Compare = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Compare-1.29-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Compare;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Compare}"
SRC_URI[x86_64_v2_perl-Data-Compare.sha256sum] = "c5b02a0fc420566c2ff06603494bb4dd04b9bb5972c1c468a40d5d0df2c53208"

URI_aarch64_perl-Data-Compare = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Compare-1.29-1.el10_2.noarch.rpm;name=aarch64_perl-Data-Compare;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Compare}"
SRC_URI[aarch64_perl-Data-Compare.sha256sum] = "5938ab86dd97368c64c8e1a3c93b6bc7aeea79935021c1116173c202d9ef8d37"

RDEPENDS:perl-Data-Compare = " \
 perl-Carp \
 perl-Clone \
 perl-Data-Compare \
 perl-Exporter \
 perl-File-Find-Rule \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-vars \
 "
