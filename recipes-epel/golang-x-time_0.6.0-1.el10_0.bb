# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-x-time"
PV = "0.6.0"
PR = "1.el10_0"
PACKAGES = " \
 golang-x-time-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-x-time-0.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab436cc78fc8f531591221c270579db8c4603567de4c4d1aa987e75d223ed20f"

URI_x86_64_v2_golang-x-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-x-time-devel-0.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-x-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-x-time-devel}"
SRC_URI[x86_64_v2_golang-x-time-devel.sha256sum] = "acf77a50bf2c555c55f58607a79b8603c22845bf8eb055bd212bc15588752c97"

URI_aarch64_golang-x-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-x-time-devel-0.6.0-1.el10_0.noarch.rpm;name=aarch64_golang-x-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-x-time-devel}"
SRC_URI[aarch64_golang-x-time-devel.sha256sum] = "18b3bdee5fcc784ec75f5b0a94348a600233f5e9f05ab074c8e6cec6bbfc27a5"

RDEPENDS:golang-x-time-devel = " \
 go-filesystem \
 "
