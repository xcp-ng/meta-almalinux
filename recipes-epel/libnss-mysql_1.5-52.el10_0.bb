# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnss-mysql"
PV = "1.5"
PR = "52.el10_0"
PACKAGES = " \
 libnss-mysql \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libnss-mysql-1.5-52.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eac97d50326dcfbcfc874e9795efbae2925573fa4bef0f13a8820bad528f7074"

URI_x86_64_v2_libnss-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnss-mysql-1.5-52.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnss-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnss-mysql}"
SRC_URI[x86_64_v2_libnss-mysql.sha256sum] = "46f1c1574bd20c9d4a1881eecac88ecf4c4844ced2604689c83ba8bcccd70204"

URI_aarch64_libnss-mysql = "${EPEL_MIRROR}/aarch64/Packages/l/libnss-mysql-1.5-52.el10_0.aarch64.rpm;name=aarch64_libnss-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnss-mysql}"
SRC_URI[aarch64_libnss-mysql.sha256sum] = "36864778cf413ae15e8144d1cd3ceb40bbaf3f1adbb737552d25ad011e9ee34f"

RDEPENDS:libnss-mysql = " \
 glibc \
 mariadb-connector-c \
 zlib-ng-compat \
 "
