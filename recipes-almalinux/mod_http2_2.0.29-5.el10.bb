# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_http2"
PV = "2.0.29"
PR = "5.el10"
PACKAGES = " \
 mod_http2 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_http2-2.0.29-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b3b70b524448d11dcc031479338e1cd828850a47a1df0be022a78ae1de1d673d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_http2-2.0.29-5.el10.x86_64_v2.rpm;name=x86_64_v2_mod_http2;unpack=0"
SRC_URI[x86_64_v2_mod_http2.sha256sum] = "ef2f178be00cc096e32a76fd8dc6961960eece9b0e83c9fb9a408a44dcc9dbb8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_http2-2.0.29-5.el10.aarch64.rpm;name=aarch64_mod_http2;unpack=0"
SRC_URI[aarch64_mod_http2.sha256sum] = "20b7f5101142fdc7543b618ffc6254f7c0a8da048bc33f8b57670cc00697d73f"

RDEPENDS:mod_http2 = " \
 glibc \
 httpd-core \
 libnghttp2 \
 openssl-libs \
 "
