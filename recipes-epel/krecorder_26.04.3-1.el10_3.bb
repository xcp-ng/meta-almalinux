# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krecorder"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 krecorder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krecorder-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc87e663ddb449750c3d8bce326644c5183287e93053c0ffa5a8e1b081528820"

URI_x86_64_v2_krecorder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krecorder-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krecorder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krecorder}"
SRC_URI[x86_64_v2_krecorder.sha256sum] = "879b9f5d54cc6c3e951d63392ffca5b538096ae7cf3d52ff455fb513d28cffbb"

URI_aarch64_krecorder = "${EPEL_MIRROR}/aarch64/Packages/k/krecorder-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_krecorder;unpack=0"
SRC_URI:append = " ${URI_aarch64_krecorder}"
SRC_URI[aarch64_krecorder.sha256sum] = "9666d64ba71cba86742e740e15805cf9db1ecf71fe8fc5ce65a5c88b898dfd8f"

RDEPENDS:krecorder = " \
 glibc \
 gstreamer1-plugins-good \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
