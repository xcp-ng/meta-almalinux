# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-oxygen"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 oxygen-cursor-themes \
 plasma-oxygen \
 plasma-oxygen-qt6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-oxygen-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a16f90cf146446d7adb74f3a0ee0d31a3e8c1da8160b73a85ebd400a986968a0"

URI_x86_64_v2_oxygen-cursor-themes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxygen-cursor-themes-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_oxygen-cursor-themes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oxygen-cursor-themes}"
SRC_URI[x86_64_v2_oxygen-cursor-themes.sha256sum] = "22e85881f260c53f112477123c4094f717d6b3184edf5e2c0f6aeae5b210b635"

URI_x86_64_v2_plasma-oxygen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-oxygen-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-oxygen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-oxygen}"
SRC_URI[x86_64_v2_plasma-oxygen.sha256sum] = "c533a5ff7426de8cdbda0789b95be45fe7e051591fc09e8cd54e70b5dffb5acd"

URI_x86_64_v2_plasma-oxygen-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-oxygen-qt6-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-oxygen-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-oxygen-qt6}"
SRC_URI[x86_64_v2_plasma-oxygen-qt6.sha256sum] = "fddac49bc2a852c0d1fec01cffb0db81e4db6b79729eec85e3aa65a9195c80a3"

URI_aarch64_oxygen-cursor-themes = "${EPEL_MIRROR}/aarch64/Packages/o/oxygen-cursor-themes-6.3.6-1.el10_0.noarch.rpm;name=aarch64_oxygen-cursor-themes;unpack=0"
SRC_URI:append = " ${URI_aarch64_oxygen-cursor-themes}"
SRC_URI[aarch64_oxygen-cursor-themes.sha256sum] = "de32e56f545d2ae366759048a6fe0241a7810cbb4d2ebca935f2c58408031a04"

URI_aarch64_plasma-oxygen = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-oxygen-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-oxygen;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-oxygen}"
SRC_URI[aarch64_plasma-oxygen.sha256sum] = "02b7d563441552c227ab67c0ba6fc9808858420cd532ebe8b01bc4bc5832f619"

URI_aarch64_plasma-oxygen-qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-oxygen-qt6-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-oxygen-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-oxygen-qt6}"
SRC_URI[aarch64_plasma-oxygen-qt6.sha256sum] = "6f083c2e2c529a64d091b2b17206ebf607295d9764cdd700234f159921e95d72"

RDEPENDS:oxygen-cursor-themes = " \
 "
RDEPENDS:plasma-oxygen = " \
 glibc \
 kdecoration \
 kf6-filesystem \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwindowsystem \
 libstdc++ \
 libxcb \
 oxygen-cursor-themes \
 oxygen-icon-theme \
 oxygen-sounds \
 plasma-oxygen-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-oxygen-qt6 = " \
 glibc \
 kf6-frameworkintegration-libs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
