# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-tempfile"
PV = "16.0.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-tempfile+default-devel \
 rust-gix-tempfile+document-features-devel \
 rust-gix-tempfile+hp-hashmap-devel \
 rust-gix-tempfile+signals-devel \
 rust-gix-tempfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-tempfile-16.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62c04b28d7eb0534faf271454ed3319f2678db064c0475f2904a4ef841753af9"

URI_x86_64_v2_rust-gix-tempfile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+default-devel-16.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+default-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+default-devel.sha256sum] = "be47ae108b7cd6e2005d40bf6836a356721e6c6e84d454d38cb0ef86d6f98217"

URI_x86_64_v2_rust-gix-tempfile+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+document-features-devel-16.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+document-features-devel.sha256sum] = "b145317fdb95a2bf8bfcd87b0f8b44b97cb1d99a1f9832607d23818d58a47b2d"

URI_x86_64_v2_rust-gix-tempfile+hp-hashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+hp-hashmap-devel-16.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+hp-hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+hp-hashmap-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+hp-hashmap-devel.sha256sum] = "33d645f2ef0065e328449b2479723c505b899bbfc371061a588b462028d49ab7"

URI_x86_64_v2_rust-gix-tempfile+signals-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+signals-devel-16.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+signals-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+signals-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+signals-devel.sha256sum] = "de9d8cc536fd6a1dcec043ae678d83ffd23da5fe1c6f60cdee383f8cc6c31962"

URI_x86_64_v2_rust-gix-tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile-devel-16.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile-devel.sha256sum] = "385a9912e121d50225d4a09df27ce8cd283fba013847e9f1e5a0ebf88a7ec154"

URI_aarch64_rust-gix-tempfile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+default-devel-16.0.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+default-devel}"
SRC_URI[aarch64_rust-gix-tempfile+default-devel.sha256sum] = "1e7a431026fe4ff771be9867bcb082b237a23dc0628292a56d0c0a85539d3632"

URI_aarch64_rust-gix-tempfile+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+document-features-devel-16.0.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-tempfile+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+document-features-devel}"
SRC_URI[aarch64_rust-gix-tempfile+document-features-devel.sha256sum] = "c77cba8e151ae0c4103c373cd5dab48574fe9d7b5f63446ed4cd812ab40d5ba2"

URI_aarch64_rust-gix-tempfile+hp-hashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+hp-hashmap-devel-16.0.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-tempfile+hp-hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+hp-hashmap-devel}"
SRC_URI[aarch64_rust-gix-tempfile+hp-hashmap-devel.sha256sum] = "52673e7a5afb06a24a0382c03d33b4d7fa32e9a8e01ed0a6ee403e8c8b12c034"

URI_aarch64_rust-gix-tempfile+signals-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+signals-devel-16.0.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-tempfile+signals-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+signals-devel}"
SRC_URI[aarch64_rust-gix-tempfile+signals-devel.sha256sum] = "4a7a541f87cf991f0cc5dab4039899bcbe23a4eeb7cdc69e70cd8b918ca88b40"

URI_aarch64_rust-gix-tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile-devel-16.0.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile-devel}"
SRC_URI[aarch64_rust-gix-tempfile-devel.sha256sum] = "b70b518ee0eb462e7aa1bff2bd58bbfdf274f5d0e7917bc5636b99332e2828bd"

RDEPENDS:rust-gix-tempfile+default-devel = " \
 cargo \
 rust-gix-tempfile+hp-hashmap-devel \
 rust-gix-tempfile-devel \
 "
RDEPENDS:rust-gix-tempfile+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-tempfile-devel \
 "
RDEPENDS:rust-gix-tempfile+hp-hashmap-devel = " \
 cargo \
 rust-dashmap+default-devel \
 rust-gix-tempfile-devel \
 "
RDEPENDS:rust-gix-tempfile+signals-devel = " \
 cargo \
 rust-gix-tempfile-devel \
 rust-signal-hook-devel \
 rust-signal-hook-registry+default-devel \
 "
RDEPENDS:rust-gix-tempfile-devel = " \
 cargo \
 rust \
 rust-gix-fs+default-devel \
 rust-libc-devel \
 rust-once_cell+race-devel \
 rust-once_cell+std-devel \
 rust-once_cell-devel \
 rust-parking_lot+default-devel \
 rust-tempfile+default-devel \
 "
