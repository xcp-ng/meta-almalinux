# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-poi-tracker"
PV = "0.0.1"
PR = "1.el10_0"
PACKAGES = " \
 poi-tracker \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-poi-tracker-0.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4147e3d1e0b86328901b3f46b0dee856226c489d7464f592da1135f1da3484f"

URI_x86_64_v2_poi-tracker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/poi-tracker-0.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_poi-tracker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poi-tracker}"
SRC_URI[x86_64_v2_poi-tracker.sha256sum] = "aaeb0ab31dc3b18e17b09b27db1f51e867eb3e1ebb48eda70c71c7ac7069b7f6"

URI_aarch64_poi-tracker = "${EPEL_MIRROR}/aarch64/Packages/p/poi-tracker-0.0.1-1.el10_0.noarch.rpm;name=aarch64_poi-tracker;unpack=0"
SRC_URI:append = " ${URI_aarch64_poi-tracker}"
SRC_URI[aarch64_poi-tracker.sha256sum] = "b279e992d3a11c47dd7805d6bc58e52f9631cba66aea51e0a37efcaf80af5e71"

RDEPENDS:poi-tracker = " \
 python3 \
 python3-click \
 python3-email-validator \
 python3-pydantic \
 python3-pyyaml \
 "
