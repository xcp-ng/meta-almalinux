# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "copyparty"
PV = "1.20.21"
PR = "1.el10_3"
PACKAGES = " \
 copyparty \
 copyparty-partyfuse \
 copyparty-u2c \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/copyparty-1.20.21-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "50cde8f03f71aecbd3f1e768616783a3235a011c292b5685149661f64c3d24e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/copyparty-1.20.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_copyparty;unpack=0"
SRC_URI[x86_64_v2_copyparty.sha256sum] = "900e655db8dd5df515a2bfcd74d15b56230955474fff743652fb9c81a4c4f01d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/copyparty-partyfuse-1.20.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_copyparty-partyfuse;unpack=0"
SRC_URI[x86_64_v2_copyparty-partyfuse.sha256sum] = "63abd33b5a373111ff25afaec928cdf2a34e616e9e0def7c310d7f9bbf616329"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/copyparty-u2c-1.20.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_copyparty-u2c;unpack=0"
SRC_URI[x86_64_v2_copyparty-u2c.sha256sum] = "b9d8b060cd11413b10b175524e9c9c64bf48f93eee416fd1e8b46d8329c6ed92"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/copyparty-1.20.21-1.el10_3.noarch.rpm;name=aarch64_copyparty;unpack=0"
SRC_URI[aarch64_copyparty.sha256sum] = "7322517b8e30545fccc177354b6066b9cf18d3afc1fa09d4c7b6f5bfca1a7b18"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/copyparty-partyfuse-1.20.21-1.el10_3.noarch.rpm;name=aarch64_copyparty-partyfuse;unpack=0"
SRC_URI[aarch64_copyparty-partyfuse.sha256sum] = "1d77396051c922eab9e34f135c324316c2980f0a992efe06e984c475f474a236"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/copyparty-u2c-1.20.21-1.el10_3.noarch.rpm;name=aarch64_copyparty-u2c;unpack=0"
SRC_URI[aarch64_copyparty-u2c.sha256sum] = "d60c2f1d5074c0113f94046c3d2f377e88b7aa697456feea036fdbc2e8ab94b1"

RDEPENDS:copyparty = " \
 python3 \
 python3-dnslib \
 python3-ifaddr \
 python3-jinja2 \
 python3-qrcodegen \
 "
RDEPENDS:copyparty-partyfuse = " \
 copyparty \
 python3 \
 python3-fusepy \
 "
RDEPENDS:copyparty-u2c = " \
 copyparty \
 python3 \
 "
