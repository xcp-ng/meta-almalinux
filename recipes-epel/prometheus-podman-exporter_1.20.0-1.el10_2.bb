# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "prometheus-podman-exporter"
PV = "1.20.0"
PR = "1.el10_2"
PACKAGES = " \
 prometheus-podman-exporter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/prometheus-podman-exporter-1.20.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70fb3af35d3430bfd61e19e7c583844926696e0707bb7c625234d972712cd403"

URI_x86_64_v2_prometheus-podman-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/prometheus-podman-exporter-1.20.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_prometheus-podman-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_prometheus-podman-exporter}"
SRC_URI[x86_64_v2_prometheus-podman-exporter.sha256sum] = "2615933203ee09d40234aef61f268af25e1f53c401ee782bb06f671b60541c27"

URI_aarch64_prometheus-podman-exporter = "${EPEL_MIRROR}/aarch64/Packages/p/prometheus-podman-exporter-1.20.0-1.el10_2.aarch64.rpm;name=aarch64_prometheus-podman-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_prometheus-podman-exporter}"
SRC_URI[aarch64_prometheus-podman-exporter.sha256sum] = "b329336000d54d106b580b086629e2e883896392a29fc267ba5db689a429c00a"

RDEPENDS:prometheus-podman-exporter = " \
 bash \
 glibc \
 gpgme \
 "
