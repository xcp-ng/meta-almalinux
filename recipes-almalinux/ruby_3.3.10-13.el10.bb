# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby"
PV = "3.3.10"
PR = "13.el10"
PACKAGES = " \
 ruby \
 ruby-bundled-gems \
 ruby-default-gems \
 ruby-devel \
 ruby-doc \
 ruby-libs \
 rubygem-bigdecimal \
 rubygem-bundler \
 rubygem-io-console \
 rubygem-irb \
 rubygem-json \
 rubygem-minitest \
 rubygem-power_assert \
 rubygem-psych \
 rubygem-racc \
 rubygem-rake \
 rubygem-rbs \
 rubygem-rdoc \
 rubygem-rexml \
 rubygem-rss \
 rubygem-test-unit \
 rubygem-typeprof \
 rubygems \
 rubygems-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ruby-3.3.10-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b40564707b7be30efa8fdd335bbaff86cda1a72a3dccfe926b89bf6a2ceaa03a"

URI_x86_64_v2_ruby = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-3.3.10-13.el10.x86_64_v2.rpm;name=x86_64_v2_ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby}"
SRC_URI[x86_64_v2_ruby.sha256sum] = "86f8572bbcababe405b81bdc902be6974af7d1e918498bc5004b5cef0ba6d7ea"
RPROVIDES:ruby:x86_64_v2 = "virtual/ruby_runtime_executable_"

URI_x86_64_v2_ruby-bundled-gems = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-bundled-gems-3.3.10-13.el10.x86_64_v2.rpm;name=x86_64_v2_ruby-bundled-gems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-bundled-gems}"
SRC_URI[x86_64_v2_ruby-bundled-gems.sha256sum] = "9a505bacaa4675d5a77b255e62d6ea6a49ae0a2193fc5aa0b9952df37144cf3b"

URI_x86_64_v2_ruby-default-gems = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-default-gems-3.3.10-13.el10.noarch.rpm;name=x86_64_v2_ruby-default-gems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-default-gems}"
SRC_URI[x86_64_v2_ruby-default-gems.sha256sum] = "9ced09d3cf68f3a17f62001b17b621d786b19159d61295bd53b7c84f5bdabfa1"

URI_x86_64_v2_ruby-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-devel-3.3.10-13.el10.x86_64_v2.rpm;name=x86_64_v2_ruby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-devel}"
SRC_URI[x86_64_v2_ruby-devel.sha256sum] = "5a55c05f2499dfe3226d1496ee26d356065906925d69cea34cc3236e6047d13e"

URI_x86_64_v2_ruby-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ruby-doc-3.3.10-13.el10.noarch.rpm;name=x86_64_v2_ruby-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-doc}"
SRC_URI[x86_64_v2_ruby-doc.sha256sum] = "3b3b828269cb9c29e2babefd8d56fdb2600fc2085c564cd8dd87b57e68296322"

URI_x86_64_v2_ruby-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-libs-3.3.10-13.el10.x86_64_v2.rpm;name=x86_64_v2_ruby-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-libs}"
SRC_URI[x86_64_v2_ruby-libs.sha256sum] = "c87b55cbd2b99823afda3faf84cea399b330f0cccce5937df87d383603cbbdab"
RPROVIDES:ruby-libs:x86_64_v2 = "virtual/ruby_release_"

URI_x86_64_v2_rubygem-bigdecimal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-bigdecimal-3.1.5-13.el10.x86_64_v2.rpm;name=x86_64_v2_rubygem-bigdecimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-bigdecimal}"
SRC_URI[x86_64_v2_rubygem-bigdecimal.sha256sum] = "ca2558c214612b4e8151d3b8d281d220d66bd8b41ee723fd4a8fef479c0bfff1"

URI_x86_64_v2_rubygem-bundler = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-bundler-2.5.22-13.el10.noarch.rpm;name=x86_64_v2_rubygem-bundler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-bundler}"
SRC_URI[x86_64_v2_rubygem-bundler.sha256sum] = "433c038c9546b05f2c00d5499db74017ab22214b3cc68ae6838c476ce6c97990"

URI_x86_64_v2_rubygem-io-console = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-io-console-0.7.1-13.el10.x86_64_v2.rpm;name=x86_64_v2_rubygem-io-console;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-io-console}"
SRC_URI[x86_64_v2_rubygem-io-console.sha256sum] = "4a9b18d0aa70bf8db92482233bbf552748cad32189bbd756d56cb0ccc6be24cf"

URI_x86_64_v2_rubygem-irb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-irb-1.13.1-13.el10.noarch.rpm;name=x86_64_v2_rubygem-irb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-irb}"
SRC_URI[x86_64_v2_rubygem-irb.sha256sum] = "134efb420a3d81d1af6c16cbfee7815f9fabcb064d1af348981b9b2e355e21fe"

URI_x86_64_v2_rubygem-json = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-json-2.7.2-13.el10.x86_64_v2.rpm;name=x86_64_v2_rubygem-json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-json}"
SRC_URI[x86_64_v2_rubygem-json.sha256sum] = "62a6ebb8d06de6ddc7cd366a7c8250d5b5caa1a7b971b2a7130b8e004a200c0a"

URI_x86_64_v2_rubygem-minitest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-minitest-5.20.0-13.el10.noarch.rpm;name=x86_64_v2_rubygem-minitest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-minitest}"
SRC_URI[x86_64_v2_rubygem-minitest.sha256sum] = "10c441552e512c1bdf69546e06c2345e7b79f0daa6216a2d022018f2dd0dc10a"

URI_x86_64_v2_rubygem-power_assert = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-power_assert-2.0.3-13.el10.noarch.rpm;name=x86_64_v2_rubygem-power_assert;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-power_assert}"
SRC_URI[x86_64_v2_rubygem-power_assert.sha256sum] = "6bfb0e10210aebfb3a3b31c974a7de07e9ff61c22dce141c1cfd69c71ae5bbda"

URI_x86_64_v2_rubygem-psych = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-psych-5.1.2-13.el10.x86_64_v2.rpm;name=x86_64_v2_rubygem-psych;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-psych}"
SRC_URI[x86_64_v2_rubygem-psych.sha256sum] = "8190380022aaa1122a9d943e5b62d9fa7c9bf5fdcc9e03be7bcd7bfeea648fe8"

URI_x86_64_v2_rubygem-racc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-racc-1.7.3-13.el10.x86_64_v2.rpm;name=x86_64_v2_rubygem-racc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-racc}"
SRC_URI[x86_64_v2_rubygem-racc.sha256sum] = "0756bb5d965617a24d235b406a05f47fc0981518456813295055698982a8c765"

URI_x86_64_v2_rubygem-rake = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rake-13.1.0-13.el10.noarch.rpm;name=x86_64_v2_rubygem-rake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rake}"
SRC_URI[x86_64_v2_rubygem-rake.sha256sum] = "3bb182b47d7a421a36f724afa8fde8b638ecbf864142ba64e2fcd7d2476fca4d"

URI_x86_64_v2_rubygem-rbs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rbs-3.4.0-13.el10.x86_64_v2.rpm;name=x86_64_v2_rubygem-rbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rbs}"
SRC_URI[x86_64_v2_rubygem-rbs.sha256sum] = "470cb263c3893c47895b2f6312abef68919b66f3ed625c4238349e789dfe90f4"

URI_x86_64_v2_rubygem-rdoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rdoc-6.6.3.1-13.el10.noarch.rpm;name=x86_64_v2_rubygem-rdoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rdoc}"
SRC_URI[x86_64_v2_rubygem-rdoc.sha256sum] = "f1fde0c0b4897f48c75c3d3ab7ad49fcb966030a7580128c4ad8c160948f82af"

URI_x86_64_v2_rubygem-rexml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rexml-3.4.4-13.el10.noarch.rpm;name=x86_64_v2_rubygem-rexml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rexml}"
SRC_URI[x86_64_v2_rubygem-rexml.sha256sum] = "201d7bd9026de6490b5f01b30ecdc7e5b1f4119dbb1bd481d57dfb0dd5591e6a"

URI_x86_64_v2_rubygem-rss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rss-0.3.1-13.el10.noarch.rpm;name=x86_64_v2_rubygem-rss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rss}"
SRC_URI[x86_64_v2_rubygem-rss.sha256sum] = "1220a4b7885162f58d1ca6e22df6dd549afb6b5c0dbda799401350f8f71b28ee"

URI_x86_64_v2_rubygem-test-unit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-test-unit-3.6.1-13.el10.noarch.rpm;name=x86_64_v2_rubygem-test-unit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-test-unit}"
SRC_URI[x86_64_v2_rubygem-test-unit.sha256sum] = "4562a17fee7b20cc4aa8d40d3b54f8196fc776ac9f268e88cd317dd0a6df2f4e"

URI_x86_64_v2_rubygem-typeprof = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-typeprof-0.21.9-13.el10.noarch.rpm;name=x86_64_v2_rubygem-typeprof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-typeprof}"
SRC_URI[x86_64_v2_rubygem-typeprof.sha256sum] = "679619969bdb3d85930c7f7592f8e5293f1ee13b3925e572b8ae94c8f018db6c"

URI_x86_64_v2_rubygems = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygems-3.5.22-13.el10.noarch.rpm;name=x86_64_v2_rubygems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygems}"
SRC_URI[x86_64_v2_rubygems.sha256sum] = "ebaeec112542c714d2c8c7c1c1656599279d0b2e400649faaf8bceb6c2a5cc65"

URI_x86_64_v2_rubygems-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygems-devel-3.5.22-13.el10.noarch.rpm;name=x86_64_v2_rubygems-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygems-devel}"
SRC_URI[x86_64_v2_rubygems-devel.sha256sum] = "1eebad2dcc6b2f9ca01643547ba87f2edd961b16c12b56176c9bd5e9d55e56f2"

URI_aarch64_ruby = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-3.3.10-13.el10.aarch64.rpm;name=aarch64_ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby}"
SRC_URI[aarch64_ruby.sha256sum] = "6eac6d0b9c5be31834bde0ed34361d3c4192035f12eb20098b4ef1e90a7bca26"
RPROVIDES:ruby:aarch64 = "virtual/ruby_runtime_executable_"

URI_aarch64_ruby-bundled-gems = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-bundled-gems-3.3.10-13.el10.aarch64.rpm;name=aarch64_ruby-bundled-gems;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-bundled-gems}"
SRC_URI[aarch64_ruby-bundled-gems.sha256sum] = "eedac74536ce9a03c6716de3d2b496cea2efacdc8923a3089e13cb10398071ae"

URI_aarch64_ruby-default-gems = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-default-gems-3.3.10-13.el10.noarch.rpm;name=aarch64_ruby-default-gems;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-default-gems}"
SRC_URI[aarch64_ruby-default-gems.sha256sum] = "9ced09d3cf68f3a17f62001b17b621d786b19159d61295bd53b7c84f5bdabfa1"

URI_aarch64_ruby-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-devel-3.3.10-13.el10.aarch64.rpm;name=aarch64_ruby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-devel}"
SRC_URI[aarch64_ruby-devel.sha256sum] = "f939f00f345d64cadd7b93535956ac7c3e4dbdb8469bd53f3499d74da62f059e"

URI_aarch64_ruby-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ruby-doc-3.3.10-13.el10.noarch.rpm;name=aarch64_ruby-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-doc}"
SRC_URI[aarch64_ruby-doc.sha256sum] = "3b3b828269cb9c29e2babefd8d56fdb2600fc2085c564cd8dd87b57e68296322"

URI_aarch64_ruby-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-libs-3.3.10-13.el10.aarch64.rpm;name=aarch64_ruby-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-libs}"
SRC_URI[aarch64_ruby-libs.sha256sum] = "66f79a82eeccb9325245ba5306e635df4d8caf5cd5b914a7ff3d863008f46694"
RPROVIDES:ruby-libs:aarch64 = "virtual/ruby_release_"

URI_aarch64_rubygem-bigdecimal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-bigdecimal-3.1.5-13.el10.aarch64.rpm;name=aarch64_rubygem-bigdecimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-bigdecimal}"
SRC_URI[aarch64_rubygem-bigdecimal.sha256sum] = "8d046c3822e6bc53610f7e1196218ef86aeaaa69cdc624460d9a2abf2a7eb5fc"

URI_aarch64_rubygem-bundler = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-bundler-2.5.22-13.el10.noarch.rpm;name=aarch64_rubygem-bundler;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-bundler}"
SRC_URI[aarch64_rubygem-bundler.sha256sum] = "433c038c9546b05f2c00d5499db74017ab22214b3cc68ae6838c476ce6c97990"

URI_aarch64_rubygem-io-console = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-io-console-0.7.1-13.el10.aarch64.rpm;name=aarch64_rubygem-io-console;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-io-console}"
SRC_URI[aarch64_rubygem-io-console.sha256sum] = "ab67c0e7bf89907483f9d39fc212490520016e0579c199ac2b577a5470bb4c67"

URI_aarch64_rubygem-irb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-irb-1.13.1-13.el10.noarch.rpm;name=aarch64_rubygem-irb;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-irb}"
SRC_URI[aarch64_rubygem-irb.sha256sum] = "134efb420a3d81d1af6c16cbfee7815f9fabcb064d1af348981b9b2e355e21fe"

URI_aarch64_rubygem-json = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-json-2.7.2-13.el10.aarch64.rpm;name=aarch64_rubygem-json;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-json}"
SRC_URI[aarch64_rubygem-json.sha256sum] = "9529f0e91f1b41e911663badddf8ef034c55c9b563056c1f09a0c95e1960cab8"

URI_aarch64_rubygem-minitest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-minitest-5.20.0-13.el10.noarch.rpm;name=aarch64_rubygem-minitest;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-minitest}"
SRC_URI[aarch64_rubygem-minitest.sha256sum] = "10c441552e512c1bdf69546e06c2345e7b79f0daa6216a2d022018f2dd0dc10a"

URI_aarch64_rubygem-power_assert = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-power_assert-2.0.3-13.el10.noarch.rpm;name=aarch64_rubygem-power_assert;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-power_assert}"
SRC_URI[aarch64_rubygem-power_assert.sha256sum] = "6bfb0e10210aebfb3a3b31c974a7de07e9ff61c22dce141c1cfd69c71ae5bbda"

URI_aarch64_rubygem-psych = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-psych-5.1.2-13.el10.aarch64.rpm;name=aarch64_rubygem-psych;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-psych}"
SRC_URI[aarch64_rubygem-psych.sha256sum] = "8ddb48d995b6a313366f6aadfb763a6fa3b8f85b5e4705b963dfb363f4620f32"

URI_aarch64_rubygem-racc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-racc-1.7.3-13.el10.aarch64.rpm;name=aarch64_rubygem-racc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-racc}"
SRC_URI[aarch64_rubygem-racc.sha256sum] = "9f3ef9007d5226cab647a0a8944105a3a3d4e7379b2daebffb3cd66aae35540a"

URI_aarch64_rubygem-rake = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rake-13.1.0-13.el10.noarch.rpm;name=aarch64_rubygem-rake;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rake}"
SRC_URI[aarch64_rubygem-rake.sha256sum] = "3bb182b47d7a421a36f724afa8fde8b638ecbf864142ba64e2fcd7d2476fca4d"

URI_aarch64_rubygem-rbs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rbs-3.4.0-13.el10.aarch64.rpm;name=aarch64_rubygem-rbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rbs}"
SRC_URI[aarch64_rubygem-rbs.sha256sum] = "624c7c08e1ba6792481e7a4df9a25b9fc01765a4c37ebac1c9480554230cade0"

URI_aarch64_rubygem-rdoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rdoc-6.6.3.1-13.el10.noarch.rpm;name=aarch64_rubygem-rdoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rdoc}"
SRC_URI[aarch64_rubygem-rdoc.sha256sum] = "f1fde0c0b4897f48c75c3d3ab7ad49fcb966030a7580128c4ad8c160948f82af"

URI_aarch64_rubygem-rexml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rexml-3.4.4-13.el10.noarch.rpm;name=aarch64_rubygem-rexml;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rexml}"
SRC_URI[aarch64_rubygem-rexml.sha256sum] = "201d7bd9026de6490b5f01b30ecdc7e5b1f4119dbb1bd481d57dfb0dd5591e6a"

URI_aarch64_rubygem-rss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rss-0.3.1-13.el10.noarch.rpm;name=aarch64_rubygem-rss;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rss}"
SRC_URI[aarch64_rubygem-rss.sha256sum] = "1220a4b7885162f58d1ca6e22df6dd549afb6b5c0dbda799401350f8f71b28ee"

URI_aarch64_rubygem-test-unit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-test-unit-3.6.1-13.el10.noarch.rpm;name=aarch64_rubygem-test-unit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-test-unit}"
SRC_URI[aarch64_rubygem-test-unit.sha256sum] = "4562a17fee7b20cc4aa8d40d3b54f8196fc776ac9f268e88cd317dd0a6df2f4e"

URI_aarch64_rubygem-typeprof = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-typeprof-0.21.9-13.el10.noarch.rpm;name=aarch64_rubygem-typeprof;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-typeprof}"
SRC_URI[aarch64_rubygem-typeprof.sha256sum] = "679619969bdb3d85930c7f7592f8e5293f1ee13b3925e572b8ae94c8f018db6c"

URI_aarch64_rubygems = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygems-3.5.22-13.el10.noarch.rpm;name=aarch64_rubygems;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygems}"
SRC_URI[aarch64_rubygems.sha256sum] = "ebaeec112542c714d2c8c7c1c1656599279d0b2e400649faaf8bceb6c2a5cc65"

URI_aarch64_rubygems-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygems-devel-3.5.22-13.el10.noarch.rpm;name=aarch64_rubygems-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygems-devel}"
SRC_URI[aarch64_rubygems-devel.sha256sum] = "1eebad2dcc6b2f9ca01643547ba87f2edd961b16c12b56176c9bd5e9d55e56f2"

RDEPENDS:ruby = " \
 glibc \
 gmp \
 libxcrypt \
 ruby-libs \
 zlib-ng-compat \
 "
RDEPENDS:ruby-bundled-gems = " \
 glibc \
 ruby \
 ruby-default-gems \
 ruby-libs \
 rubygem-irb \
 rubygems \
 "
RDEPENDS:ruby-default-gems = " \
 ruby \
 ruby-default-gems \
 rubygem-io-console \
 rubygems \
 "
RDEPENDS:ruby-devel = " \
 pkgconf-pkg-config \
 ruby \
 ruby-libs \
 rubygems \
 "
RDEPENDS:ruby-doc = " \
 rubygem-rdoc \
 "
RDEPENDS:ruby-libs = " \
 glibc \
 gmp \
 libffi \
 libgcc \
 libxcrypt \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:rubygem-bigdecimal = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-bundler = " \
 ruby \
 rubygem-io-console \
 rubygems \
 "
RDEPENDS:rubygem-io-console = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-irb = " \
 ruby \
 ruby-default-gems \
 rubygem-rdoc \
 rubygems \
 "
RDEPENDS:rubygem-json = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-minitest = " \
 rubygems \
 "
RDEPENDS:rubygem-power_assert = " \
 rubygems \
 "
RDEPENDS:rubygem-psych = " \
 glibc \
 libyaml \
 ruby-default-gems \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-racc = " \
 glibc \
 ruby \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-rake = " \
 ruby \
 rubygems \
 "
RDEPENDS:rubygem-rbs = " \
 glibc \
 ruby \
 ruby-default-gems \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-rdoc = " \
 ruby \
 rubygem-io-console \
 rubygem-json \
 rubygem-psych \
 rubygems \
 "
RDEPENDS:rubygem-rexml = " \
 rubygems \
 "
RDEPENDS:rubygem-rss = " \
 rubygem-rexml \
 rubygems \
 "
RDEPENDS:rubygem-test-unit = " \
 rubygem-power_assert \
 rubygems \
 "
RDEPENDS:rubygem-typeprof = " \
 ruby \
 rubygem-rbs \
 rubygems \
 "
RDEPENDS:rubygems = " \
 ruby \
 rubygem-psych \
 virtual/ruby_release_ \
 "
RDEPENDS:rubygems-devel = " \
 ruby \
 rubygem-json \
 rubygem-rdoc \
 rubygems \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/ruby_release_ rpm/virtual/ruby_runtime_executable_"

PROVIDES:append:aarch64 = " rpm/virtual/ruby_release_ rpm/virtual/ruby_runtime_executable_"
