# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-core"
PV = "0.21.3"
PR = "1.el10_3"
PACKAGES = " \
 python3-colcon-core \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-core-0.21.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7a7d89725a815d0d1d9a9c1a041a28f4560bafc6650bdb385ae848e7b44fb3e8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-core-0.21.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-core;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-core.sha256sum] = "1316076f761ae463a224179e5729cc03f4fc8cda50c573c8dbe79113c6cda8bb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-core-0.21.3-1.el10_3.noarch.rpm;name=aarch64_python3-colcon-core;unpack=0"
SRC_URI[aarch64_python3-colcon-core.sha256sum] = "fda964d37830f5ac8a498bc40fc8e887ae41f492eed6508e4606bbd59f370511"

RDEPENDS:python3-colcon-core = " \
 python3 \
 python3-distlib \
 python3-empy \
 python3-packaging \
 python3-setuptools \
 "
