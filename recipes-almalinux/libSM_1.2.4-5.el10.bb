# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libSM"
PV = "1.2.4"
PR = "5.el10"
PACKAGES = " \
 libSM \
 libSM-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libSM-1.2.4-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d5fd5e5262ae7031464bd44c15428492e007534a227afde7b2465169e0c2d5a"

URI_x86_64_v2_libSM = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libSM-1.2.4-5.el10.x86_64_v2.rpm;name=x86_64_v2_libSM;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libSM}"
SRC_URI[x86_64_v2_libSM.sha256sum] = "096a4878913609999b12be4f576943dd1617e91e4bd19b69e58e6a8dc65ba0fb"

URI_x86_64_v2_libSM-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libSM-devel-1.2.4-5.el10.x86_64_v2.rpm;name=x86_64_v2_libSM-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libSM-devel}"
SRC_URI[x86_64_v2_libSM-devel.sha256sum] = "b536f350a0533ef89dd404cdcb53238e335f13ca5dda50a7a491692bed051866"

URI_aarch64_libSM = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libSM-1.2.4-5.el10.aarch64.rpm;name=aarch64_libSM;unpack=0"
SRC_URI:append = " ${URI_aarch64_libSM}"
SRC_URI[aarch64_libSM.sha256sum] = "72a06c819484dccba3c35fd0b1cae8447549b3450288bcc5ea4c179cad63413e"

URI_aarch64_libSM-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libSM-devel-1.2.4-5.el10.aarch64.rpm;name=aarch64_libSM-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libSM-devel}"
SRC_URI[aarch64_libSM-devel.sha256sum] = "974cef9c28a83e1e643d70af2a363f426caac6836e0241a111bd5e2ccffa2e2e"

RDEPENDS:libSM = " \
 glibc \
 libICE \
 libuuid \
 "
RDEPENDS:libSM-devel = " \
 libICE-devel \
 libSM \
 libuuid-devel \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
