# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "man-pages"
PV = "6.06"
PR = "8.el10_0"
PACKAGES = " \
 man-pages \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/man-pages-6.06-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "87dc5505a510486a3c9ab7e5465afbeb36b637617d4a9ec568c9864b520f49ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/man-pages-6.06-8.el10_0.noarch.rpm;name=x86_64_v2_man-pages;unpack=0"
SRC_URI[x86_64_v2_man-pages.sha256sum] = "a308406301ddf53854decf02f713ec69f5a7a831f6e2981b68286ddcbbf59d65"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/man-pages-6.06-8.el10_0.noarch.rpm;name=aarch64_man-pages;unpack=0"
SRC_URI[aarch64_man-pages.sha256sum] = "a308406301ddf53854decf02f713ec69f5a7a831f6e2981b68286ddcbbf59d65"

RDEPENDS:man-pages = " \
 alternatives \
 bash \
 "
