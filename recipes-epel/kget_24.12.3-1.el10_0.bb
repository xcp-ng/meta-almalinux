# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kget"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kget \
 kget-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kget-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10eb860f0b3e12c1246fe57fbbd80efc56fed6158060858e2ec5acd2c80a85bd"

URI_x86_64_v2_kget = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kget-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kget;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kget}"
SRC_URI[x86_64_v2_kget.sha256sum] = "fccb1e29a146021681c641e653cba9a59dede536208558f2f97ce701a10964b2"

URI_x86_64_v2_kget-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kget-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kget-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kget-libs}"
SRC_URI[x86_64_v2_kget-libs.sha256sum] = "67ad08ce0df63a9bdf381de2d426eaa6063c20e925d00986b23921d61610a745"

URI_aarch64_kget = "${EPEL_MIRROR}/aarch64/Packages/k/kget-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kget;unpack=0"
SRC_URI:append = " ${URI_aarch64_kget}"
SRC_URI[aarch64_kget.sha256sum] = "4568d262f01a736c29632639fbeec7d0bda1f8c0be310351c50c79bfdc292847"

URI_aarch64_kget-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kget-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kget-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kget-libs}"
SRC_URI[aarch64_kget-libs.sha256sum] = "64d87dbc28e85a095825c228b2944d11db3b8f2d7cd0ab1cfa6b8be35160b52b"

RDEPENDS:kget = " \
 glibc \
 gpgmepp \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kget-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kget-libs = " \
 glibc \
 gpgmepp \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kget \
 libgcc \
 libmms \
 libstdc++ \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
