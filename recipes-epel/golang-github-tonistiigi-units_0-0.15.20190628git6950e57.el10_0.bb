# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-tonistiigi-units"
PV = "0"
PR = "0.15.20190628git6950e57.el10_0"
PACKAGES = " \
 golang-github-tonistiigi-units-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-tonistiigi-units-0-0.15.20190628git6950e57.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b673da9c211e93a086df3ce5b7f3f64a17bb6cbfe67632cdba5b4b3661b383e9"

URI_aarch64_golang-github-tonistiigi-units-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-tonistiigi-units-devel-0-0.15.20190628git6950e57.el10_0.noarch.rpm;name=aarch64_golang-github-tonistiigi-units-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-tonistiigi-units-devel}"
SRC_URI[aarch64_golang-github-tonistiigi-units-devel.sha256sum] = "e6e5407a9805552d713c8c337289bc429faeff63bec4aaa39e2928918998a6fa"

RDEPENDS:golang-github-tonistiigi-units-devel = " \
 go-filesystem \
 "
