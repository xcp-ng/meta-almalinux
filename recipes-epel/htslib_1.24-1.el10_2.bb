# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "htslib"
PV = "1.24"
PR = "1.el10_2"
PACKAGES = " \
 htslib \
 htslib-devel \
 htslib-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/htslib-1.24-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed5bb68d51119d4ab1ebb8f5946ffddbeb72cf3a2fa108f4b4742c4edc19f975"

URI_x86_64_v2_htslib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/htslib-1.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_htslib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_htslib}"
SRC_URI[x86_64_v2_htslib.sha256sum] = "27952f25cd0a090f5820eb8d47a7403d0e1e0c2063e523402dd2ba1c73099670"

URI_x86_64_v2_htslib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/htslib-devel-1.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_htslib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_htslib-devel}"
SRC_URI[x86_64_v2_htslib-devel.sha256sum] = "48203a4a40d80fc8ca59078395ae19b370ff12b81234936d1430ddad8077d945"

URI_x86_64_v2_htslib-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/htslib-tools-1.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_htslib-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_htslib-tools}"
SRC_URI[x86_64_v2_htslib-tools.sha256sum] = "e0ffb726128149bce25ab4b3c8327289add8126419deb47b53f0e1740b24bf1a"

URI_aarch64_htslib = "${EPEL_MIRROR}/aarch64/Packages/h/htslib-1.24-1.el10_2.aarch64.rpm;name=aarch64_htslib;unpack=0"
SRC_URI:append = " ${URI_aarch64_htslib}"
SRC_URI[aarch64_htslib.sha256sum] = "3de1be0b7fcd7764aee4d83baef73280017814c940c7fcdf76b3a85f75b2ffc2"

URI_aarch64_htslib-devel = "${EPEL_MIRROR}/aarch64/Packages/h/htslib-devel-1.24-1.el10_2.aarch64.rpm;name=aarch64_htslib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_htslib-devel}"
SRC_URI[aarch64_htslib-devel.sha256sum] = "701e8bdfb68f9b659b72ef06fdaafe881f47d99470460fbe00097d0b4b98e464"

URI_aarch64_htslib-tools = "${EPEL_MIRROR}/aarch64/Packages/h/htslib-tools-1.24-1.el10_2.aarch64.rpm;name=aarch64_htslib-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_htslib-tools}"
SRC_URI[aarch64_htslib-tools.sha256sum] = "3dd385801fec3150f1f22ac9e99ebf4c17b5efbfb5523028348c9a5b534b526d"

RDEPENDS:htslib = " \
 bzip2-libs \
 glibc \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:htslib-devel = " \
 htslib \
 pkgconf-pkg-config \
 "
RDEPENDS:htslib-tools = " \
 bzip2-libs \
 glibc \
 htslib \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
