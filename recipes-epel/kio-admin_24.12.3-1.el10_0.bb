# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kio-admin"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kio-admin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kio-admin-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57b7659ab3a5b4e2e2af5e213e93e16e9724e195608086966c2d53e7027de6c4"

URI_x86_64_v2_kio-admin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-admin-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-admin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-admin}"
SRC_URI[x86_64_v2_kio-admin.sha256sum] = "f16589cdfb5fc004b8f324b5c3d1e4d3aa114bb11ed83af13233aac5487c24af"

URI_aarch64_kio-admin = "${EPEL_MIRROR}/aarch64/Packages/k/kio-admin-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kio-admin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-admin}"
SRC_URI[aarch64_kio-admin.sha256sum] = "7c15a23e5aaa16a75aebb507f4ea26c47d1888198dd1997558b5d17f5a1ca9b5"

RDEPENDS:kio-admin = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 libatomic \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
