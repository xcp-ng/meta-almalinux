# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrow-arith"
PV = "57.3.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-arrow-arith+default-devel \
 rust-arrow-arith-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrow-arith-57.3.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "047ae63d3c80a2071470f93b8b3e077fd4555cd93c456d301605b2ca29927729"

URI_x86_64_v2_rust-arrow-arith+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-arith+default-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-arith+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-arith+default-devel}"
SRC_URI[x86_64_v2_rust-arrow-arith+default-devel.sha256sum] = "6bfd0343ff0ece52f2d8b1f540770640e433b1fe4f578890dc9b822b45770a25"

URI_x86_64_v2_rust-arrow-arith-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-arith-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-arith-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-arith-devel}"
SRC_URI[x86_64_v2_rust-arrow-arith-devel.sha256sum] = "8ab2a645cbda114f6d4ad3c57bc3bcf80eb70de4713f24804261bd9333707fba"

URI_aarch64_rust-arrow-arith+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-arith+default-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-arith+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-arith+default-devel}"
SRC_URI[aarch64_rust-arrow-arith+default-devel.sha256sum] = "51421dea4fa636fd49f45d5c6116c16822abfef02391d29fe3f1038345774f40"

URI_aarch64_rust-arrow-arith-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-arith-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-arith-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-arith-devel}"
SRC_URI[aarch64_rust-arrow-arith-devel.sha256sum] = "b39dc55ffb2ec967110b8cf558cae3f659642d0779512902f753ac0b68fdbd95"

RDEPENDS:rust-arrow-arith+default-devel = " \
 cargo \
 rust-arrow-arith-devel \
 "
RDEPENDS:rust-arrow-arith-devel = " \
 cargo \
 rust \
 rust-arrow-array+default-devel \
 rust-arrow-buffer+default-devel \
 rust-arrow-data+default-devel \
 rust-arrow-schema+default-devel \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-num-traits+std-devel \
 rust-num-traits-devel \
 "
