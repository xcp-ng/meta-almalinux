# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-wayland-protocols"
PV = "1.21.0"
PR = "1.el10_3"
PACKAGES = " \
 plasma-wayland-protocols \
 plasma-wayland-protocols-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-wayland-protocols-1.21.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15120f6d0e6e13732ef7d7d0358731456ebf9e673daea2595143a5ca116de7fd"

URI_x86_64_v2_plasma-wayland-protocols = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-wayland-protocols-1.21.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-wayland-protocols;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-wayland-protocols}"
SRC_URI[x86_64_v2_plasma-wayland-protocols.sha256sum] = "7392867a16ac3581283b514aa5e3d4c834edccc374ad16a0ed0a0096eb46465d"

URI_x86_64_v2_plasma-wayland-protocols-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-wayland-protocols-devel-1.21.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-wayland-protocols-devel}"
SRC_URI[x86_64_v2_plasma-wayland-protocols-devel.sha256sum] = "c9e0f79cb68d47d57a80b5277690fad5bd09e5a2665bc1f96af959577a3380c3"

URI_aarch64_plasma-wayland-protocols = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-wayland-protocols-1.21.0-1.el10_3.aarch64.rpm;name=aarch64_plasma-wayland-protocols;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-wayland-protocols}"
SRC_URI[aarch64_plasma-wayland-protocols.sha256sum] = "98ee449a3f13a281af0b2f0fb1936f69722964d5b5103cde9da27d000998ec86"

URI_aarch64_plasma-wayland-protocols-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-wayland-protocols-devel-1.21.0-1.el10_3.aarch64.rpm;name=aarch64_plasma-wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-wayland-protocols-devel}"
SRC_URI[aarch64_plasma-wayland-protocols-devel.sha256sum] = "61db384476b95f4895cf8c6b8a3acb0a46fae67c4eccb307283b28493fb61045"

RDEPENDS:plasma-wayland-protocols = " \
 "
RDEPENDS:plasma-wayland-protocols-devel = " \
 cmake-filesystem \
 plasma-wayland-protocols \
 "
