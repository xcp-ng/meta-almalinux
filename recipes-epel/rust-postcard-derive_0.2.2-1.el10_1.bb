# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-postcard-derive"
PV = "0.2.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-postcard-derive+default-devel \
 rust-postcard-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-postcard-derive-0.2.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1030faa3f1a217941376eee858b9b62bd990054ee3e269c1623824c1d48868f0"

URI_x86_64_v2_rust-postcard-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard-derive+default-devel-0.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard-derive+default-devel}"
SRC_URI[x86_64_v2_rust-postcard-derive+default-devel.sha256sum] = "1e50332c2186c66b668d8f9ccea5218a87562b5320ea589f51040ce33288f8f9"

URI_x86_64_v2_rust-postcard-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard-derive-devel-0.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard-derive-devel}"
SRC_URI[x86_64_v2_rust-postcard-derive-devel.sha256sum] = "9a75cbf6447cc47bf1806a02a4110f516965bbec9f60502e92a8305843f50aef"

URI_aarch64_rust-postcard-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard-derive+default-devel-0.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-postcard-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard-derive+default-devel}"
SRC_URI[aarch64_rust-postcard-derive+default-devel.sha256sum] = "01a1f5a071076623686233f8e971c29bf2bb852c6f996544a8512c17c1286cfd"

URI_aarch64_rust-postcard-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard-derive-devel-0.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-postcard-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard-derive-devel}"
SRC_URI[aarch64_rust-postcard-derive-devel.sha256sum] = "aae8d281a5597485879109b99f63d92df3b41919efda7bdee2c74bd4b50df2cc"

RDEPENDS:rust-postcard-derive+default-devel = " \
 cargo \
 rust-postcard-derive-devel \
 "
RDEPENDS:rust-postcard-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
