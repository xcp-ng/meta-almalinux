# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtnetworkauth"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtnetworkauth \
 qt5-qtnetworkauth-devel \
 qt5-qtnetworkauth-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtnetworkauth-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "731372ec93b3bee69244c790a398aeea2f1f1fe4702beca9ca13cef7d6a8e7a2"

URI_x86_64_v2_qt5-qtnetworkauth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtnetworkauth-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtnetworkauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtnetworkauth}"
SRC_URI[x86_64_v2_qt5-qtnetworkauth.sha256sum] = "2eaa58648945e60512660522f9f4e1820357a417d82832b8eb8b6a97ee174022"

URI_x86_64_v2_qt5-qtnetworkauth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtnetworkauth-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtnetworkauth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtnetworkauth-devel}"
SRC_URI[x86_64_v2_qt5-qtnetworkauth-devel.sha256sum] = "a4e6826a3a92f78c6c6553809332d8b5f6a7c547f6e6410c028560331465e15a"

URI_x86_64_v2_qt5-qtnetworkauth-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtnetworkauth-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtnetworkauth-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtnetworkauth-examples}"
SRC_URI[x86_64_v2_qt5-qtnetworkauth-examples.sha256sum] = "cf0a39abf3894a3d1fd5deb14bfc13b53f79309578cdcff93025a3ad9cece153"

URI_aarch64_qt5-qtnetworkauth = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtnetworkauth-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtnetworkauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtnetworkauth}"
SRC_URI[aarch64_qt5-qtnetworkauth.sha256sum] = "6920e3eed457efbb07f4e1f4237a434a7916d637f5dda91ea4065ded38111fcd"

URI_aarch64_qt5-qtnetworkauth-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtnetworkauth-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtnetworkauth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtnetworkauth-devel}"
SRC_URI[aarch64_qt5-qtnetworkauth-devel.sha256sum] = "b21f3c7dcee7f2a6c77e8da9d447853fadf8588b76ef90f25b3b81e833bbdfc9"

URI_aarch64_qt5-qtnetworkauth-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtnetworkauth-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtnetworkauth-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtnetworkauth-examples}"
SRC_URI[aarch64_qt5-qtnetworkauth-examples.sha256sum] = "89c38defd3e03d952ed6345a3de7864f1854f08d53e6e5fe4a83b14269f90bf7"

RDEPENDS:qt5-qtnetworkauth = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtnetworkauth-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtnetworkauth \
 "
RDEPENDS:qt5-qtnetworkauth-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtnetworkauth \
 "
