# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpkg"
PV = "1.68"
PR = "3.el10_1"
PACKAGES = " \
 python3-rpkg \
 rpkg-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rpkg-1.68-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8452e0c61cb5448c8760daa02fb90d875f2b107f186336de6b8fb230a8d77e79"

URI_x86_64_v2_python3-rpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpkg-1.68-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpkg}"
SRC_URI[x86_64_v2_python3-rpkg.sha256sum] = "0a0352c2583970644caf0066576f034b6393d15cab57fc5b03bbe956256a6b24"

URI_x86_64_v2_rpkg-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpkg-common-1.68-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rpkg-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpkg-common}"
SRC_URI[x86_64_v2_rpkg-common.sha256sum] = "c6e64c3d02b0638d840764ebb91c8d801ba44fb053bdd8fc97928f03f40bf210"

URI_aarch64_python3-rpkg = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpkg-1.68-3.el10_1.noarch.rpm;name=aarch64_python3-rpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpkg}"
SRC_URI[aarch64_python3-rpkg.sha256sum] = "6dbe763fe422de4db7f7963067d157c00d5dc0f2557bc9bd1f42177f113f4edd"

URI_aarch64_rpkg-common = "${EPEL_MIRROR}/aarch64/Packages/r/rpkg-common-1.68-3.el10_1.noarch.rpm;name=aarch64_rpkg-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpkg-common}"
SRC_URI[aarch64_rpkg-common.sha256sum] = "617e28f77f47938d0e332aa6032cfd50ae61e52c84af03929467b5d0297e9fc2"

RDEPENDS:python3-rpkg = " \
 libmodulemd \
 mock \
 python3 \
 python3-GitPython \
 python3-argcomplete \
 python3-cccolutils \
 python3-gobject-base \
 python3-koji \
 python3-pycurl \
 python3-pyyaml \
 python3-requests \
 python3-requests-gssapi \
 python3-rpm \
 python3-six \
 redhat-rpm-config \
 rpkg-common \
 rpm-build \
 rpmdevtools \
 rpmlint \
 "
RDEPENDS:rpkg-common = " \
 "
