# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-uuid-types"
PV = "1.0.5.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-uuid-types \
 ghc-uuid-types-devel \
 ghc-uuid-types-doc \
 ghc-uuid-types-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-uuid-types-1.0.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc801fced74eeaf6dcc029bdfdac1ac518c932a8a47444fdf2adf7cbafab8ba8"

URI_x86_64_v2_ghc-uuid-types = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uuid-types-1.0.5.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-uuid-types;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uuid-types}"
SRC_URI[x86_64_v2_ghc-uuid-types.sha256sum] = "4ca160408c121fc45ec3e62ccd72571b46525700574dab4e04e474153c13e1d5"

URI_x86_64_v2_ghc-uuid-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uuid-types-devel-1.0.5.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-uuid-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uuid-types-devel}"
SRC_URI[x86_64_v2_ghc-uuid-types-devel.sha256sum] = "947d30a63ef694b54435b34d0aa366718eefbea22ab1345d34cef1fb50b58564"

URI_x86_64_v2_ghc-uuid-types-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uuid-types-doc-1.0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-uuid-types-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uuid-types-doc}"
SRC_URI[x86_64_v2_ghc-uuid-types-doc.sha256sum] = "951c584e06eedce71c049adb5154a112761cc532e115a3a7866b734fa84343d4"

URI_x86_64_v2_ghc-uuid-types-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uuid-types-prof-1.0.5.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-uuid-types-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uuid-types-prof}"
SRC_URI[x86_64_v2_ghc-uuid-types-prof.sha256sum] = "f63842b8c0e5e7cc6723fdec28fa6e35dd1409751004b9dfdbb3505c2128da05"

URI_aarch64_ghc-uuid-types = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uuid-types-1.0.5.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-uuid-types;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uuid-types}"
SRC_URI[aarch64_ghc-uuid-types.sha256sum] = "e69cd02ca38f012f18de1d9ab9fa6d1cb62fbe9cfc2b1fb8955111759936ea31"

URI_aarch64_ghc-uuid-types-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uuid-types-devel-1.0.5.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-uuid-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uuid-types-devel}"
SRC_URI[aarch64_ghc-uuid-types-devel.sha256sum] = "afefbdac1aeb5d624f38611b90746a38028d61fbeaceb244836987d1f8386ad2"

URI_aarch64_ghc-uuid-types-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uuid-types-doc-1.0.5.1-1.el10_0.noarch.rpm;name=aarch64_ghc-uuid-types-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uuid-types-doc}"
SRC_URI[aarch64_ghc-uuid-types-doc.sha256sum] = "78b1adb181e9899a13e25cf00daa50cddf6b30a9402fe33015202e1c70a4169f"

URI_aarch64_ghc-uuid-types-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uuid-types-prof-1.0.5.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-uuid-types-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uuid-types-prof}"
SRC_URI[aarch64_ghc-uuid-types-prof.sha256sum] = "ead72c7dcff25c426d0cb0a806148f32ffe25fbd0a30038ebd0b87d3f33a5cd5"

RDEPENDS:ghc-uuid-types = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-random \
 ghc-splitmix \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-uuid-types-devel = " \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-hashable-devel \
 ghc-random-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-uuid-types \
 "
RDEPENDS:ghc-uuid-types-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-uuid-types-prof = " \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-deepseq-prof \
 ghc-hashable-prof \
 ghc-random-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-uuid-types-devel \
 "
