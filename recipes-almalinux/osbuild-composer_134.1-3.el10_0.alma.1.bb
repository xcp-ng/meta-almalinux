# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osbuild-composer"
PV = "134.1"
PR = "3.el10_0.alma.1"
PACKAGES = " \
 osbuild-composer \
 osbuild-composer-core \
 osbuild-composer-worker \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/osbuild-composer-134.1-3.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40ebecf69fd87c16faae4894f5d14273974b07f975b59b3c039001b86b9356f6"

URI_x86_64_v2_osbuild-composer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-composer-134.1-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_osbuild-composer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-composer}"
SRC_URI[x86_64_v2_osbuild-composer.sha256sum] = "0aee62e9ce3bf33a52236eadb96e76d21c4c1549f62d54c9a6ce19f85144ebd1"

URI_x86_64_v2_osbuild-composer-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-composer-core-134.1-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_osbuild-composer-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-composer-core}"
SRC_URI[x86_64_v2_osbuild-composer-core.sha256sum] = "cc85fdff91de20028eae952a624249987e0cc2abe72255a369b238868470ff14"

URI_x86_64_v2_osbuild-composer-worker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-composer-worker-134.1-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_osbuild-composer-worker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-composer-worker}"
SRC_URI[x86_64_v2_osbuild-composer-worker.sha256sum] = "3327d671fe4187de1ced614f272f0fb0b6571aa421f377731ca367faa177aac2"

URI_aarch64_osbuild-composer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-composer-134.1-3.el10_0.alma.1.aarch64.rpm;name=aarch64_osbuild-composer;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-composer}"
SRC_URI[aarch64_osbuild-composer.sha256sum] = "8da6ddb2dcba67a97a86b3e05a092f1d0a6c0ed001e273c4dfc1e1b7b11f4231"

URI_aarch64_osbuild-composer-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-composer-core-134.1-3.el10_0.alma.1.aarch64.rpm;name=aarch64_osbuild-composer-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-composer-core}"
SRC_URI[aarch64_osbuild-composer-core.sha256sum] = "7c545cdf924d1e00a66b4d7e165c3e112bc5a3e49fe643c76fb33e829ab4ea21"

URI_aarch64_osbuild-composer-worker = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-composer-worker-134.1-3.el10_0.alma.1.aarch64.rpm;name=aarch64_osbuild-composer-worker;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-composer-worker}"
SRC_URI[aarch64_osbuild-composer-worker.sha256sum] = "478e47c81542edd57ece1942c0a9889d7fb846ea478e1ea2ea841dc4d1db0813"

RDEPENDS:osbuild-composer = " \
 bash \
 osbuild-composer-core \
 osbuild-composer-worker \
 systemd \
 "
RDEPENDS:osbuild-composer-core = " \
 glibc \
 gpgme \
 libxcrypt \
 osbuild-depsolve-dnf \
 "
RDEPENDS:osbuild-composer-worker = " \
 bash \
 glibc \
 gpgme \
 krb5-libs \
 libcom_err \
 libxcrypt \
 osbuild \
 osbuild-depsolve-dnf \
 osbuild-luks2 \
 osbuild-lvm2 \
 osbuild-ostree \
 qemu-img \
 systemd \
 "
