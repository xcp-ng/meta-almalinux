# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ffmpegthumbs"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 ffmpegthumbs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/ffmpegthumbs-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ef2ff1e1ce6e9db0c42f0fd8f2c523341d093ae87a62d320781a6716b7a887d4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ffmpegthumbs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ffmpegthumbs;unpack=0"
SRC_URI[x86_64_v2_ffmpegthumbs.sha256sum] = "38000b89da0a69fc6f6f7e43a035e5fe434875c0d0660c5048f674c9705af804"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/ffmpegthumbs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ffmpegthumbs;unpack=0"
SRC_URI[aarch64_ffmpegthumbs.sha256sum] = "8775b1aba27c01ec1da168ba96c5e62ce0cac2ac68b264ca4161eda35f84c110"

RDEPENDS:ffmpegthumbs = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libstdc++ \
 libswscale-free \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
