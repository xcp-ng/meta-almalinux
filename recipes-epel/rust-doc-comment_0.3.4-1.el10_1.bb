# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-doc-comment"
PV = "0.3.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-doc-comment+default-devel \
 rust-doc-comment+no_core-devel \
 rust-doc-comment+old_macros-devel \
 rust-doc-comment-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-doc-comment-0.3.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab7ccfcc2b72d11c82e743d22f6674b69004a5e98f2ce6e9d703ac48afc9c0e1"

URI_x86_64_v2_rust-doc-comment+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-doc-comment+default-devel-0.3.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-doc-comment+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc-comment+default-devel}"
SRC_URI[x86_64_v2_rust-doc-comment+default-devel.sha256sum] = "a91f679631e00192568c04d3a864e9b483ef3e3941eae26aef148be5e73c14d8"

URI_x86_64_v2_rust-doc-comment+no_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-doc-comment+no_core-devel-0.3.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-doc-comment+no_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc-comment+no_core-devel}"
SRC_URI[x86_64_v2_rust-doc-comment+no_core-devel.sha256sum] = "731347af6741d0bb7513bc0d0eecca78b4305d1df4115c8a9d27fb375ea46be7"

URI_x86_64_v2_rust-doc-comment+old_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-doc-comment+old_macros-devel-0.3.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-doc-comment+old_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc-comment+old_macros-devel}"
SRC_URI[x86_64_v2_rust-doc-comment+old_macros-devel.sha256sum] = "7863c619b6abfe6984747cd2a2f8971a726ef6bf238feba63aa4b13a80b1dbed"

URI_x86_64_v2_rust-doc-comment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-doc-comment-devel-0.3.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-doc-comment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc-comment-devel}"
SRC_URI[x86_64_v2_rust-doc-comment-devel.sha256sum] = "94c654d9a57dd703605aa2a0f4c94d02831597100e7f14a1d27ebbb6e010cc2e"

URI_aarch64_rust-doc-comment+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-doc-comment+default-devel-0.3.4-1.el10_1.noarch.rpm;name=aarch64_rust-doc-comment+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc-comment+default-devel}"
SRC_URI[aarch64_rust-doc-comment+default-devel.sha256sum] = "13b2f52d87ced0283151187a9f282c37d13017f53b3a8b8c1590d15ef4c02943"

URI_aarch64_rust-doc-comment+no_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-doc-comment+no_core-devel-0.3.4-1.el10_1.noarch.rpm;name=aarch64_rust-doc-comment+no_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc-comment+no_core-devel}"
SRC_URI[aarch64_rust-doc-comment+no_core-devel.sha256sum] = "aa611afe1bf0fdaecb48c87701cf535eeab934c1a7eb82982e904ab7779c01f6"

URI_aarch64_rust-doc-comment+old_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-doc-comment+old_macros-devel-0.3.4-1.el10_1.noarch.rpm;name=aarch64_rust-doc-comment+old_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc-comment+old_macros-devel}"
SRC_URI[aarch64_rust-doc-comment+old_macros-devel.sha256sum] = "c89342ada4a6026d8fc5ef6a901291eed680206b3cd806999e7ab41035dd517b"

URI_aarch64_rust-doc-comment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-doc-comment-devel-0.3.4-1.el10_1.noarch.rpm;name=aarch64_rust-doc-comment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc-comment-devel}"
SRC_URI[aarch64_rust-doc-comment-devel.sha256sum] = "c0728a8650bcab62cfd439715625eb8997977291d06e70b7fef75ffe21743061"

RDEPENDS:rust-doc-comment+default-devel = " \
 cargo \
 rust-doc-comment-devel \
 "
RDEPENDS:rust-doc-comment+no_core-devel = " \
 cargo \
 rust-doc-comment-devel \
 "
RDEPENDS:rust-doc-comment+old_macros-devel = " \
 cargo \
 rust-doc-comment-devel \
 "
RDEPENDS:rust-doc-comment-devel = " \
 cargo \
 "
