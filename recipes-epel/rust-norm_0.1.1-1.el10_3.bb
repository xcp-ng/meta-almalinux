# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-norm"
PV = "0.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-norm+__any-metric-devel \
 rust-norm+__benches-devel \
 rust-norm+__into-score-devel \
 rust-norm+__tests-devel \
 rust-norm+default-devel \
 rust-norm+fzf-v1-devel \
 rust-norm+fzf-v2-devel \
 rust-norm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-norm-0.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ac769501c5e1d8b58d11eff90bb4794317c91cdc90969f26a29ff2043026cda"

URI_x86_64_v2_rust-norm+__any-metric-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-norm+__any-metric-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-norm+__any-metric-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-norm+__any-metric-devel}"
SRC_URI[x86_64_v2_rust-norm+__any-metric-devel.sha256sum] = "d2a88f728b33f49d7dc6380c21f1cee2ae943cee97f73945558a65b633cc3d31"

URI_x86_64_v2_rust-norm+__benches-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-norm+__benches-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-norm+__benches-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-norm+__benches-devel}"
SRC_URI[x86_64_v2_rust-norm+__benches-devel.sha256sum] = "4d4aa5759b61a5cb01fbe76317b4b6aa1ef422524810335fcbfc2b87f04388d4"

URI_x86_64_v2_rust-norm+__into-score-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-norm+__into-score-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-norm+__into-score-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-norm+__into-score-devel}"
SRC_URI[x86_64_v2_rust-norm+__into-score-devel.sha256sum] = "77b0d5ffb1d434d48a499313f42cedababe85727e2269bc66215fb41e2e6d6f6"

URI_x86_64_v2_rust-norm+__tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-norm+__tests-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-norm+__tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-norm+__tests-devel}"
SRC_URI[x86_64_v2_rust-norm+__tests-devel.sha256sum] = "216ca865f424129949a80b5d7d3a68d5afe130c713d0ea5bc069f243ed850fd2"

URI_x86_64_v2_rust-norm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-norm+default-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-norm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-norm+default-devel}"
SRC_URI[x86_64_v2_rust-norm+default-devel.sha256sum] = "ad31af31ba8a178320b7f0cc4a671c8505ce40400b0723b132aff83f1ce5521d"

URI_x86_64_v2_rust-norm+fzf-v1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-norm+fzf-v1-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-norm+fzf-v1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-norm+fzf-v1-devel}"
SRC_URI[x86_64_v2_rust-norm+fzf-v1-devel.sha256sum] = "7e1b5b4170306005aa14134f5f526fd25984b6206630782d3a00243ca6b28dd0"

URI_x86_64_v2_rust-norm+fzf-v2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-norm+fzf-v2-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-norm+fzf-v2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-norm+fzf-v2-devel}"
SRC_URI[x86_64_v2_rust-norm+fzf-v2-devel.sha256sum] = "f81f0c666d87f44b93acb75d55e5e0528294854638b69e897362aea7420893be"

URI_x86_64_v2_rust-norm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-norm-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-norm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-norm-devel}"
SRC_URI[x86_64_v2_rust-norm-devel.sha256sum] = "d5663678e84a690b747f2d36089bbfb7a9f2845d60a7e7a1fd8876c3517de5d3"

URI_aarch64_rust-norm+__any-metric-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-norm+__any-metric-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-norm+__any-metric-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-norm+__any-metric-devel}"
SRC_URI[aarch64_rust-norm+__any-metric-devel.sha256sum] = "34e716b96b60c7278442a8bd7bb4c4fc82e4f7a2b52f0b9596cf4468a77a244e"

URI_aarch64_rust-norm+__benches-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-norm+__benches-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-norm+__benches-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-norm+__benches-devel}"
SRC_URI[aarch64_rust-norm+__benches-devel.sha256sum] = "355fe185c8ba7b4557a20e64c09d5c654a07ba1bdfcfdde25480550164a095b2"

URI_aarch64_rust-norm+__into-score-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-norm+__into-score-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-norm+__into-score-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-norm+__into-score-devel}"
SRC_URI[aarch64_rust-norm+__into-score-devel.sha256sum] = "d37af415a124bfdd80a476f4233761bce5a0241ab6606e67fff48a3c5d65ff83"

URI_aarch64_rust-norm+__tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-norm+__tests-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-norm+__tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-norm+__tests-devel}"
SRC_URI[aarch64_rust-norm+__tests-devel.sha256sum] = "73140e560a7eb472c6da2b5fb3e83e13f9be056280806a3976ee996ef8c889d8"

URI_aarch64_rust-norm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-norm+default-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-norm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-norm+default-devel}"
SRC_URI[aarch64_rust-norm+default-devel.sha256sum] = "62b2c0351971fa177882ba4a4cfb2623c4492ae3242b68e35a2199d4223d7602"

URI_aarch64_rust-norm+fzf-v1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-norm+fzf-v1-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-norm+fzf-v1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-norm+fzf-v1-devel}"
SRC_URI[aarch64_rust-norm+fzf-v1-devel.sha256sum] = "3fe8e31ef900f6cfb8aa0e2c153885e762712d28c5af8381f2b6fba3845e4008"

URI_aarch64_rust-norm+fzf-v2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-norm+fzf-v2-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-norm+fzf-v2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-norm+fzf-v2-devel}"
SRC_URI[aarch64_rust-norm+fzf-v2-devel.sha256sum] = "e09c862fd114fb6af4179464dc994cbe8213e2bb43f7ac0e2cbf18314df4e673"

URI_aarch64_rust-norm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-norm-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-norm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-norm-devel}"
SRC_URI[aarch64_rust-norm-devel.sha256sum] = "8c6b9c0b8a93c08694042b7be442a9bb5e1f41d5e7eb990546ab2d2ec4dc6338"

RDEPENDS:rust-norm+__any-metric-devel = " \
 cargo \
 rust-norm-devel \
 "
RDEPENDS:rust-norm+__benches-devel = " \
 cargo \
 rust-norm-devel \
 "
RDEPENDS:rust-norm+__into-score-devel = " \
 cargo \
 rust-norm-devel \
 "
RDEPENDS:rust-norm+__tests-devel = " \
 cargo \
 rust-norm+fzf-v1-devel \
 rust-norm+fzf-v2-devel \
 rust-norm-devel \
 "
RDEPENDS:rust-norm+default-devel = " \
 cargo \
 rust-norm-devel \
 "
RDEPENDS:rust-norm+fzf-v1-devel = " \
 cargo \
 rust-norm+__any-metric-devel \
 rust-norm-devel \
 "
RDEPENDS:rust-norm+fzf-v2-devel = " \
 cargo \
 rust-norm+__any-metric-devel \
 rust-norm-devel \
 "
RDEPENDS:rust-norm-devel = " \
 cargo \
 rust-memchr+default-devel \
 "
