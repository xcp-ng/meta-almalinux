# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-prettyplease"
PV = "0.2.37"
PR = "1.el10_2"
PACKAGES = " \
 rust-prettyplease+default-devel \
 rust-prettyplease+verbatim-devel \
 rust-prettyplease-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-prettyplease-0.2.37-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17813911b4d30e1646c14f9189c74eced13a777bde49a343d9508bccb1eacd79"

URI_x86_64_v2_rust-prettyplease+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prettyplease+default-devel-0.2.37-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prettyplease+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prettyplease+default-devel}"
SRC_URI[x86_64_v2_rust-prettyplease+default-devel.sha256sum] = "573c5199116f49e935c025bc25da3b1b7e70351d51ca9adaa7238a9991ad6d9a"

URI_x86_64_v2_rust-prettyplease+verbatim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prettyplease+verbatim-devel-0.2.37-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prettyplease+verbatim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prettyplease+verbatim-devel}"
SRC_URI[x86_64_v2_rust-prettyplease+verbatim-devel.sha256sum] = "0c38f1dea51e9056ccc8cba07614a56926fa489afbbe690aac5d94ba459d0754"

URI_x86_64_v2_rust-prettyplease-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prettyplease-devel-0.2.37-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prettyplease-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prettyplease-devel}"
SRC_URI[x86_64_v2_rust-prettyplease-devel.sha256sum] = "e63189065ad0c1680781ae748e1638406f0bafda6bad4554998b7f82ac66bde3"

URI_aarch64_rust-prettyplease+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prettyplease+default-devel-0.2.37-1.el10_2.noarch.rpm;name=aarch64_rust-prettyplease+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prettyplease+default-devel}"
SRC_URI[aarch64_rust-prettyplease+default-devel.sha256sum] = "9787208cf467995966c8ed87716a20cacef16cbfcbe4f897184d469b03221272"

URI_aarch64_rust-prettyplease+verbatim-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prettyplease+verbatim-devel-0.2.37-1.el10_2.noarch.rpm;name=aarch64_rust-prettyplease+verbatim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prettyplease+verbatim-devel}"
SRC_URI[aarch64_rust-prettyplease+verbatim-devel.sha256sum] = "fcef24648ab6460fcb402a78c9b8100433837b2302250e38da94a742ae3c9c9b"

URI_aarch64_rust-prettyplease-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prettyplease-devel-0.2.37-1.el10_2.noarch.rpm;name=aarch64_rust-prettyplease-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prettyplease-devel}"
SRC_URI[aarch64_rust-prettyplease-devel.sha256sum] = "144cd797260916fa77a393275bb04a6d6320f02fb21d295c9d5841d743121f9c"

RDEPENDS:rust-prettyplease+default-devel = " \
 cargo \
 rust-prettyplease-devel \
 "
RDEPENDS:rust-prettyplease+verbatim-devel = " \
 cargo \
 rust-prettyplease-devel \
 rust-syn2+parsing-devel \
 "
RDEPENDS:rust-prettyplease-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-syn2+full-devel \
 rust-syn2-devel \
 "
