# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-orderly-set"
PV = "5.5.0"
PR = "2.el10_2"
PACKAGES = " \
 python3-orderly-set \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-orderly-set-5.5.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c1828463d90fa6e3685c05909b9d5f2cf5acd0e289db41aed755ee695ea759c"

URI_x86_64_v2_python3-orderly-set = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-orderly-set-5.5.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-orderly-set;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-orderly-set}"
SRC_URI[x86_64_v2_python3-orderly-set.sha256sum] = "9c290282168563ff0845a637aef3c33c477a4a9ef00e4514adcb6476d2496d14"

URI_aarch64_python3-orderly-set = "${EPEL_MIRROR}/aarch64/Packages/p/python3-orderly-set-5.5.0-2.el10_2.noarch.rpm;name=aarch64_python3-orderly-set;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-orderly-set}"
SRC_URI[aarch64_python3-orderly-set.sha256sum] = "5c922a056269f0d0153a3f5b89b6e8b356a749705c42c0c998e5f31e4e6774d8"

RDEPENDS:python3-orderly-set = " \
 python3 \
 "
