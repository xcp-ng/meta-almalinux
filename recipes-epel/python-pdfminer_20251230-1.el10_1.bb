# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pdfminer"
PV = "20251230"
PR = "1.el10_1"
PACKAGES = " \
 python3-pdfminer \
 python3-pdfminer+image \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pdfminer-20251230-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d98b227e95b5964837141aacf4ea6d6ec4232aa804b468fe1cb36e5ce0a18b3a"

URI_x86_64_v2_python3-pdfminer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pdfminer-20251230-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pdfminer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pdfminer}"
SRC_URI[x86_64_v2_python3-pdfminer.sha256sum] = "06d3ea1dda45ab2f3221a8a0b6c922e711d91266076a524deb890f7ec767a6c9"

URI_x86_64_v2_python3-pdfminer+image = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pdfminer+image-20251230-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pdfminer+image;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pdfminer+image}"
SRC_URI[x86_64_v2_python3-pdfminer+image.sha256sum] = "dc60181109bd16a342b1efc35410d8622cac89bfb181d73d10e3bf662065d782"

URI_aarch64_python3-pdfminer = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pdfminer-20251230-1.el10_1.noarch.rpm;name=aarch64_python3-pdfminer;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pdfminer}"
SRC_URI[aarch64_python3-pdfminer.sha256sum] = "c7c2194f4aecabe61ba93167ed1d283f3e34970716c30141a90ea602cb2792d6"

URI_aarch64_python3-pdfminer+image = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pdfminer+image-20251230-1.el10_1.noarch.rpm;name=aarch64_python3-pdfminer+image;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pdfminer+image}"
SRC_URI[aarch64_python3-pdfminer+image.sha256sum] = "4e139125bc09d7bdd879616c9b0440ca4f09bcc83000ba7a66a0f496d2452abc"

RDEPENDS:python3-pdfminer = " \
 python3 \
 python3-charset-normalizer \
 python3-cryptography \
 "
RDEPENDS:python3-pdfminer+image = " \
 python3 \
 python3-pdfminer \
 python3-pillow \
 "
