# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtserialport"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtserialport \
 qt5-qtserialport-devel \
 qt5-qtserialport-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtserialport-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ed6ae3c11dd9ab154ee0d3c7ea3a9dd1b7f80047fe24543fe3b1afd0c736708"

URI_x86_64_v2_qt5-qtserialport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialport-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialport}"
SRC_URI[x86_64_v2_qt5-qtserialport.sha256sum] = "6d35de12ee0a20fb19ff63b0800b24451155baddbcb4279efdee7da105e84726"

URI_x86_64_v2_qt5-qtserialport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialport-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialport-devel}"
SRC_URI[x86_64_v2_qt5-qtserialport-devel.sha256sum] = "d8c7a0daf832409a675ade2c918f706fad227a96bd2bfc9a76ad92f63c38e0f5"

URI_x86_64_v2_qt5-qtserialport-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialport-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialport-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialport-examples}"
SRC_URI[x86_64_v2_qt5-qtserialport-examples.sha256sum] = "6ffff07c50fb5264a5143dd06e9e24b11c3f37ee626e85e966ef4197808e9400"

URI_aarch64_qt5-qtserialport = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialport-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtserialport;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialport}"
SRC_URI[aarch64_qt5-qtserialport.sha256sum] = "282d57d390be06827e23d055db08c837329b81a1e6c9197072532073101ec026"

URI_aarch64_qt5-qtserialport-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialport-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtserialport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialport-devel}"
SRC_URI[aarch64_qt5-qtserialport-devel.sha256sum] = "e0579fb82da18f548e1152def772dc51407ff83f597930616ff462f9a7fd007c"

URI_aarch64_qt5-qtserialport-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialport-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtserialport-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialport-examples}"
SRC_URI[aarch64_qt5-qtserialport-examples.sha256sum] = "5339289c3b2d57419f6da88c66227ee1dcaf24ee26a4bf9d9444ed567ec6d832"

RDEPENDS:qt5-qtserialport = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 systemd-libs \
 "
RDEPENDS:qt5-qtserialport-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtserialport \
 "
RDEPENDS:qt5-qtserialport-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtserialport \
 "
