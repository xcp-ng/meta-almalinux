# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-x11rb-protocol"
PV = "0.13.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-x11rb-protocol+all-extensions-devel \
 rust-x11rb-protocol+composite-devel \
 rust-x11rb-protocol+damage-devel \
 rust-x11rb-protocol+dbe-devel \
 rust-x11rb-protocol+default-devel \
 rust-x11rb-protocol+dpms-devel \
 rust-x11rb-protocol+dri2-devel \
 rust-x11rb-protocol+dri3-devel \
 rust-x11rb-protocol+extra-traits-devel \
 rust-x11rb-protocol+glx-devel \
 rust-x11rb-protocol+present-devel \
 rust-x11rb-protocol+randr-devel \
 rust-x11rb-protocol+record-devel \
 rust-x11rb-protocol+render-devel \
 rust-x11rb-protocol+request-parsing-devel \
 rust-x11rb-protocol+res-devel \
 rust-x11rb-protocol+resource_manager-devel \
 rust-x11rb-protocol+screensaver-devel \
 rust-x11rb-protocol+serde-devel \
 rust-x11rb-protocol+shape-devel \
 rust-x11rb-protocol+shm-devel \
 rust-x11rb-protocol+std-devel \
 rust-x11rb-protocol+sync-devel \
 rust-x11rb-protocol+xevie-devel \
 rust-x11rb-protocol+xf86dri-devel \
 rust-x11rb-protocol+xf86vidmode-devel \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol+xinerama-devel \
 rust-x11rb-protocol+xinput-devel \
 rust-x11rb-protocol+xkb-devel \
 rust-x11rb-protocol+xprint-devel \
 rust-x11rb-protocol+xselinux-devel \
 rust-x11rb-protocol+xtest-devel \
 rust-x11rb-protocol+xv-devel \
 rust-x11rb-protocol+xvmc-devel \
 rust-x11rb-protocol-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-x11rb-protocol-0.13.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b67f6aeca707dc0499c9c660aeb55272c664c58af1323d8dc14dbe74a483ab1"

URI_x86_64_v2_rust-x11rb-protocol+all-extensions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+all-extensions-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+all-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+all-extensions-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+all-extensions-devel.sha256sum] = "c073060abdb9edd850d48aa39bd302313dfc991b09c6e1b22bd8cbac2e56de05"

URI_x86_64_v2_rust-x11rb-protocol+composite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+composite-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+composite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+composite-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+composite-devel.sha256sum] = "71e23409bfc8a4b187ad90591b68b8930a3a2617f46ac45d71b1cd13fdb46851"

URI_x86_64_v2_rust-x11rb-protocol+damage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+damage-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+damage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+damage-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+damage-devel.sha256sum] = "b2fe56bf0841322c42c9a0bf58fc534de21e319867a0d6d7f21a312e0b8d080d"

URI_x86_64_v2_rust-x11rb-protocol+dbe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+dbe-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+dbe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+dbe-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+dbe-devel.sha256sum] = "23bfec1e5ef0527d21623467e37db7d11ff1ef80d86bc44386c70ebf960389f5"

URI_x86_64_v2_rust-x11rb-protocol+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+default-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+default-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+default-devel.sha256sum] = "6e7e7dc98f33f366b9fc5ae6e18f1fa836a5eba89fbfe18cbf5697a6f64195df"

URI_x86_64_v2_rust-x11rb-protocol+dpms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+dpms-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+dpms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+dpms-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+dpms-devel.sha256sum] = "f4914fa76e7988ec38ecde1da26fe8844e61eff0e469163bd54e421efb2caee3"

URI_x86_64_v2_rust-x11rb-protocol+dri2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+dri2-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+dri2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+dri2-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+dri2-devel.sha256sum] = "b790766d9d7aec85f31f60221d8b2b01ed277ce92164fe4967002c6ee914d56e"

URI_x86_64_v2_rust-x11rb-protocol+dri3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+dri3-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+dri3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+dri3-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+dri3-devel.sha256sum] = "a94c36e574d6741bdab66bbbc0f4775a1089cb3ea7b0a25162fad4cf3ae6cc47"

URI_x86_64_v2_rust-x11rb-protocol+extra-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+extra-traits-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+extra-traits-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+extra-traits-devel.sha256sum] = "275305da50255efbe44bee1f735481e12424a1e5e6d3a429467c21418b92e927"

URI_x86_64_v2_rust-x11rb-protocol+glx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+glx-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+glx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+glx-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+glx-devel.sha256sum] = "6bb827bde2b415b11d1fb41b84c0dccd3a76808cbf707e547a9fa853ba96c030"

URI_x86_64_v2_rust-x11rb-protocol+present-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+present-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+present-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+present-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+present-devel.sha256sum] = "00840a467fd13028b76e5bf5b233270d9fbd3035e73a7ea7824d1b52b48fdeeb"

URI_x86_64_v2_rust-x11rb-protocol+randr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+randr-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+randr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+randr-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+randr-devel.sha256sum] = "19cd0438c32bf7454912e9a6aa7f73cb429dac6c4726eb56c5b9da35af52275d"

URI_x86_64_v2_rust-x11rb-protocol+record-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+record-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+record-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+record-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+record-devel.sha256sum] = "6a203eb64cf91ac52a24afab721027ca249f4b925f2a7b93d5250d603e6da3a5"

URI_x86_64_v2_rust-x11rb-protocol+render-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+render-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+render-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+render-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+render-devel.sha256sum] = "9676f143ca47aaa5336c7c3b267f8fae7cf4e3e1004d9540b6a012a9572816bd"

URI_x86_64_v2_rust-x11rb-protocol+request-parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+request-parsing-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+request-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+request-parsing-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+request-parsing-devel.sha256sum] = "fd20d17355a9a8842a0bf107a6dd0ad0e7c4db6ca0a251477883aee24b8141b9"

URI_x86_64_v2_rust-x11rb-protocol+res-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+res-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+res-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+res-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+res-devel.sha256sum] = "d38cdd3e8b046a2deaf0a13d9ad6099a84a33b951fdeb8404e840735cecc84aa"

URI_x86_64_v2_rust-x11rb-protocol+resource_manager-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+resource_manager-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+resource_manager-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+resource_manager-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+resource_manager-devel.sha256sum] = "762c2de5b4a4a746acff6aaa3b9f1a3f8e7374ad79c972551f60d6ce325fecc3"

URI_x86_64_v2_rust-x11rb-protocol+screensaver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+screensaver-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+screensaver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+screensaver-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+screensaver-devel.sha256sum] = "6314a63769bdc0d06c55856953207a6c69ec1902138e8606ade253136c3e71ca"

URI_x86_64_v2_rust-x11rb-protocol+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+serde-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+serde-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+serde-devel.sha256sum] = "c0a1ec89c93658ff27d9414e803c6257e40b2e008083c1ddb4d1c5c70627fd2d"

URI_x86_64_v2_rust-x11rb-protocol+shape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+shape-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+shape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+shape-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+shape-devel.sha256sum] = "a8c811ef4cf3856a313abc86cc046d5cd02c3e6877ead6fbde85b9db58c38e02"

URI_x86_64_v2_rust-x11rb-protocol+shm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+shm-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+shm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+shm-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+shm-devel.sha256sum] = "d376d3918076eded19de806d4e37e8fdaf6b8edb5e151593f78493ac7bf412eb"

URI_x86_64_v2_rust-x11rb-protocol+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+std-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+std-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+std-devel.sha256sum] = "aa244cce9614cfa2ba295a43d78fc9a33daaeb6ca372e298917bb3cebf33dda6"

URI_x86_64_v2_rust-x11rb-protocol+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+sync-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+sync-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+sync-devel.sha256sum] = "19c1f492c04c74ec92edcc3e33f23a2ff14b07de2a60e06b0a4af6d74872b3d8"

URI_x86_64_v2_rust-x11rb-protocol+xevie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xevie-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xevie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xevie-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xevie-devel.sha256sum] = "0d05d575fa14cd6aef979e765762f16bf60410d0d6477790a6e2baa9c35bf298"

URI_x86_64_v2_rust-x11rb-protocol+xf86dri-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xf86dri-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xf86dri-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xf86dri-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xf86dri-devel.sha256sum] = "ad4b930cbe790617ddd82af2a7d2c4cbc85293de9ede6a744fb0dc06372de501"

URI_x86_64_v2_rust-x11rb-protocol+xf86vidmode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xf86vidmode-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xf86vidmode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xf86vidmode-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xf86vidmode-devel.sha256sum] = "765c53f3ea35043bc098faa3b8c4f598cbd46019f04940a1fce1ea9681b6d0f0"

URI_x86_64_v2_rust-x11rb-protocol+xfixes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xfixes-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xfixes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xfixes-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xfixes-devel.sha256sum] = "038416031feec87e0c0cf9b3047c4286f1ae5433b25dd7adb75be624d42892f7"

URI_x86_64_v2_rust-x11rb-protocol+xinerama-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xinerama-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xinerama-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xinerama-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xinerama-devel.sha256sum] = "138ca8817a042d406497faa248371d8573e9176ec8c18186d96bd4ae669e1465"

URI_x86_64_v2_rust-x11rb-protocol+xinput-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xinput-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xinput-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xinput-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xinput-devel.sha256sum] = "b6a4d9bfa2a35d93819899e060a7567b79e077bc4f11dfaba33b5d6d60c454e5"

URI_x86_64_v2_rust-x11rb-protocol+xkb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xkb-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xkb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xkb-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xkb-devel.sha256sum] = "31151bda5dc2d81aaffbc637949b90ffaccae4d17ed4d4677e285a85cbe9d55c"

URI_x86_64_v2_rust-x11rb-protocol+xprint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xprint-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xprint-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xprint-devel.sha256sum] = "14a34ba0bdbe980d06f588f33795361165999b0d6a45c2dea4f440f5304d67b7"

URI_x86_64_v2_rust-x11rb-protocol+xselinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xselinux-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xselinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xselinux-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xselinux-devel.sha256sum] = "9bf499c66f7e8bafcb8d6f18d9defdea1cce295385fe0e9f0161afb6625419fd"

URI_x86_64_v2_rust-x11rb-protocol+xtest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xtest-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xtest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xtest-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xtest-devel.sha256sum] = "14acbcfa2dcff7ce40272cae62752e62c990462fcd399e82c52c621603fd4953"

URI_x86_64_v2_rust-x11rb-protocol+xv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xv-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xv-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xv-devel.sha256sum] = "9dbc8ed25fc6cb2e8b4b4b29d874a2f485d9ec6a3476e1c068392b06714a6c1b"

URI_x86_64_v2_rust-x11rb-protocol+xvmc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xvmc-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xvmc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xvmc-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xvmc-devel.sha256sum] = "b9ffbda990db2bfa1cc0169bfb099cc47e732246995051697cae7b13c99bc4f5"

URI_x86_64_v2_rust-x11rb-protocol-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol-devel.sha256sum] = "a1b196cfe48cf02b3d8e9568735a1f511aaf08b5e61374e723313a90b9a0194d"

URI_aarch64_rust-x11rb-protocol+all-extensions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+all-extensions-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+all-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+all-extensions-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+all-extensions-devel.sha256sum] = "88681318a47dbf8fb74c128419f72fdcc84c53012fdb99018253dad4b73187b6"

URI_aarch64_rust-x11rb-protocol+composite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+composite-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+composite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+composite-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+composite-devel.sha256sum] = "c73b72caaebe986f3cd4558d42c87f83516d94b11a865aff5939717b271b756b"

URI_aarch64_rust-x11rb-protocol+damage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+damage-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+damage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+damage-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+damage-devel.sha256sum] = "c9aeddc2ed89abec4189c4f69e7cdf4d96c59d2633770daa61086cb9635dffa6"

URI_aarch64_rust-x11rb-protocol+dbe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+dbe-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+dbe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+dbe-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+dbe-devel.sha256sum] = "0a30c18037b74e4f6b596885177a68a46cb57eb74d9f53613d7c3e117e968d5c"

URI_aarch64_rust-x11rb-protocol+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+default-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+default-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+default-devel.sha256sum] = "010c9f73fa54cc471f56bafee0fd4cbe5c101cb724d9cfc71372ada98f8f6d6a"

URI_aarch64_rust-x11rb-protocol+dpms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+dpms-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+dpms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+dpms-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+dpms-devel.sha256sum] = "f827b0b7752a9e8e6b772793bad29caf97b0bb645165010f9b822d5fbad98912"

URI_aarch64_rust-x11rb-protocol+dri2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+dri2-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+dri2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+dri2-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+dri2-devel.sha256sum] = "a6dc497b00664b3b1fddc986875d288d667cbca458f7b7bae9aafd4ec3a175b7"

URI_aarch64_rust-x11rb-protocol+dri3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+dri3-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+dri3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+dri3-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+dri3-devel.sha256sum] = "458a23dd5dbc39db144f3ed97d1c8b6e4088f818f083837c850075d8d85ea6bf"

URI_aarch64_rust-x11rb-protocol+extra-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+extra-traits-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+extra-traits-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+extra-traits-devel.sha256sum] = "c89536ef9145c47dc0d93a1dbe6b76c6379716b0e6eab5dc6d0550aac260bded"

URI_aarch64_rust-x11rb-protocol+glx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+glx-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+glx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+glx-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+glx-devel.sha256sum] = "506bc8f9b1fe643a02e64a3844a87f016cb659728cfad27281e9feda01b0687d"

URI_aarch64_rust-x11rb-protocol+present-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+present-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+present-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+present-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+present-devel.sha256sum] = "7e42f43d8a18950a0f669ed3b70064001f12a290f23c104583ecd6cbf5b476d2"

URI_aarch64_rust-x11rb-protocol+randr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+randr-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+randr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+randr-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+randr-devel.sha256sum] = "4c406fe2a70199f0dd5e5071cc46802ebbdcd71bd50cf698f21e00ad60163e0c"

URI_aarch64_rust-x11rb-protocol+record-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+record-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+record-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+record-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+record-devel.sha256sum] = "f046c3c81a7d0b203871286cb7c755ab3e79d4cbafe83f4916bab0c03604de18"

URI_aarch64_rust-x11rb-protocol+render-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+render-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+render-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+render-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+render-devel.sha256sum] = "992d6036f04788c5add5aaed7af35b1b9ff52f3820a112afb173e174d7a437f9"

URI_aarch64_rust-x11rb-protocol+request-parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+request-parsing-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+request-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+request-parsing-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+request-parsing-devel.sha256sum] = "fdf7629bfc2fa8f8c7f064bb6ebb3fdfcbc9831bcc481ef696e2dc68d09e14dc"

URI_aarch64_rust-x11rb-protocol+res-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+res-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+res-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+res-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+res-devel.sha256sum] = "6c5818fbc0eb119a4ad3436af6079b7375138ca85113577aa1c2c83e60d6aa10"

URI_aarch64_rust-x11rb-protocol+resource_manager-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+resource_manager-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+resource_manager-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+resource_manager-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+resource_manager-devel.sha256sum] = "89659ec9b074ca7f8bbc677367e702105a7e4bb9ab7441eba104c8275e78d8d4"

URI_aarch64_rust-x11rb-protocol+screensaver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+screensaver-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+screensaver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+screensaver-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+screensaver-devel.sha256sum] = "acd9838daf412d036b36fc9a8edf2ec13dc88c99a038cb675325d3dad468603f"

URI_aarch64_rust-x11rb-protocol+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+serde-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+serde-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+serde-devel.sha256sum] = "b799007f7a4b3f107b8684e3757151f70afdb825d6528bd6c5e06925b05e6ee7"

URI_aarch64_rust-x11rb-protocol+shape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+shape-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+shape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+shape-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+shape-devel.sha256sum] = "3cc1f5f6b43455eb0fd53fa16287eed8ea8777a2228bc74546ed89ff636e1302"

URI_aarch64_rust-x11rb-protocol+shm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+shm-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+shm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+shm-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+shm-devel.sha256sum] = "3f08ea8ddd7e06bfd3dbcf7ad44f76ddf8ea6096b5a8aeaf10f0081bb2ebdae2"

URI_aarch64_rust-x11rb-protocol+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+std-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+std-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+std-devel.sha256sum] = "8a2bd2bb1bbd14fb6f49a4f9c6e5093c45c813ef0fc88d3c079ddef1453a89f0"

URI_aarch64_rust-x11rb-protocol+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+sync-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+sync-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+sync-devel.sha256sum] = "e2570c8c9d0c703a8d27aa2c87e90a710fa4232d0fc53f951103547bc9ac5076"

URI_aarch64_rust-x11rb-protocol+xevie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xevie-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+xevie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xevie-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xevie-devel.sha256sum] = "3d71a95abbfa7a2b0e6c78c54725fa0fdb8c263da9231bc087d5d50cc9a34aa5"

URI_aarch64_rust-x11rb-protocol+xf86dri-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xf86dri-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+xf86dri-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xf86dri-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xf86dri-devel.sha256sum] = "3be81570dbd47ae8585507968ef005b00f409560c545412b4510f4eed2d810d5"

URI_aarch64_rust-x11rb-protocol+xf86vidmode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xf86vidmode-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+xf86vidmode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xf86vidmode-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xf86vidmode-devel.sha256sum] = "269bef9e67899785e48beceb126a6a892c411aff707918ec4b9060a52f2b7e2c"

URI_aarch64_rust-x11rb-protocol+xfixes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xfixes-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+xfixes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xfixes-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xfixes-devel.sha256sum] = "ab4f47c18ccba99f4613d08a33c5c78bb3e02d6d2462479549fde919a2e7074c"

URI_aarch64_rust-x11rb-protocol+xinerama-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xinerama-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+xinerama-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xinerama-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xinerama-devel.sha256sum] = "ebf97dc7b74f2834f6dc2c3fc1fcade8fca69fc80c84bdb1b9f130b93ecd9f55"

URI_aarch64_rust-x11rb-protocol+xinput-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xinput-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+xinput-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xinput-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xinput-devel.sha256sum] = "1bb82f6b8432e3ab92f8144795117e6870cea05a9f80f22df92878828858d070"

URI_aarch64_rust-x11rb-protocol+xkb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xkb-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+xkb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xkb-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xkb-devel.sha256sum] = "53b3c3af0c5bc94ba1d91bd6b984b667e9b99dc21d8778d510eb4d5ebea57fec"

URI_aarch64_rust-x11rb-protocol+xprint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xprint-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+xprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xprint-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xprint-devel.sha256sum] = "68aa8c469e8d2982256b865aa1595b5b291f633a9cb86d755609d52db49743e0"

URI_aarch64_rust-x11rb-protocol+xselinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xselinux-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+xselinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xselinux-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xselinux-devel.sha256sum] = "9b6f4ea14726305c3fd61f13873153916dcbee2daf42c317d6566b87be5c9428"

URI_aarch64_rust-x11rb-protocol+xtest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xtest-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+xtest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xtest-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xtest-devel.sha256sum] = "9c2045c6f2982a95dd02efa9007173346ceae659b6bdf9f9894642e581961a00"

URI_aarch64_rust-x11rb-protocol+xv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xv-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+xv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xv-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xv-devel.sha256sum] = "28f7cf0b34b8358cf028ab0ddab7983a0190a637cb71ed88b66d4748db419728"

URI_aarch64_rust-x11rb-protocol+xvmc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xvmc-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol+xvmc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xvmc-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xvmc-devel.sha256sum] = "c35b3717685df7143129e281a8bf412adf11fade1b534d78f6f31e64b07dd84b"

URI_aarch64_rust-x11rb-protocol-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol-devel}"
SRC_URI[aarch64_rust-x11rb-protocol-devel.sha256sum] = "ada4d383470ef5367e2c617c76c4724cd06ab94ea748775b9b2981de35d85197"

RDEPENDS:rust-x11rb-protocol+all-extensions-devel = " \
 cargo \
 rust-x11rb-protocol+composite-devel \
 rust-x11rb-protocol+damage-devel \
 rust-x11rb-protocol+dbe-devel \
 rust-x11rb-protocol+dpms-devel \
 rust-x11rb-protocol+dri2-devel \
 rust-x11rb-protocol+dri3-devel \
 rust-x11rb-protocol+glx-devel \
 rust-x11rb-protocol+present-devel \
 rust-x11rb-protocol+randr-devel \
 rust-x11rb-protocol+record-devel \
 rust-x11rb-protocol+render-devel \
 rust-x11rb-protocol+res-devel \
 rust-x11rb-protocol+screensaver-devel \
 rust-x11rb-protocol+shape-devel \
 rust-x11rb-protocol+shm-devel \
 rust-x11rb-protocol+sync-devel \
 rust-x11rb-protocol+xevie-devel \
 rust-x11rb-protocol+xf86dri-devel \
 rust-x11rb-protocol+xf86vidmode-devel \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol+xinerama-devel \
 rust-x11rb-protocol+xinput-devel \
 rust-x11rb-protocol+xkb-devel \
 rust-x11rb-protocol+xprint-devel \
 rust-x11rb-protocol+xselinux-devel \
 rust-x11rb-protocol+xtest-devel \
 rust-x11rb-protocol+xv-devel \
 rust-x11rb-protocol+xvmc-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+composite-devel = " \
 cargo \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+damage-devel = " \
 cargo \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+dbe-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+default-devel = " \
 cargo \
 rust-x11rb-protocol+std-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+dpms-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+dri2-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+dri3-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+extra-traits-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+glx-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+present-devel = " \
 cargo \
 rust-x11rb-protocol+randr-devel \
 rust-x11rb-protocol+sync-devel \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+randr-devel = " \
 cargo \
 rust-x11rb-protocol+render-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+record-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+render-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+request-parsing-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+res-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+resource_manager-devel = " \
 cargo \
 rust-x11rb-protocol+std-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+screensaver-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+shape-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+shm-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+std-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+sync-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xevie-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xf86dri-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xf86vidmode-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xfixes-devel = " \
 cargo \
 rust-x11rb-protocol+render-devel \
 rust-x11rb-protocol+shape-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xinerama-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xinput-devel = " \
 cargo \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xkb-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xprint-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xselinux-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xtest-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xv-devel = " \
 cargo \
 rust-x11rb-protocol+shm-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xvmc-devel = " \
 cargo \
 rust-x11rb-protocol+xv-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol-devel = " \
 cargo \
 rust \
 "
