# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-List-MoreUtils-XS"
PV = "0.430"
PR = "18.el10"
PACKAGES = " \
 perl-List-MoreUtils-XS \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-List-MoreUtils-XS-0.430-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e59a5701623e15058cbfae2cca9db9890e524e8d6497c545ae11658ae5a9dabd"

URI_x86_64_v2_perl-List-MoreUtils-XS = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-List-MoreUtils-XS-0.430-18.el10.x86_64_v2.rpm;name=x86_64_v2_perl-List-MoreUtils-XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-List-MoreUtils-XS}"
SRC_URI[x86_64_v2_perl-List-MoreUtils-XS.sha256sum] = "dffe329127b85230e5f4a08a374f6473f9753a2086cd49378b2536cb3088fbf0"

URI_aarch64_perl-List-MoreUtils-XS = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-List-MoreUtils-XS-0.430-18.el10.aarch64.rpm;name=aarch64_perl-List-MoreUtils-XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-List-MoreUtils-XS}"
SRC_URI[aarch64_perl-List-MoreUtils-XS.sha256sum] = "717310b5e929ea599f53b1628f1bcc23698aec7bef49da249fa174d1d6f7b0f0"

RDEPENDS:perl-List-MoreUtils-XS = " \
 glibc \
 perl-base \
 perl-libs \
 perl-vars \
 "
