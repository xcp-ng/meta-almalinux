# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-URandom"
PV = "0.40"
PR = "2.el10_0"
PACKAGES = " \
 perl-Crypt-URandom \
 perl-Crypt-URandom-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-URandom-0.40-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6548a34387e874fd85b34aebe1b95bea0f2a48d0360ae3045c30f4221a2fa83"

URI_x86_64_v2_perl-Crypt-URandom = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-URandom-0.40-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-URandom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-URandom}"
SRC_URI[x86_64_v2_perl-Crypt-URandom.sha256sum] = "0a734da9fa20116c1b8cf978c4b105067e88d3aad1d3f22d47a154c947035c96"

URI_x86_64_v2_perl-Crypt-URandom-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-URandom-tests-0.40-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-URandom-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-URandom-tests}"
SRC_URI[x86_64_v2_perl-Crypt-URandom-tests.sha256sum] = "82b44340df8ac436b3dcc913a8e5fc342bfe3bae471573c96969966b7a42900e"

URI_aarch64_perl-Crypt-URandom = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-URandom-0.40-2.el10_0.noarch.rpm;name=aarch64_perl-Crypt-URandom;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-URandom}"
SRC_URI[aarch64_perl-Crypt-URandom.sha256sum] = "c062fdd7717bfeb89552f59d06858c3bb48bf806e76a1bea1ddd85f14c2d12a2"

URI_aarch64_perl-Crypt-URandom-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-URandom-tests-0.40-2.el10_0.noarch.rpm;name=aarch64_perl-Crypt-URandom-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-URandom-tests}"
SRC_URI[aarch64_perl-Crypt-URandom-tests.sha256sum] = "f93bb6cfae479a1de561fe9bc60dc11f3e38369c71e76e1f7286315baf3474b7"

RDEPENDS:perl-Crypt-URandom = " \
 perl-Carp \
 perl-English \
 perl-Exporter \
 perl-FileHandle \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Crypt-URandom-tests = " \
 bash \
 perl-Crypt-URandom \
 perl-Encode \
 perl-POSIX \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
