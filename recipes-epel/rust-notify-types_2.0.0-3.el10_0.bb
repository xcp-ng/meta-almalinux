# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-notify-types"
PV = "2.0.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-notify-types+default-devel \
 rust-notify-types+serde-devel \
 rust-notify-types+serialization-compat-6-devel \
 rust-notify-types-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-notify-types-2.0.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e13fcb9c6c413e65e1c1faca3f26af3cc54ab37139491b5b78ab1cd7eb7b883"

URI_x86_64_v2_rust-notify-types+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-types+default-devel-2.0.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-types+default-devel}"
SRC_URI[x86_64_v2_rust-notify-types+default-devel.sha256sum] = "27936c3d85b048e3c78eea1717c226e480f2ae0469655a898d91d7523efe64cc"

URI_x86_64_v2_rust-notify-types+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-types+serde-devel-2.0.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-types+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-types+serde-devel}"
SRC_URI[x86_64_v2_rust-notify-types+serde-devel.sha256sum] = "1d18c46f01b454bd2b74acb075e8da95ffe355ffe834ff8e1627a8924c4b581e"

URI_x86_64_v2_rust-notify-types+serialization-compat-6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-types+serialization-compat-6-devel-2.0.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-types+serialization-compat-6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-types+serialization-compat-6-devel}"
SRC_URI[x86_64_v2_rust-notify-types+serialization-compat-6-devel.sha256sum] = "7c183f063de27bf51b676d383db977ba4734e52df4ce496285e2b665390309d3"

URI_x86_64_v2_rust-notify-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-types-devel-2.0.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-types-devel}"
SRC_URI[x86_64_v2_rust-notify-types-devel.sha256sum] = "50cca48c3dd960923cb6b7406d83a8e7341a03c4f6c2513a828bc973c29f9329"

URI_aarch64_rust-notify-types+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-types+default-devel-2.0.0-3.el10_0.noarch.rpm;name=aarch64_rust-notify-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-types+default-devel}"
SRC_URI[aarch64_rust-notify-types+default-devel.sha256sum] = "2151f64301533ea543f9725d65b4f3daf3d08520a658db349d050c17716c49e6"

URI_aarch64_rust-notify-types+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-types+serde-devel-2.0.0-3.el10_0.noarch.rpm;name=aarch64_rust-notify-types+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-types+serde-devel}"
SRC_URI[aarch64_rust-notify-types+serde-devel.sha256sum] = "949aaa4cc831aa9077906af9fef89ebb2ec05537e89d698e6bbe224fcdddeff6"

URI_aarch64_rust-notify-types+serialization-compat-6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-types+serialization-compat-6-devel-2.0.0-3.el10_0.noarch.rpm;name=aarch64_rust-notify-types+serialization-compat-6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-types+serialization-compat-6-devel}"
SRC_URI[aarch64_rust-notify-types+serialization-compat-6-devel.sha256sum] = "c96257f3130d2ad2c6c19e3d47dc26fd626d65043a64edbf0834348625abf146"

URI_aarch64_rust-notify-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-types-devel-2.0.0-3.el10_0.noarch.rpm;name=aarch64_rust-notify-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-types-devel}"
SRC_URI[aarch64_rust-notify-types-devel.sha256sum] = "c4425a538cd40527ed0dae09a0290466184d7ece316b57be3d7bfa1ad6731bcc"

RDEPENDS:rust-notify-types+default-devel = " \
 cargo \
 rust-notify-types-devel \
 "
RDEPENDS:rust-notify-types+serde-devel = " \
 cargo \
 rust-notify-types-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-notify-types+serialization-compat-6-devel = " \
 cargo \
 rust-notify-types-devel \
 "
RDEPENDS:rust-notify-types-devel = " \
 cargo \
 rust \
 "
