# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-oxygen"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 oxygen-cursor-themes \
 plasma-oxygen \
 plasma-oxygen-qt6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-oxygen-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "626b1174888f925ac84a0cc29c7ceb8782a566c4e6b43fef202a6b49b4bdc856"

URI_x86_64_v2_oxygen-cursor-themes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxygen-cursor-themes-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_oxygen-cursor-themes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oxygen-cursor-themes}"
SRC_URI[x86_64_v2_oxygen-cursor-themes.sha256sum] = "2fcb50530ce2e79f2d2fe8bd20eb4346c3b1c337b179c10a0911946da41d9737"

URI_x86_64_v2_plasma-oxygen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-oxygen-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-oxygen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-oxygen}"
SRC_URI[x86_64_v2_plasma-oxygen.sha256sum] = "49a1c81a3ebf18edc6468665277473eade124a466c730316c2a0b0a0cf162b8a"

URI_x86_64_v2_plasma-oxygen-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-oxygen-qt6-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-oxygen-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-oxygen-qt6}"
SRC_URI[x86_64_v2_plasma-oxygen-qt6.sha256sum] = "53b86e7f18c4d34196720fde59f7b8bd9225a842c21624b23bce90632ea975f1"

URI_aarch64_oxygen-cursor-themes = "${EPEL_MIRROR}/aarch64/Packages/o/oxygen-cursor-themes-6.7.3-1.el10_3.noarch.rpm;name=aarch64_oxygen-cursor-themes;unpack=0"
SRC_URI:append = " ${URI_aarch64_oxygen-cursor-themes}"
SRC_URI[aarch64_oxygen-cursor-themes.sha256sum] = "a65b6297261ba80a41ae08583dc2c990efa60476b20f58fe04f239b6b02fefbf"

URI_aarch64_plasma-oxygen = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-oxygen-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-oxygen;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-oxygen}"
SRC_URI[aarch64_plasma-oxygen.sha256sum] = "e74927a24509b1875c548f381622505fad268ba775dcfaa151ab49435e4380d4"

URI_aarch64_plasma-oxygen-qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-oxygen-qt6-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-oxygen-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-oxygen-qt6}"
SRC_URI[aarch64_plasma-oxygen-qt6.sha256sum] = "12ff8bcc2e441f84f22e6183339a623561ace1f0bc88087b9bc2cafb229b7cb9"

RDEPENDS:oxygen-cursor-themes = " \
 "
RDEPENDS:plasma-oxygen = " \
 glibc \
 kdecoration \
 kf6-filesystem \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwindowsystem \
 libstdc++ \
 libxcb \
 oxygen-cursor-themes \
 oxygen-icon-theme \
 oxygen-sounds \
 plasma-oxygen-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-oxygen-qt6 = " \
 glibc \
 kf6-frameworkintegration-libs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
