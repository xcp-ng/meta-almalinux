# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-normal"
PV = "0.9.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-unic-normal+default-devel \
 rust-unic-normal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-normal-0.9.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f94f799dee9fcee9399ac89fa021bb929149fbc0fc2a5f32744bfd8fc7ed8f8a"

URI_x86_64_v2_rust-unic-normal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-normal+default-devel-0.9.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-normal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-normal+default-devel}"
SRC_URI[x86_64_v2_rust-unic-normal+default-devel.sha256sum] = "6da88844d88f259b8f7164030c1707647a4f0ed656e491332c0f3ed516a11694"

URI_x86_64_v2_rust-unic-normal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-normal-devel-0.9.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-normal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-normal-devel}"
SRC_URI[x86_64_v2_rust-unic-normal-devel.sha256sum] = "442796f97881e901e1fbb861eef788fc3ee0659373751fc0ad7c1840199afe21"

URI_aarch64_rust-unic-normal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-normal+default-devel-0.9.0-4.el10_0.noarch.rpm;name=aarch64_rust-unic-normal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-normal+default-devel}"
SRC_URI[aarch64_rust-unic-normal+default-devel.sha256sum] = "1f653c6076c0b27e31abea124f27ec2e2276496d0092972f0e7f57197b00ee7b"

URI_aarch64_rust-unic-normal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-normal-devel-0.9.0-4.el10_0.noarch.rpm;name=aarch64_rust-unic-normal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-normal-devel}"
SRC_URI[aarch64_rust-unic-normal-devel.sha256sum] = "f073561728d4f53769b0e3ea4a72efa7c118a87ef650c2ed7b4615482848d532"

RDEPENDS:rust-unic-normal+default-devel = " \
 cargo \
 rust-unic-normal-devel \
 "
RDEPENDS:rust-unic-normal-devel = " \
 cargo \
 rust-unic-ucd-normal+default-devel \
 "
