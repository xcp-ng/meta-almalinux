# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "anaconda"
PV = "40.22.3.54"
PR = "1.el10.alma.1"
PACKAGES = " \
 anaconda \
 anaconda-core \
 anaconda-dracut \
 anaconda-gui \
 anaconda-install-env-deps \
 anaconda-install-img-deps \
 anaconda-tui \
 anaconda-widgets \
 anaconda-widgets-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/anaconda-40.22.3.54-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44aa76d6336c8f0de6f77e32a4dfddd6a2a19ebfc8f2532c86b70cb8e910416a"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - anaconda-install-env-deps: tmux

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - anaconda-install-env-deps: tmux

URI_x86_64_v2_anaconda = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-40.22.3.54-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda}"
SRC_URI[x86_64_v2_anaconda.sha256sum] = "a47980d72a1fdb5aa8584a88785481a9e42867b06c2f40ac56bdf14854d6871a"

URI_x86_64_v2_anaconda-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-core-40.22.3.54-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-core}"
SRC_URI[x86_64_v2_anaconda-core.sha256sum] = "761bddc3a0853a85592d130e6feb89f2329000d25533c12cae221159f7c4a7e2"

URI_x86_64_v2_anaconda-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-dracut-40.22.3.54-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-dracut}"
SRC_URI[x86_64_v2_anaconda-dracut.sha256sum] = "6aa663cfe7a6e329b8e17e15a409deceaeb49f6da3db29f59989ceb46f7f24ff"

URI_x86_64_v2_anaconda-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-gui-40.22.3.54-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-gui}"
SRC_URI[x86_64_v2_anaconda-gui.sha256sum] = "73ceb5619baa7523dca9d8113586f5ed38189b12481d6af70ef2943fabb3fae0"

URI_x86_64_v2_anaconda-install-env-deps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-install-env-deps-40.22.3.54-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-install-env-deps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-install-env-deps}"
SRC_URI[x86_64_v2_anaconda-install-env-deps.sha256sum] = "241bea53526a7dc6ffa796b48f15d02c910fd7bfe81459c2c9e35f97aa001a5a"

URI_x86_64_v2_anaconda-install-img-deps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-install-img-deps-40.22.3.54-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-install-img-deps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-install-img-deps}"
SRC_URI[x86_64_v2_anaconda-install-img-deps.sha256sum] = "5bd6861bcc24a49ccd3ec9b4accffe8d99c2462fb55ef30e449487d235bd2f0b"

URI_x86_64_v2_anaconda-tui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-tui-40.22.3.54-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-tui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-tui}"
SRC_URI[x86_64_v2_anaconda-tui.sha256sum] = "abbe9c4f557052bf948ffaec84634b7d2cd56c35c287745a764968e9cfd83c89"

URI_x86_64_v2_anaconda-widgets = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-widgets-40.22.3.54-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-widgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-widgets}"
SRC_URI[x86_64_v2_anaconda-widgets.sha256sum] = "41e59b90efab6b86773b89e38ca51019f8be058c0a60503f4929e327dd7c555d"

URI_x86_64_v2_anaconda-widgets-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/anaconda-widgets-devel-40.22.3.54-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-widgets-devel}"
SRC_URI[x86_64_v2_anaconda-widgets-devel.sha256sum] = "c30530e4f3b8c947c71de4a3bf0fb76253d6d9c21033ba1a1401fa9b56867cf9"

URI_aarch64_anaconda = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-40.22.3.54-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda}"
SRC_URI[aarch64_anaconda.sha256sum] = "c079a3fa419cedb3d965375886e4052f3c23c0f24a1ac4d2cfbda0f78fbef4de"

URI_aarch64_anaconda-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-core-40.22.3.54-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-core}"
SRC_URI[aarch64_anaconda-core.sha256sum] = "6a4b77b6376feeebf754dfe300222c0ae5db84a97145e341613d12da80e81d83"

URI_aarch64_anaconda-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-dracut-40.22.3.54-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-dracut}"
SRC_URI[aarch64_anaconda-dracut.sha256sum] = "de44ba33fd7ecfa81a75b472a7321502f935bc14587b12fd62e9ec0154dd70f4"

URI_aarch64_anaconda-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-gui-40.22.3.54-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-gui}"
SRC_URI[aarch64_anaconda-gui.sha256sum] = "7242a014a5db0de4cf46b6b82ec778c8c757b7208180014aa42a4e0b7d290449"

URI_aarch64_anaconda-install-env-deps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-install-env-deps-40.22.3.54-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-install-env-deps;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-install-env-deps}"
SRC_URI[aarch64_anaconda-install-env-deps.sha256sum] = "28035e3f56204c92c4dc7dfbdaf070787dc976b5b99118fca7e9a4c0c21657ff"

URI_aarch64_anaconda-install-img-deps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-install-img-deps-40.22.3.54-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-install-img-deps;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-install-img-deps}"
SRC_URI[aarch64_anaconda-install-img-deps.sha256sum] = "7e4a45248e94e00e82828e7843b17ff1787480aa75793a5a4530df5aa2302461"

URI_aarch64_anaconda-tui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-tui-40.22.3.54-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-tui;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-tui}"
SRC_URI[aarch64_anaconda-tui.sha256sum] = "f685d237882926fe31640730e8cf0147dd9b28b261c32f30007753ee50cb9a3c"

URI_aarch64_anaconda-widgets = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-widgets-40.22.3.54-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-widgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-widgets}"
SRC_URI[aarch64_anaconda-widgets.sha256sum] = "23705a4f35e1d59d500883acba07b8e619fcd415e642766822094f2817567d28"

URI_aarch64_anaconda-widgets-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/anaconda-widgets-devel-40.22.3.54-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-widgets-devel}"
SRC_URI[aarch64_anaconda-widgets-devel.sha256sum] = "1fbf66bb67edec3f0c2250b27039a435179d0ee97af861f6e1ca3b6a176381af"

RDEPENDS:anaconda = " \
 anaconda-gui \
 anaconda-tui \
 "
RDEPENDS:anaconda-core = " \
 NetworkManager \
 NetworkManager-libnm \
 anaconda-tui \
 bash \
 chrony \
 cracklib-dicts \
 crypto-policies \
 crypto-policies-scripts \
 dbus-daemon \
 flatpak \
 flatpak-libs \
 grub2-common \
 kbd \
 python3 \
 python3-blivet \
 python3-blockdev \
 python3-dasbus \
 python3-dnf \
 python3-gobject-base \
 python3-kickstart \
 python3-langtable \
 python3-libs \
 python3-libselinux \
 python3-meh \
 python3-pid \
 python3-productmd \
 python3-pwquality \
 python3-pyparted \
 python3-requests \
 python3-requests-file \
 python3-requests-ftp \
 python3-rpm \
 python3-systemd \
 systemd \
 util-linux \
 virtual//usr/bin/date \
 virtual/glibc-langpack-en_or_glibc-all-langpacks \
 "
RDEPENDS:anaconda-dracut = " \
 bash \
 dnsconfd \
 dnsconfd-dracut \
 dracut \
 dracut-live \
 dracut-network \
 glibc \
 iputils \
 libarchive \
 python3 \
 python3-kickstart \
 rpm-libs \
 xz \
 "
RDEPENDS:anaconda-gui = " \
 NetworkManager-wifi \
 adwaita-icon-theme \
 almalinux-logos \
 anaconda-core \
 anaconda-widgets \
 nm-connection-editor \
 python3 \
 python3-iso639 \
 python3-meh-gui \
 python3-xkbregistry \
 tecla \
 "
RDEPENDS:anaconda-install-env-deps = " \
 dosfstools \
 e2fsprogs \
 gdb \
 isomd5sum \
 kexec-tools \
 libblockdev-plugins-all \
 realmd \
 rsync \
 udisks2-iscsi \
 xfsprogs \
 "
RDEPENDS:anaconda-install-img-deps:x86_64_v2 = " \
 anaconda-install-env-deps \
 bootc \
 bootupd \
 brltty \
 createrepo_c \
 device-mapper-multipath \
 dnsconfd \
 dnsconfd-dracut \
 fcoe-utils \
 gnome-kiosk \
 gnome-remote-desktop \
 gsettings-desktop-schemas \
 kdump-anaconda-addon \
 librsvg2 \
 libselinux-utils \
 mesa-dri-drivers \
 nm-connection-editor \
 nvme-cli \
 openssl \
 ostree \
 policycoreutils \
 policycoreutils-python-utils \
 python3-pam \
 rpm-ostree \
 selinux-policy \
 selinux-policy-targeted \
 skopeo \
 zram-generator-defaults \
"
RDEPENDS:anaconda-install-img-deps:aarch64 = " \
 anaconda-install-env-deps \
 bootc \
 bootupd \
 brltty \
 createrepo_c \
 device-mapper-multipath \
 dnsconfd \
 dnsconfd-dracut \
 gnome-kiosk \
 gnome-remote-desktop \
 gsettings-desktop-schemas \
 kdump-anaconda-addon \
 librsvg2 \
 libselinux-utils \
 mesa-dri-drivers \
 nm-connection-editor \
 nvme-cli \
 openssl \
 ostree \
 policycoreutils \
 policycoreutils-python-utils \
 python3-pam \
 rpm-ostree \
 selinux-policy \
 selinux-policy-targeted \
 skopeo \
 zram-generator-defaults \
"
RDEPENDS:anaconda-tui = " \
 anaconda-core \
 python3 \
 python3-simpleline \
 "
RDEPENDS:anaconda-widgets = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libgcc \
 pango \
 python3 \
 "
RDEPENDS:anaconda-widgets-devel = " \
 anaconda-widgets \
 "
