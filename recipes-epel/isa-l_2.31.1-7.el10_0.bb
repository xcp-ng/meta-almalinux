# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "isa-l"
PV = "2.31.1"
PR = "7.el10_0"
PACKAGES = " \
 isa-l \
 isa-l-devel \
 isa-l-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/isa-l-2.31.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a6bcf0398c62fe16a9321fa9098ec2b80e4fe000cc91e62c29d852c4a9af1a2"

URI_x86_64_v2_isa-l = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isa-l-2.31.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isa-l;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isa-l}"
SRC_URI[x86_64_v2_isa-l.sha256sum] = "2669dfcb50bba770ef80505c7af0c75f5d81e00f14404ade93e2cddda507d453"

URI_x86_64_v2_isa-l-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isa-l-devel-2.31.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isa-l-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isa-l-devel}"
SRC_URI[x86_64_v2_isa-l-devel.sha256sum] = "f8dd1bce61f07b80543f5318b897b3c8cf904bb0f1605f01a42666b048e93261"

URI_x86_64_v2_isa-l-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isa-l-tools-2.31.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isa-l-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isa-l-tools}"
SRC_URI[x86_64_v2_isa-l-tools.sha256sum] = "86ceb6675d9474affdf9d800a6844333a081f8313e9860d26ba343b7a9cf715a"

URI_aarch64_isa-l = "${EPEL_MIRROR}/aarch64/Packages/i/isa-l-2.31.1-7.el10_0.aarch64.rpm;name=aarch64_isa-l;unpack=0"
SRC_URI:append = " ${URI_aarch64_isa-l}"
SRC_URI[aarch64_isa-l.sha256sum] = "dd00b78650bd75d9098648ad3ac845ccf1bfe6b4002a4a1a2f61fafa3bcc8010"

URI_aarch64_isa-l-devel = "${EPEL_MIRROR}/aarch64/Packages/i/isa-l-devel-2.31.1-7.el10_0.aarch64.rpm;name=aarch64_isa-l-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_isa-l-devel}"
SRC_URI[aarch64_isa-l-devel.sha256sum] = "cd9cfa559029ce9ff7fcb47c7d40792c0c910b649f2068a8b8d899fe57ce6009"

URI_aarch64_isa-l-tools = "${EPEL_MIRROR}/aarch64/Packages/i/isa-l-tools-2.31.1-7.el10_0.aarch64.rpm;name=aarch64_isa-l-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_isa-l-tools}"
SRC_URI[aarch64_isa-l-tools.sha256sum] = "87bb816c557570ada983406ceca9bdd1777d452946498083632e9f4fc401c824"

RDEPENDS:isa-l = " \
 glibc \
 "
RDEPENDS:isa-l-devel = " \
 isa-l \
 pkgconf-pkg-config \
 "
RDEPENDS:isa-l-tools = " \
 glibc \
 isa-l \
 "
