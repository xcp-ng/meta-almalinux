# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-uz"
PV = "0.6"
PR = "33.el10"
PACKAGES = " \
 hunspell-uz \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-uz-0.6-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a77307dd07d58536021c7dbfd5461cb1b61639ed8096edcb25962677f4e7d5bd"

URI_x86_64_v2_hunspell-uz = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-uz-0.6-33.el10.noarch.rpm;name=x86_64_v2_hunspell-uz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-uz}"
SRC_URI[x86_64_v2_hunspell-uz.sha256sum] = "40a213284ef11c12d0dcaf014084bba6e36d9d0337272c2a8666bf151fbd35e4"

URI_aarch64_hunspell-uz = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-uz-0.6-33.el10.noarch.rpm;name=aarch64_hunspell-uz;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-uz}"
SRC_URI[aarch64_hunspell-uz.sha256sum] = "40a213284ef11c12d0dcaf014084bba6e36d9d0337272c2a8666bf151fbd35e4"

RDEPENDS:hunspell-uz = " \
 hunspell-filesystem \
 "
