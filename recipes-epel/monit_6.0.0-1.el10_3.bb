# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "monit"
PV = "6.0.0"
PR = "1.el10_3"
PACKAGES = " \
 monit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/monit-6.0.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f46778214c2bf64922daf08d5d0ff645ed539bb0553bbfe425b4bfa320303661"

URI_x86_64_v2_monit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/monit-6.0.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_monit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_monit}"
SRC_URI[x86_64_v2_monit.sha256sum] = "95e21ec6e4a84faa99d57faf19e8b1c735b66fa7c1d566ed3334576c46312725"

URI_aarch64_monit = "${EPEL_MIRROR}/aarch64/Packages/m/monit-6.0.0-1.el10_3.aarch64.rpm;name=aarch64_monit;unpack=0"
SRC_URI:append = " ${URI_aarch64_monit}"
SRC_URI[aarch64_monit.sha256sum] = "af76c1b6b0a5486b2203502dd73257952510cbcb153411e0dae85c4736769f39"

RDEPENDS:monit = " \
 bash \
 glibc \
 libxcrypt \
 openssl-libs \
 pam-libs \
 systemd \
 zlib-ng-compat \
 "
