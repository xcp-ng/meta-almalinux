# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdm"
PE = "1"
PV = "47.0"
PR = "24.el10_2"
PACKAGES = " \
 gdm \
 gdm-devel \
 gdm-pam-extensions-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdm-47.0-24.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b08e0be73924f199cc5d277870e85334949828296bded3e15fdf3b85ee274541"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdm-47.0-24.el10_2.x86_64_v2.rpm;name=x86_64_v2_gdm;unpack=0"
SRC_URI[x86_64_v2_gdm.sha256sum] = "93c5dbdffb69c3902e07871d62b316535cc8f74598f57f4d7fa17d14cfeb2307"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdm-devel-47.0-24.el10_2.x86_64_v2.rpm;name=x86_64_v2_gdm-devel;unpack=0"
SRC_URI[x86_64_v2_gdm-devel.sha256sum] = "bb643340af1985f27cffe22ce442335bb2f5c348a79b1aae5153fe5c0ee860ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdm-pam-extensions-devel-47.0-24.el10_2.x86_64_v2.rpm;name=x86_64_v2_gdm-pam-extensions-devel;unpack=0"
SRC_URI[x86_64_v2_gdm-pam-extensions-devel.sha256sum] = "e137d69fcea59d77c97fb8db9fca9be2ddbafe7abb3a6d94c54ee430676a3bb6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdm-47.0-24.el10_2.aarch64.rpm;name=aarch64_gdm;unpack=0"
SRC_URI[aarch64_gdm.sha256sum] = "de82c76d5f09749f318fce8ea84a0a8dc1ee4304c9c323bb6477ac6bb52c95dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdm-devel-47.0-24.el10_2.aarch64.rpm;name=aarch64_gdm-devel;unpack=0"
SRC_URI[aarch64_gdm-devel.sha256sum] = "a7a727cc5e49036ce756eb3be12e025b3e7f055f139741811a822673e9175620"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdm-pam-extensions-devel-47.0-24.el10_2.aarch64.rpm;name=aarch64_gdm-pam-extensions-devel;unpack=0"
SRC_URI[aarch64_gdm-pam-extensions-devel.sha256sum] = "8f918f76d3acb844e614e4fe2cd708730d4932ce6a0349ec7e0795064c4af9d2"

RDEPENDS:gdm = " \
 accountsservice \
 accountsservice-libs \
 almalinux-logos \
 audit-libs \
 bash \
 dbus-daemon \
 dconf \
 glib2 \
 glibc \
 gnome-keyring-pam \
 gnome-session \
 gnome-session-wayland-session \
 gnome-settings-daemon \
 gnome-shell \
 iso-codes \
 json-glib \
 keyutils-libs \
 libXau \
 libgcc \
 libgudev \
 libselinux \
 pam \
 pam-libs \
 polkit-libs \
 python3-pam \
 shadow-utils \
 systemd \
 systemd-libs \
 util-linux \
 "
RDEPENDS:gdm-devel = " \
 gdm \
 gdm-pam-extensions-devel \
 glib2-devel \
 libselinux-devel \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:gdm-pam-extensions-devel = " \
 pam-devel \
 pkgconf-pkg-config \
 "
