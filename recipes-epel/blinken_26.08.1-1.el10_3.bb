# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "blinken"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 blinken \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/blinken-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "65363297ce040ae97c671eca5ac44cd720bd00a4707e228869089f6b34e92338"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blinken-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blinken;unpack=0"
SRC_URI[x86_64_v2_blinken.sha256sum] = "3d2f05c75dc6a3320be51e745789ad7d8cab86142a37fb1805b7af863ac10573"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/blinken-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_blinken;unpack=0"
SRC_URI[aarch64_blinken.sha256sum] = "4dcf8764514a1bd3b7840f42362fa576515c2a075dcff5dca926b05508097ad9"

RDEPENDS:blinken = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 sj-stevehand-fonts \
 "
