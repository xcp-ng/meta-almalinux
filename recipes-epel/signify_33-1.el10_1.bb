# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "signify"
PV = "33"
PR = "1.el10_1"
PACKAGES = " \
 signify \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/signify-33-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1b46090beae1ac13f190a38804d05fca82a2641d4ee35f685e0823d2d241f818"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signify-33-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signify;unpack=0"
SRC_URI[x86_64_v2_signify.sha256sum] = "efeb5421a50dfead0dbd2fca8420d3c9f62a78eef1031d9eece2721cee00c3d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/signify-33-1.el10_1.aarch64.rpm;name=aarch64_signify;unpack=0"
SRC_URI[aarch64_signify.sha256sum] = "ca404850763283d95b1951aadd326afd43f1bdadfaa77a116453d890e3eed833"

RDEPENDS:signify = " \
 glibc \
 libbsd \
 "
