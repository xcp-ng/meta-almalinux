# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lttng-ust"
PV = "2.13.7"
PR = "5.el10"
PACKAGES = " \
 lttng-ust \
 lttng-ust-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/lttng-ust-2.13.7-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdf62b3b1781c3f922d5d2171255d536a619237766fcd7ad2fe67220674bd694"

URI_x86_64_v2_lttng-ust = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/lttng-ust-2.13.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_lttng-ust;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lttng-ust}"
SRC_URI[x86_64_v2_lttng-ust.sha256sum] = "f0708030e079712c7f3d2e4a9dc537931ee2c4cd95bffc0df7b5122f9c8761ee"

URI_x86_64_v2_lttng-ust-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/lttng-ust-devel-2.13.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_lttng-ust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lttng-ust-devel}"
SRC_URI[x86_64_v2_lttng-ust-devel.sha256sum] = "574c72bf2ad4db7a0a12e4226095149e2fe95aad1875ef238451dbd021fdd43d"

URI_aarch64_lttng-ust = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/lttng-ust-2.13.7-5.el10.aarch64.rpm;name=aarch64_lttng-ust;unpack=0"
SRC_URI:append = " ${URI_aarch64_lttng-ust}"
SRC_URI[aarch64_lttng-ust.sha256sum] = "f1f781d609fee9be54f6e520bdd2688b5516db94536cd1f5ddd452dc178b2163"

URI_aarch64_lttng-ust-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/lttng-ust-devel-2.13.7-5.el10.aarch64.rpm;name=aarch64_lttng-ust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lttng-ust-devel}"
SRC_URI[aarch64_lttng-ust-devel.sha256sum] = "2153dd49b925f2ca1a0c945a65229feec1b6583bac45559852c9ffea7a571223"

RDEPENDS:lttng-ust = " \
 glibc \
 numactl-libs \
 "
RDEPENDS:lttng-ust-devel = " \
 lttng-ust \
 pkgconf-pkg-config \
 python3 \
 systemtap-sdt-devel \
 userspace-rcu-devel \
 "
