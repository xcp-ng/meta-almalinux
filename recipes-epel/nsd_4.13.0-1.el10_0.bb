# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nsd"
PV = "4.13.0"
PR = "1.el10_0"
PACKAGES = " \
 nsd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nsd-4.13.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5142fc0069c68eff6843d5127bc8274a51df3cf2606ebc57f11d3d4ffcb5f8d"

URI_x86_64_v2_nsd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nsd-4.13.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nsd}"
SRC_URI[x86_64_v2_nsd.sha256sum] = "0899c574675adbacd80ca9fd462c99bfad09172d2b65bfeaaf17599d751e9db0"

URI_aarch64_nsd = "${EPEL_MIRROR}/aarch64/Packages/n/nsd-4.13.0-1.el10_0.aarch64.rpm;name=aarch64_nsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nsd}"
SRC_URI[aarch64_nsd.sha256sum] = "377aac598e4d47a4dfa5d65a6d6473a0f3eba03e7af2fe816459ab2a904c4b4d"

RDEPENDS:nsd = " \
 bash \
 fstrm \
 glibc \
 libevent \
 openssl-libs \
 protobuf-c \
 systemd-libs \
 "
