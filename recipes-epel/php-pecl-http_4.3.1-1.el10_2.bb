# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-http"
PV = "4.3.1"
PR = "1.el10_2"
PACKAGES = " \
 php-pecl-http \
 php-pecl-http-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-http-4.3.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6d46212018b69ed576f448f1e8ac6f99defb4ee3d142191c3a5e08613e9eae2"

URI_x86_64_v2_php-pecl-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-http-4.3.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-http}"
SRC_URI[x86_64_v2_php-pecl-http.sha256sum] = "97da5b32a275bbef9ef57e9b9e893d17fcec671877049b136bfdb3f45ce4895a"

URI_x86_64_v2_php-pecl-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-http-devel-4.3.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-http-devel}"
SRC_URI[x86_64_v2_php-pecl-http-devel.sha256sum] = "4d2e88675a9e8f59d6d003ffc83d7af1a769f5e83052898120d615eecfc9bab5"

URI_aarch64_php-pecl-http = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-http-4.3.1-1.el10_2.aarch64.rpm;name=aarch64_php-pecl-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-http}"
SRC_URI[aarch64_php-pecl-http.sha256sum] = "3a93b5a70de12c1e77f5e374c99fcbe646df6ca9ee454d1213ab5b44a16c03e2"

URI_aarch64_php-pecl-http-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-http-devel-4.3.1-1.el10_2.aarch64.rpm;name=aarch64_php-pecl-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-http-devel}"
SRC_URI[aarch64_php-pecl-http-devel.sha256sum] = "74707d619609793f9c9adb325adecea90e70231009e7a1ee78a8b8adbf567f05"

RDEPENDS:php-pecl-http:x86_64_v2 = " \
 glibc \
 libbrotli \
 libevent \
 libicu \
 openssl-libs \
 php-common \
 php-pecl-raphf \
 virtual/libcurl.so.4___64bit_ \
 virtual/php-iconv_x86-64_ \
 virtual/php-spl_x86-64_ \
 zlib-ng-compat \
"
RDEPENDS:php-pecl-http:aarch64 = " \
 glibc \
 libbrotli \
 libevent \
 libicu \
 openssl-libs \
 php-common \
 php-pecl-raphf \
 virtual/libcurl.so.4___64bit_ \
 virtual/php-iconv_aarch-64_ \
 virtual/php-spl_aarch-64_ \
 zlib-ng-compat \
"
RDEPENDS:php-pecl-http-devel:x86_64_v2 = " \
 php-pecl-http \
 virtual/php-devel_x86-64__ge_5.3.0 \
"
RDEPENDS:php-pecl-http-devel:aarch64 = " \
 php-pecl-http \
 virtual/php-devel_aarch-64__ge_5.3.0 \
"
