# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "debugedit"
PV = "5.1"
PR = "5.el10_0"
PACKAGES = " \
 debugedit \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/debugedit-5.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e0e2ca44e3226105b75f7fe39acc536e5017bdf247d174ec07365548a3469ab"

URI_x86_64_v2_debugedit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/debugedit-5.1-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_debugedit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debugedit}"
SRC_URI[x86_64_v2_debugedit.sha256sum] = "259db6e58ab8587863b8308391f61453ec3e706ebfa6c9c7f878e46592db02e8"

URI_aarch64_debugedit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/debugedit-5.1-5.el10_0.aarch64.rpm;name=aarch64_debugedit;unpack=0"
SRC_URI:append = " ${URI_aarch64_debugedit}"
SRC_URI[aarch64_debugedit.sha256sum] = "41d2bd213e60f8cfc4e8bb80c3b36375405cd1ab5f334875aae01a431a586971"

RDEPENDS:debugedit = " \
 bash \
 binutils \
 dwz \
 elfutils \
 elfutils-libelf \
 elfutils-libs \
 findutils \
 gawk \
 glibc \
 grep \
 sed \
 virtual//usr/bin/gdb-add-index \
 virtual/coreutils \
 xz \
 "
