# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "okular"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 okular \
 okular-devel \
 okular-libs \
 okular-mobile \
 okular-part \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/okular-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a52cc5c61dc10dd6b5b133d8f7071f826bc41bb7572db28be66558162af5a07"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - okular-part: libQMobipocket6.so.2()(64bit)

URI_x86_64_v2_okular = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular}"
SRC_URI[x86_64_v2_okular.sha256sum] = "7c0f46593172532e989f04fe9ec37de47bdc3c5ff3c28a571b7d4f79f0a4eeab"

URI_x86_64_v2_okular-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-devel}"
SRC_URI[x86_64_v2_okular-devel.sha256sum] = "5f1a12d383641f53e92f14a36fb2ba6913e84601545260fd3031c94ac5da6d06"

URI_x86_64_v2_okular-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-libs-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-libs}"
SRC_URI[x86_64_v2_okular-libs.sha256sum] = "737921603760bea24712292793c58c166d8b0d33bda863bf3d1fd5545cb52afe"

URI_x86_64_v2_okular-mobile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-mobile-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-mobile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-mobile}"
SRC_URI[x86_64_v2_okular-mobile.sha256sum] = "42c8be0338590f3686e26755c25a6109af748dc54a71c9da009c51a4eb7c0f05"

URI_x86_64_v2_okular-part = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-part-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-part;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-part}"
SRC_URI[x86_64_v2_okular-part.sha256sum] = "bb23228491b71d8dfb379458f9a25751fd18f5fd10329d572fc1e85c06fb5c77"

URI_aarch64_okular = "${EPEL_MIRROR}/aarch64/Packages/o/okular-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_okular;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular}"
SRC_URI[aarch64_okular.sha256sum] = "8027fe738987faec367b227f80aa500652ae43172e86358312b6f638aa06e145"

URI_aarch64_okular-devel = "${EPEL_MIRROR}/aarch64/Packages/o/okular-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_okular-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-devel}"
SRC_URI[aarch64_okular-devel.sha256sum] = "257c8b02b083f35507715062b5a55ed1df3f30d3ba790d6af06da02219c21ce3"

URI_aarch64_okular-libs = "${EPEL_MIRROR}/aarch64/Packages/o/okular-libs-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_okular-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-libs}"
SRC_URI[aarch64_okular-libs.sha256sum] = "f8875e80d77af1e563fc040709e646c1c71a754f58d9451d13496670071162b1"

URI_aarch64_okular-mobile = "${EPEL_MIRROR}/aarch64/Packages/o/okular-mobile-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_okular-mobile;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-mobile}"
SRC_URI[aarch64_okular-mobile.sha256sum] = "a519527401e1a063a0f0b74ce1e6e1ace2424a43e2e62560a7e3c3e5a9ed1a95"

URI_aarch64_okular-part = "${EPEL_MIRROR}/aarch64/Packages/o/okular-part-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_okular-part;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-part}"
SRC_URI[aarch64_okular-part.sha256sum] = "0c9c92431bab5f5b59ff309a3c17ca56b88869b835953e2c63f291528eb574f1"

RDEPENDS:okular = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-purpose \
 libstdc++ \
 okular-part \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:okular-devel = " \
 cmake-filesystem \
 okular-libs \
 "
RDEPENDS:okular-libs = " \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-threadweaver \
 libstdc++ \
 phonon-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 zlib-ng-compat \
 "
RDEPENDS:okular-mobile = " \
 glibc \
 kf6-kbookmarks \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 okular-libs \
 okular-part \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:okular-part:x86_64_v2 = " \
 freetype \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kparts \
 kf6-kpty \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 libkexiv2-qt6 \
 libmarkdown \
 libspectre \
 libstdc++ \
 libtiff \
 okular-libs \
 phonon-qt6 \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
"
RDEPENDS:okular-part:aarch64 = " \
 freetype \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kparts \
 kf6-kpty \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 libkexiv2-qt6 \
 libmarkdown \
 libspectre \
 libstdc++ \
 libtiff \
 okular-libs \
 phonon-qt6 \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
"
