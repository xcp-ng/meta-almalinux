# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-attributes"
PV = "0.28.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-attributes+default-devel \
 rust-gix-attributes+document-features-devel \
 rust-gix-attributes+serde-devel \
 rust-gix-attributes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-attributes-0.28.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38fb48e54c6929363ca351ddcf92c34e5597922c679155c63e07437b925040a6"

URI_x86_64_v2_rust-gix-attributes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes+default-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes+default-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes+default-devel.sha256sum] = "0bf8f67dfa036904b94f4003ac8da06018384f7471d0612611ac830cda80e4f0"

URI_x86_64_v2_rust-gix-attributes+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes+document-features-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes+document-features-devel.sha256sum] = "e2dcd9116507008d0261bfdce9dc286caad879a4fdf6e56666a7adb40a20f385"

URI_x86_64_v2_rust-gix-attributes+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes+serde-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes+serde-devel.sha256sum] = "360c8cbd60766974a428053ad71aa5261640af1892cd6a417232112c29496b8f"

URI_x86_64_v2_rust-gix-attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes-devel.sha256sum] = "059547c275af96b22b72a74f58d51a7990dba58ecc886106c957e8f12c98418b"

URI_aarch64_rust-gix-attributes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes+default-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes+default-devel}"
SRC_URI[aarch64_rust-gix-attributes+default-devel.sha256sum] = "f1db9d79fe0f8eca9082f41529afe88138b8e14f2e0ab489f3e3faf7eec6c842"

URI_aarch64_rust-gix-attributes+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes+document-features-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-attributes+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes+document-features-devel}"
SRC_URI[aarch64_rust-gix-attributes+document-features-devel.sha256sum] = "1d347186e0b5e238001d002548ba97a7ae50ad83c7f5346ebacb94f09f9b1326"

URI_aarch64_rust-gix-attributes+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes+serde-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-attributes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes+serde-devel}"
SRC_URI[aarch64_rust-gix-attributes+serde-devel.sha256sum] = "a9240b94252cbe6f5fc5b10a2e03b3d818e0fa3bc86facb43b571bdf361f22dc"

URI_aarch64_rust-gix-attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes-devel}"
SRC_URI[aarch64_rust-gix-attributes-devel.sha256sum] = "7d10517c6c32cd7401200bf8399af736f58c1da420c2e6d3341ff3c15a49f65b"

RDEPENDS:rust-gix-attributes+default-devel = " \
 cargo \
 rust-gix-attributes-devel \
 "
RDEPENDS:rust-gix-attributes+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-attributes-devel \
 "
RDEPENDS:rust-gix-attributes+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-attributes-devel \
 rust-gix-glob+serde-devel \
 rust-kstring+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-attributes-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-glob+default-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-trace+default-devel \
 rust-kstring+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 rust-unicode-bom+default-devel \
 "
