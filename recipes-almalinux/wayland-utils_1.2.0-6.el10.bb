# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wayland-utils"
PV = "1.2.0"
PR = "6.el10"
PACKAGES = " \
 wayland-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wayland-utils-1.2.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f621fe1910a7451d6ce32b121e380884d39bbc976362daf959cead63e469fdd"

URI_x86_64_v2_wayland-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wayland-utils-1.2.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_wayland-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wayland-utils}"
SRC_URI[x86_64_v2_wayland-utils.sha256sum] = "f6e1373365b8b6896905b17267d673d054371623f6aec326a102950bca2f805f"

URI_aarch64_wayland-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wayland-utils-1.2.0-6.el10.aarch64.rpm;name=aarch64_wayland-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_wayland-utils}"
SRC_URI[aarch64_wayland-utils.sha256sum] = "1df7d88f4a4c11e661052bd5e6884d2b978a67bc50a75cc18f6beb9061261722"

RDEPENDS:wayland-utils = " \
 glibc \
 libdrm \
 libwayland-client \
 "
