# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iperf3"
PV = "3.21"
PR = "2.el10"
PACKAGES = " \
 iperf3 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/iperf3-3.21-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b3c0c2406059c4ab44b61d10cff96756e1697aed3d2d551208d2b3f4053a8b52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iperf3-3.21-2.el10.x86_64_v2.rpm;name=x86_64_v2_iperf3;unpack=0"
SRC_URI[x86_64_v2_iperf3.sha256sum] = "23a219f150546e87caf0de6935efe37263664bd6ffcfec42c09521bc69834685"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iperf3-3.21-2.el10.aarch64.rpm;name=aarch64_iperf3;unpack=0"
SRC_URI[aarch64_iperf3.sha256sum] = "67dd7cf4dc52bb9398f78e5d08e2f0f26b67321a2ef5af41a54d7b89a90e5164"

RDEPENDS:iperf3 = " \
 glibc \
 lksctp-tools \
 openssl-libs \
 "
