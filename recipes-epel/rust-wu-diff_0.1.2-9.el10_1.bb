# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wu-diff"
PV = "0.1.2"
PR = "9.el10_1"
PACKAGES = " \
 rust-wu-diff+default-devel \
 rust-wu-diff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wu-diff-0.1.2-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f10de251516bd34e3dbe2067c8044b14ad71b76fd41591da6f0fd63ab871d90b"

URI_x86_64_v2_rust-wu-diff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wu-diff+default-devel-0.1.2-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wu-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wu-diff+default-devel}"
SRC_URI[x86_64_v2_rust-wu-diff+default-devel.sha256sum] = "4e23fee8ccf5ad8e490e44d35590e86e26dc1dd630af3f9b3d031bbc663cb7ef"

URI_x86_64_v2_rust-wu-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wu-diff-devel-0.1.2-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wu-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wu-diff-devel}"
SRC_URI[x86_64_v2_rust-wu-diff-devel.sha256sum] = "7a7d5cb95a40b8167acb98b94de529ddf68a5c6f81de17ed33481920dbe1bfc7"

URI_aarch64_rust-wu-diff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wu-diff+default-devel-0.1.2-9.el10_1.noarch.rpm;name=aarch64_rust-wu-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wu-diff+default-devel}"
SRC_URI[aarch64_rust-wu-diff+default-devel.sha256sum] = "f237bfd04ef707ff788af554d4b5eebdffc7921df38b0f11d1e6de62e4430994"

URI_aarch64_rust-wu-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wu-diff-devel-0.1.2-9.el10_1.noarch.rpm;name=aarch64_rust-wu-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wu-diff-devel}"
SRC_URI[aarch64_rust-wu-diff-devel.sha256sum] = "3f3626a5c4bf29dab7d522cfa8aa07522eb35b42ed683cc185b272a0f796eae7"

RDEPENDS:rust-wu-diff+default-devel = " \
 cargo \
 rust-wu-diff-devel \
 "
RDEPENDS:rust-wu-diff-devel = " \
 cargo \
 "
