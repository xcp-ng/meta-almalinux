# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uperf"
PV = "1.0.8"
PR = "12.el10_2"
PACKAGES = " \
 uperf \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/u/uperf-1.0.8-12.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "85b07831b67baf58b649e2bd67fbfed6b429390a4a09a6a44a19f03663e00d37"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uperf-1.0.8-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uperf;unpack=0"
SRC_URI[x86_64_v2_uperf.sha256sum] = "2c44b33629ae14f0c234ad71817a7d10af6687f36a7d493738745c11ba45fbfd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/uperf-1.0.8-12.el10_2.aarch64.rpm;name=aarch64_uperf;unpack=0"
SRC_URI[aarch64_uperf.sha256sum] = "2059c9ae1699080542e67064f1ac99c47ca43efe0c7f7adf69262a9a80faa62f"

RDEPENDS:uperf = " \
 glibc \
 lksctp-tools \
 openssl-libs \
 "
