# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "coreutils"
PV = "9.5"
PR = "8.el10_2.1"
PACKAGES = " \
 coreutils \
 coreutils-common \
 coreutils-single \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/coreutils-9.5-8.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9ab32373e4669ad3e3f89d535ba727f6d2657650e175981a0ffcf68754aed56a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/coreutils-9.5-8.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_coreutils;unpack=0"
SRC_URI[x86_64_v2_coreutils.sha256sum] = "6c4006995399f5d239ca95d582439f3f251d19fa15ce31756e6daf2586a5cf62"
RPROVIDES:coreutils:append:x86_64_v2 = " virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/coreutils-common-9.5-8.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_coreutils-common;unpack=0"
SRC_URI[x86_64_v2_coreutils-common.sha256sum] = "1856bb423ca9c958c2a5d73f6f471b3650cdc59dde683520a317aa7ebfb44aa4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/coreutils-single-9.5-8.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_coreutils-single;unpack=0"
SRC_URI[x86_64_v2_coreutils-single.sha256sum] = "90e9f377012d5a0e4406dd20c68c8e540bc3f415562b6ca6a823183bb52b7bd6"
RPROVIDES:coreutils-single:append:x86_64_v2 = " virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/coreutils-9.5-8.el10_2.1.aarch64.rpm;name=aarch64_coreutils;unpack=0"
SRC_URI[aarch64_coreutils.sha256sum] = "fa8af807f206c22568cd52c05d7e6676da9c7eca584df7ad9adfea59db54fc60"
RPROVIDES:coreutils:append:aarch64 = " virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/coreutils-common-9.5-8.el10_2.1.aarch64.rpm;name=aarch64_coreutils-common;unpack=0"
SRC_URI[aarch64_coreutils-common.sha256sum] = "0910bf4de3c5479df8a43229c92f1129f97b64aa26c4a9dc3cb61d041fb9dcad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/coreutils-single-9.5-8.el10_2.1.aarch64.rpm;name=aarch64_coreutils-single;unpack=0"
SRC_URI[aarch64_coreutils-single.sha256sum] = "25ef68bf5391571d85a13a2f565f1e743bbf9e401c5034bce9098ab10a6efad5"
RPROVIDES:coreutils-single:append:aarch64 = " virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

RDEPENDS:coreutils = " \
 coreutils-common \
 glibc \
 gmp \
 libacl \
 libattr \
 libcap \
 libselinux \
 openssl-libs \
 "
RDEPENDS:coreutils-common = " \
 "
RDEPENDS:coreutils-single = " \
 glibc \
 libacl \
 libattr \
 libcap \
 libselinux \
 "
