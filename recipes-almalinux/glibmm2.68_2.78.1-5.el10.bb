# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glibmm2.68"
PV = "2.78.1"
PR = "5.el10"
PACKAGES = " \
 glibmm2.68 \
 glibmm2.68-devel \
 glibmm2.68-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/glibmm2.68-2.78.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c4843aa2dc27f52474f491922b43bf2102338da7cab068973cda6ef65317017"

URI_x86_64_v2_glibmm2.68 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibmm2.68-2.78.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_glibmm2.68;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibmm2.68}"
SRC_URI[x86_64_v2_glibmm2.68.sha256sum] = "ead7b52166b165c887ecd2acde3438932591a6e71c314e1662e4452171827ae5"

URI_x86_64_v2_glibmm2.68-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibmm2.68-devel-2.78.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_glibmm2.68-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibmm2.68-devel}"
SRC_URI[x86_64_v2_glibmm2.68-devel.sha256sum] = "b574b65d8b7f08953e69aafad4bcf1f4bab9a3ea4970c2a6cbddfd3718777bda"

URI_x86_64_v2_glibmm2.68-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibmm2.68-doc-2.78.1-5.el10.noarch.rpm;name=x86_64_v2_glibmm2.68-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibmm2.68-doc}"
SRC_URI[x86_64_v2_glibmm2.68-doc.sha256sum] = "3c57beec9554f2e56827b837c2a90801ca4a020c5aa443043d54551596e15c42"

URI_aarch64_glibmm2.68 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibmm2.68-2.78.1-5.el10.aarch64.rpm;name=aarch64_glibmm2.68;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibmm2.68}"
SRC_URI[aarch64_glibmm2.68.sha256sum] = "18e1a79f1354d6e1ed467924cad9732f42e66a62d529b4bad01bcd127b9b1299"

URI_aarch64_glibmm2.68-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibmm2.68-devel-2.78.1-5.el10.aarch64.rpm;name=aarch64_glibmm2.68-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibmm2.68-devel}"
SRC_URI[aarch64_glibmm2.68-devel.sha256sum] = "7a7f4b8caaf13c44227f595c81aee9c03ffe133c03c30822b02fc81cd0ee1474"

URI_aarch64_glibmm2.68-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibmm2.68-doc-2.78.1-5.el10.noarch.rpm;name=aarch64_glibmm2.68-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibmm2.68-doc}"
SRC_URI[aarch64_glibmm2.68-doc.sha256sum] = "3c57beec9554f2e56827b837c2a90801ca4a020c5aa443043d54551596e15c42"

RDEPENDS:glibmm2.68 = " \
 glib2 \
 glibc \
 libgcc \
 libsigc++30 \
 libstdc++ \
 "
RDEPENDS:glibmm2.68-devel = " \
 glib2-devel \
 glibmm2.68 \
 glibmm2.68-devel \
 libsigc++30-devel \
 perl-Exporter \
 perl-XML-Parser \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-open \
 pkgconf-pkg-config \
 "
RDEPENDS:glibmm2.68-doc = " \
 glibmm2.68 \
 libsigc++30-doc \
 "
