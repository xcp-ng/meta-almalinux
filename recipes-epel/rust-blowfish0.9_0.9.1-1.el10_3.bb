# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blowfish0.9"
PV = "0.9.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-blowfish0.9+bcrypt-devel \
 rust-blowfish0.9+default-devel \
 rust-blowfish0.9+zeroize-devel \
 rust-blowfish0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blowfish0.9-0.9.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3dd7c008a2699475503af59db291977a6c63f1aa1681292df9212745a921a309"

URI_x86_64_v2_rust-blowfish0.9+bcrypt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blowfish0.9+bcrypt-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blowfish0.9+bcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blowfish0.9+bcrypt-devel}"
SRC_URI[x86_64_v2_rust-blowfish0.9+bcrypt-devel.sha256sum] = "9207cff173a2c92aa5625bc86013a24d16d1397608b085261abf2f8e32006027"

URI_x86_64_v2_rust-blowfish0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blowfish0.9+default-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blowfish0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blowfish0.9+default-devel}"
SRC_URI[x86_64_v2_rust-blowfish0.9+default-devel.sha256sum] = "8db70305da81b0bcfd9e14245cb42669aef22fd16eafe746772daabe9372058d"

URI_x86_64_v2_rust-blowfish0.9+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blowfish0.9+zeroize-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blowfish0.9+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blowfish0.9+zeroize-devel}"
SRC_URI[x86_64_v2_rust-blowfish0.9+zeroize-devel.sha256sum] = "fec9f23df510206629a20689074f649c4b9997a4e75ea58c973dd0f6a5522eb4"

URI_x86_64_v2_rust-blowfish0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blowfish0.9-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blowfish0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blowfish0.9-devel}"
SRC_URI[x86_64_v2_rust-blowfish0.9-devel.sha256sum] = "e5e756887144b91de26ab7f5e5e6f4154b23af15f7511af922e1d75073f33f13"

URI_aarch64_rust-blowfish0.9+bcrypt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blowfish0.9+bcrypt-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-blowfish0.9+bcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blowfish0.9+bcrypt-devel}"
SRC_URI[aarch64_rust-blowfish0.9+bcrypt-devel.sha256sum] = "ae8676fa175b6e03a910b746d959074e944e75d9950e1253e4519911f447636e"

URI_aarch64_rust-blowfish0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blowfish0.9+default-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-blowfish0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blowfish0.9+default-devel}"
SRC_URI[aarch64_rust-blowfish0.9+default-devel.sha256sum] = "dd9324a93b0c05d725ce4a85450de515b0f89a06a66ae72e92c7d7d5d3b66a61"

URI_aarch64_rust-blowfish0.9+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blowfish0.9+zeroize-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-blowfish0.9+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blowfish0.9+zeroize-devel}"
SRC_URI[aarch64_rust-blowfish0.9+zeroize-devel.sha256sum] = "f1baeeb042cd18d319e381fb1b80b4113fec775458fbf43afc7483948b510626"

URI_aarch64_rust-blowfish0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blowfish0.9-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-blowfish0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blowfish0.9-devel}"
SRC_URI[aarch64_rust-blowfish0.9-devel.sha256sum] = "88a3b5c76093cba2cf922df058c9478ff2dcc2221850c722f8add06c1132b58c"

RDEPENDS:rust-blowfish0.9+bcrypt-devel = " \
 cargo \
 rust-blowfish0.9-devel \
 "
RDEPENDS:rust-blowfish0.9+default-devel = " \
 cargo \
 rust-blowfish0.9-devel \
 "
RDEPENDS:rust-blowfish0.9+zeroize-devel = " \
 cargo \
 rust-blowfish0.9-devel \
 rust-cipher0.4+zeroize-devel \
 "
RDEPENDS:rust-blowfish0.9-devel = " \
 cargo \
 rust \
 rust-byteorder-devel \
 rust-cipher0.4+default-devel \
 "
