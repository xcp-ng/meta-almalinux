# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kongress"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kongress \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kongress-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "900fb4831bb8472fc400dee55fb804364857145c831892c06a60137c5c0d1593"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kongress-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kongress;unpack=0"
SRC_URI[x86_64_v2_kongress.sha256sum] = "8f2b536f215a0922c39b5865d8d75f8d67274f3f21e7769bcf0af40ecae8a369"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kongress-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kongress;unpack=0"
SRC_URI[aarch64_kongress.sha256sum] = "a865780e339aff2b49a97b434e62b7a7747667ed7d13606a099c187a93fe4837"

RDEPENDS:kongress = " \
 glibc \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kosmindoormap \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtpositioning \
 "
