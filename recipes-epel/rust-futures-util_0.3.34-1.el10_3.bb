# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-util"
PV = "0.3.34"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-util+alloc-devel \
 rust-futures-util+async-await-devel \
 rust-futures-util+async-await-macro-devel \
 rust-futures-util+bilock-devel \
 rust-futures-util+cfg-target-has-atomic-devel \
 rust-futures-util+channel-devel \
 rust-futures-util+default-devel \
 rust-futures-util+futures-channel-devel \
 rust-futures-util+futures-io-devel \
 rust-futures-util+futures-macro-devel \
 rust-futures-util+futures-sink-devel \
 rust-futures-util+io-devel \
 rust-futures-util+libc-devel \
 rust-futures-util+memchr-devel \
 rust-futures-util+portable-atomic-alloc-devel \
 rust-futures-util+portable-atomic-devel \
 rust-futures-util+portable-atomic-util-devel \
 rust-futures-util+portable_atomic_crate-devel \
 rust-futures-util+sink-devel \
 rust-futures-util+slab-devel \
 rust-futures-util+spin-devel \
 rust-futures-util+std-devel \
 rust-futures-util+unstable-devel \
 rust-futures-util+write-all-vectored-devel \
 rust-futures-util-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-futures-util-0.3.34-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4486d29c52a4aa2569ae55a6ea0b87c8344cd61a0551b60b25a4ba3cf9a372f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+alloc-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+alloc-devel.sha256sum] = "954fbd2c3dae2580f258da3e376c35b26f92c49df1c2eb16e7c9dfa6f8432656"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+async-await-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+async-await-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+async-await-devel.sha256sum] = "aed4d0c7a1f9663e3fb76c20d78975ca998c0dbe72d438d63411982df03cff9d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+async-await-macro-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+async-await-macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+async-await-macro-devel.sha256sum] = "34ab5984245964aacc436cee52bd1945265d76c51395b888910c9f3b7283a292"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+bilock-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+bilock-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+bilock-devel.sha256sum] = "96b3742f08d56677d1459d73eecae5f9f5dd9b5094eb1b42fc316d4e3e3b0a3f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+cfg-target-has-atomic-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+cfg-target-has-atomic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+cfg-target-has-atomic-devel.sha256sum] = "e45f2944ee51c5f83e0a31e8f0fcb5fad662bcec394ae4a21ccd3227f4781940"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+channel-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+channel-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+channel-devel.sha256sum] = "94b96aae831a360fe819d71e6c6b37c5081ab0669bb3494d359d87dbf0e07bd9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+default-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+default-devel.sha256sum] = "2ad1aac94ab38c3e74d1175c373729418b43eb503a73e6c7e437dd83dfa62134"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-channel-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-channel-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+futures-channel-devel.sha256sum] = "2d977a2ddbcf0ac80fe5083c477792c51d1957a795cbdfbd113a05efd15fbb00"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-io-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-io-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+futures-io-devel.sha256sum] = "2de61057d97ab86e1b0f80a96e9cad4e91c7b02929a3fa8c898079003ed0f34b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-macro-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+futures-macro-devel.sha256sum] = "a08f77052480c51dd6f27a82d4693010a193e931c9dad3d4efa9ea2877c6d8d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-sink-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-sink-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+futures-sink-devel.sha256sum] = "93f3780685637d90dcebb9fb284b46859327947e526fbe7da6416dbe05eae3d4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+io-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+io-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+io-devel.sha256sum] = "bb220a340a6c6b04eb60101e67b2e249011a0e3a040b0d688bdffc1b3f7cf475"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+libc-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+libc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+libc-devel.sha256sum] = "5a551b5f6e66e52288c7251abef0d8ebc650198870ef152988af851527ac0c51"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+memchr-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+memchr-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+memchr-devel.sha256sum] = "1dd60c21d3649124e8ff789752e96d017c1551962bec7fb212182eea2c9ff2a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+portable-atomic-alloc-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+portable-atomic-alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+portable-atomic-alloc-devel.sha256sum] = "d7e8f123f29a69565dcade810c85e9da21c68b655a76e9d7e04edb8ac4abb0ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+portable-atomic-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+portable-atomic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+portable-atomic-devel.sha256sum] = "08ef35a26ec8ce14caa3f8f20870ac7ced4739b362ef16b6a59371958a30c422"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+portable-atomic-util-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+portable-atomic-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+portable-atomic-util-devel.sha256sum] = "c1c0054fe16f5ded721d93859d88fc05485a3038c234e957618eb40e5fbb40bf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+portable_atomic_crate-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+portable_atomic_crate-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+portable_atomic_crate-devel.sha256sum] = "ec734ae3ca4ac30fd9cda02dc4103e978862567b0850d076dcebbe5a90a25294"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+sink-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+sink-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+sink-devel.sha256sum] = "f1465fc502a7f152cbbe2a61db55731bfeb93182207ec11c5dbd45a0afdb31f9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+slab-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+slab-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+slab-devel.sha256sum] = "b0abafe06fce90044b61961173219d26a9671ad3a6f9559b81074f11776b7db2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+spin-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+spin-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+spin-devel.sha256sum] = "c23763e4f771e9c723d17b4127289f8ebee4ae8f678d9a133fdd31f57e32223f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+std-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+std-devel.sha256sum] = "837cf93bcc144c405549055d93403651468d24e6ced68fe4aab8737fdc7e2679"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+unstable-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+unstable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+unstable-devel.sha256sum] = "5e498f8958ed6abef074332180c1e37440f237bbd2320eda10ddbf5ce5330d9e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+write-all-vectored-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+write-all-vectored-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util+write-all-vectored-devel.sha256sum] = "50eee64564bccc01506d1f4ca30b91c37ad3ab968c520078256e4054450e43ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-util-devel.sha256sum] = "e9126c1971dbdbb4d70f57d12c4e28921e0f7a36601a80a2f1bd3dded2a678b9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+alloc-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+alloc-devel.sha256sum] = "d403b01085c02ef8f79d685459794c08c69cc9cc20c4335b9356b2cd667f6260"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+async-await-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+async-await-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+async-await-devel.sha256sum] = "77a12592a894a0a36e6bcfd9197c746d0b967399f30bf9f8b526f051a5366dd2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+async-await-macro-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+async-await-macro-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+async-await-macro-devel.sha256sum] = "a08053d2973828fc114150dec87c01d0c8aac16a73d60efa9067d570204311c6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+bilock-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+bilock-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+bilock-devel.sha256sum] = "66af1c38fa36f4dc6c78c1e6f17e5c949bab98499ccd1f2a7ad7649d8106bc46"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+cfg-target-has-atomic-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+cfg-target-has-atomic-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+cfg-target-has-atomic-devel.sha256sum] = "6b054cc7670ff552571192a0856eb5d5ffb68ce3ab9fef04fd1e877f59260995"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+channel-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+channel-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+channel-devel.sha256sum] = "a5eb01b30a05ead209235c2a6af0eeeaf058ef7b5804ab9e4843f1d65c67650f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+default-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+default-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+default-devel.sha256sum] = "83ef463a0736f68e431ce3a803d5a79eecb8cf803173c8b2373b1eb730fad615"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-channel-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+futures-channel-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+futures-channel-devel.sha256sum] = "beb3ddbf0987b2af7cfde424ae5ffa45b80fd6d42c6f2498a9a60fee4806892a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-io-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+futures-io-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+futures-io-devel.sha256sum] = "8bf420528455407f21d5a6a231fd961ab15343645d2f1bde7e40edb3c7c8e056"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-macro-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+futures-macro-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+futures-macro-devel.sha256sum] = "139d19d21f7a428d440e522a2ac08a3d353869ba8a683cdf90069f19a651bea6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-sink-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+futures-sink-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+futures-sink-devel.sha256sum] = "4c7c311e2e342e58c9b025c0c5b29c9cfb146c0d2720eb446759058a05807a13"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+io-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+io-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+io-devel.sha256sum] = "3e85832423d678704757914cefb001277434160304aeafe791d28a558f2c9c37"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+libc-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+libc-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+libc-devel.sha256sum] = "b34e985033d71a92e225195c340267129270a13de6418660463c39640439898d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+memchr-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+memchr-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+memchr-devel.sha256sum] = "faf22268a5f00731504b1aa496b85770c194969607b3b3ef4720cd953a9fb46a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+portable-atomic-alloc-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+portable-atomic-alloc-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+portable-atomic-alloc-devel.sha256sum] = "b5fc5428a877d65d49abefc5e2d0923425735161d8082587a64aa1062b23fdca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+portable-atomic-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+portable-atomic-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+portable-atomic-devel.sha256sum] = "f886066f1003982c25f72197fd49172d354d8c05f34b8e35aedf62e6af139413"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+portable-atomic-util-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+portable-atomic-util-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+portable-atomic-util-devel.sha256sum] = "d5f9fbf2101abf87de695e99786f3eca65e74e9114c00b4dff1d34e82224cf44"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+portable_atomic_crate-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+portable_atomic_crate-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+portable_atomic_crate-devel.sha256sum] = "37fadb531e73e7f1cb6fa976ee2b4341685ced2e530b0df85985d07293df2a25"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+sink-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+sink-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+sink-devel.sha256sum] = "ed97cde63f72b48af074fec234b775c595d50797813ed38c4a5f2d96b2b74ab8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+slab-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+slab-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+slab-devel.sha256sum] = "585c33922b0c20afb5cd8a62c4040de7a385e75e834636c092d548a31d85d6c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+spin-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+spin-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+spin-devel.sha256sum] = "512ebfcf1f6f54ece4034bb609ff8628723f8df84912c706a40dbd4a768ffc66"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+std-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+std-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+std-devel.sha256sum] = "f48a7d9f7209dd58aa2f4f4e77aa846294b83017e6ef300425acb6a02ef22edf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+unstable-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+unstable-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+unstable-devel.sha256sum] = "ba6b21936aa53bc4848380a19749de11d7b2f1762301525bce2dd30f2767fc8e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+write-all-vectored-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+write-all-vectored-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util+write-all-vectored-devel.sha256sum] = "518044bac8c0474f2ac7b81bfae688e1b1fa3ed5150a66e8e77d8cb3251b2273"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util-devel;unpack=0"
SRC_URI[aarch64_rust-futures-util-devel.sha256sum] = "2f35ff812efc1b0b7f7070f1715a9b8da2ef4fb1bee3a144a9cd4c419e041f81"

RDEPENDS:rust-futures-util+alloc-devel = " \
 cargo \
 rust-futures-core+alloc-devel \
 rust-futures-task+alloc-devel \
 rust-futures-util+slab-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+async-await-devel = " \
 cargo \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+async-await-macro-devel = " \
 cargo \
 rust-futures-util+async-await-devel \
 rust-futures-util+futures-macro-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+bilock-devel = " \
 cargo \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+channel-devel = " \
 cargo \
 rust-futures-util+futures-channel-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+default-devel = " \
 cargo \
 rust-futures-util+async-await-devel \
 rust-futures-util+async-await-macro-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-channel-devel = " \
 cargo \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-io-devel = " \
 cargo \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-macro-devel = " \
 cargo \
 rust-futures-macro-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-sink-devel = " \
 cargo \
 rust-futures-sink-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+io-devel = " \
 cargo \
 rust-futures-util+futures-io-devel \
 rust-futures-util+memchr-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+libc-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-futures-util+memchr-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-memchr+default-devel \
 "
RDEPENDS:rust-futures-util+portable-atomic-alloc-devel = " \
 cargo \
 rust-futures-util+portable-atomic-devel \
 rust-futures-util-devel \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-futures-util+portable-atomic-devel = " \
 cargo \
 rust-futures-core+portable-atomic-devel \
 rust-futures-util+portable_atomic_crate-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+portable-atomic-util-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-futures-util+portable_atomic_crate-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-futures-util+sink-devel = " \
 cargo \
 rust-futures-util+futures-sink-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+slab-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-slab-devel \
 "
RDEPENDS:rust-futures-util+spin-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-spin+default-devel \
 "
RDEPENDS:rust-futures-util+std-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-task+std-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-slab+std-devel \
 rust-slab-devel \
 "
RDEPENDS:rust-futures-util+unstable-devel = " \
 cargo \
 rust-futures-core+unstable-devel \
 rust-futures-task+unstable-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+write-all-vectored-devel = " \
 cargo \
 rust-futures-util+io-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-futures-task-devel \
 rust-pin-project-lite+default-devel \
 "
