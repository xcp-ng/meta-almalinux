# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keylime"
PV = "7.12.1"
PR = "11.el10_1.4"
PACKAGES = " \
 keylime \
 keylime-base \
 keylime-registrar \
 keylime-selinux \
 keylime-tenant \
 keylime-tools \
 keylime-verifier \
 python3-keylime \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/keylime-7.12.1-11.el10_1.4.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87694f45e8793d5191215ed0204e236840bb177fbb08ed1abb923a0f32f93f7f"

URI_x86_64_v2_keylime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-7.12.1-11.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_keylime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime}"
SRC_URI[x86_64_v2_keylime.sha256sum] = "ade3248572260b45f4806bb167e702e3db220dbcb874ff59fbeb8914608927c4"

URI_x86_64_v2_keylime-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-base-7.12.1-11.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_keylime-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-base}"
SRC_URI[x86_64_v2_keylime-base.sha256sum] = "16f24348f844a5487e580fd141f60dffaa92ebf38031fcc476b11a157214893e"

URI_x86_64_v2_keylime-registrar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-registrar-7.12.1-11.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_keylime-registrar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-registrar}"
SRC_URI[x86_64_v2_keylime-registrar.sha256sum] = "9a075b4d126abee72d01902d3661f3f8ee366c04184074916f955a4b7e77ccbd"

URI_x86_64_v2_keylime-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-selinux-7.12.1-11.el10_1.4.noarch.rpm;name=x86_64_v2_keylime-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-selinux}"
SRC_URI[x86_64_v2_keylime-selinux.sha256sum] = "ed68406d962714d8354e13eecae48dc3cec8b752c8a401e90dd2925167bfb623"

URI_x86_64_v2_keylime-tenant = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-tenant-7.12.1-11.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_keylime-tenant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-tenant}"
SRC_URI[x86_64_v2_keylime-tenant.sha256sum] = "7d17c8176622edc391d4d86cf490c3cd922a30b5455acec8cf5871b66e799606"

URI_x86_64_v2_keylime-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-tools-7.12.1-11.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_keylime-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-tools}"
SRC_URI[x86_64_v2_keylime-tools.sha256sum] = "aaa9ef20bf153f421ecce77427e4932434cfc66495c740ebc1c34cf5de6ca3a0"

URI_x86_64_v2_keylime-verifier = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-verifier-7.12.1-11.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_keylime-verifier;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-verifier}"
SRC_URI[x86_64_v2_keylime-verifier.sha256sum] = "d39d8108629baaa9df13cb2243f53c924c590d438eea301bfcab8cbb6d038ce6"

URI_x86_64_v2_python3-keylime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-keylime-7.12.1-11.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_python3-keylime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keylime}"
SRC_URI[x86_64_v2_python3-keylime.sha256sum] = "1e4905175694558b13b3d564c653a66fad44c3cc8668bf06c10af49389da89e2"

URI_aarch64_keylime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-7.12.1-11.el10_1.4.aarch64.rpm;name=aarch64_keylime;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime}"
SRC_URI[aarch64_keylime.sha256sum] = "ae12b6f630e133f9704a58778be02ad675722582baf524a860f8cb7cc3a195f5"

URI_aarch64_keylime-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-base-7.12.1-11.el10_1.4.aarch64.rpm;name=aarch64_keylime-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-base}"
SRC_URI[aarch64_keylime-base.sha256sum] = "7541cc115b65d8370aea9c19d74e1415be238ab0313409ebf95cc1b5ebf9cc06"

URI_aarch64_keylime-registrar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-registrar-7.12.1-11.el10_1.4.aarch64.rpm;name=aarch64_keylime-registrar;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-registrar}"
SRC_URI[aarch64_keylime-registrar.sha256sum] = "bbe16ba83a65e76187bb809fca93b028618134e1d8fec13bf87f5ca4115d1efb"

URI_aarch64_keylime-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-selinux-7.12.1-11.el10_1.4.noarch.rpm;name=aarch64_keylime-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-selinux}"
SRC_URI[aarch64_keylime-selinux.sha256sum] = "ed68406d962714d8354e13eecae48dc3cec8b752c8a401e90dd2925167bfb623"

URI_aarch64_keylime-tenant = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-tenant-7.12.1-11.el10_1.4.aarch64.rpm;name=aarch64_keylime-tenant;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-tenant}"
SRC_URI[aarch64_keylime-tenant.sha256sum] = "55acae802d46c8bd7851b3bb3b7c3d4d9cca0edb9c80371dc20604bb0419e8f7"

URI_aarch64_keylime-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-tools-7.12.1-11.el10_1.4.aarch64.rpm;name=aarch64_keylime-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-tools}"
SRC_URI[aarch64_keylime-tools.sha256sum] = "6aef7c45f4c244c52ffe3c62c135170652d78339887d91d9427a2e8684a3a5de"

URI_aarch64_keylime-verifier = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-verifier-7.12.1-11.el10_1.4.aarch64.rpm;name=aarch64_keylime-verifier;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-verifier}"
SRC_URI[aarch64_keylime-verifier.sha256sum] = "98a9946026b07f4843453918cf5b5706d2197fade734880c06fee69071e6b3f6"

URI_aarch64_python3-keylime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-keylime-7.12.1-11.el10_1.4.aarch64.rpm;name=aarch64_python3-keylime;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keylime}"
SRC_URI[aarch64_python3-keylime.sha256sum] = "a1b78b1ce8e1bdddd7546966163584b4c0cde6d4cc2553e775d9642095a31cbf"

RDEPENDS:keylime = " \
 keylime-agent-rust \
 keylime-base \
 keylime-registrar \
 keylime-tenant \
 keylime-tools \
 keylime-verifier \
 python3-keylime \
 "
RDEPENDS:keylime-base = " \
 bash \
 efivar-libs \
 openssl \
 procps-ng \
 python3 \
 python3-jinja2 \
 shadow-utils \
 tpm2-tss \
 "
RDEPENDS:keylime-registrar = " \
 bash \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:keylime-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:keylime-tenant = " \
 bash \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:keylime-tools = " \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:keylime-verifier = " \
 bash \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:python3-keylime = " \
 keylime-base \
 python3 \
 python3-alembic \
 python3-cryptography \
 python3-gpg \
 python3-jsonschema \
 python3-lark \
 python3-packaging \
 python3-psutil \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-pyyaml \
 python3-requests \
 python3-sqlalchemy \
 python3-tornado \
 python3-typing-extensions \
 tpm2-tools \
 "
