# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-files"
PV = "16"
PR = "1.el10"
PACKAGES = " \
 cockpit-files \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-files-16-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7fa66ff911fdc144760f253766d6ff6490d4b5c35959816ef2cacf3b4ce248e"

URI_x86_64_v2_cockpit-files = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-files-16-1.el10.noarch.rpm;name=x86_64_v2_cockpit-files;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-files}"
SRC_URI[x86_64_v2_cockpit-files.sha256sum] = "b90a0e7cc3c35b25a7b7a61905091d2e160f6b729b02b4e112697586dd92c742"

URI_aarch64_cockpit-files = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-files-16-1.el10.noarch.rpm;name=aarch64_cockpit-files;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-files}"
SRC_URI[aarch64_cockpit-files.sha256sum] = "b90a0e7cc3c35b25a7b7a61905091d2e160f6b729b02b4e112697586dd92c742"

RDEPENDS:cockpit-files = " \
 cockpit-bridge \
 "
