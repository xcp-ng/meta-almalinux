# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_datetime"
PV = "1.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-toml_datetime+alloc-devel \
 rust-toml_datetime+default-devel \
 rust-toml_datetime+serde-devel \
 rust-toml_datetime+std-devel \
 rust-toml_datetime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_datetime-1.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09398986d3bfabaaa81ca1108be0f661b1613884fa4088c41f2163a670e9b5d4"

URI_x86_64_v2_rust-toml_datetime+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime+alloc-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime+alloc-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime+alloc-devel.sha256sum] = "a82c39275b62d34e40a25d0514b2e71adac82f496352cda2cf8cc35bb6ebf708"

URI_x86_64_v2_rust-toml_datetime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime+default-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime+default-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime+default-devel.sha256sum] = "5faaa9882b9ba0dab3b7ad24b94ae58eea8bb9dea0d9a47bc049668153718bd3"

URI_x86_64_v2_rust-toml_datetime+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime+serde-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime+serde-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime+serde-devel.sha256sum] = "b1c92554dd56b6a1292ad744d32b67e5eec23b4a8f09666778cbf59a0e3079e1"

URI_x86_64_v2_rust-toml_datetime+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime+std-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime+std-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime+std-devel.sha256sum] = "1112b10a92419f3fcaa3547d37626a5a333d9111caf5a7ce53e048a9378745dc"

URI_x86_64_v2_rust-toml_datetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime-devel.sha256sum] = "670680dbdcbf03c163c8c5ddec05196b726639d83c9f1bf256e2174a178efb4f"

URI_aarch64_rust-toml_datetime+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime+alloc-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-toml_datetime+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime+alloc-devel}"
SRC_URI[aarch64_rust-toml_datetime+alloc-devel.sha256sum] = "4332f4037dc0d0cce875e0714a10af200a5f3acfc559cc7ef9cc228b5e9a6a7d"

URI_aarch64_rust-toml_datetime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime+default-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-toml_datetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime+default-devel}"
SRC_URI[aarch64_rust-toml_datetime+default-devel.sha256sum] = "2ca8d41e9936e64a056fb4a50dbfc6862ff68ad868bf215ed8ea6c4906439cda"

URI_aarch64_rust-toml_datetime+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime+serde-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-toml_datetime+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime+serde-devel}"
SRC_URI[aarch64_rust-toml_datetime+serde-devel.sha256sum] = "db0bd6355b1d5e4a35d606cf8233d42ea6b4a619676df3c778a698232b8c1ec6"

URI_aarch64_rust-toml_datetime+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime+std-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-toml_datetime+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime+std-devel}"
SRC_URI[aarch64_rust-toml_datetime+std-devel.sha256sum] = "4cf46e4253863a1600740df3bd5c76f4386d0e20222234b73ce9978c934861cb"

URI_aarch64_rust-toml_datetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-toml_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime-devel}"
SRC_URI[aarch64_rust-toml_datetime-devel.sha256sum] = "b08dc1d137ce73e26971ebfbe734a8709af4f785ff68be5187a6c91dd7f6ec73"

RDEPENDS:rust-toml_datetime+alloc-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-toml_datetime-devel \
 "
RDEPENDS:rust-toml_datetime+default-devel = " \
 cargo \
 rust-toml_datetime+std-devel \
 rust-toml_datetime-devel \
 "
RDEPENDS:rust-toml_datetime+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-toml_datetime-devel \
 "
RDEPENDS:rust-toml_datetime+std-devel = " \
 cargo \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-toml_datetime+alloc-devel \
 rust-toml_datetime-devel \
 "
RDEPENDS:rust-toml_datetime-devel = " \
 cargo \
 rust \
 "
