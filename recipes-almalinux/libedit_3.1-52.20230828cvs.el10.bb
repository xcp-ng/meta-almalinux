# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libedit"
PV = "3.1"
PR = "52.20230828cvs.el10"
PACKAGES = " \
 libedit \
 libedit-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libedit-3.1-52.20230828cvs.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4857400a31fafab98df013b27cf36e5655b5a1cdeabb1f04d3811fc7f0e02c52"

URI_x86_64_v2_libedit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libedit-3.1-52.20230828cvs.el10.x86_64_v2.rpm;name=x86_64_v2_libedit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libedit}"
SRC_URI[x86_64_v2_libedit.sha256sum] = "42721020101064bd8106878264cf1b547128ea705f3f8bf13434d53ded854072"

URI_x86_64_v2_libedit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libedit-devel-3.1-52.20230828cvs.el10.x86_64_v2.rpm;name=x86_64_v2_libedit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libedit-devel}"
SRC_URI[x86_64_v2_libedit-devel.sha256sum] = "d14f5adcb23a303f0828e7f4c5b11bf1abc42a92c4aca5705f9cb89eb56be0a6"

URI_aarch64_libedit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libedit-3.1-52.20230828cvs.el10.aarch64.rpm;name=aarch64_libedit;unpack=0"
SRC_URI:append = " ${URI_aarch64_libedit}"
SRC_URI[aarch64_libedit.sha256sum] = "183cc585ad539ae4788e6ebc9d9269b78fd79a1e544467c672306447d2b8e29c"

URI_aarch64_libedit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libedit-devel-3.1-52.20230828cvs.el10.aarch64.rpm;name=aarch64_libedit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libedit-devel}"
SRC_URI[aarch64_libedit-devel.sha256sum] = "b46fc23ec2933ac32e661a53c474c280475a2370e6d05aea9fd626e179effd62"

RDEPENDS:libedit = " \
 glibc \
 ncurses-libs \
 "
RDEPENDS:libedit-devel = " \
 libedit \
 ncurses-devel \
 pkgconf-pkg-config \
 "
