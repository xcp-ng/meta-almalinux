# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-infer-license"
PV = "0.2.0"
PR = "21.el10_0"
PACKAGES = " \
 ghc-infer-license \
 ghc-infer-license-devel \
 ghc-infer-license-doc \
 ghc-infer-license-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-infer-license-0.2.0-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d20b823ad1c17e8aca5c0fa56257e96962b529bb8156375d5d79e2d02718c72"

URI_x86_64_v2_ghc-infer-license = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-infer-license-0.2.0-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-infer-license;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-infer-license}"
SRC_URI[x86_64_v2_ghc-infer-license.sha256sum] = "6ffe4eb6d0c7cd6e5bc2550015af8301aa0f4776594422adfb9feb45927a3385"

URI_x86_64_v2_ghc-infer-license-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-infer-license-devel-0.2.0-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-infer-license-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-infer-license-devel}"
SRC_URI[x86_64_v2_ghc-infer-license-devel.sha256sum] = "b00f5fbb99b9b577e2a78b539dfeafa080dd84d96a214a9fe4a795d78fea067b"

URI_x86_64_v2_ghc-infer-license-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-infer-license-doc-0.2.0-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-infer-license-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-infer-license-doc}"
SRC_URI[x86_64_v2_ghc-infer-license-doc.sha256sum] = "4a78f623d84cffce63c2411b4b7676f92273efed50cd01c294143789807b5d86"

URI_x86_64_v2_ghc-infer-license-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-infer-license-prof-0.2.0-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-infer-license-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-infer-license-prof}"
SRC_URI[x86_64_v2_ghc-infer-license-prof.sha256sum] = "05b48ceb72bf0c755c380a2e0ae713b84783bbed9472e3d934a4e4b47b45a78c"

URI_aarch64_ghc-infer-license = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-infer-license-0.2.0-21.el10_0.aarch64.rpm;name=aarch64_ghc-infer-license;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-infer-license}"
SRC_URI[aarch64_ghc-infer-license.sha256sum] = "ee3867c26882ab0a4d09bab3c3636537db3d7b94c56d6cc7c778246db84eb48c"

URI_aarch64_ghc-infer-license-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-infer-license-devel-0.2.0-21.el10_0.aarch64.rpm;name=aarch64_ghc-infer-license-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-infer-license-devel}"
SRC_URI[aarch64_ghc-infer-license-devel.sha256sum] = "0a0739b1019d3bff42f2b7c35cee1e905c57432c9709598031fb183433bbcda0"

URI_aarch64_ghc-infer-license-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-infer-license-doc-0.2.0-21.el10_0.noarch.rpm;name=aarch64_ghc-infer-license-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-infer-license-doc}"
SRC_URI[aarch64_ghc-infer-license-doc.sha256sum] = "a262371605bc9365ca48b13b3234780d47c0dd34df6715d0e8e5707d19d4eec3"

URI_aarch64_ghc-infer-license-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-infer-license-prof-0.2.0-21.el10_0.aarch64.rpm;name=aarch64_ghc-infer-license-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-infer-license-prof}"
SRC_URI[aarch64_ghc-infer-license-prof.sha256sum] = "43e813b954a34bf73a06d826028dd627d5e1c60bd9fc260f99db83e283e8889f"

RDEPENDS:ghc-infer-license = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-primitive \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-text-metrics \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-infer-license-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-infer-license \
 ghc-text-devel \
 ghc-text-metrics-devel \
 "
RDEPENDS:ghc-infer-license-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-infer-license-prof = " \
 ghc-base-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-infer-license-devel \
 ghc-text-metrics-prof \
 ghc-text-prof \
 "
