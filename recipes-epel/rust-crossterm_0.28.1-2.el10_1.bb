# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossterm"
PV = "0.28.1"
PR = "2.el10_1"
PACKAGES = " \
 rust-crossterm+bracketed-paste-devel \
 rust-crossterm+default-devel \
 rust-crossterm+event-stream-devel \
 rust-crossterm+events-devel \
 rust-crossterm+filedescriptor-devel \
 rust-crossterm+libc-devel \
 rust-crossterm+serde-devel \
 rust-crossterm+use-dev-tty-devel \
 rust-crossterm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossterm-0.28.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f08072c6e44a2121c7e1030f96ebadd4a59c5a72ec254dc0080b7d48f8fbfc1"

URI_x86_64_v2_rust-crossterm+bracketed-paste-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+bracketed-paste-devel-0.28.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+bracketed-paste-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+bracketed-paste-devel}"
SRC_URI[x86_64_v2_rust-crossterm+bracketed-paste-devel.sha256sum] = "0907539437d131b414434221ad803473f76b94d7338ca5efd47cb0de7a81c051"

URI_x86_64_v2_rust-crossterm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+default-devel-0.28.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+default-devel}"
SRC_URI[x86_64_v2_rust-crossterm+default-devel.sha256sum] = "95c8f2c9b8f67c9a01027fab59bb2d5b43a194bd020127ee387af688bae6b3e6"

URI_x86_64_v2_rust-crossterm+event-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+event-stream-devel-0.28.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+event-stream-devel}"
SRC_URI[x86_64_v2_rust-crossterm+event-stream-devel.sha256sum] = "6ae7ee8ee41df9e836b92d9304d005752e06128b95daa4cc3bc8d4a2314c4deb"

URI_x86_64_v2_rust-crossterm+events-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+events-devel-0.28.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+events-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+events-devel}"
SRC_URI[x86_64_v2_rust-crossterm+events-devel.sha256sum] = "8664a52d3f8286091ff967d6b265a02cdc5c23a0a0e52a219afd63f8d84ad93c"

URI_x86_64_v2_rust-crossterm+filedescriptor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+filedescriptor-devel-0.28.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+filedescriptor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+filedescriptor-devel}"
SRC_URI[x86_64_v2_rust-crossterm+filedescriptor-devel.sha256sum] = "1ab09d58702842ff7915d1540af33f85123102111695722210fa56fea32b4221"

URI_x86_64_v2_rust-crossterm+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+libc-devel-0.28.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+libc-devel}"
SRC_URI[x86_64_v2_rust-crossterm+libc-devel.sha256sum] = "dc64c337646680d5a19376a33154b34b2b182864aec69ee138c5b9b844adbee1"

URI_x86_64_v2_rust-crossterm+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+serde-devel-0.28.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+serde-devel}"
SRC_URI[x86_64_v2_rust-crossterm+serde-devel.sha256sum] = "c83eba4972d169124b3ba34d92a04e8afb19846d3dbff4402a6276330c4b9366"

URI_x86_64_v2_rust-crossterm+use-dev-tty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+use-dev-tty-devel-0.28.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+use-dev-tty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+use-dev-tty-devel}"
SRC_URI[x86_64_v2_rust-crossterm+use-dev-tty-devel.sha256sum] = "2d2787e4dc77e658c3899df2615e3429b13bdb102804ca6cc2d33521f6c69aa2"

URI_x86_64_v2_rust-crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm-devel-0.28.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm-devel}"
SRC_URI[x86_64_v2_rust-crossterm-devel.sha256sum] = "791f4373633bd92263e0630f6bc84f097405ac49b7d8083e07ad6c0796f3b5c1"

URI_aarch64_rust-crossterm+bracketed-paste-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+bracketed-paste-devel-0.28.1-2.el10_1.noarch.rpm;name=aarch64_rust-crossterm+bracketed-paste-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+bracketed-paste-devel}"
SRC_URI[aarch64_rust-crossterm+bracketed-paste-devel.sha256sum] = "0d6a872118f2139574c46907e34776575abad1907f49a5a5c0e10e02e181bed8"

URI_aarch64_rust-crossterm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+default-devel-0.28.1-2.el10_1.noarch.rpm;name=aarch64_rust-crossterm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+default-devel}"
SRC_URI[aarch64_rust-crossterm+default-devel.sha256sum] = "9048a53a8690018095cdf7b6c0576af489a26cf7c1dbb127890051436e514616"

URI_aarch64_rust-crossterm+event-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+event-stream-devel-0.28.1-2.el10_1.noarch.rpm;name=aarch64_rust-crossterm+event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+event-stream-devel}"
SRC_URI[aarch64_rust-crossterm+event-stream-devel.sha256sum] = "348e5bd4c310ea530eefce2dc7a35f1f9a01bec28d453fef5e82307172e830ad"

URI_aarch64_rust-crossterm+events-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+events-devel-0.28.1-2.el10_1.noarch.rpm;name=aarch64_rust-crossterm+events-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+events-devel}"
SRC_URI[aarch64_rust-crossterm+events-devel.sha256sum] = "bc2b3748284c4c869cc970a054c5e7d07509a0a01b7b0d5ede8475c8a4dae791"

URI_aarch64_rust-crossterm+filedescriptor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+filedescriptor-devel-0.28.1-2.el10_1.noarch.rpm;name=aarch64_rust-crossterm+filedescriptor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+filedescriptor-devel}"
SRC_URI[aarch64_rust-crossterm+filedescriptor-devel.sha256sum] = "9b7950352fa53a8baf334982761cbb772a93a1427cbe76173c5de7d93a792396"

URI_aarch64_rust-crossterm+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+libc-devel-0.28.1-2.el10_1.noarch.rpm;name=aarch64_rust-crossterm+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+libc-devel}"
SRC_URI[aarch64_rust-crossterm+libc-devel.sha256sum] = "5ba0fd6135ed54f825707bd3e68365f458303454d32a267ee98b341fff7cc45c"

URI_aarch64_rust-crossterm+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+serde-devel-0.28.1-2.el10_1.noarch.rpm;name=aarch64_rust-crossterm+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+serde-devel}"
SRC_URI[aarch64_rust-crossterm+serde-devel.sha256sum] = "39416a00ee5612468c70b6df715c54236f2510e9cd77901baf5f1b877218970e"

URI_aarch64_rust-crossterm+use-dev-tty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+use-dev-tty-devel-0.28.1-2.el10_1.noarch.rpm;name=aarch64_rust-crossterm+use-dev-tty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+use-dev-tty-devel}"
SRC_URI[aarch64_rust-crossterm+use-dev-tty-devel.sha256sum] = "ef1ea123ff4e0a013c66214705fc6502e5383995e4fdd3b87e0cb0d3cffe24ca"

URI_aarch64_rust-crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm-devel-0.28.1-2.el10_1.noarch.rpm;name=aarch64_rust-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm-devel}"
SRC_URI[aarch64_rust-crossterm-devel.sha256sum] = "03a8d50c4a6b120d20a6e39e2939a23d5dd634594a16d4487452d99403439286"

RDEPENDS:rust-crossterm+bracketed-paste-devel = " \
 cargo \
 rust-crossterm-devel \
 "
RDEPENDS:rust-crossterm+default-devel = " \
 cargo \
 rust-crossterm+bracketed-paste-devel \
 rust-crossterm+events-devel \
 rust-crossterm-devel \
 "
RDEPENDS:rust-crossterm+event-stream-devel = " \
 cargo \
 rust-crossterm+events-devel \
 rust-crossterm-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-crossterm+events-devel = " \
 cargo \
 rust-crossterm-devel \
 rust-mio+default-devel \
 rust-mio+os-poll-devel \
 rust-signal-hook+default-devel \
 rust-signal-hook-mio+default-devel \
 rust-signal-hook-mio+support-v1_0-devel \
 "
RDEPENDS:rust-crossterm+filedescriptor-devel = " \
 cargo \
 rust-crossterm-devel \
 rust-filedescriptor+default-devel \
 "
RDEPENDS:rust-crossterm+libc-devel = " \
 cargo \
 rust-crossterm-devel \
 rust-libc-devel \
 "
RDEPENDS:rust-crossterm+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-crossterm-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-crossterm+use-dev-tty-devel = " \
 cargo \
 rust-crossterm+filedescriptor-devel \
 rust-crossterm-devel \
 rust-rustix0.38+process-devel \
 "
RDEPENDS:rust-crossterm-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-parking_lot+default-devel \
 rust-rustix0.38+std-devel \
 rust-rustix0.38+stdio-devel \
 rust-rustix0.38+termios-devel \
 rust-rustix0.38-devel \
 "
