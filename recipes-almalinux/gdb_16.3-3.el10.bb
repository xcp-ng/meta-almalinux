# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdb"
PV = "16.3"
PR = "3.el10"
PACKAGES = " \
 gdb \
 gdb-doc \
 gdb-gdbserver \
 gdb-headless \
 gdb-minimal \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdb-16.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d96ff67e5602b84c322bf75982d87458f8175bfefda34671c7bd914b5c1bad4"

URI_x86_64_v2_gdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-16.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_gdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdb}"
SRC_URI[x86_64_v2_gdb.sha256sum] = "7ce3f702271175adb17ca56b23d1755b3d2c44ebeb0a8e34d2102bd337709281"

URI_x86_64_v2_gdb-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-doc-16.3-3.el10.noarch.rpm;name=x86_64_v2_gdb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdb-doc}"
SRC_URI[x86_64_v2_gdb-doc.sha256sum] = "4c36cd298200ce03ac3d872eac84d1b95b9e3c2b1ab477716b19898f549d84e1"

URI_x86_64_v2_gdb-gdbserver = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-gdbserver-16.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_gdb-gdbserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdb-gdbserver}"
SRC_URI[x86_64_v2_gdb-gdbserver.sha256sum] = "95414437282d888435048c252d9688a679eebac8d9d7e712ea3f209fc924f374"

URI_x86_64_v2_gdb-headless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-headless-16.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_gdb-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdb-headless}"
SRC_URI[x86_64_v2_gdb-headless.sha256sum] = "8c77b0f67295cce290ffa92446d4cac9f9990ea6896799c31d6c9255589e68f8"
RPROVIDES:gdb-headless:x86_64_v2 = "virtual//usr/bin/gdb-add-index"

URI_x86_64_v2_gdb-minimal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-minimal-16.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_gdb-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdb-minimal}"
SRC_URI[x86_64_v2_gdb-minimal.sha256sum] = "d5bc7bb3ba00d5015fb05c56c2bf4b52751fda4b88753e0c7537ea3eb21ba8f8"
RPROVIDES:gdb-minimal:x86_64_v2 = "virtual//usr/bin/gdb-add-index"

URI_aarch64_gdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-16.3-3.el10.aarch64.rpm;name=aarch64_gdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdb}"
SRC_URI[aarch64_gdb.sha256sum] = "5b2ac577641b7ac8abf02b3845edb12ac358e45bcefc8e80e2fb39550df2c0cb"

URI_aarch64_gdb-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-doc-16.3-3.el10.noarch.rpm;name=aarch64_gdb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdb-doc}"
SRC_URI[aarch64_gdb-doc.sha256sum] = "4c36cd298200ce03ac3d872eac84d1b95b9e3c2b1ab477716b19898f549d84e1"

URI_aarch64_gdb-gdbserver = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-gdbserver-16.3-3.el10.aarch64.rpm;name=aarch64_gdb-gdbserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdb-gdbserver}"
SRC_URI[aarch64_gdb-gdbserver.sha256sum] = "9c43a83b9faaed39795633c29a7cb481fa9fb57d2843b8dd4560c5488ef0db2e"

URI_aarch64_gdb-headless = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-headless-16.3-3.el10.aarch64.rpm;name=aarch64_gdb-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdb-headless}"
SRC_URI[aarch64_gdb-headless.sha256sum] = "997c3a9471ea319d4300ecc8b60290ea89ff1f9541d607a5af1bb49eaff95b9c"
RPROVIDES:gdb-headless:aarch64 = "virtual//usr/bin/gdb-add-index"

URI_aarch64_gdb-minimal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-minimal-16.3-3.el10.aarch64.rpm;name=aarch64_gdb-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdb-minimal}"
SRC_URI[aarch64_gdb-minimal.sha256sum] = "6a8c55962202e5ec53d436fbd7408ed4142df1028738eb6a5e1aa2b16ecbe1fc"
RPROVIDES:gdb-minimal:aarch64 = "virtual//usr/bin/gdb-add-index"

RDEPENDS:gdb = " \
 bash \
 gdb-headless \
 "
RDEPENDS:gdb-doc = " \
 "
RDEPENDS:gdb-gdbserver = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gdb-headless:x86_64_v2 = " \
 bash \
 binutils \
 elfutils-debuginfod-client \
 expat \
 glibc \
 gmp \
 libbabeltrace \
 libgcc \
 libipt \
 libstdc++ \
 mpfr \
 ncurses-libs \
 python3-libs \
 readline \
 source-highlight \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:gdb-headless:aarch64 = " \
 bash \
 binutils \
 elfutils-debuginfod-client \
 expat \
 glibc \
 gmp \
 libbabeltrace \
 libgcc \
 libstdc++ \
 mpfr \
 ncurses-libs \
 python3-libs \
 readline \
 source-highlight \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:gdb-minimal = " \
 bash \
 elfutils-debuginfod-client \
 glibc \
 gmp \
 libgcc \
 libstdc++ \
 mpfr \
 ncurses-libs \
 readline \
 xz-libs \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/gdb-add-index"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/gdb-add-index"
