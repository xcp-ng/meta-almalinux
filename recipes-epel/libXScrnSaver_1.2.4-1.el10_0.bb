# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXScrnSaver"
PV = "1.2.4"
PR = "1.el10_0"
PACKAGES = " \
 libXScrnSaver \
 libXScrnSaver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libXScrnSaver-1.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd736feedbb57952acc3cda397739b3809333c2e8e7b37f4ce1bffe8b3cc567c"

URI_x86_64_v2_libXScrnSaver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXScrnSaver-1.2.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXScrnSaver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXScrnSaver}"
SRC_URI[x86_64_v2_libXScrnSaver.sha256sum] = "5d19e12f37a0f4a520b7749a4535c4fd307a25ccccef320b932843e1b5f3667c"

URI_x86_64_v2_libXScrnSaver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXScrnSaver-devel-1.2.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXScrnSaver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXScrnSaver-devel}"
SRC_URI[x86_64_v2_libXScrnSaver-devel.sha256sum] = "01b532e96b1c9007974032736ee20f4ed4ef7d094155cbb8251e1311e8d0ba5c"

URI_aarch64_libXScrnSaver = "${EPEL_MIRROR}/aarch64/Packages/l/libXScrnSaver-1.2.4-1.el10_0.aarch64.rpm;name=aarch64_libXScrnSaver;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXScrnSaver}"
SRC_URI[aarch64_libXScrnSaver.sha256sum] = "9211ff7b00fca51379b9dc758747cd0aaf15bee0493237aca79c060145960e3d"

URI_aarch64_libXScrnSaver-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libXScrnSaver-devel-1.2.4-1.el10_0.aarch64.rpm;name=aarch64_libXScrnSaver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXScrnSaver-devel}"
SRC_URI[aarch64_libXScrnSaver-devel.sha256sum] = "baf2d30674b98bf392bb098bd94fcab4b7d5053fa35e0d3f1d4caad554f21df7"

RDEPENDS:libXScrnSaver = " \
 glibc \
 libX11 \
 libXext \
 "
RDEPENDS:libXScrnSaver-devel = " \
 libX11-devel \
 libXScrnSaver \
 libXext-devel \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
