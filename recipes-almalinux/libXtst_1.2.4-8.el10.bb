# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXtst"
PV = "1.2.4"
PR = "8.el10"
PACKAGES = " \
 libXtst \
 libXtst-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libXtst-1.2.4-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46e7284fead04bfafff58bb5d9bcc6d283b7b9467567acc271cec15fa0a3bbe2"

URI_x86_64_v2_libXtst = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXtst-1.2.4-8.el10.x86_64_v2.rpm;name=x86_64_v2_libXtst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXtst}"
SRC_URI[x86_64_v2_libXtst.sha256sum] = "d18442acb12779684f5dce6efaa378fe0cfcb7875988840bbc373253a3689723"

URI_x86_64_v2_libXtst-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXtst-devel-1.2.4-8.el10.x86_64_v2.rpm;name=x86_64_v2_libXtst-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXtst-devel}"
SRC_URI[x86_64_v2_libXtst-devel.sha256sum] = "46da9e131da6aa47688afb1402ae93b76ff1ee4a25e01159dbc8bf317782d3c9"

URI_aarch64_libXtst = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXtst-1.2.4-8.el10.aarch64.rpm;name=aarch64_libXtst;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXtst}"
SRC_URI[aarch64_libXtst.sha256sum] = "8ed35b9cc5023c4da9e1f91eb354a5003a0ebfefabc9128233ba97308ec0e2d6"

URI_aarch64_libXtst-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXtst-devel-1.2.4-8.el10.aarch64.rpm;name=aarch64_libXtst-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXtst-devel}"
SRC_URI[aarch64_libXtst-devel.sha256sum] = "89dce69e32e7fad2b645445b8633e610fea516f346125042065eecd74755a1a3"

RDEPENDS:libXtst = " \
 glibc \
 libX11 \
 libXext \
 libXi \
 "
RDEPENDS:libXtst-devel = " \
 libX11-devel \
 libXext-devel \
 libXi-devel \
 libXtst \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
