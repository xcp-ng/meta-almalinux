# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpm-ostree"
PV = "2026.2"
PR = "1.el10"
PACKAGES = " \
 rpm-ostree \
 rpm-ostree-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rpm-ostree-2026.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c51e7e55eaa95b2324a85a374c919436907c45d21846e0ed3948897259eb4ad8"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - rpm-ostree: libcap.so.2()(64bit)

URI_x86_64_v2_rpm-ostree = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-ostree-2026.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_rpm-ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-ostree}"
SRC_URI[x86_64_v2_rpm-ostree.sha256sum] = "f530cd4fd1d05bb9aeb5ce23605828e4e4a611cd2709b31e6dc63247da8675be"

URI_x86_64_v2_rpm-ostree-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-ostree-libs-2026.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_rpm-ostree-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-ostree-libs}"
SRC_URI[x86_64_v2_rpm-ostree-libs.sha256sum] = "44e1199dcc24bd8ff7629a293d931dc6a61acb0671181dc5aa6c9e36c8be6abb"

URI_aarch64_rpm-ostree = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-ostree-2026.2-1.el10.aarch64.rpm;name=aarch64_rpm-ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-ostree}"
SRC_URI[aarch64_rpm-ostree.sha256sum] = "237bc82096c264c4fa7a6fd0f4fbdb0b2f2a71f4370a1957436a7205babca57a"

URI_aarch64_rpm-ostree-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-ostree-libs-2026.2-1.el10.aarch64.rpm;name=aarch64_rpm-ostree-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-ostree-libs}"
SRC_URI[aarch64_rpm-ostree-libs.sha256sum] = "879b3344bb2225b195549c4137ad369ab9b1bf5a686a4ee31b31148fd27edbbf"

RDEPENDS:rpm-ostree:x86_64_v2 = " \
 bash \
 bootc \
 bubblewrap \
 fuse3 \
 glib2 \
 glibc \
 json-c \
 json-glib \
 libarchive \
 libcap \
 libgcc \
 libmodulemd \
 librepo \
 libsolv \
 libstdc++ \
 libzstd \
 openssl-libs \
 ostree \
 ostree-libs \
 polkit-libs \
 rpm-libs \
 rpm-ostree-libs \
 skopeo \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
"
RDEPENDS:rpm-ostree:aarch64 = " \
 bash \
 bootc \
 bubblewrap \
 fuse3 \
 glib2 \
 glibc \
 json-c \
 json-glib \
 libarchive \
 libgcc \
 libmodulemd \
 librepo \
 libsolv \
 libstdc++ \
 libzstd \
 openssl-libs \
 ostree \
 ostree-libs \
 polkit-libs \
 rpm-libs \
 rpm-ostree-libs \
 skopeo \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
"
RDEPENDS:rpm-ostree-libs = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 ostree-libs \
 popt \
 rpm-libs \
 "
