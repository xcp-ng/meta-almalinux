# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crypto-auditing-log-parser"
PV = "0.3.2"
PR = "1.el10"
PACKAGES = " \
 crypto-auditing-log-parser \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-crypto-auditing-log-parser-0.3.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b807226e24d60d7f79cc3162eabb59fb6b6c134e0f0c283938678432ed1cf3a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crypto-auditing-log-parser-0.3.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_crypto-auditing-log-parser;unpack=0"
SRC_URI[x86_64_v2_crypto-auditing-log-parser.sha256sum] = "a3b779968abd95e9a2196474a7ff67ec66518acf119175503b53c7427a045c7c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crypto-auditing-log-parser-0.3.2-1.el10.aarch64.rpm;name=aarch64_crypto-auditing-log-parser;unpack=0"
SRC_URI[aarch64_crypto-auditing-log-parser.sha256sum] = "ebd8548d2187d0dfd712b03a2c403c4226776832c755f108cdc643b84850eaae"

RDEPENDS:crypto-auditing-log-parser = " \
 glibc \
 libgcc \
 "
