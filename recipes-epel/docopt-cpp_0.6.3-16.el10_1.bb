# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "docopt-cpp"
PV = "0.6.3"
PR = "16.el10_1"
PACKAGES = " \
 docopt-cpp \
 docopt-cpp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/docopt-cpp-0.6.3-16.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf8dd16684a77dc78327d51ce7fdca889ca1ce8bb304e9e633793fd96d4f304a"

URI_x86_64_v2_docopt-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/docopt-cpp-0.6.3-16.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_docopt-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_docopt-cpp}"
SRC_URI[x86_64_v2_docopt-cpp.sha256sum] = "4ba534febf6f7e8ace6c3fe9a7ec6dc3d1fbc7707cbb531874c8439293efa22f"

URI_x86_64_v2_docopt-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/docopt-cpp-devel-0.6.3-16.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_docopt-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_docopt-cpp-devel}"
SRC_URI[x86_64_v2_docopt-cpp-devel.sha256sum] = "891d45b892fe8b05eb3efcd7eff2777ebabe885d760f1584560044aecb73087b"

URI_aarch64_docopt-cpp = "${EPEL_MIRROR}/aarch64/Packages/d/docopt-cpp-0.6.3-16.el10_1.aarch64.rpm;name=aarch64_docopt-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_docopt-cpp}"
SRC_URI[aarch64_docopt-cpp.sha256sum] = "fa38d8ee0c37779557475537bf16378de1b68c7ad99b276d434c997775a70675"

URI_aarch64_docopt-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/d/docopt-cpp-devel-0.6.3-16.el10_1.aarch64.rpm;name=aarch64_docopt-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_docopt-cpp-devel}"
SRC_URI[aarch64_docopt-cpp-devel.sha256sum] = "132d694c74890d3ba9335ca475745c64d8400c9deb99ce065ba104883d7e1daa"

RDEPENDS:docopt-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:docopt-cpp-devel = " \
 cmake-filesystem \
 docopt-cpp \
 pkgconf-pkg-config \
 "
