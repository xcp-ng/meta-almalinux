# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blocking"
PV = "1.6.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-blocking+default-devel \
 rust-blocking+tracing-devel \
 rust-blocking-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blocking-1.6.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63a91502f382ac3a85c1c3d6a25936739dec97d1662461dc35f4a57d5e4bd115"

URI_x86_64_v2_rust-blocking+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blocking+default-devel-1.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blocking+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blocking+default-devel}"
SRC_URI[x86_64_v2_rust-blocking+default-devel.sha256sum] = "59dfeacf6e426e6c93aaf8e1a1b16e09cecc3414ede60130ba9d3c0f4e28f5a8"

URI_x86_64_v2_rust-blocking+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blocking+tracing-devel-1.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blocking+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blocking+tracing-devel}"
SRC_URI[x86_64_v2_rust-blocking+tracing-devel.sha256sum] = "165fdc3ae0cd116ff8a510f632761fdb2207f141bd8cf9bf95193f4b18f967f5"

URI_x86_64_v2_rust-blocking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blocking-devel-1.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blocking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blocking-devel}"
SRC_URI[x86_64_v2_rust-blocking-devel.sha256sum] = "0beff590ce8143d49f49ae877ec1badf3e66f98ea1aeb6b28fc73258a1e72367"

URI_aarch64_rust-blocking+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blocking+default-devel-1.6.2-1.el10_0.noarch.rpm;name=aarch64_rust-blocking+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blocking+default-devel}"
SRC_URI[aarch64_rust-blocking+default-devel.sha256sum] = "30af6fce15a5558fcc3c311e28370c566f8a3d92b7d6381c4d2cf109351bacb8"

URI_aarch64_rust-blocking+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blocking+tracing-devel-1.6.2-1.el10_0.noarch.rpm;name=aarch64_rust-blocking+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blocking+tracing-devel}"
SRC_URI[aarch64_rust-blocking+tracing-devel.sha256sum] = "2150ab0d005404b4af7b77039cb64de513637f6e1b469e6f7df828d32fec1266"

URI_aarch64_rust-blocking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blocking-devel-1.6.2-1.el10_0.noarch.rpm;name=aarch64_rust-blocking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blocking-devel}"
SRC_URI[aarch64_rust-blocking-devel.sha256sum] = "299b8ea70a6ae24277c5d147be98c4aa391a68eeacf9c91acbd3c644e2c5ba9d"

RDEPENDS:rust-blocking+default-devel = " \
 cargo \
 rust-blocking-devel \
 "
RDEPENDS:rust-blocking+tracing-devel = " \
 cargo \
 rust-blocking-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-blocking-devel = " \
 cargo \
 rust \
 rust-async-channel+default-devel \
 rust-async-task+default-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-lite-devel \
 rust-piper+default-devel \
 "
