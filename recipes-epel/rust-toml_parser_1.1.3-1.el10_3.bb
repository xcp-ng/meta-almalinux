# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_parser"
PV = "1.1.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-toml_parser+alloc-devel \
 rust-toml_parser+debug-devel \
 rust-toml_parser+default-devel \
 rust-toml_parser+simd-devel \
 rust-toml_parser+std-devel \
 rust-toml_parser+unsafe-devel \
 rust-toml_parser-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-toml_parser-1.1.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a1e59fd36c8c983e395799a41c107f7c026e235f8f598bc9a4eeba3b88d07da4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+alloc-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_parser+alloc-devel.sha256sum] = "ed93c61c873f34e14a43779c6cb44a57446e9ffc41acb974f82d37293d59d693"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+debug-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_parser+debug-devel.sha256sum] = "9e5d1fc978c9f901eecbeea6d4fac85fa8ec399630a799df29e7ffe3b9e9e02d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+default-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_parser+default-devel.sha256sum] = "e8a0a3ee522928c862dbace07da92a9ab52b53aabbc48fed61c3755904fcc795"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+simd-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+simd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_parser+simd-devel.sha256sum] = "c93fc46f04e3bcdeb697525f1b059229e1a07ee6f2dc6237df93ab155a05c1ac"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+std-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_parser+std-devel.sha256sum] = "a76f20decb8880b55391fefabb01e87990d3329674a527ca5862147c763dcdde"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+unsafe-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+unsafe-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_parser+unsafe-devel.sha256sum] = "c3259b25c98db691df43e8a6222db23012202d7677a4dff2928399958c7395a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_parser-devel.sha256sum] = "ec2ae81a792277b5fdec9aa8dd7f8960291e01eb413786a7fa098a11b33d683e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+alloc-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml_parser+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-toml_parser+alloc-devel.sha256sum] = "33521f8f4050ff15524bb7a6a6ca4a5a0e1db4dec4eb0ba333e13006c130f93d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+debug-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml_parser+debug-devel;unpack=0"
SRC_URI[aarch64_rust-toml_parser+debug-devel.sha256sum] = "81b1e6523218db9f2f043089b31c07355e38eff7177d309ce8fe957a8c6e2dd4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+default-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml_parser+default-devel;unpack=0"
SRC_URI[aarch64_rust-toml_parser+default-devel.sha256sum] = "eae15cf99254ecd7fad73a164599cfc89a8ecebb15aa898f98523b243c260eec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+simd-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml_parser+simd-devel;unpack=0"
SRC_URI[aarch64_rust-toml_parser+simd-devel.sha256sum] = "bd896c71bd0b24e510be28c0090b8bbc48b0006bd8f3f899679d22698bde2863"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+std-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml_parser+std-devel;unpack=0"
SRC_URI[aarch64_rust-toml_parser+std-devel.sha256sum] = "d0255d82af60fca83f02e0cad197ace581c4c6bed5177af78139790b4ed7dc27"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+unsafe-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml_parser+unsafe-devel;unpack=0"
SRC_URI[aarch64_rust-toml_parser+unsafe-devel.sha256sum] = "5715b43b35d50e3b70abce8b53a5b56aaff9bd599ff3fd371c5ba6144afc621e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml_parser-devel;unpack=0"
SRC_URI[aarch64_rust-toml_parser-devel.sha256sum] = "cb453a1a16ca59f4b0722bf136a2ee3dce82c108639a49d43300860144c226f9"

RDEPENDS:rust-toml_parser+alloc-devel = " \
 cargo \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml_parser+debug-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-toml_parser+std-devel \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml_parser+default-devel = " \
 cargo \
 rust-toml_parser+std-devel \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml_parser+simd-devel = " \
 cargo \
 rust-toml_parser-devel \
 rust-winnow+simd-devel \
 "
RDEPENDS:rust-toml_parser+std-devel = " \
 cargo \
 rust-toml_parser+alloc-devel \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml_parser+unsafe-devel = " \
 cargo \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml_parser-devel = " \
 cargo \
 rust \
 rust-winnow-devel \
 "
