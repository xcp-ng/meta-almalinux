# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apcupsd"
PV = "3.14.14"
PR = "39.el10_0"
PACKAGES = " \
 apcupsd \
 apcupsd-cgi \
 apcupsd-gui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/apcupsd-3.14.14-39.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9043444a3c6bea08b5dd8f052575e4b8446abafe5acf93d6c4f9fb539839dc52"

URI_x86_64_v2_apcupsd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apcupsd-3.14.14-39.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apcupsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apcupsd}"
SRC_URI[x86_64_v2_apcupsd.sha256sum] = "51396c3da4a8bee06219eb994cd8081dd289e93f9e1974e79dabcd189dda11db"

URI_x86_64_v2_apcupsd-cgi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apcupsd-cgi-3.14.14-39.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apcupsd-cgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apcupsd-cgi}"
SRC_URI[x86_64_v2_apcupsd-cgi.sha256sum] = "555194bd3bed213a4feaee143bae04797a448989beb7732c1c3693791c0f5422"

URI_x86_64_v2_apcupsd-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apcupsd-gui-3.14.14-39.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apcupsd-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apcupsd-gui}"
SRC_URI[x86_64_v2_apcupsd-gui.sha256sum] = "b170a7f0c8e519bce766a667b929e9a67426c28fd7309fba22c72198e9913a9b"

URI_aarch64_apcupsd = "${EPEL_MIRROR}/aarch64/Packages/a/apcupsd-3.14.14-39.el10_0.aarch64.rpm;name=aarch64_apcupsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_apcupsd}"
SRC_URI[aarch64_apcupsd.sha256sum] = "1f351974bcc962b204cecea6659812e787a2db16ba0d8cd176494e316467f266"

URI_aarch64_apcupsd-cgi = "${EPEL_MIRROR}/aarch64/Packages/a/apcupsd-cgi-3.14.14-39.el10_0.aarch64.rpm;name=aarch64_apcupsd-cgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_apcupsd-cgi}"
SRC_URI[aarch64_apcupsd-cgi.sha256sum] = "af65aa326f38f65cd6ed3090328786f82a63f7aca7f052dd1e9d42b8f8e89542"

URI_aarch64_apcupsd-gui = "${EPEL_MIRROR}/aarch64/Packages/a/apcupsd-gui-3.14.14-39.el10_0.aarch64.rpm;name=aarch64_apcupsd-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_apcupsd-gui}"
SRC_URI[aarch64_apcupsd-gui.sha256sum] = "a58f51b9fdf4b4584277c11e2b9650e96db8a04a96ba272622789c555ffb9c95"

RDEPENDS:apcupsd = " \
 bash \
 glibc \
 libstdc++ \
 libusb-compat-0.1 \
 s-nail \
 systemd \
 util-linux \
 "
RDEPENDS:apcupsd-cgi = " \
 apcupsd \
 gd \
 glibc \
 httpd \
 "
RDEPENDS:apcupsd-gui = " \
 GConf2 \
 apcupsd \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 libX11 \
 pango \
 "
