# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager"
PV = "15.10"
PR = "1.el10_2"
PACKAGES = " \
 globus-gram-job-manager \
 globus-seg-job-manager \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-15.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d0e7c2273415dbce267a00397bd8d27ae49de7b193e3b75b7b3f1592b68b9c5"

URI_x86_64_v2_globus-gram-job-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-15.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager}"
SRC_URI[x86_64_v2_globus-gram-job-manager.sha256sum] = "92ff36f1fed3a098db92c67015132998dbb296a30d25c1ea2e9c10a0ad373239"

URI_x86_64_v2_globus-seg-job-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-seg-job-manager-15.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-seg-job-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-seg-job-manager}"
SRC_URI[x86_64_v2_globus-seg-job-manager.sha256sum] = "c12e989b89e392ddf78b0385577754a03d05b1312ce768464c1596cabf9563c1"

URI_aarch64_globus-gram-job-manager = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-15.10-1.el10_2.aarch64.rpm;name=aarch64_globus-gram-job-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager}"
SRC_URI[aarch64_globus-gram-job-manager.sha256sum] = "7fad8c0d6110c7254fc59985529b6a02d40ca947172032b0e1989dcd87295c3f"

URI_aarch64_globus-seg-job-manager = "${EPEL_MIRROR}/aarch64/Packages/g/globus-seg-job-manager-15.10-1.el10_2.aarch64.rpm;name=aarch64_globus-seg-job-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-seg-job-manager}"
SRC_URI[aarch64_globus-seg-job-manager.sha256sum] = "b48ae6a0b6b9505c3d0d6c2056043ae5b1472af56d42d92fd2ec7c0653120edd"

RDEPENDS:globus-gram-job-manager = " \
 bash \
 glibc \
 globus-callout \
 globus-common \
 globus-common-progs \
 globus-gass-cache \
 globus-gass-cache-program \
 globus-gass-copy-progs \
 globus-gass-transfer \
 globus-gatekeeper \
 globus-gram-client-tools \
 globus-gram-job-manager-callout-error \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 globus-gsi-cert-utils-progs \
 globus-gsi-credential \
 globus-gsi-sysconfig \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-proxy-utils \
 globus-rsl \
 globus-scheduler-event-generator \
 globus-seg-job-manager \
 globus-xio \
 globus-xio-popen-driver \
 logrotate \
 openssl-libs \
 "
RDEPENDS:globus-seg-job-manager = " \
 glibc \
 globus-common \
 globus-gram-job-manager \
 globus-scheduler-event-generator \
 "
