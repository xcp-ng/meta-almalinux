# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qatlib"
PV = "26.02.0"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 qatlib \
 qatlib-devel \
 qatlib-service \
 qatlib-tests \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qatlib-26.02.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd6d7f649c463eda6090a37aa756a7ab4a8342b34a5c16eb6ebcac435a48c118"

URI_x86_64_v2_qatlib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatlib-26.02.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatlib}"
SRC_URI[x86_64_v2_qatlib.sha256sum] = "1216571929a3796b8ae01ababd0fa4695d6c7b3751abe33d50bd37a8ffca001f"

URI_x86_64_v2_qatlib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qatlib-devel-26.02.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatlib-devel}"
SRC_URI[x86_64_v2_qatlib-devel.sha256sum] = "e3f396a3113c773fe35c9369d15982e7385b63ec767c3f25beeb16351b0e15cc"

URI_x86_64_v2_qatlib-service = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatlib-service-26.02.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatlib-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatlib-service}"
SRC_URI[x86_64_v2_qatlib-service.sha256sum] = "61dd4e39b89afaac284a371743a69d18bf4d0d54b1aa035761cd3e33198afbf2"

URI_x86_64_v2_qatlib-tests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qatlib-tests-26.02.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatlib-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatlib-tests}"
SRC_URI[x86_64_v2_qatlib-tests.sha256sum] = "f073724e6fd7b8ac6c2c3b129c16bb6b36d29e6b715a02860fa5b4dfeb15b4df"

RDEPENDS:qatlib = " \
 glibc \
 numactl-libs \
 openssl-libs \
 selinux-policy \
 "
RDEPENDS:qatlib-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 qatlib \
 qatlib-devel \
 "
RDEPENDS:qatlib-service = " \
 bash \
 glibc \
 numactl-libs \
 pciutils \
 qatlib \
 systemd \
 "
RDEPENDS:qatlib-tests = " \
 glibc \
 openssl-libs \
 qatlib \
 zlib-ng-compat \
 "
