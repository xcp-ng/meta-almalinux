# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qcoro"
PV = "0.11.0"
PR = "2.el10_1"
PACKAGES = " \
 qcoro-qt5 \
 qcoro-qt5-devel \
 qcoro-qt6 \
 qcoro-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qcoro-0.11.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80f392ac699248ad150c29330aee705916a055cfc64efca3dd06060a95696f96"

URI_x86_64_v2_qcoro-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcoro-qt5-0.11.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcoro-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcoro-qt5}"
SRC_URI[x86_64_v2_qcoro-qt5.sha256sum] = "a684ad6ee8629fbeca7d012c97a5889f65ac2d5dfccde6272a013bb48c190c48"

URI_x86_64_v2_qcoro-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcoro-qt5-devel-0.11.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcoro-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcoro-qt5-devel}"
SRC_URI[x86_64_v2_qcoro-qt5-devel.sha256sum] = "94d75d2c0533f3f18e72dfa6ddf0ddc203f55ced0c07f6c39ebd09e055086973"

URI_x86_64_v2_qcoro-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcoro-qt6-0.11.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcoro-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcoro-qt6}"
SRC_URI[x86_64_v2_qcoro-qt6.sha256sum] = "c76b584db83d60dc4f4942356c2c561ef448b2c15a40c980143e80c702afc750"

URI_x86_64_v2_qcoro-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcoro-qt6-devel-0.11.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcoro-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcoro-qt6-devel}"
SRC_URI[x86_64_v2_qcoro-qt6-devel.sha256sum] = "6c7c9469d2a7aa05335ecc825eea24babdb190826d8ba3137bb82daec2f4e15d"

URI_aarch64_qcoro-qt5 = "${EPEL_MIRROR}/aarch64/Packages/q/qcoro-qt5-0.11.0-2.el10_1.aarch64.rpm;name=aarch64_qcoro-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcoro-qt5}"
SRC_URI[aarch64_qcoro-qt5.sha256sum] = "9c84b0917de38042ddda9371b2f20280c8fea1209185c6dd97c97ffdcd3d3195"

URI_aarch64_qcoro-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qcoro-qt5-devel-0.11.0-2.el10_1.aarch64.rpm;name=aarch64_qcoro-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcoro-qt5-devel}"
SRC_URI[aarch64_qcoro-qt5-devel.sha256sum] = "57b9f4e5109c0d83014af54e185ba56e7590afb2ee2bed038a5a51af3b500912"

URI_aarch64_qcoro-qt6 = "${EPEL_MIRROR}/aarch64/Packages/q/qcoro-qt6-0.11.0-2.el10_1.aarch64.rpm;name=aarch64_qcoro-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcoro-qt6}"
SRC_URI[aarch64_qcoro-qt6.sha256sum] = "fbb9d2891871e90dd9a4d319c82b914debca4e93a875459676a9af50022fe20c"

URI_aarch64_qcoro-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qcoro-qt6-devel-0.11.0-2.el10_1.aarch64.rpm;name=aarch64_qcoro-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcoro-qt6-devel}"
SRC_URI[aarch64_qcoro-qt6-devel.sha256sum] = "d531ad669944c946f3d65d82d2ed3d3a6bf298e4f0b85314616a4452888ed978"

RDEPENDS:qcoro-qt5 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtwebsockets \
 "
RDEPENDS:qcoro-qt5-devel = " \
 cmake-filesystem \
 qcoro-qt5 \
 qt5-qtbase-devel \
 "
RDEPENDS:qcoro-qt6 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 "
RDEPENDS:qcoro-qt6-devel = " \
 cmake-filesystem \
 qcoro-qt6 \
 qt6-qtbase-devel \
 "
