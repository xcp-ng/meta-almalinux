# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-syn1"
PV = "1.0.109"
PR = "4.el10_0"
PACKAGES = " \
 rust-syn1+clone-impls-devel \
 rust-syn1+default-devel \
 rust-syn1+derive-devel \
 rust-syn1+extra-traits-devel \
 rust-syn1+fold-devel \
 rust-syn1+full-devel \
 rust-syn1+parsing-devel \
 rust-syn1+printing-devel \
 rust-syn1+proc-macro-devel \
 rust-syn1+quote-devel \
 rust-syn1+test-devel \
 rust-syn1+visit-devel \
 rust-syn1+visit-mut-devel \
 rust-syn1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-syn1-1.0.109-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85c87a7786a08ebb29f931d08c4e30520fc251fe21ac13c5b6e3d467453caa3e"

URI_x86_64_v2_rust-syn1+clone-impls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn1+clone-impls-devel-1.0.109-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn1+clone-impls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn1+clone-impls-devel}"
SRC_URI[x86_64_v2_rust-syn1+clone-impls-devel.sha256sum] = "8c08039cff17357eaae3b26890d203ecfeac56758766242f943734bb773587f4"

URI_x86_64_v2_rust-syn1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn1+default-devel-1.0.109-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn1+default-devel}"
SRC_URI[x86_64_v2_rust-syn1+default-devel.sha256sum] = "c6d0545b84ebd009d237d7bda2b7ea0f355188f597b2d32cf49a2e8f0145b6a4"

URI_x86_64_v2_rust-syn1+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn1+derive-devel-1.0.109-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn1+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn1+derive-devel}"
SRC_URI[x86_64_v2_rust-syn1+derive-devel.sha256sum] = "2638ee829f686abd905a8b4695591d291ae8963572c5b621943a65067a69b2ec"

URI_x86_64_v2_rust-syn1+extra-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn1+extra-traits-devel-1.0.109-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn1+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn1+extra-traits-devel}"
SRC_URI[x86_64_v2_rust-syn1+extra-traits-devel.sha256sum] = "6535599caf55693be33f265fe43485379db30be1c3534dce847847d141f1df28"

URI_x86_64_v2_rust-syn1+fold-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn1+fold-devel-1.0.109-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn1+fold-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn1+fold-devel}"
SRC_URI[x86_64_v2_rust-syn1+fold-devel.sha256sum] = "b8b17a218073e328bb1a62d34db6fd77f6c3111f563c5ef2450ba6dbac896110"

URI_x86_64_v2_rust-syn1+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn1+full-devel-1.0.109-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn1+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn1+full-devel}"
SRC_URI[x86_64_v2_rust-syn1+full-devel.sha256sum] = "8f6cd243ab858db51378cbbf17e73924005ca703e56f853bdbc77905fd6055d0"

URI_x86_64_v2_rust-syn1+parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn1+parsing-devel-1.0.109-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn1+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn1+parsing-devel}"
SRC_URI[x86_64_v2_rust-syn1+parsing-devel.sha256sum] = "6b85b2cb086737ff6d194d22c98e1d037474ca37bccbefb420d414452602dd99"

URI_x86_64_v2_rust-syn1+printing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn1+printing-devel-1.0.109-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn1+printing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn1+printing-devel}"
SRC_URI[x86_64_v2_rust-syn1+printing-devel.sha256sum] = "5d18faa9d70f47b5c095f6c57004c8f0314eb13352b4e495556136373c97186c"

URI_x86_64_v2_rust-syn1+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn1+proc-macro-devel-1.0.109-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn1+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn1+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-syn1+proc-macro-devel.sha256sum] = "ce71dd675311e792e775393eb34ebdfbaf40c0a15e963a9a39331c0cc1cf5035"

URI_x86_64_v2_rust-syn1+quote-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn1+quote-devel-1.0.109-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn1+quote-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn1+quote-devel}"
SRC_URI[x86_64_v2_rust-syn1+quote-devel.sha256sum] = "7fcf3539a9e499ca771446fc420ccd249e142b52509284e7fe203992a79c1114"

URI_x86_64_v2_rust-syn1+test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn1+test-devel-1.0.109-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn1+test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn1+test-devel}"
SRC_URI[x86_64_v2_rust-syn1+test-devel.sha256sum] = "23a9b77a0d16c898a5a89c0a1db6866af5375635fca3d184ab1494d5d99e62bf"

URI_x86_64_v2_rust-syn1+visit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn1+visit-devel-1.0.109-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn1+visit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn1+visit-devel}"
SRC_URI[x86_64_v2_rust-syn1+visit-devel.sha256sum] = "208867a580d3cc8ceaad6f8d5a45b823c6e629c74a76b11fa79a232687ce792e"

URI_x86_64_v2_rust-syn1+visit-mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn1+visit-mut-devel-1.0.109-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn1+visit-mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn1+visit-mut-devel}"
SRC_URI[x86_64_v2_rust-syn1+visit-mut-devel.sha256sum] = "2ba108b688f86b6e3461ac760c9ad7d441fc377ef6a0c280902943ea7922e44a"

URI_x86_64_v2_rust-syn1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn1-devel-1.0.109-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn1-devel}"
SRC_URI[x86_64_v2_rust-syn1-devel.sha256sum] = "cfb30452058831c36e8ffb7e88c053878ac497225b0f6c2b985781ccee824fb2"

URI_aarch64_rust-syn1+clone-impls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn1+clone-impls-devel-1.0.109-4.el10_0.noarch.rpm;name=aarch64_rust-syn1+clone-impls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn1+clone-impls-devel}"
SRC_URI[aarch64_rust-syn1+clone-impls-devel.sha256sum] = "bfa164108b87cd8ef8e6b72c1ffcec4aa232544408150c852dca4419a0a6c2c3"

URI_aarch64_rust-syn1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn1+default-devel-1.0.109-4.el10_0.noarch.rpm;name=aarch64_rust-syn1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn1+default-devel}"
SRC_URI[aarch64_rust-syn1+default-devel.sha256sum] = "fd75928e4c5a0bd09d32aac7561cf4133b6a11029ea9a536df71267c0f01e003"

URI_aarch64_rust-syn1+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn1+derive-devel-1.0.109-4.el10_0.noarch.rpm;name=aarch64_rust-syn1+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn1+derive-devel}"
SRC_URI[aarch64_rust-syn1+derive-devel.sha256sum] = "531fdaeadb7bed8b46a42bd0efc7fe672399049600336e513530ced4ffc1a16d"

URI_aarch64_rust-syn1+extra-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn1+extra-traits-devel-1.0.109-4.el10_0.noarch.rpm;name=aarch64_rust-syn1+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn1+extra-traits-devel}"
SRC_URI[aarch64_rust-syn1+extra-traits-devel.sha256sum] = "9d779f99088fad306b900f84ea9823e2354d24f044c07505ebcfbcb374eef0fa"

URI_aarch64_rust-syn1+fold-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn1+fold-devel-1.0.109-4.el10_0.noarch.rpm;name=aarch64_rust-syn1+fold-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn1+fold-devel}"
SRC_URI[aarch64_rust-syn1+fold-devel.sha256sum] = "9a38b216b2864ebccca4e7f81d79d76b50444237aea64dc02129ef9bec868be0"

URI_aarch64_rust-syn1+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn1+full-devel-1.0.109-4.el10_0.noarch.rpm;name=aarch64_rust-syn1+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn1+full-devel}"
SRC_URI[aarch64_rust-syn1+full-devel.sha256sum] = "9d341142493bb6fa0d2a797735e978dfb18132e19f2e49e01c45c20f423e33b5"

URI_aarch64_rust-syn1+parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn1+parsing-devel-1.0.109-4.el10_0.noarch.rpm;name=aarch64_rust-syn1+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn1+parsing-devel}"
SRC_URI[aarch64_rust-syn1+parsing-devel.sha256sum] = "5147577103430e8b74c7726d01999df0768b93dffd749634e4d7772d0e93e11d"

URI_aarch64_rust-syn1+printing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn1+printing-devel-1.0.109-4.el10_0.noarch.rpm;name=aarch64_rust-syn1+printing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn1+printing-devel}"
SRC_URI[aarch64_rust-syn1+printing-devel.sha256sum] = "f1849b762c8a1a10d992e30755e55145806a0198cfdc5e78a6dadbe26e9e945d"

URI_aarch64_rust-syn1+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn1+proc-macro-devel-1.0.109-4.el10_0.noarch.rpm;name=aarch64_rust-syn1+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn1+proc-macro-devel}"
SRC_URI[aarch64_rust-syn1+proc-macro-devel.sha256sum] = "c36a902d3e2bfd15734d3a617a14e18ee77ac7d482a1deb1f34cf98d3b9a8a81"

URI_aarch64_rust-syn1+quote-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn1+quote-devel-1.0.109-4.el10_0.noarch.rpm;name=aarch64_rust-syn1+quote-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn1+quote-devel}"
SRC_URI[aarch64_rust-syn1+quote-devel.sha256sum] = "912587894c6299b21dea6cd5515c1ed2dcd53b4a313cfe625be55018809d9d7e"

URI_aarch64_rust-syn1+test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn1+test-devel-1.0.109-4.el10_0.noarch.rpm;name=aarch64_rust-syn1+test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn1+test-devel}"
SRC_URI[aarch64_rust-syn1+test-devel.sha256sum] = "bba33794264ae9a283121a13118274a9479cd6bdb3515835467d735b4235f34a"

URI_aarch64_rust-syn1+visit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn1+visit-devel-1.0.109-4.el10_0.noarch.rpm;name=aarch64_rust-syn1+visit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn1+visit-devel}"
SRC_URI[aarch64_rust-syn1+visit-devel.sha256sum] = "05a4c915d3252275ce94574be6f0f67561b75e773541572ba274a163b1880df4"

URI_aarch64_rust-syn1+visit-mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn1+visit-mut-devel-1.0.109-4.el10_0.noarch.rpm;name=aarch64_rust-syn1+visit-mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn1+visit-mut-devel}"
SRC_URI[aarch64_rust-syn1+visit-mut-devel.sha256sum] = "262b3b3ab35972d5a43ad03b9b8668e00435bc7fea8048feb84948e42d7b9e09"

URI_aarch64_rust-syn1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn1-devel-1.0.109-4.el10_0.noarch.rpm;name=aarch64_rust-syn1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn1-devel}"
SRC_URI[aarch64_rust-syn1-devel.sha256sum] = "fe8b2d389f9684111e3b0a92b703a3dcbf6004b1832d6b2c88d659b2015ef86b"

RDEPENDS:rust-syn1+clone-impls-devel = " \
 cargo \
 rust-syn1-devel \
 "
RDEPENDS:rust-syn1+default-devel = " \
 cargo \
 rust-syn1+clone-impls-devel \
 rust-syn1+derive-devel \
 rust-syn1+parsing-devel \
 rust-syn1+printing-devel \
 rust-syn1+proc-macro-devel \
 rust-syn1-devel \
 "
RDEPENDS:rust-syn1+derive-devel = " \
 cargo \
 rust-syn1-devel \
 "
RDEPENDS:rust-syn1+extra-traits-devel = " \
 cargo \
 rust-syn1-devel \
 "
RDEPENDS:rust-syn1+fold-devel = " \
 cargo \
 rust-syn1-devel \
 "
RDEPENDS:rust-syn1+full-devel = " \
 cargo \
 rust-syn1-devel \
 "
RDEPENDS:rust-syn1+parsing-devel = " \
 cargo \
 rust-syn1-devel \
 "
RDEPENDS:rust-syn1+printing-devel = " \
 cargo \
 rust-syn1+quote-devel \
 rust-syn1-devel \
 "
RDEPENDS:rust-syn1+proc-macro-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn1-devel \
 "
RDEPENDS:rust-syn1+quote-devel = " \
 cargo \
 rust-quote-devel \
 rust-syn1-devel \
 "
RDEPENDS:rust-syn1+test-devel = " \
 cargo \
 rust-syn1-devel \
 "
RDEPENDS:rust-syn1+visit-devel = " \
 cargo \
 rust-syn1-devel \
 "
RDEPENDS:rust-syn1+visit-mut-devel = " \
 cargo \
 rust-syn1-devel \
 "
RDEPENDS:rust-syn1-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-unicode-ident+default-devel \
 "
