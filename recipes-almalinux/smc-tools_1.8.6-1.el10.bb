# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "smc-tools"
PV = "1.8.6"
PR = "1.el10"
PACKAGES = " \
 smc-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/smc-tools-1.8.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1526223c6c8e9ca38cc3e6c96eed98324ca6f0282e735d6cae02033ea6733155"

URI_x86_64_v2_smc-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/smc-tools-1.8.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_smc-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_smc-tools}"
SRC_URI[x86_64_v2_smc-tools.sha256sum] = "1a88de012245f87aea6ca5086c4f2c715a0806999e7a29347badb2af035ea9e1"

URI_aarch64_smc-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/smc-tools-1.8.6-1.el10.aarch64.rpm;name=aarch64_smc-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_smc-tools}"
SRC_URI[aarch64_smc-tools.sha256sum] = "2be315004a6a096fb84c1bca302a60587f01afc4faff15a346668a30be1b414b"

RDEPENDS:smc-tools = " \
 bash \
 glibc \
 libnl3 \
 "
