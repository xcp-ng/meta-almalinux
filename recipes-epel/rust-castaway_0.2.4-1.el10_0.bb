# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-castaway"
PV = "0.2.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-castaway+alloc-devel \
 rust-castaway+default-devel \
 rust-castaway+std-devel \
 rust-castaway-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-castaway-0.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27bac981403e6d3743d1b9906b6ad1fd1336e27665e977f08a5ed2bbe894f11d"

URI_x86_64_v2_rust-castaway+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-castaway+alloc-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-castaway+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-castaway+alloc-devel}"
SRC_URI[x86_64_v2_rust-castaway+alloc-devel.sha256sum] = "92b0836720c25b3c009ef2b0b6bddacd62cffd2572bc5027691e98f655314046"

URI_x86_64_v2_rust-castaway+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-castaway+default-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-castaway+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-castaway+default-devel}"
SRC_URI[x86_64_v2_rust-castaway+default-devel.sha256sum] = "3d8e151a38d88e658e89a0d40764cf43a171a397782c7e24b2466879c7121d0a"

URI_x86_64_v2_rust-castaway+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-castaway+std-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-castaway+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-castaway+std-devel}"
SRC_URI[x86_64_v2_rust-castaway+std-devel.sha256sum] = "f587125fd3d4944f82a6425e471168ab34e72c1d0b75a799a4a39c00fcc2a44e"

URI_x86_64_v2_rust-castaway-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-castaway-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-castaway-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-castaway-devel}"
SRC_URI[x86_64_v2_rust-castaway-devel.sha256sum] = "085651668bbaa0c54c1b2e48964381edd5cd4dad9c79764ee00a77591a422100"

URI_aarch64_rust-castaway+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-castaway+alloc-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-castaway+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-castaway+alloc-devel}"
SRC_URI[aarch64_rust-castaway+alloc-devel.sha256sum] = "868a4587a0ac8f932a11097d4368fd853acbfadd03f817396d75f11b35c93f08"

URI_aarch64_rust-castaway+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-castaway+default-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-castaway+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-castaway+default-devel}"
SRC_URI[aarch64_rust-castaway+default-devel.sha256sum] = "45b8d27c7042c6a8fa112500cdb0397a5f218560d321a480f8a4491e7d8456d6"

URI_aarch64_rust-castaway+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-castaway+std-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-castaway+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-castaway+std-devel}"
SRC_URI[aarch64_rust-castaway+std-devel.sha256sum] = "60a7db89c68d464bb99dd15f51c59c570a45c1ac9196d36ff3c5f99d904c5f24"

URI_aarch64_rust-castaway-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-castaway-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-castaway-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-castaway-devel}"
SRC_URI[aarch64_rust-castaway-devel.sha256sum] = "db0526c9923b6887a32dc9c4ad2c0c3215aa0b56e826cf96bbd93376ad4b2866"

RDEPENDS:rust-castaway+alloc-devel = " \
 cargo \
 rust-castaway-devel \
 "
RDEPENDS:rust-castaway+default-devel = " \
 cargo \
 rust-castaway+std-devel \
 rust-castaway-devel \
 "
RDEPENDS:rust-castaway+std-devel = " \
 cargo \
 rust-castaway+alloc-devel \
 rust-castaway-devel \
 "
RDEPENDS:rust-castaway-devel = " \
 cargo \
 rust-rustversion+default-devel \
 "
