# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yascreen"
PV = "2.14"
PR = "1.el10_3"
PACKAGES = " \
 yascreen \
 yascreen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yascreen-2.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29f0207b724e9a06f7997a45ea193a7b755c33ad28d1dfe659e38dd69f094d82"

URI_x86_64_v2_yascreen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yascreen-2.14-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yascreen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yascreen}"
SRC_URI[x86_64_v2_yascreen.sha256sum] = "8b342721c0195ade786720e513fa43bbae02f0a5dac348bdbaa78370bec10c10"

URI_x86_64_v2_yascreen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yascreen-devel-2.14-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yascreen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yascreen-devel}"
SRC_URI[x86_64_v2_yascreen-devel.sha256sum] = "ad0c414213864429cf4376626f0fe911c90f73edc3d46b507d18c2ebf2c544e7"

URI_aarch64_yascreen = "${EPEL_MIRROR}/aarch64/Packages/y/yascreen-2.14-1.el10_3.aarch64.rpm;name=aarch64_yascreen;unpack=0"
SRC_URI:append = " ${URI_aarch64_yascreen}"
SRC_URI[aarch64_yascreen.sha256sum] = "50f11b532c6eb403b3de1435d58dc7146cbe291b5edba5b818b7f2add4302bd8"

URI_aarch64_yascreen-devel = "${EPEL_MIRROR}/aarch64/Packages/y/yascreen-devel-2.14-1.el10_3.aarch64.rpm;name=aarch64_yascreen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yascreen-devel}"
SRC_URI[aarch64_yascreen-devel.sha256sum] = "4eda3e5be2019a387006033935a4cac572dafdf6fc939a9b9e7dc6e19bbe2a8a"

RDEPENDS:yascreen = " \
 glibc \
 "
RDEPENDS:yascreen-devel = " \
 pkgconf-pkg-config \
 yascreen \
 "
