# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtgrpc"
PV = "6.9.1"
PR = "1.el10_1"
PACKAGES = " \
 qt6-qtgrpc \
 qt6-qtgrpc-devel \
 qt6-qtgrpc-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtgrpc-6.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "738a9673b66ea49d73f8247232074b5866258ebae819b4ecba2a133340578368"

URI_x86_64_v2_qt6-qtgrpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgrpc-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgrpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgrpc}"
SRC_URI[x86_64_v2_qt6-qtgrpc.sha256sum] = "7265241dc6ad49235b9bd7fc157dcf1e635f63dd5aed0a6518cbd0705317c9b4"

URI_x86_64_v2_qt6-qtgrpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgrpc-devel-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgrpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgrpc-devel}"
SRC_URI[x86_64_v2_qt6-qtgrpc-devel.sha256sum] = "882bd0af9ba0e3b41f29cbeb9e7bbd915ddcc0a8346422fbe60d0c02ba7d377f"

URI_x86_64_v2_qt6-qtgrpc-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgrpc-examples-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgrpc-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgrpc-examples}"
SRC_URI[x86_64_v2_qt6-qtgrpc-examples.sha256sum] = "57ef476eb68278c70ef9e154103125adbedab45ea96c0de28868907535d82b7a"

URI_aarch64_qt6-qtgrpc = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgrpc-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtgrpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgrpc}"
SRC_URI[aarch64_qt6-qtgrpc.sha256sum] = "ded03f4719f9033039b264801c5f4a2f6f7501e3c66156102b787df1c879cacb"

URI_aarch64_qt6-qtgrpc-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgrpc-devel-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtgrpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgrpc-devel}"
SRC_URI[aarch64_qt6-qtgrpc-devel.sha256sum] = "9e9b72f1e1722859760e3b23b368dc6cb33b40b168328bd490c5f16142999a1b"

URI_aarch64_qt6-qtgrpc-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgrpc-examples-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtgrpc-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgrpc-examples}"
SRC_URI[aarch64_qt6-qtgrpc-examples.sha256sum] = "4e1546c718cdc88f8dee05ea43a50b32981ead8950f6ae0732eb16085eaa55d6"

RDEPENDS:qt6-qtgrpc = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtgrpc-devel = " \
 cmake-filesystem \
 glibc \
 grpc-devel \
 libgcc \
 libstdc++ \
 pkgconf-pkg-config \
 protobuf \
 protobuf-compiler \
 protobuf-devel \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtgrpc \
 qt6-qtgrpc-devel \
 "
RDEPENDS:qt6-qtgrpc-examples = " \
 abseil-cpp \
 bash \
 glibc \
 grpc \
 grpc-cpp \
 libgcc \
 libstdc++ \
 protobuf \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtgrpc \
 "
