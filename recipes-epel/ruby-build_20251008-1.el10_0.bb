# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby-build"
PV = "20251008"
PR = "1.el10_0"
PACKAGES = " \
 ruby-build \
 ruby-build-rbenv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/ruby-build-20251008-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eaf98bf8e2e2996753b439e1cbb7f6c594fec3417586b9381030125b96a619ea"

URI_x86_64_v2_ruby-build = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-20251008-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ruby-build;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build}"
SRC_URI[x86_64_v2_ruby-build.sha256sum] = "b4c070a54c823518c52f53b4a9a774a22746c588b8d8326419510bab178263bb"

URI_x86_64_v2_ruby-build-rbenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-rbenv-20251008-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ruby-build-rbenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-rbenv}"
SRC_URI[x86_64_v2_ruby-build-rbenv.sha256sum] = "d605774f53460ff7053de1f0396362b423492c5b55335e3a43062b1c9c4f64a7"

URI_aarch64_ruby-build = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-20251008-1.el10_0.aarch64.rpm;name=aarch64_ruby-build;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build}"
SRC_URI[aarch64_ruby-build.sha256sum] = "a416adca3858afa12baa04afa5fb18359f46955f8ded42122d80771114f9c74a"

URI_aarch64_ruby-build-rbenv = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-rbenv-20251008-1.el10_0.aarch64.rpm;name=aarch64_ruby-build-rbenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-rbenv}"
SRC_URI[aarch64_ruby-build-rbenv.sha256sum] = "37bc7e94ce5c5e2c7890fdcb2f8bc5494aad5fd2cacb1c1210c0850f28df28ab"

RDEPENDS:ruby-build = " \
 bash \
 "
RDEPENDS:ruby-build-rbenv = " \
 bash \
 rbenv \
 ruby-build \
 "
