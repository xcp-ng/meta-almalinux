# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clifm"
PV = "1.28"
PR = "1.el10_2"
PACKAGES = " \
 clifm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clifm-1.28-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a6d9a4886029169b17c83656fa7c9ed922bcf8731c46c96bce6ff49ad841af1"

URI_x86_64_v2_clifm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clifm-1.28-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clifm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clifm}"
SRC_URI[x86_64_v2_clifm.sha256sum] = "d83986dc0fdcc5c7809a76101e3e03645b3b43bf5b93cd41be860735faaa34f5"

URI_aarch64_clifm = "${EPEL_MIRROR}/aarch64/Packages/c/clifm-1.28-1.el10_2.aarch64.rpm;name=aarch64_clifm;unpack=0"
SRC_URI:append = " ${URI_aarch64_clifm}"
SRC_URI[aarch64_clifm.sha256sum] = "18665d76a0678b5459c8c74bfc33e625ae40e29f2d108a5a9a81c74d0e12509d"

RDEPENDS:clifm = " \
 bash \
 file-libs \
 glibc \
 hicolor-icon-theme \
 libacl \
 libcap \
 python3 \
 readline \
 "
