# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aer-inject"
PV = "0^20240730git"
PR = "1.el10_1"
PACKAGES = " \
 aer-inject \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/aer-inject-0^20240730git-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d7af1ed2a23ac8a5305fda80f31f76eef532da71c5b355a6219719f6512de87b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aer-inject-0^20240730git-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aer-inject;unpack=0"
SRC_URI[x86_64_v2_aer-inject.sha256sum] = "303a8c42f980c1f560861c1f8a9d06a18f1e19cd9ced7671ac7712ec00ce9c9a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/aer-inject-0^20240730git-1.el10_1.aarch64.rpm;name=aarch64_aer-inject;unpack=0"
SRC_URI[aarch64_aer-inject.sha256sum] = "e9839c94b2c6cbb7fdfc2ff7f97b2b30a358ae0b592f4c034abe6611aaf50815"

RDEPENDS:aer-inject = " \
 glibc \
 "
