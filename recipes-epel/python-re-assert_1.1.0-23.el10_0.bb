# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-re-assert"
PV = "1.1.0"
PR = "23.el10_0"
PACKAGES = " \
 python3-re-assert \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-re-assert-1.1.0-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b4fd41ad9f188b675fe96dff8f802a1c2f588f501ec0eb027c3204a0be5b6c0c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-re-assert-1.1.0-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-re-assert;unpack=0"
SRC_URI[x86_64_v2_python3-re-assert.sha256sum] = "1133de463178ddcfb75ad9f97fbd54fb8a8463ae5aadc925add0944e12722050"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-re-assert-1.1.0-23.el10_0.noarch.rpm;name=aarch64_python3-re-assert;unpack=0"
SRC_URI[aarch64_python3-re-assert.sha256sum] = "090615c29662005be810c804e1f6fc87b79e95ff81abd88a9218272ce5e94691"

RDEPENDS:python3-re-assert = " \
 python3 \
 python3-regex \
 "
