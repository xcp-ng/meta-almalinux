# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-filesystem \
 kf6-rpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddc763b1b99ef9e7f529ee91e2813452a652557711c365b51e4772b000e0ff84"

URI_x86_64_v2_kf6-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-filesystem-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-filesystem}"
SRC_URI[x86_64_v2_kf6-filesystem.sha256sum] = "c4764c906f1c3b0292fe5aeab5d276fc00e49a9b613eddfb87adbc0d5f6b6023"

URI_x86_64_v2_kf6-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-rpm-macros-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-rpm-macros}"
SRC_URI[x86_64_v2_kf6-rpm-macros.sha256sum] = "45a3400bca59f2eb4e5f7ea8ef148146c9b320a23af1705f9e8a118a6dfc00ab"

URI_aarch64_kf6-filesystem = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-filesystem-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-filesystem}"
SRC_URI[aarch64_kf6-filesystem.sha256sum] = "1a47d8d88361f918ce502cd07c8e416b78b0da454aa7ca19e0660051157974ff"

URI_aarch64_kf6-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-rpm-macros-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-rpm-macros}"
SRC_URI[aarch64_kf6-rpm-macros.sha256sum] = "3b39a3de4d443a1ecfb4b62891d0acf06d77746a2efdb971b58a3d2d801f1cac"

RDEPENDS:kf6-filesystem = " \
 kde-filesystem \
 "
RDEPENDS:kf6-rpm-macros = " \
 cmake \
 doxygen \
 gcc-c++ \
 kde-qdoc-common \
 qt6-doc-devel \
 qt6-qttools-devel \
 qt6-rpm-macros \
 "
