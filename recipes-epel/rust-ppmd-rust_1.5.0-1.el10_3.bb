# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ppmd-rust"
PV = "1.5.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-ppmd-rust+default-devel \
 rust-ppmd-rust-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-ppmd-rust-1.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ffa542052d2f6e8b65dc414f5dd9f552365249433c5427f1a35402898674a3e6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ppmd-rust+default-devel-1.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ppmd-rust+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ppmd-rust+default-devel.sha256sum] = "12c20879a0ae48a66ff17b76269f06af602bd5687ca7ef89c3d7c64b8c2df0c6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ppmd-rust-devel-1.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ppmd-rust-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ppmd-rust-devel.sha256sum] = "3b6250cee7eb442343d6f755b133f1923e398173837f9fa5a69eba4911c8e75d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ppmd-rust+default-devel-1.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-ppmd-rust+default-devel;unpack=0"
SRC_URI[aarch64_rust-ppmd-rust+default-devel.sha256sum] = "aebbf5397f16e475dd7383c9275181ff25110433e39400eff5eb4e0298011233"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ppmd-rust-devel-1.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-ppmd-rust-devel;unpack=0"
SRC_URI[aarch64_rust-ppmd-rust-devel.sha256sum] = "4468ba709016e4dc8c49ee206889dbb17e78bfb34bedd83f3fbb55e6e6ae8343"

RDEPENDS:rust-ppmd-rust+default-devel = " \
 cargo \
 rust-ppmd-rust-devel \
 "
RDEPENDS:rust-ppmd-rust-devel = " \
 cargo \
 rust \
 "
