# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-streaming-iterator"
PV = "0.1.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-streaming-iterator+alloc-devel \
 rust-streaming-iterator+default-devel \
 rust-streaming-iterator+std-devel \
 rust-streaming-iterator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-streaming-iterator-0.1.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ea593a1a79d8f51eff51b75899c904ec239107613cc4a907304d7d357b529b7"

URI_x86_64_v2_rust-streaming-iterator+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streaming-iterator+alloc-devel-0.1.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streaming-iterator+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streaming-iterator+alloc-devel}"
SRC_URI[x86_64_v2_rust-streaming-iterator+alloc-devel.sha256sum] = "7d300998ae34c6d9310040386e604f7f0d74ea38cd391fe0d14b30aec26446b1"

URI_x86_64_v2_rust-streaming-iterator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streaming-iterator+default-devel-0.1.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streaming-iterator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streaming-iterator+default-devel}"
SRC_URI[x86_64_v2_rust-streaming-iterator+default-devel.sha256sum] = "5dc0c9f25ad9eecab5304aa0cb01f21f0fb6aa302bf28b47f0b2353c98f78d6b"

URI_x86_64_v2_rust-streaming-iterator+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streaming-iterator+std-devel-0.1.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streaming-iterator+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streaming-iterator+std-devel}"
SRC_URI[x86_64_v2_rust-streaming-iterator+std-devel.sha256sum] = "6102bd59c12a67c0ad566ae648ceefc4c93ad3200a4c4bd023915fd742a420f2"

URI_x86_64_v2_rust-streaming-iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streaming-iterator-devel-0.1.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streaming-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streaming-iterator-devel}"
SRC_URI[x86_64_v2_rust-streaming-iterator-devel.sha256sum] = "e47bd051b7ab99f3b4ddb9a04a97ee895c0886f0161c9c33a25b738415456282"

URI_aarch64_rust-streaming-iterator+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streaming-iterator+alloc-devel-0.1.9-1.el10_0.noarch.rpm;name=aarch64_rust-streaming-iterator+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streaming-iterator+alloc-devel}"
SRC_URI[aarch64_rust-streaming-iterator+alloc-devel.sha256sum] = "09a5e10bac1bc8b632e8d38e215062250f82b6e4279b7c9b676df446c3da8306"

URI_aarch64_rust-streaming-iterator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streaming-iterator+default-devel-0.1.9-1.el10_0.noarch.rpm;name=aarch64_rust-streaming-iterator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streaming-iterator+default-devel}"
SRC_URI[aarch64_rust-streaming-iterator+default-devel.sha256sum] = "ef1a74aab6a35facf3f5a0967e81b8503c11dc3fcc88ee450821d66780dc70c6"

URI_aarch64_rust-streaming-iterator+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streaming-iterator+std-devel-0.1.9-1.el10_0.noarch.rpm;name=aarch64_rust-streaming-iterator+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streaming-iterator+std-devel}"
SRC_URI[aarch64_rust-streaming-iterator+std-devel.sha256sum] = "a1cf3759247878b698d4811ef30a912e55099590f3255df3854fd12bdd3cefd6"

URI_aarch64_rust-streaming-iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streaming-iterator-devel-0.1.9-1.el10_0.noarch.rpm;name=aarch64_rust-streaming-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streaming-iterator-devel}"
SRC_URI[aarch64_rust-streaming-iterator-devel.sha256sum] = "2b23216ff1897b43c7f14eb732fa2a109c9e84aeb46b7be25d30b811a19210c1"

RDEPENDS:rust-streaming-iterator+alloc-devel = " \
 cargo \
 rust-streaming-iterator-devel \
 "
RDEPENDS:rust-streaming-iterator+default-devel = " \
 cargo \
 rust-streaming-iterator-devel \
 "
RDEPENDS:rust-streaming-iterator+std-devel = " \
 cargo \
 rust-streaming-iterator+alloc-devel \
 rust-streaming-iterator-devel \
 "
RDEPENDS:rust-streaming-iterator-devel = " \
 cargo \
 rust \
 "
