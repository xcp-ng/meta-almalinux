# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hwk"
PV = "0.6"
PR = "10.el10_0"
PACKAGES = " \
 hwk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hwk-0.6-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9f00eca11c4801b89964b69d5da23d99dd38750e4382b40f0a36c71499d6109"

URI_x86_64_v2_hwk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hwk-0.6-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hwk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hwk}"
SRC_URI[x86_64_v2_hwk.sha256sum] = "baf0f3421087469f410028f2976868394d9f9fac11cefbaa0ab48e4ccff5b716"

URI_aarch64_hwk = "${EPEL_MIRROR}/aarch64/Packages/h/hwk-0.6-10.el10_0.aarch64.rpm;name=aarch64_hwk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hwk}"
SRC_URI[aarch64_hwk.sha256sum] = "636f1c5c51cf5c1a3857f5e85ef5c8266073a8ebe5bd2d72da3174e411a51f99"

RDEPENDS:hwk = " \
 ghc-compiler \
 glibc \
 gmp \
 libffi \
 "
