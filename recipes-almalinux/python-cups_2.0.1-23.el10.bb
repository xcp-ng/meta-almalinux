# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cups"
PV = "2.0.1"
PR = "23.el10"
PACKAGES = " \
 python-cups-doc \
 python3-cups \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-cups-2.0.1-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8f968e861d06f70c4bc856f157bb1673867f706d6dae017a3a07dc1887b87fd"

URI_x86_64_v2_python-cups-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-cups-doc-2.0.1-23.el10.x86_64_v2.rpm;name=x86_64_v2_python-cups-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-cups-doc}"
SRC_URI[x86_64_v2_python-cups-doc.sha256sum] = "a962b615e5adafaaa1e631071ad81e3764b9352b18bd5a4241f79f943f7a21b1"

URI_x86_64_v2_python3-cups = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-cups-2.0.1-23.el10.x86_64_v2.rpm;name=x86_64_v2_python3-cups;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cups}"
SRC_URI[x86_64_v2_python3-cups.sha256sum] = "482f228ece4e19575f040a472c51736b85af1056dcc2b632d8c56e83154f3e82"

URI_aarch64_python-cups-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-cups-doc-2.0.1-23.el10.aarch64.rpm;name=aarch64_python-cups-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-cups-doc}"
SRC_URI[aarch64_python-cups-doc.sha256sum] = "b34ae448663231847d846be236dfc346dea16e588f388119fe6c13eff16a72fa"

URI_aarch64_python3-cups = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-cups-2.0.1-23.el10.aarch64.rpm;name=aarch64_python3-cups;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cups}"
SRC_URI[aarch64_python3-cups.sha256sum] = "1bb0e918179b3338d0dd85d2bc31cfce2c85d87b810469191426758a99a07543"

RDEPENDS:python-cups-doc = " \
 "
RDEPENDS:python3-cups = " \
 cups-libs \
 glibc \
 python3 \
 "
