# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-uritemplate"
PV = "4.2.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-uritemplate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-uritemplate-4.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea9efebb32981365df489eda3cf159bbd3d16822a4a545d4dda9798287f8c869"

URI_x86_64_v2_python3-uritemplate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-uritemplate-4.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-uritemplate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-uritemplate}"
SRC_URI[x86_64_v2_python3-uritemplate.sha256sum] = "94b23dee8de9a8dbab5178334d8ff721b317f10fd57b855c24d6690178a432ec"

URI_aarch64_python3-uritemplate = "${EPEL_MIRROR}/aarch64/Packages/p/python3-uritemplate-4.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-uritemplate;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-uritemplate}"
SRC_URI[aarch64_python3-uritemplate.sha256sum] = "fc9ff1912e85f6897f3d8c8fc3f0c5c2061911d42b2d9dbb000b7537364eee23"

RDEPENDS:python3-uritemplate = " \
 python3 \
 "
