# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdoctools"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kdoctools \
 kf6-kdoctools-devel \
 kf6-kdoctools-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kdoctools-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cfd80deea71ecbf46a3cfedb5520d18bdb0172b2cac714a76952ffced3e93757"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdoctools;unpack=0"
SRC_URI[x86_64_v2_kf6-kdoctools.sha256sum] = "bbb0a279f83f62c5e8e3c937da0f160e8ba65f152acbf489022eb85e16e3fdb4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdoctools-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kdoctools-devel.sha256sum] = "6b896a44ebee014de32004aae0fc7818168fccba5aad106e4e92741dd8029384"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdoctools-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kdoctools-doc.sha256sum] = "16a15f1201e866dc0a4f9bcd0b0ae2bafe6f5adfe59eee02c6d894570223c948"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kdoctools;unpack=0"
SRC_URI[aarch64_kf6-kdoctools.sha256sum] = "9b86a74157f2ab8ca71df8b3b2b5f2ac9ef8c180cf6ecce3b7e01afca968dc4d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kdoctools-devel;unpack=0"
SRC_URI[aarch64_kf6-kdoctools-devel.sha256sum] = "18f7d1b6199089e8d5c4c9097050794469fe5fd04ea48ccb0d4e5033a5ed3bfe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kdoctools-doc;unpack=0"
SRC_URI[aarch64_kf6-kdoctools-doc.sha256sum] = "7bc0890fdcb10fee2d8afce9d564bc9e3254f52e4770243e2535cfe65ae73aad"

RDEPENDS:kf6-kdoctools = " \
 docbook-dtds \
 docbook-style-xsl \
 glibc \
 kf6-karchive \
 libstdc++ \
 libxml2 \
 libxslt \
 qt6-qtbase \
 "
RDEPENDS:kf6-kdoctools-devel = " \
 cmake-filesystem \
 kf6-kdoctools \
 perl-Any-URI-Escape \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kdoctools-doc = " \
 "
