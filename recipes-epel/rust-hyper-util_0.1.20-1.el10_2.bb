# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hyper-util"
PV = "0.1.20"
PR = "1.el10_2"
PACKAGES = " \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+client-pool-devel \
 rust-hyper-util+client-proxy-devel \
 rust-hyper-util+client-proxy-system-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+full-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-auto-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+server-graceful-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util+tracing-devel \
 rust-hyper-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hyper-util-0.1.20-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e93b0f06c9eba0e8da321ad3f29f9b3df90d083def39062830646a1ed56cc22c"

URI_x86_64_v2_rust-hyper-util+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+client-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+client-devel.sha256sum] = "b7d0656e2de9633b9b25532453b2589afc82ebb45aced78c714c5c3c7029b4b5"

URI_x86_64_v2_rust-hyper-util+client-legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-legacy-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+client-legacy-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+client-legacy-devel.sha256sum] = "a084b8eedbca8ff63ae9ff9314ff24706e1f113c5f07370f7a9bfbaf3d81565b"

URI_x86_64_v2_rust-hyper-util+client-pool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-pool-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-pool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+client-pool-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+client-pool-devel.sha256sum] = "0731504701aa74d4e12ac1f6889d053ef91dfcaf0c7860fdf16c39bdcca7e096"

URI_x86_64_v2_rust-hyper-util+client-proxy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-proxy-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-proxy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+client-proxy-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+client-proxy-devel.sha256sum] = "34734e333d0fba5720713e2100623a71df3df1939197f174c313d1ed8eb8c4be"

URI_x86_64_v2_rust-hyper-util+client-proxy-system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-proxy-system-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-proxy-system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+client-proxy-system-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+client-proxy-system-devel.sha256sum] = "535171f7ed5cc2c40540c6e8c5d9959e0fd2b53d2659e945e3ca1a3bc7bc6d1b"

URI_x86_64_v2_rust-hyper-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+default-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+default-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+default-devel.sha256sum] = "d8758db700ffd5e27fee1967eb016cecb60f693865bba3decae65ac7d1dabf75"

URI_x86_64_v2_rust-hyper-util+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+full-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+full-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+full-devel.sha256sum] = "5670237173e5917e4d985227d29debc63252aeae70b3657362dcc950b5aa0070"

URI_x86_64_v2_rust-hyper-util+http1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+http1-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+http1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+http1-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+http1-devel.sha256sum] = "969e69cd78d5b632502062ed90d39bf1f51857c9e6ee6b394192c5ca288960be"

URI_x86_64_v2_rust-hyper-util+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+http2-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+http2-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+http2-devel.sha256sum] = "f1161cda747045a12128836fdbe9d669ae70f7f3e96d75f03bc82543d995cf4c"

URI_x86_64_v2_rust-hyper-util+server-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+server-auto-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+server-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+server-auto-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+server-auto-devel.sha256sum] = "5023fd331bd8dfcf36bbf1101fa3b9782adc947bb8231942694f6a4e1d4429c9"

URI_x86_64_v2_rust-hyper-util+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+server-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+server-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+server-devel.sha256sum] = "d9b1b77a2394422e66250bb8f8b1ec8d7d492dc7f112592771f30e847bac177e"

URI_x86_64_v2_rust-hyper-util+server-graceful-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+server-graceful-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+server-graceful-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+server-graceful-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+server-graceful-devel.sha256sum] = "63783cfda2c585d9ac3f3965aea043ab7de1fd0edd486cf64e91c93fe3585119"

URI_x86_64_v2_rust-hyper-util+service-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+service-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+service-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+service-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+service-devel.sha256sum] = "b1a0d0b0bcf38ea326ff9eed2057bd0531f43b469c2bffde0e5d574fddddac6e"

URI_x86_64_v2_rust-hyper-util+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+tokio-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+tokio-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+tokio-devel.sha256sum] = "74061752e1ee87bf81974f2eb31128dfc37569de571287cfefd9a2fed4392411"

URI_x86_64_v2_rust-hyper-util+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+tracing-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+tracing-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+tracing-devel.sha256sum] = "c4cbe7b4ac72dde89eab2f50703213d4725e7d20870ff3281add806ba50294f7"

URI_x86_64_v2_rust-hyper-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util-devel-0.1.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util-devel}"
SRC_URI[x86_64_v2_rust-hyper-util-devel.sha256sum] = "d1d0ebdeea3c0eb0068429f949d9f99711517de96467aec0e34887922cfa674b"

URI_aarch64_rust-hyper-util+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+client-devel}"
SRC_URI[aarch64_rust-hyper-util+client-devel.sha256sum] = "e409eb26ea43a4c506f2dc65da89910be6ee6a05e37f9833f8b3134b95fc562a"

URI_aarch64_rust-hyper-util+client-legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-legacy-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util+client-legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+client-legacy-devel}"
SRC_URI[aarch64_rust-hyper-util+client-legacy-devel.sha256sum] = "8dc9af382580069a29ad0add28873549cf3af78f1c603499e1e0f8ff715f0a1b"

URI_aarch64_rust-hyper-util+client-pool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-pool-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util+client-pool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+client-pool-devel}"
SRC_URI[aarch64_rust-hyper-util+client-pool-devel.sha256sum] = "ba16ec0f60e4e87fc0eb7b8f75a88c3d7ca0eed8501e6868c9e7382122957c50"

URI_aarch64_rust-hyper-util+client-proxy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-proxy-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util+client-proxy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+client-proxy-devel}"
SRC_URI[aarch64_rust-hyper-util+client-proxy-devel.sha256sum] = "31130c37e5f25f46f9d606b7cd5cd0546aee40c242cfb9ab3ba0e67bf622770c"

URI_aarch64_rust-hyper-util+client-proxy-system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-proxy-system-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util+client-proxy-system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+client-proxy-system-devel}"
SRC_URI[aarch64_rust-hyper-util+client-proxy-system-devel.sha256sum] = "ae59e81bf80001cabaf891341cd8d247c8bd6c8cffac9fdf42abd2a7dac313d4"

URI_aarch64_rust-hyper-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+default-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+default-devel}"
SRC_URI[aarch64_rust-hyper-util+default-devel.sha256sum] = "962d0add8ebb27bbbdfeca1cfae879a06ec09dea27322532a58e6dd4ec8b9c60"

URI_aarch64_rust-hyper-util+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+full-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+full-devel}"
SRC_URI[aarch64_rust-hyper-util+full-devel.sha256sum] = "490a6fa1870415473ddc373addbea83762b2c86dfebe84f73b0c77711a928b0f"

URI_aarch64_rust-hyper-util+http1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+http1-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util+http1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+http1-devel}"
SRC_URI[aarch64_rust-hyper-util+http1-devel.sha256sum] = "c990629883c037a9e379971028d4f657296d6ba5d8cdd7d5c3af8b0ac825fa2b"

URI_aarch64_rust-hyper-util+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+http2-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+http2-devel}"
SRC_URI[aarch64_rust-hyper-util+http2-devel.sha256sum] = "252227d4b91882a5086bcb95afe6c80fb9614e208bd7224bd443220df6854a9d"

URI_aarch64_rust-hyper-util+server-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+server-auto-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util+server-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+server-auto-devel}"
SRC_URI[aarch64_rust-hyper-util+server-auto-devel.sha256sum] = "ca058fc1347efaa39619ec36ec05ea1266d03ad292d351e3ffb8843ab1491518"

URI_aarch64_rust-hyper-util+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+server-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+server-devel}"
SRC_URI[aarch64_rust-hyper-util+server-devel.sha256sum] = "95560b3841617117ee8e09d761d289598a032449d4d48cc9168dbf994c0d8c49"

URI_aarch64_rust-hyper-util+server-graceful-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+server-graceful-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util+server-graceful-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+server-graceful-devel}"
SRC_URI[aarch64_rust-hyper-util+server-graceful-devel.sha256sum] = "0de666738e05f4f48db5ca1f958166c67771ab78a1cf94f08f2f2fb1c08f6637"

URI_aarch64_rust-hyper-util+service-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+service-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util+service-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+service-devel}"
SRC_URI[aarch64_rust-hyper-util+service-devel.sha256sum] = "a48ec1af326fe4135ff8323e3117ffda243b3a0231f7022b7d0f11c5a5ed032b"

URI_aarch64_rust-hyper-util+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+tokio-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+tokio-devel}"
SRC_URI[aarch64_rust-hyper-util+tokio-devel.sha256sum] = "e7d13bf873e6e8f6bcfbef0b55302b53bb348e66f7a7a1600595c40a60131f49"

URI_aarch64_rust-hyper-util+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+tracing-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+tracing-devel}"
SRC_URI[aarch64_rust-hyper-util+tracing-devel.sha256sum] = "3aa96c2ffcb3d7a4861090b860b3dd42f76c6754822164c718e436ce655a7bbb"

URI_aarch64_rust-hyper-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util-devel-0.1.20-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util-devel}"
SRC_URI[aarch64_rust-hyper-util-devel.sha256sum] = "a8158afdc740695a852e8f5a8b467fbef985c0daff7a49d47b5701be871da6a5"

RDEPENDS:rust-hyper-util+client-devel = " \
 cargo \
 rust-futures-channel+default-devel \
 rust-hyper+client-devel \
 rust-hyper-util-devel \
 rust-tokio+net-devel \
 rust-tokio-devel \
 rust-tower-service+default-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-hyper-util+client-legacy-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util-devel \
 rust-libc+default-devel \
 rust-tokio+sync-devel \
 rust-tokio-devel \
 virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~ \
 virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~ \
 "
RDEPENDS:rust-hyper-util+client-pool-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util-devel \
 rust-tower-layer+default-devel \
 "
RDEPENDS:rust-hyper-util+client-proxy-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util-devel \
 rust-ipnet+default-devel \
 rust-percent-encoding+default-devel \
 "
RDEPENDS:rust-hyper-util+client-proxy-system-devel = " \
 cargo \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+default-devel = " \
 cargo \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+full-devel = " \
 cargo \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+client-pool-devel \
 rust-hyper-util+client-proxy-devel \
 rust-hyper-util+client-proxy-system-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-auto-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+server-graceful-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util+tracing-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+http1-devel = " \
 cargo \
 rust-hyper+http1-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+http2-devel = " \
 cargo \
 rust-hyper+http2-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+server-auto-devel = " \
 cargo \
 rust-hyper-util+http1-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+server-devel = " \
 cargo \
 rust-hyper+server-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+server-graceful-devel = " \
 cargo \
 rust-hyper-util+server-devel \
 rust-hyper-util-devel \
 rust-tokio+sync-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-hyper-util+service-devel = " \
 cargo \
 rust-hyper-util-devel \
 rust-tower-service+default-devel \
 "
RDEPENDS:rust-hyper-util+tokio-devel = " \
 cargo \
 rust-hyper-util-devel \
 rust-tokio+rt-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-hyper-util+tracing-devel = " \
 cargo \
 rust-hyper-util-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-hyper-util-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-hyper+default-devel \
 rust-pin-project-lite+default-devel \
 "
