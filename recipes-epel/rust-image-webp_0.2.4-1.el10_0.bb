# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-image-webp"
PV = "0.2.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-image-webp+default-devel \
 rust-image-webp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-image-webp-0.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02605be8c8b793f8878ef705f93fdd3bed530db1a523deebd3268d55c828a388"

URI_x86_64_v2_rust-image-webp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image-webp+default-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image-webp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image-webp+default-devel}"
SRC_URI[x86_64_v2_rust-image-webp+default-devel.sha256sum] = "6a961ed3096d3e8f0dc660a452dbd747da67bfd93815eaffd71cba93223a69aa"

URI_x86_64_v2_rust-image-webp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image-webp-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image-webp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image-webp-devel}"
SRC_URI[x86_64_v2_rust-image-webp-devel.sha256sum] = "06142a8d4fec18dc54329a99c244da0eded936a096e6f022770e8f507b162184"

URI_aarch64_rust-image-webp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image-webp+default-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-image-webp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image-webp+default-devel}"
SRC_URI[aarch64_rust-image-webp+default-devel.sha256sum] = "d5591f680857aec5c150efb51a338b217cb3e0943466d50220526dd6c29ccfa1"

URI_aarch64_rust-image-webp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image-webp-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-image-webp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image-webp-devel}"
SRC_URI[aarch64_rust-image-webp-devel.sha256sum] = "4c98d9b668afff99d106d369180a0d04988d3dcf1656787f62b3891663ec624e"

RDEPENDS:rust-image-webp+default-devel = " \
 cargo \
 rust-image-webp-devel \
 "
RDEPENDS:rust-image-webp-devel = " \
 cargo \
 rust \
 rust-byteorder-lite+default-devel \
 rust-quick-error+default-devel \
 "
