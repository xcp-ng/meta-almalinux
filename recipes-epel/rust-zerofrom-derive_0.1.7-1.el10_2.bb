# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerofrom-derive"
PV = "0.1.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-zerofrom-derive+default-devel \
 rust-zerofrom-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerofrom-derive-0.1.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7326ef6de88d0faa91b0124aa8fd5f4236265ecd21652874edbef74ef8aecac0"

URI_x86_64_v2_rust-zerofrom-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom-derive+default-devel-0.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom-derive+default-devel}"
SRC_URI[x86_64_v2_rust-zerofrom-derive+default-devel.sha256sum] = "274d2d56a8c2da9d4eea5530ece6461d00975d65f668f1e8884896ba81fb18cb"

URI_x86_64_v2_rust-zerofrom-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom-derive-devel-0.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom-derive-devel}"
SRC_URI[x86_64_v2_rust-zerofrom-derive-devel.sha256sum] = "3e819dc0f00c62b6c9ad272658b47ecda4f5852b39ed576c68b9a1ae20766f5e"

URI_aarch64_rust-zerofrom-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom-derive+default-devel-0.1.7-1.el10_2.noarch.rpm;name=aarch64_rust-zerofrom-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom-derive+default-devel}"
SRC_URI[aarch64_rust-zerofrom-derive+default-devel.sha256sum] = "1351e7fd3eb3fd3124d0a5bb343b3b128ae3ac7e70074f46644f9678fc79975d"

URI_aarch64_rust-zerofrom-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom-derive-devel-0.1.7-1.el10_2.noarch.rpm;name=aarch64_rust-zerofrom-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom-derive-devel}"
SRC_URI[aarch64_rust-zerofrom-derive-devel.sha256sum] = "b4509086c345029d1d504d635ad3165fd1979609acc325f54aaa710780899c11"

RDEPENDS:rust-zerofrom-derive+default-devel = " \
 cargo \
 rust-zerofrom-derive-devel \
 "
RDEPENDS:rust-zerofrom-derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+fold-devel \
 rust-synstructure+default-devel \
 "
