# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinxcontrib-trio"
PV = "1.1.2"
PR = "25.el10_0"
PACKAGES = " \
 python3-sphinxcontrib-trio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinxcontrib-trio-1.1.2-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "099231f977a9fdc0835a2988b2e938d22af8ae8e9cce23545ea9557a15ee75e3"

URI_x86_64_v2_python3-sphinxcontrib-trio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinxcontrib-trio-1.1.2-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinxcontrib-trio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinxcontrib-trio}"
SRC_URI[x86_64_v2_python3-sphinxcontrib-trio.sha256sum] = "0ed858442e7bccafd62a606c5aab30215b2a3b3e4168cf17803615470d1c9cee"

URI_aarch64_python3-sphinxcontrib-trio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinxcontrib-trio-1.1.2-25.el10_0.noarch.rpm;name=aarch64_python3-sphinxcontrib-trio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinxcontrib-trio}"
SRC_URI[aarch64_python3-sphinxcontrib-trio.sha256sum] = "20269ee4dbdc6a7b324f8caa8a873bb38ca607c5de13f811a1bdc9f2b4b4f966"

RDEPENDS:python3-sphinxcontrib-trio = " \
 python3 \
 python3-sphinx \
 "
