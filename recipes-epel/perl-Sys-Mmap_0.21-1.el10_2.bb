# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sys-Mmap"
PV = "0.21"
PR = "1.el10_2"
PACKAGES = " \
 perl-Sys-Mmap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sys-Mmap-0.21-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf074a94222a54aaab39234b8f195a502c8742b5e2fc61ff3a6d9fa319685c12"

URI_x86_64_v2_perl-Sys-Mmap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-Mmap-0.21-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Mmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-Mmap}"
SRC_URI[x86_64_v2_perl-Sys-Mmap.sha256sum] = "bbdef08342b9b001aab1f666164dee3c99d13ea134c981c609c7ce850eb5956e"

URI_aarch64_perl-Sys-Mmap = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-Mmap-0.21-1.el10_2.aarch64.rpm;name=aarch64_perl-Sys-Mmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-Mmap}"
SRC_URI[aarch64_perl-Sys-Mmap.sha256sum] = "3b504afa19271d3625bb831edd1a31cf85bea8dd37f1c8dde61b52319b2c991d"

RDEPENDS:perl-Sys-Mmap = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
