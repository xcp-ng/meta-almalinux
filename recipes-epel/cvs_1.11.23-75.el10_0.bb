# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cvs"
PV = "1.11.23"
PR = "75.el10_0"
PACKAGES = " \
 cvs \
 cvs-contrib \
 cvs-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cvs-1.11.23-75.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "292ffbf8e1b50a5145279c541c6d2d167b3e96f60ce63931681abf1c4d75c72a"

URI_x86_64_v2_cvs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cvs-1.11.23-75.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cvs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cvs}"
SRC_URI[x86_64_v2_cvs.sha256sum] = "05690054e52dc4269ab397b004cc1f31cc6333fe0cf6da7a83bb354b25c651ec"

URI_x86_64_v2_cvs-contrib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cvs-contrib-1.11.23-75.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_cvs-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cvs-contrib}"
SRC_URI[x86_64_v2_cvs-contrib.sha256sum] = "f1260a4b3cf817f4b8417ba00daa40f564867625b0252ac5022069f0442a0fb6"

URI_x86_64_v2_cvs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cvs-doc-1.11.23-75.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cvs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cvs-doc}"
SRC_URI[x86_64_v2_cvs-doc.sha256sum] = "975c459ebfcb9c378bc4244ea1a61bcf7782764fa05123951fcd88ab56d11891"

URI_aarch64_cvs = "${EPEL_MIRROR}/aarch64/Packages/c/cvs-1.11.23-75.el10_0.aarch64.rpm;name=aarch64_cvs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cvs}"
SRC_URI[aarch64_cvs.sha256sum] = "330b888c6398a3f4fb4f627c2b44011668226051f813de9d512c8f8bd947eea0"

URI_aarch64_cvs-contrib = "${EPEL_MIRROR}/aarch64/Packages/c/cvs-contrib-1.11.23-75.el10_0.noarch.rpm;name=aarch64_cvs-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_cvs-contrib}"
SRC_URI[aarch64_cvs-contrib.sha256sum] = "e849d87fc34594cb637a50e70d93318690fa2463b2b9db59b8ad005073b8540b"

URI_aarch64_cvs-doc = "${EPEL_MIRROR}/aarch64/Packages/c/cvs-doc-1.11.23-75.el10_0.aarch64.rpm;name=aarch64_cvs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cvs-doc}"
SRC_URI[aarch64_cvs-doc.sha256sum] = "0356a0c700c042482005a26699e03911f55bb5400c31a4c1fba4672fd823e89a"

RDEPENDS:cvs = " \
 bash \
 glibc \
 krb5-libs \
 libxcrypt \
 pam-libs \
 vim-minimal \
 zlib-ng-compat \
 "
RDEPENDS:cvs-contrib = " \
 bash \
 cvs \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-IO \
 perl-PathTools \
 perl-Perl4-CoreLibs \
 perl-interpreter \
 perl-libs \
 tcsh \
 "
RDEPENDS:cvs-doc = " \
 "
