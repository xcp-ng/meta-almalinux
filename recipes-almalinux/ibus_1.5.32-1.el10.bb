# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ibus"
PV = "1.5.32"
PR = "1.el10"
PACKAGES = " \
 ibus \
 ibus-devel \
 ibus-devel-docs \
 ibus-gtk3 \
 ibus-gtk4 \
 ibus-libs \
 ibus-panel \
 ibus-setup \
 ibus-wayland \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ibus-1.5.32-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a56496b169d01808fb6e378677d0c89fc735b60809a1d8803d4398c2a6c2c08f"

URI_x86_64_v2_ibus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-1.5.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_ibus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus}"
SRC_URI[x86_64_v2_ibus.sha256sum] = "85b22aeca13053f66d923d6fb4d9d51775c94b1d56f53c3a8aa6e439e6919fe6"

URI_x86_64_v2_ibus-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ibus-devel-1.5.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-devel}"
SRC_URI[x86_64_v2_ibus-devel.sha256sum] = "438b7de0a1abb39436b3569fc81f23f5303c93e2f8d9e10f134b38f257facc1c"

URI_x86_64_v2_ibus-devel-docs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ibus-devel-docs-1.5.32-1.el10.noarch.rpm;name=x86_64_v2_ibus-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-devel-docs}"
SRC_URI[x86_64_v2_ibus-devel-docs.sha256sum] = "77f0f9ba4b1f48f16414bd489e5a958c44a4e7768bce1a64284ea67a1d891465"

URI_x86_64_v2_ibus-gtk3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-gtk3-1.5.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-gtk3}"
SRC_URI[x86_64_v2_ibus-gtk3.sha256sum] = "5bc0810181fc362ea87d6ca93eb6f3d03d1686f742e0dc3b3c7b84d2e4b8480b"

URI_x86_64_v2_ibus-gtk4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-gtk4-1.5.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-gtk4}"
SRC_URI[x86_64_v2_ibus-gtk4.sha256sum] = "1a20f3156e84f767a079493a4e06f8994d0eb3820ff5809981d04042f698e66b"

URI_x86_64_v2_ibus-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-libs-1.5.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-libs}"
SRC_URI[x86_64_v2_ibus-libs.sha256sum] = "352f004966bcaaf6b50b367143f278cee13efc1f29f4fd8196386766d8a5b6fa"

URI_x86_64_v2_ibus-panel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ibus-panel-1.5.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-panel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-panel}"
SRC_URI[x86_64_v2_ibus-panel.sha256sum] = "a21e9256bad060f586df72094ce0f9d6417e382a78d09b3ae711abe76177d1d6"

URI_x86_64_v2_ibus-setup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-setup-1.5.32-1.el10.noarch.rpm;name=x86_64_v2_ibus-setup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-setup}"
SRC_URI[x86_64_v2_ibus-setup.sha256sum] = "4fc572c69cefc437a3868a08e0dfb09e5899216598dd383417acdeae471030ae"

URI_x86_64_v2_ibus-wayland = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-wayland-1.5.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-wayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-wayland}"
SRC_URI[x86_64_v2_ibus-wayland.sha256sum] = "4cda5d9eacf9dc6debbb9bfe0d4378f6eb123749236ebd9bb58c8c6eb6dbfb03"

URI_aarch64_ibus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-1.5.32-1.el10.aarch64.rpm;name=aarch64_ibus;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus}"
SRC_URI[aarch64_ibus.sha256sum] = "2e3ccdce0655d1c9a1f37edbb0813d29d5a584f38854cb306abad1694f0691d8"

URI_aarch64_ibus-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ibus-devel-1.5.32-1.el10.aarch64.rpm;name=aarch64_ibus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-devel}"
SRC_URI[aarch64_ibus-devel.sha256sum] = "2f6aea9ca57066a347ff85402f742d3ea077687d6ff48e28d3ac752816cf22a8"

URI_aarch64_ibus-devel-docs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ibus-devel-docs-1.5.32-1.el10.noarch.rpm;name=aarch64_ibus-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-devel-docs}"
SRC_URI[aarch64_ibus-devel-docs.sha256sum] = "77f0f9ba4b1f48f16414bd489e5a958c44a4e7768bce1a64284ea67a1d891465"

URI_aarch64_ibus-gtk3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-gtk3-1.5.32-1.el10.aarch64.rpm;name=aarch64_ibus-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-gtk3}"
SRC_URI[aarch64_ibus-gtk3.sha256sum] = "d7484d0030411ce8b5efabd0150ece0aadc830a6d90decf0e2a99e0109d581ef"

URI_aarch64_ibus-gtk4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-gtk4-1.5.32-1.el10.aarch64.rpm;name=aarch64_ibus-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-gtk4}"
SRC_URI[aarch64_ibus-gtk4.sha256sum] = "a35a1d9167c5e8cdeabf21055eb1dbdc6ddf0faaed80c0daf45126c294fbea9b"

URI_aarch64_ibus-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-libs-1.5.32-1.el10.aarch64.rpm;name=aarch64_ibus-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-libs}"
SRC_URI[aarch64_ibus-libs.sha256sum] = "cef31b85ddb33ca7a7f12b9583357fda40fe2e1bd93b00f259afac58de1f26f5"

URI_aarch64_ibus-panel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ibus-panel-1.5.32-1.el10.aarch64.rpm;name=aarch64_ibus-panel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-panel}"
SRC_URI[aarch64_ibus-panel.sha256sum] = "5fec43c31caf575baf5ddcb9297a61928adb125f0db547e8e23bf51fc7917899"

URI_aarch64_ibus-setup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-setup-1.5.32-1.el10.noarch.rpm;name=aarch64_ibus-setup;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-setup}"
SRC_URI[aarch64_ibus-setup.sha256sum] = "4fc572c69cefc437a3868a08e0dfb09e5899216598dd383417acdeae471030ae"

URI_aarch64_ibus-wayland = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-wayland-1.5.32-1.el10.aarch64.rpm;name=aarch64_ibus-wayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-wayland}"
SRC_URI[aarch64_ibus-wayland.sha256sum] = "d496c4a326e3b64c4d85a4b2a65a7c50911322cb39781a857e05fa40f95dea95"

RDEPENDS:ibus = " \
 alternatives \
 bash \
 dconf \
 desktop-file-utils \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 ibus-gtk3 \
 ibus-libs \
 ibus-setup \
 iso-codes \
 libX11 \
 libXfixes \
 libXi \
 libwayland-client \
 pango \
 python3 \
 python3-gobject \
 "
RDEPENDS:ibus-devel = " \
 dbus-devel \
 gettext-runtime \
 glib2-devel \
 ibus-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:ibus-devel-docs = " \
 "
RDEPENDS:ibus-gtk3 = " \
 atk \
 cairo \
 cairo-gobject \
 dbus-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 ibus-libs \
 pango \
 "
RDEPENDS:ibus-gtk4 = " \
 cairo \
 cairo-gobject \
 dbus-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 harfbuzz \
 ibus-libs \
 pango \
 vulkan-loader \
 "
RDEPENDS:ibus-libs = " \
 dbus \
 glib2 \
 glibc \
 gobject-introspection \
 "
RDEPENDS:ibus-panel = " \
 atk \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 ibus \
 ibus-libs \
 libX11 \
 libXi \
 libdbusmenu \
 libdbusmenu-gtk3 \
 libnotify \
 libwayland-client \
 libxkbcommon \
 pango \
 "
RDEPENDS:ibus-setup = " \
 bash \
 ibus \
 python3 \
 python3-gobject \
 "
RDEPENDS:ibus-wayland = " \
 glib2 \
 glibc \
 ibus-libs \
 libwayland-client \
 libxkbcommon \
 "
