# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cloud-init"
PV = "24.4"
PR = "3.el10_0.2"
PACKAGES = " \
 cloud-init \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cloud-init-24.4-3.el10_0.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19bb270987c5242272d371049f29a698493914cf7741e7310136338159e7acc6"

URI_x86_64_v2_cloud-init = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cloud-init-24.4-3.el10_0.2.noarch.rpm;name=x86_64_v2_cloud-init;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cloud-init}"
SRC_URI[x86_64_v2_cloud-init.sha256sum] = "c8703d31e5f37391a9b6dadd4843f0bbc6ef9b36508e47af0b8d9228e66d4893"

URI_aarch64_cloud-init = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cloud-init-24.4-3.el10_0.2.noarch.rpm;name=aarch64_cloud-init;unpack=0"
SRC_URI:append = " ${URI_aarch64_cloud-init}"
SRC_URI[aarch64_cloud-init.sha256sum] = "c8703d31e5f37391a9b6dadd4843f0bbc6ef9b36508e47af0b8d9228e66d4893"

RDEPENDS:cloud-init = " \
 bash \
 dhcpcd \
 e2fsprogs \
 hostname \
 iproute \
 openssl \
 procps-ng \
 python3 \
 python3-configobj \
 python3-jinja2 \
 python3-jsonpatch \
 python3-libselinux \
 python3-oauthlib \
 python3-policycoreutils \
 python3-pyserial \
 python3-pyyaml \
 python3-requests \
 shadow-utils \
 systemd \
 util-linux \
 xfsprogs \
 "
