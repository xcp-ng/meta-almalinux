# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-sink"
PV = "0.3.33"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-sink+alloc-devel \
 rust-futures-sink+default-devel \
 rust-futures-sink+std-devel \
 rust-futures-sink-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-sink-0.3.33-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04a52a46d6176dd8612bf3742a4f965263d0066655670605053e504e7efbab07"

URI_x86_64_v2_rust-futures-sink+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink+alloc-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-sink+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-sink+alloc-devel.sha256sum] = "efecedb9961e71f1daaf4a76dfbe0122783a92b9d79ee03409f7f33594e343ce"

URI_x86_64_v2_rust-futures-sink+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink+default-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-sink+default-devel}"
SRC_URI[x86_64_v2_rust-futures-sink+default-devel.sha256sum] = "97bc4e20d12cfeeb8f62980ecf78f27b6ed3d5238f69dc64a02b04051394cb43"

URI_x86_64_v2_rust-futures-sink+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink+std-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-sink+std-devel}"
SRC_URI[x86_64_v2_rust-futures-sink+std-devel.sha256sum] = "48d997fc6f6e1fca23096838486fe052ce7758f50d1ee9a401771425c95df5cb"

URI_x86_64_v2_rust-futures-sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-sink-devel}"
SRC_URI[x86_64_v2_rust-futures-sink-devel.sha256sum] = "fe33461cefaf0655da24092d76fa1c9c3d40b10a277da8d67d36ab3fc6e998d7"

URI_aarch64_rust-futures-sink+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink+alloc-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-sink+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-sink+alloc-devel}"
SRC_URI[aarch64_rust-futures-sink+alloc-devel.sha256sum] = "95989bd94f9d4bd4edb9b4a40c55b68ab7c96da93d64b45a5c3bbec30153d402"

URI_aarch64_rust-futures-sink+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink+default-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-sink+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-sink+default-devel}"
SRC_URI[aarch64_rust-futures-sink+default-devel.sha256sum] = "3cb89994e37ae1ebcc5dd03235415749cb27d307118e6cae68ff7e6c8ff41fba"

URI_aarch64_rust-futures-sink+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink+std-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-sink+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-sink+std-devel}"
SRC_URI[aarch64_rust-futures-sink+std-devel.sha256sum] = "3c8e13997120ddc0af3eb0f3729699a29140e72ca987914e245b156cd0e36670"

URI_aarch64_rust-futures-sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-sink-devel}"
SRC_URI[aarch64_rust-futures-sink-devel.sha256sum] = "4d1427959a14a0c55ea34c5b2fea2426e63753b40f033bac7da17b29c072965b"

RDEPENDS:rust-futures-sink+alloc-devel = " \
 cargo \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-sink+default-devel = " \
 cargo \
 rust-futures-sink+std-devel \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-sink+std-devel = " \
 cargo \
 rust-futures-sink+alloc-devel \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-sink-devel = " \
 cargo \
 rust \
 "
