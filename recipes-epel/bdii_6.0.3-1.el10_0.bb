# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bdii"
PV = "6.0.3"
PR = "1.el10_0"
PACKAGES = " \
 bdii \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bdii-6.0.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f03cdb7ffd0011b325ddab88aa103a50766f2c6b52d94cf2eb5f981be000691d"

URI_x86_64_v2_bdii = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bdii-6.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bdii;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bdii}"
SRC_URI[x86_64_v2_bdii.sha256sum] = "1abf449c4c27ba4a7c3290ffb8d2a1a7c11038801bec636c38afcadc93de52b2"

URI_aarch64_bdii = "${EPEL_MIRROR}/aarch64/Packages/b/bdii-6.0.3-1.el10_0.noarch.rpm;name=aarch64_bdii;unpack=0"
SRC_URI:append = " ${URI_aarch64_bdii}"
SRC_URI[aarch64_bdii.sha256sum] = "a3bfa318458d5c43d8a70dc0679a70dbc1241017e0e10cdf69eca180db25b6cb"

RDEPENDS:bdii = " \
 bash \
 glue-schema \
 logrotate \
 mkpasswd \
 openldap-clients \
 openldap-servers \
 policycoreutils-python-utils \
 python3 \
 systemd \
 "
