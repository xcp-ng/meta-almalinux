# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtbase"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtbase \
 qt5-qtbase-common \
 qt5-qtbase-devel \
 qt5-qtbase-examples \
 qt5-qtbase-gui \
 qt5-qtbase-mysql \
 qt5-qtbase-odbc \
 qt5-qtbase-postgresql \
 qt5-qtbase-private-devel \
 qt5-qtbase-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtbase-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f28ea1ef346ab497daf2ba3a7ee3ac286f722d70a95bfc039ec3e97e9a1211fa"

URI_x86_64_v2_qt5-qtbase = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase}"
SRC_URI[x86_64_v2_qt5-qtbase.sha256sum] = "081adb7e607c0d0b7c5504438f17b55f5300ed06700a51df9a36324451295a07"

URI_x86_64_v2_qt5-qtbase-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-common-5.15.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtbase-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-common}"
SRC_URI[x86_64_v2_qt5-qtbase-common.sha256sum] = "5b00bd1d37caca8cbe51e3de07cf133cb670ea8c1392e15b692f2870a20dd9ac"

URI_x86_64_v2_qt5-qtbase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-devel}"
SRC_URI[x86_64_v2_qt5-qtbase-devel.sha256sum] = "01d606cd278261505d9d793dfe973e32f9e84d27fdfafca44d430c91ff0fdf67"

URI_x86_64_v2_qt5-qtbase-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-examples}"
SRC_URI[x86_64_v2_qt5-qtbase-examples.sha256sum] = "108c0281b9fc8cdef64bf17674f088ba7625e65044d0bcff2703f87b78cd5b60"

URI_x86_64_v2_qt5-qtbase-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-gui-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-gui}"
SRC_URI[x86_64_v2_qt5-qtbase-gui.sha256sum] = "52ed72f0a571270e0bb9ad36d2b1433e32c31322bc34ad04817ec66fcc5218b8"

URI_x86_64_v2_qt5-qtbase-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-mysql-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-mysql}"
SRC_URI[x86_64_v2_qt5-qtbase-mysql.sha256sum] = "af0903caeae0475415a6fe927ab181f454f2339dac957288d2f553cac8152ffe"

URI_x86_64_v2_qt5-qtbase-odbc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-odbc-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-odbc}"
SRC_URI[x86_64_v2_qt5-qtbase-odbc.sha256sum] = "b27e0f599bb8cc6600b65b5fbccfdfd83671787987bfc61a229d9cfff496de2e"

URI_x86_64_v2_qt5-qtbase-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-postgresql-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-postgresql}"
SRC_URI[x86_64_v2_qt5-qtbase-postgresql.sha256sum] = "96bfeb1c3665319ee0c6c03870a1fe6b383becfd792b422748da047b6dfbf3d5"

URI_x86_64_v2_qt5-qtbase-private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-private-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-private-devel}"
SRC_URI[x86_64_v2_qt5-qtbase-private-devel.sha256sum] = "0db5d9e68ac8fb9f69d8d839164a40f7e196ee4459296ac14bbb3c07ff3656b9"

URI_x86_64_v2_qt5-qtbase-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-static-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-static}"
SRC_URI[x86_64_v2_qt5-qtbase-static.sha256sum] = "dd15638b14c5b64aa31536866047ddaaac06cac3b79ab314b674be35f806d99c"

URI_aarch64_qt5-qtbase = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtbase;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase}"
SRC_URI[aarch64_qt5-qtbase.sha256sum] = "3f9a04040a03386618230cf7607397e6bba72d37cddf927ee81e25547980674a"

URI_aarch64_qt5-qtbase-common = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-common-5.15.15-1.el10_0.noarch.rpm;name=aarch64_qt5-qtbase-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-common}"
SRC_URI[aarch64_qt5-qtbase-common.sha256sum] = "c0c6a81295273486a50e6f89c420458f72e1c6e7f58ffe1d2314e3135a2b214c"

URI_aarch64_qt5-qtbase-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtbase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-devel}"
SRC_URI[aarch64_qt5-qtbase-devel.sha256sum] = "855143f16e67886f88124c175ed5d7f46cf45136426d41ef642373c0feb11bd8"

URI_aarch64_qt5-qtbase-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtbase-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-examples}"
SRC_URI[aarch64_qt5-qtbase-examples.sha256sum] = "bc2e8eccb9d0a375618ab48409e54ea0d9a0737c7c65a5b3f4e448ecf203bef8"

URI_aarch64_qt5-qtbase-gui = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-gui-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtbase-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-gui}"
SRC_URI[aarch64_qt5-qtbase-gui.sha256sum] = "ccde41e580925feeeeefcbea96b8793abda3998db614aee9563472219d9b0f7d"

URI_aarch64_qt5-qtbase-mysql = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-mysql-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtbase-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-mysql}"
SRC_URI[aarch64_qt5-qtbase-mysql.sha256sum] = "1b041cf134b0e118d8084942395edb8a26952d636b05e7b4ad782c55cef3f7fb"

URI_aarch64_qt5-qtbase-odbc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-odbc-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtbase-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-odbc}"
SRC_URI[aarch64_qt5-qtbase-odbc.sha256sum] = "f5447e93bf18d2664c065ddf562f430a30e0e63f81896f4e009c632101c897cf"

URI_aarch64_qt5-qtbase-postgresql = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-postgresql-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtbase-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-postgresql}"
SRC_URI[aarch64_qt5-qtbase-postgresql.sha256sum] = "091935f60879574594c6314563d1aa14beb0571609fc8f939ae74bc8d479c1e9"

URI_aarch64_qt5-qtbase-private-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-private-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtbase-private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-private-devel}"
SRC_URI[aarch64_qt5-qtbase-private-devel.sha256sum] = "1643cf412b97e16be8716a68e060f88907cc5dc31fbc1bed1265ff8eeea0ca51"

URI_aarch64_qt5-qtbase-static = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-static-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtbase-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-static}"
SRC_URI[aarch64_qt5-qtbase-static.sha256sum] = "986465ecec9af4cdeeb62a32c885bd36de99bf1af8f07938b0a327900f4322fb"

RDEPENDS:qt5-qtbase = " \
 alternatives \
 bash \
 dbus-libs \
 double-conversion \
 glib2 \
 glibc \
 krb5-libs \
 libgcc \
 libicu \
 libproxy \
 libstdc++ \
 libzstd \
 openssl-libs \
 pcre2-utf16 \
 qt5-filesystem \
 qt5-qtbase-common \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qtbase-common = " \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtbase-devel = " \
 bash \
 cmake-filesystem \
 glibc \
 libgcc \
 libglvnd-devel \
 libstdc++ \
 libzstd \
 mesa-libEGL-devel \
 perl-English \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-IO \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 python3 \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtbase-gui \
 qt5-rpm-macros \
 vulkan-loader-devel \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qtbase-examples = " \
 glibc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:qt5-qtbase-gui = " \
 bash \
 cups-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 glx-utils \
 harfbuzz \
 libICE \
 libSM \
 libX11 \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libglvnd-glx \
 libinput \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libxcb \
 libxkbcommon \
 libxkbcommon-x11 \
 mesa-libgbm \
 qt5-qtbase \
 systemd-libs \
 xcb-util-image \
 xcb-util-keysyms \
 xcb-util-renderutil \
 xcb-util-wm \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qtbase-mysql = " \
 glibc \
 libstdc++ \
 mariadb-connector-c \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtbase-odbc = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 unixODBC \
 "
RDEPENDS:qt5-qtbase-postgresql = " \
 glibc \
 libpq \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtbase-private-devel = " \
 cups-devel \
 qt5-qtbase-devel \
 "
RDEPENDS:qt5-qtbase-static = " \
 cmake-filesystem \
 fontconfig-devel \
 glib2-devel \
 libinput-devel \
 libxkbcommon-devel \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 zlib-ng-compat-devel \
 "
