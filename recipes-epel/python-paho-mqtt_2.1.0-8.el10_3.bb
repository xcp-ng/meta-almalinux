# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-paho-mqtt"
PV = "2.1.0"
PR = "8.el10_3"
PACKAGES = " \
 python3-paho-mqtt \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-paho-mqtt-2.1.0-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e5fc38edb619fdb9083a22e58d2e2add1ded321acf6e9651adad758d83fa2eb0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-paho-mqtt-2.1.0-8.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-paho-mqtt;unpack=0"
SRC_URI[x86_64_v2_python3-paho-mqtt.sha256sum] = "fdada461bed56fada79fb36b400886918898070f8d82f529d4f3ff58ac060484"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-paho-mqtt-2.1.0-8.el10_3.noarch.rpm;name=aarch64_python3-paho-mqtt;unpack=0"
SRC_URI[aarch64_python3-paho-mqtt.sha256sum] = "9f8dd3179412a753e139395a933dddd7a60140dfeeae35a75a8c2c26faaa2a64"

RDEPENDS:python3-paho-mqtt = " \
 python3 \
 "
