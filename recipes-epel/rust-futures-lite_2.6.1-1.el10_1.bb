# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-lite"
PV = "2.6.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-futures-lite+alloc-devel \
 rust-futures-lite+default-devel \
 rust-futures-lite+fastrand-devel \
 rust-futures-lite+futures-io-devel \
 rust-futures-lite+memchr-devel \
 rust-futures-lite+parking-devel \
 rust-futures-lite+race-devel \
 rust-futures-lite+std-devel \
 rust-futures-lite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-lite-2.6.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81e11ffadbc03677e075c4b07f475a9e59d5956d63c979b160419a5a1e589d14"

URI_x86_64_v2_rust-futures-lite+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+alloc-devel-2.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+alloc-devel.sha256sum] = "f3bdd040ae550d1d1008a0f2c55a0cc152fe9310181f4038b77eedfb569031d8"

URI_x86_64_v2_rust-futures-lite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+default-devel-2.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+default-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+default-devel.sha256sum] = "775a05c37eff02103bfcd104f7bf1a379dfafafd3ca562968c0fed30fb83f9e2"

URI_x86_64_v2_rust-futures-lite+fastrand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+fastrand-devel-2.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+fastrand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+fastrand-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+fastrand-devel.sha256sum] = "06f335b7e876f42e5c11bbf27f55a835aab1719b3e1cbb1cbe93de1eac17ac91"

URI_x86_64_v2_rust-futures-lite+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+futures-io-devel-2.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+futures-io-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+futures-io-devel.sha256sum] = "0e507a5705e6000e8ba603cb1b35fd1e696e0cf031822a3f003c78ab781bc97e"

URI_x86_64_v2_rust-futures-lite+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+memchr-devel-2.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+memchr-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+memchr-devel.sha256sum] = "e91dafb00dea0943146ee1959c45f3a4bd1e80335c94d9855c8c9b13d56b8a06"

URI_x86_64_v2_rust-futures-lite+parking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+parking-devel-2.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+parking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+parking-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+parking-devel.sha256sum] = "b53d74058d8bcbc63a4fd5911a183809b9e23f77ce0c38bfde3cfd73f0b31636"

URI_x86_64_v2_rust-futures-lite+race-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+race-devel-2.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+race-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+race-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+race-devel.sha256sum] = "1f7a585657c08b838fe5abc48dcf0eacb110e2b2a94f0ec9ca28ae9d75e02746"

URI_x86_64_v2_rust-futures-lite+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+std-devel-2.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+std-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+std-devel.sha256sum] = "64909244d5ad39e3992528d0b7039b860de30cbf6c0250bec078f817f4b4f2fa"

URI_x86_64_v2_rust-futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite-devel-2.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite-devel}"
SRC_URI[x86_64_v2_rust-futures-lite-devel.sha256sum] = "5d15509f7fac7a5f7c75d0da1d78fa5ea27dd45fd8c8e3ddff576e31e61a09cf"

URI_aarch64_rust-futures-lite+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+alloc-devel-2.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-futures-lite+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+alloc-devel}"
SRC_URI[aarch64_rust-futures-lite+alloc-devel.sha256sum] = "75ac0fd5a279c4e29f3b05a36f60637d09e9121dea19cf9bc0afbc0c3158f60f"

URI_aarch64_rust-futures-lite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+default-devel-2.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-futures-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+default-devel}"
SRC_URI[aarch64_rust-futures-lite+default-devel.sha256sum] = "b4af70ea2d999ae2ef68f91e4ee351e6172a494afe166adb781cf397387c9798"

URI_aarch64_rust-futures-lite+fastrand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+fastrand-devel-2.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-futures-lite+fastrand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+fastrand-devel}"
SRC_URI[aarch64_rust-futures-lite+fastrand-devel.sha256sum] = "c11de543ab1a99bcd2e10b4f48308f0d9f35cedc580f79abe3e6c6ae63520ffe"

URI_aarch64_rust-futures-lite+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+futures-io-devel-2.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-futures-lite+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+futures-io-devel}"
SRC_URI[aarch64_rust-futures-lite+futures-io-devel.sha256sum] = "b0e9df0331ddbdaee102890fe10abce108245543449ce844849f89cf7b61d855"

URI_aarch64_rust-futures-lite+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+memchr-devel-2.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-futures-lite+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+memchr-devel}"
SRC_URI[aarch64_rust-futures-lite+memchr-devel.sha256sum] = "f8adfd0537369e1048df511adc3462e998d695f80cd44f01bde047bdf167d2ab"

URI_aarch64_rust-futures-lite+parking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+parking-devel-2.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-futures-lite+parking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+parking-devel}"
SRC_URI[aarch64_rust-futures-lite+parking-devel.sha256sum] = "995a85646c2243ecf38504000d7f39a50513d4141275aa063e00afdf1ca7ad1e"

URI_aarch64_rust-futures-lite+race-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+race-devel-2.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-futures-lite+race-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+race-devel}"
SRC_URI[aarch64_rust-futures-lite+race-devel.sha256sum] = "779f8a30948ac3d2ed4c002895cea8479b60ee87159c283746c1756b9eb6de78"

URI_aarch64_rust-futures-lite+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+std-devel-2.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-futures-lite+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+std-devel}"
SRC_URI[aarch64_rust-futures-lite+std-devel.sha256sum] = "62940f2a09d5c90bf0bfa15ab1d2040411e0d19e0ef67a3a2e071c203de52b76"

URI_aarch64_rust-futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite-devel-2.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite-devel}"
SRC_URI[aarch64_rust-futures-lite-devel.sha256sum] = "d8d0282e31b0dd76aa1381b338f210a2619d875c61fd7150d544eeaba837e0f3"

RDEPENDS:rust-futures-lite+alloc-devel = " \
 cargo \
 rust-futures-lite-devel \
 "
RDEPENDS:rust-futures-lite+default-devel = " \
 cargo \
 rust-futures-lite+race-devel \
 rust-futures-lite+std-devel \
 rust-futures-lite-devel \
 "
RDEPENDS:rust-futures-lite+fastrand-devel = " \
 cargo \
 rust-fastrand-devel \
 rust-futures-lite-devel \
 "
RDEPENDS:rust-futures-lite+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-futures-lite-devel \
 "
RDEPENDS:rust-futures-lite+memchr-devel = " \
 cargo \
 rust-futures-lite-devel \
 rust-memchr+default-devel \
 "
RDEPENDS:rust-futures-lite+parking-devel = " \
 cargo \
 rust-futures-lite-devel \
 rust-parking+default-devel \
 "
RDEPENDS:rust-futures-lite+race-devel = " \
 cargo \
 rust-futures-lite+fastrand-devel \
 rust-futures-lite-devel \
 "
RDEPENDS:rust-futures-lite+std-devel = " \
 cargo \
 rust-fastrand+std-devel \
 rust-fastrand-devel \
 rust-futures-lite+alloc-devel \
 rust-futures-lite+futures-io-devel \
 rust-futures-lite+parking-devel \
 rust-futures-lite-devel \
 "
RDEPENDS:rust-futures-lite-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-pin-project-lite+default-devel \
 "
