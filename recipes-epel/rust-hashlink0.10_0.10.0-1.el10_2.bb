# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashlink0.10"
PV = "0.10.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-hashlink0.10+default-devel \
 rust-hashlink0.10+serde-devel \
 rust-hashlink0.10+serde_impl-devel \
 rust-hashlink0.10-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hashlink0.10-0.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46102d0857ad16db78ca7559f9784d26edaf2cee5f32ba889640380c8affffe7"

URI_x86_64_v2_rust-hashlink0.10+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink0.10+default-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink0.10+default-devel}"
SRC_URI[x86_64_v2_rust-hashlink0.10+default-devel.sha256sum] = "7b8e6ca7cfcbdfe00001adb2d42c4eb7262f882bd8412b91e010c36ca371f395"

URI_x86_64_v2_rust-hashlink0.10+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink0.10+serde-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink0.10+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink0.10+serde-devel}"
SRC_URI[x86_64_v2_rust-hashlink0.10+serde-devel.sha256sum] = "9357228ae6d612e5bcbd1e8a65b3e9d9607bf90f2ee238850a58666b939daa82"

URI_x86_64_v2_rust-hashlink0.10+serde_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink0.10+serde_impl-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink0.10+serde_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink0.10+serde_impl-devel}"
SRC_URI[x86_64_v2_rust-hashlink0.10+serde_impl-devel.sha256sum] = "7d31945e4e7574fe7fbf661d63377c129a6a72ef56cbacfc48e0606b18d88afd"

URI_x86_64_v2_rust-hashlink0.10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink0.10-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink0.10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink0.10-devel}"
SRC_URI[x86_64_v2_rust-hashlink0.10-devel.sha256sum] = "f0ba0106fab5ab3906ad86d570c1930a2eb7ee30ce1e4d9662232f440ed3ff2b"

URI_aarch64_rust-hashlink0.10+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink0.10+default-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-hashlink0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink0.10+default-devel}"
SRC_URI[aarch64_rust-hashlink0.10+default-devel.sha256sum] = "28d582b5dead32e6fc3957fb689d73e5ea32945f49c2d41d264424a3425aac39"

URI_aarch64_rust-hashlink0.10+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink0.10+serde-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-hashlink0.10+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink0.10+serde-devel}"
SRC_URI[aarch64_rust-hashlink0.10+serde-devel.sha256sum] = "708120f26f2656989b5288fd3e88283aebcb055f9b77e9df7b6a8305a2402e29"

URI_aarch64_rust-hashlink0.10+serde_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink0.10+serde_impl-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-hashlink0.10+serde_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink0.10+serde_impl-devel}"
SRC_URI[aarch64_rust-hashlink0.10+serde_impl-devel.sha256sum] = "49d29bc1d2ba873efcad515fdec3f4779f7a2ef38fbc5d0bd12e7f18e08f2a3f"

URI_aarch64_rust-hashlink0.10-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink0.10-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-hashlink0.10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink0.10-devel}"
SRC_URI[aarch64_rust-hashlink0.10-devel.sha256sum] = "00e2ce91210682854f653dfacd2dfe4f56901b435b382b51ec5f4df0a6642da9"

RDEPENDS:rust-hashlink0.10+default-devel = " \
 cargo \
 rust-hashlink0.10-devel \
 "
RDEPENDS:rust-hashlink0.10+serde-devel = " \
 cargo \
 rust-hashlink0.10-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-hashlink0.10+serde_impl-devel = " \
 cargo \
 rust-hashlink0.10+serde-devel \
 rust-hashlink0.10-devel \
 "
RDEPENDS:rust-hashlink0.10-devel = " \
 cargo \
 rust \
 rust-hashbrown0.15+default-hasher-devel \
 rust-hashbrown0.15+inline-more-devel \
 rust-hashbrown0.15-devel \
 "
