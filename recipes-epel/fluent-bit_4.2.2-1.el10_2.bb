# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fluent-bit"
PV = "4.2.2"
PR = "1.el10_2"
PACKAGES = " \
 fluent-bit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fluent-bit-4.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e46d6f1592406a8a08d9d48a3da771887ea5f7986f1cbc2e3acebc6c1fa1cc8"

URI_x86_64_v2_fluent-bit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fluent-bit-4.2.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fluent-bit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fluent-bit}"
SRC_URI[x86_64_v2_fluent-bit.sha256sum] = "399203827e88a16403b2ffbcdd535cc2a23deb7ac8a93c84c3698371b88da264"

URI_aarch64_fluent-bit = "${EPEL_MIRROR}/aarch64/Packages/f/fluent-bit-4.2.2-1.el10_2.aarch64.rpm;name=aarch64_fluent-bit;unpack=0"
SRC_URI:append = " ${URI_aarch64_fluent-bit}"
SRC_URI[aarch64_fluent-bit.sha256sum] = "3a164d8f83e5bf4e3954c5112df4299fcc8fb0c1f3d94412c637c14698d2f1f2"

RDEPENDS:fluent-bit = " \
 bash \
 cyrus-sasl-lib \
 glibc \
 libgcc \
 libstdc++ \
 libyaml \
 libzstd \
 openssl-libs \
 systemd \
 systemd-libs \
 zlib-ng-compat \
 "
