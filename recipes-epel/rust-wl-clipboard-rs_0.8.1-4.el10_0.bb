# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wl-clipboard-rs"
PV = "0.8.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-wl-clipboard-rs+default-devel \
 rust-wl-clipboard-rs+dlopen-devel \
 rust-wl-clipboard-rs+native_lib-devel \
 rust-wl-clipboard-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wl-clipboard-rs-0.8.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52afd2461b1dccd25be9748d796ec71d1f5d106f24f2eb840b018af9e2fed8c0"

URI_x86_64_v2_rust-wl-clipboard-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wl-clipboard-rs+default-devel-0.8.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wl-clipboard-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wl-clipboard-rs+default-devel}"
SRC_URI[x86_64_v2_rust-wl-clipboard-rs+default-devel.sha256sum] = "63fe84b4800572e4b6128fc8dcadb22f2cf76f74c2309e881a676af68e04f33f"

URI_x86_64_v2_rust-wl-clipboard-rs+dlopen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wl-clipboard-rs+dlopen-devel-0.8.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wl-clipboard-rs+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wl-clipboard-rs+dlopen-devel}"
SRC_URI[x86_64_v2_rust-wl-clipboard-rs+dlopen-devel.sha256sum] = "7b711303647caf8679a6dab2338d7436d74786dd8a2d02dc3f7cd442a4c29386"

URI_x86_64_v2_rust-wl-clipboard-rs+native_lib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wl-clipboard-rs+native_lib-devel-0.8.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wl-clipboard-rs+native_lib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wl-clipboard-rs+native_lib-devel}"
SRC_URI[x86_64_v2_rust-wl-clipboard-rs+native_lib-devel.sha256sum] = "4211730ef160f315d1a5a71c276208ee218985b2e4d56ccf99e889fc266b19b7"

URI_x86_64_v2_rust-wl-clipboard-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wl-clipboard-rs-devel-0.8.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wl-clipboard-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wl-clipboard-rs-devel}"
SRC_URI[x86_64_v2_rust-wl-clipboard-rs-devel.sha256sum] = "005caf4e4083bb4b2d0389ac1a39081985c0594106f77c7a2162d348ba4fa9e8"

URI_aarch64_rust-wl-clipboard-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wl-clipboard-rs+default-devel-0.8.1-4.el10_0.noarch.rpm;name=aarch64_rust-wl-clipboard-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wl-clipboard-rs+default-devel}"
SRC_URI[aarch64_rust-wl-clipboard-rs+default-devel.sha256sum] = "79a9d1dce30430f36dd3daa35bf96a764369ca20fbba84589bb3db463d8dac25"

URI_aarch64_rust-wl-clipboard-rs+dlopen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wl-clipboard-rs+dlopen-devel-0.8.1-4.el10_0.noarch.rpm;name=aarch64_rust-wl-clipboard-rs+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wl-clipboard-rs+dlopen-devel}"
SRC_URI[aarch64_rust-wl-clipboard-rs+dlopen-devel.sha256sum] = "08e559e0191d20dc8de1dd80e5e9661c32dd6c6da2e164ccaa0e7a460c1d4573"

URI_aarch64_rust-wl-clipboard-rs+native_lib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wl-clipboard-rs+native_lib-devel-0.8.1-4.el10_0.noarch.rpm;name=aarch64_rust-wl-clipboard-rs+native_lib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wl-clipboard-rs+native_lib-devel}"
SRC_URI[aarch64_rust-wl-clipboard-rs+native_lib-devel.sha256sum] = "7978af23f281bbd3248be78c1c5c650b11d3332edf61ec95646bd98cbb836eb5"

URI_aarch64_rust-wl-clipboard-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wl-clipboard-rs-devel-0.8.1-4.el10_0.noarch.rpm;name=aarch64_rust-wl-clipboard-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wl-clipboard-rs-devel}"
SRC_URI[aarch64_rust-wl-clipboard-rs-devel.sha256sum] = "bca9ecf63fb2bad68c1dd3d323ea4b979ef4fa7390f82a2a45aa9c95f2d6af6d"

RDEPENDS:rust-wl-clipboard-rs+default-devel = " \
 cargo \
 rust-wl-clipboard-rs-devel \
 "
RDEPENDS:rust-wl-clipboard-rs+dlopen-devel = " \
 cargo \
 rust-wayland-backend+dlopen-devel \
 rust-wl-clipboard-rs+native_lib-devel \
 rust-wl-clipboard-rs-devel \
 "
RDEPENDS:rust-wl-clipboard-rs+native_lib-devel = " \
 cargo \
 rust-wayland-backend+client_system-devel \
 rust-wayland-backend+server_system-devel \
 rust-wl-clipboard-rs-devel \
 "
RDEPENDS:rust-wl-clipboard-rs-devel = " \
 cargo \
 rust-derive-new+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-nix0.28+default-devel \
 rust-nix0.28+event-devel \
 rust-nix0.28+fs-devel \
 rust-nix0.28+process-devel \
 rust-os_pipe+default-devel \
 rust-os_pipe+io_safety-devel \
 rust-tempfile+default-devel \
 rust-thiserror1+default-devel \
 rust-tree_magic_mini+default-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-client+default-devel \
 rust-wayland-protocols+client-devel \
 rust-wayland-protocols+default-devel \
 rust-wayland-protocols-wlr+client-devel \
 rust-wayland-protocols-wlr+default-devel \
 "
