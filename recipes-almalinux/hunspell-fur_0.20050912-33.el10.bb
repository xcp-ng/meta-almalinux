# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-fur"
PV = "0.20050912"
PR = "33.el10"
PACKAGES = " \
 hunspell-fur \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-fur-0.20050912-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c80cccb11c62e1587f21c87c0a1cdf69bb7f71835dcf04a03988399d1fbd5124"

URI_x86_64_v2_hunspell-fur = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-fur-0.20050912-33.el10.noarch.rpm;name=x86_64_v2_hunspell-fur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-fur}"
SRC_URI[x86_64_v2_hunspell-fur.sha256sum] = "609c225c395e1de8a09011b776d3d4b54a96533799cfc9d1117a5b995dcf4363"

URI_aarch64_hunspell-fur = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-fur-0.20050912-33.el10.noarch.rpm;name=aarch64_hunspell-fur;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-fur}"
SRC_URI[aarch64_hunspell-fur.sha256sum] = "609c225c395e1de8a09011b776d3d4b54a96533799cfc9d1117a5b995dcf4363"

RDEPENDS:hunspell-fur = " \
 hunspell-filesystem \
 "
