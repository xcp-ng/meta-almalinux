# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-linux-raw-sys"
PV = "0.9.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-linux-raw-sys+bootparam-devel \
 rust-linux-raw-sys+btrfs-devel \
 rust-linux-raw-sys+default-devel \
 rust-linux-raw-sys+elf-devel \
 rust-linux-raw-sys+elf_uapi-devel \
 rust-linux-raw-sys+errno-devel \
 rust-linux-raw-sys+general-devel \
 rust-linux-raw-sys+if_arp-devel \
 rust-linux-raw-sys+if_ether-devel \
 rust-linux-raw-sys+if_packet-devel \
 rust-linux-raw-sys+image-devel \
 rust-linux-raw-sys+io_uring-devel \
 rust-linux-raw-sys+ioctl-devel \
 rust-linux-raw-sys+landlock-devel \
 rust-linux-raw-sys+loop_device-devel \
 rust-linux-raw-sys+mempolicy-devel \
 rust-linux-raw-sys+net-devel \
 rust-linux-raw-sys+netlink-devel \
 rust-linux-raw-sys+no_std-devel \
 rust-linux-raw-sys+prctl-devel \
 rust-linux-raw-sys+ptrace-devel \
 rust-linux-raw-sys+std-devel \
 rust-linux-raw-sys+system-devel \
 rust-linux-raw-sys+xdp-devel \
 rust-linux-raw-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-linux-raw-sys-0.9.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e99ffcab5e8b586456760b048a753bb26706f4d1c8bb78d4e7cdd8a02a9b031"

URI_x86_64_v2_rust-linux-raw-sys+bootparam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+bootparam-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+bootparam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+bootparam-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+bootparam-devel.sha256sum] = "96be2ee446184eace2834ad3e52254c584781aa58050a880cf27b754326e30cf"

URI_x86_64_v2_rust-linux-raw-sys+btrfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+btrfs-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+btrfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+btrfs-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+btrfs-devel.sha256sum] = "27f194cb86e41ff48c1895de1309f5dbf0a8927734e4baca41453fcc363b7652"

URI_x86_64_v2_rust-linux-raw-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+default-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+default-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+default-devel.sha256sum] = "8048b044b4ba83ae03ffd977e59c124eb3076d96b328f17e65003a649055acd1"

URI_x86_64_v2_rust-linux-raw-sys+elf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+elf-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+elf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+elf-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+elf-devel.sha256sum] = "014c4deb7017bac7690064c64c3c508e8b3a7a0869dbc4c9a6e11d9a6f99348a"

URI_x86_64_v2_rust-linux-raw-sys+elf_uapi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+elf_uapi-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+elf_uapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+elf_uapi-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+elf_uapi-devel.sha256sum] = "066aaabdf1f24de6291c2c39ddf808b70bfbee351d3ce3c1f96b9a536bf98bbb"

URI_x86_64_v2_rust-linux-raw-sys+errno-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+errno-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+errno-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+errno-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+errno-devel.sha256sum] = "80c6c6f6eac244202ae86e1d145561aa94d011a8a061b2a64f15569fc3568e2f"

URI_x86_64_v2_rust-linux-raw-sys+general-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+general-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+general-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+general-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+general-devel.sha256sum] = "688b6c6e17de6324dadc0a306a6b45dd8ce197befb47e83abc1513dc7ab33117"

URI_x86_64_v2_rust-linux-raw-sys+if_arp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+if_arp-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+if_arp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+if_arp-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+if_arp-devel.sha256sum] = "bd72db97151045600111c1261da04194f38d905b3d4feef5fd2918cc72fe7a3a"

URI_x86_64_v2_rust-linux-raw-sys+if_ether-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+if_ether-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+if_ether-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+if_ether-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+if_ether-devel.sha256sum] = "b04969c04727aeb4d33fc231d4dcc3726b5a77304ff4262f88dacdbc3d4a35dd"

URI_x86_64_v2_rust-linux-raw-sys+if_packet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+if_packet-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+if_packet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+if_packet-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+if_packet-devel.sha256sum] = "e4d7939363f8ee4414aa3ffa5885205dc677f3cb4408939324f73be3f166372a"

URI_x86_64_v2_rust-linux-raw-sys+image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+image-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+image-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+image-devel.sha256sum] = "947173ccf0bfe1bf73075f977cd48812310ab5db0b2617b1f80b63b8a542c285"

URI_x86_64_v2_rust-linux-raw-sys+io_uring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+io_uring-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+io_uring-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+io_uring-devel.sha256sum] = "c91bacef9ef006e82434671cddd61208c1930a6410a6adbf40dc7791cdaf3f52"

URI_x86_64_v2_rust-linux-raw-sys+ioctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+ioctl-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+ioctl-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+ioctl-devel.sha256sum] = "c78edfac38f09a378e102ae1764681d9d7d3091404d3b4b9061b200a3a5c967b"

URI_x86_64_v2_rust-linux-raw-sys+landlock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+landlock-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+landlock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+landlock-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+landlock-devel.sha256sum] = "e73fd82cf5a441f527275bc1e6d487671ce12269d22d75978e187f5c71c61bf7"

URI_x86_64_v2_rust-linux-raw-sys+loop_device-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+loop_device-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+loop_device-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+loop_device-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+loop_device-devel.sha256sum] = "b1f0dc7497ec9034f000da68e5febbc1027841da7e9c0e90c18aaadd98837d43"

URI_x86_64_v2_rust-linux-raw-sys+mempolicy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+mempolicy-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+mempolicy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+mempolicy-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+mempolicy-devel.sha256sum] = "dc5eaaa3e257e0d548ba96883b042109e30aa37c80d775a497373de28d0013b7"

URI_x86_64_v2_rust-linux-raw-sys+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+net-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+net-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+net-devel.sha256sum] = "32ce650c25d6d2bf1b4409e967bc0b1559d66249665850b5e4395c7e2a551796"

URI_x86_64_v2_rust-linux-raw-sys+netlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+netlink-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+netlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+netlink-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+netlink-devel.sha256sum] = "a1d1ab7509d450e85e563e30e83e91f00b7695aaae49153884aae6db5d9b3797"

URI_x86_64_v2_rust-linux-raw-sys+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+no_std-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+no_std-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+no_std-devel.sha256sum] = "438617b97bbcb16717e6b00f4c045674ba5f69ddb9ac1846c41bf1a7c0d73aa5"

URI_x86_64_v2_rust-linux-raw-sys+prctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+prctl-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+prctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+prctl-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+prctl-devel.sha256sum] = "1dcb098c772e35de252fa7c1b509ff96a541f5b4cce1812d988cf2ce76177c74"

URI_x86_64_v2_rust-linux-raw-sys+ptrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+ptrace-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+ptrace-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+ptrace-devel.sha256sum] = "af5a3972e0fd2f714b93f8e5118e733d7f81a64fe6fbd01e7e51fb3ee95c8abc"

URI_x86_64_v2_rust-linux-raw-sys+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+std-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+std-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+std-devel.sha256sum] = "32ee11582247967d526488e2b92e145038cb115ccedeeed30aad7f95a0322b6c"

URI_x86_64_v2_rust-linux-raw-sys+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+system-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+system-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+system-devel.sha256sum] = "fd4580910debdf4e32260b82793db0350fe4f8ed95b6bd13e8cd3058a8974632"

URI_x86_64_v2_rust-linux-raw-sys+xdp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+xdp-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+xdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+xdp-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+xdp-devel.sha256sum] = "f3c3717cb5789c254357909e87452b3b75f8c719c7eb779250bc628a6d60dd66"

URI_x86_64_v2_rust-linux-raw-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys-devel-0.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys-devel.sha256sum] = "945d2b0438b9104ceb4db9b3515e1e70c349408d7cc44005c984ec60af8a0fa2"

URI_aarch64_rust-linux-raw-sys+bootparam-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+bootparam-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+bootparam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+bootparam-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+bootparam-devel.sha256sum] = "1427ff21a0a1cd363b7ed003606c2be85c367c3bbb4a0c0415e6c4e0c4cdcaea"

URI_aarch64_rust-linux-raw-sys+btrfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+btrfs-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+btrfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+btrfs-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+btrfs-devel.sha256sum] = "aa2a063d5abeceaaf9664534288ad933cb1f6bc106b8baa523549fdc975fbb41"

URI_aarch64_rust-linux-raw-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+default-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+default-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+default-devel.sha256sum] = "9b7dc2f8e0f63282d07ca21305884d6293a83d45084b9e03417a4c1a656f3088"

URI_aarch64_rust-linux-raw-sys+elf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+elf-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+elf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+elf-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+elf-devel.sha256sum] = "9aaacd50d0294ce105dddad7065738c739ad66cc8d92853d46f3571982e019db"

URI_aarch64_rust-linux-raw-sys+elf_uapi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+elf_uapi-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+elf_uapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+elf_uapi-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+elf_uapi-devel.sha256sum] = "b6c66f4d12a0bb0185a7496ca495eca033b867353a33f456ccacfd842ba8f11b"

URI_aarch64_rust-linux-raw-sys+errno-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+errno-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+errno-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+errno-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+errno-devel.sha256sum] = "101175b5f26db6f0b3c416892a35a07908e3b5c75b1d0ad7d7421d292c9064c7"

URI_aarch64_rust-linux-raw-sys+general-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+general-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+general-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+general-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+general-devel.sha256sum] = "65a94dd232dec0b7741ff1ed28952c8edf2f0e8e6dc72d387315b310a53b1140"

URI_aarch64_rust-linux-raw-sys+if_arp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+if_arp-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+if_arp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+if_arp-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+if_arp-devel.sha256sum] = "57a747f94b41542061dbb32d497dc7bd4fc1e59c4df7a4618d1052abdb9bb6d4"

URI_aarch64_rust-linux-raw-sys+if_ether-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+if_ether-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+if_ether-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+if_ether-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+if_ether-devel.sha256sum] = "795b4a53d0a5d7e7cdaee97cdd273b7052e611fb0ad6d5d3d927781fbb427b69"

URI_aarch64_rust-linux-raw-sys+if_packet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+if_packet-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+if_packet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+if_packet-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+if_packet-devel.sha256sum] = "bd1497e36d85f3516e872ed2dd2ff38e9f0b50fede0f24abdb2ebf4faed58dcb"

URI_aarch64_rust-linux-raw-sys+image-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+image-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+image-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+image-devel.sha256sum] = "e4a219b069b664aa02a071fdff876cf6c8f79c8f6055db641e1b541efda833ca"

URI_aarch64_rust-linux-raw-sys+io_uring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+io_uring-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+io_uring-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+io_uring-devel.sha256sum] = "1645a3fcfc147f64cbe4f5684cd6ed9f535aa37e90eb712a557cedcc8b5c4c11"

URI_aarch64_rust-linux-raw-sys+ioctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+ioctl-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+ioctl-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+ioctl-devel.sha256sum] = "ac286216471d52fb534f37dc1ee2fc5d067762fa368de7c9d0476d6ecae55140"

URI_aarch64_rust-linux-raw-sys+landlock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+landlock-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+landlock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+landlock-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+landlock-devel.sha256sum] = "b5f43563d7f8b4b83c6de24321649772da533a7f8a773f39879ab980aa9b9fb5"

URI_aarch64_rust-linux-raw-sys+loop_device-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+loop_device-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+loop_device-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+loop_device-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+loop_device-devel.sha256sum] = "9c2ec056d73d47e285d12df9178dafd6fab88d74c817229ad468f018a1eccc14"

URI_aarch64_rust-linux-raw-sys+mempolicy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+mempolicy-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+mempolicy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+mempolicy-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+mempolicy-devel.sha256sum] = "77704eb8de69ea069e79772bcdd1672a780bc7165a523b89a051a0dc1f81a5ca"

URI_aarch64_rust-linux-raw-sys+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+net-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+net-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+net-devel.sha256sum] = "91769b20a8ef4c3f3aa3ca6aeeb68b0b8ef216de1d549b62ed526ec97074d4b8"

URI_aarch64_rust-linux-raw-sys+netlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+netlink-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+netlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+netlink-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+netlink-devel.sha256sum] = "be702da80a4c021f9e8b6a664918802c010b9dd387d15502eee190bb39af4a0c"

URI_aarch64_rust-linux-raw-sys+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+no_std-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+no_std-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+no_std-devel.sha256sum] = "cd5842d596d73314249e90a87de95bbe14393b992638965580594806c0329337"

URI_aarch64_rust-linux-raw-sys+prctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+prctl-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+prctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+prctl-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+prctl-devel.sha256sum] = "20cc01a1578eff777229e19cacf58c6a8f3f3445d0836c6b59200aeecbd53487"

URI_aarch64_rust-linux-raw-sys+ptrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+ptrace-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+ptrace-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+ptrace-devel.sha256sum] = "d50f8dde718cdb0064c6c305d76811856fd59ffc892e2528cf7a4cdebfd3a09c"

URI_aarch64_rust-linux-raw-sys+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+std-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+std-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+std-devel.sha256sum] = "5e6549c07261825c1deee591a6fe56035637aaa96a54987e7347f9a02ff09e5a"

URI_aarch64_rust-linux-raw-sys+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+system-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+system-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+system-devel.sha256sum] = "cb95f968712a2c43d896e77d31b2c0f0a9b443613216348297bea6334eda9747"

URI_aarch64_rust-linux-raw-sys+xdp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+xdp-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys+xdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+xdp-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+xdp-devel.sha256sum] = "5cc4d986859fab44ee2d00b1898cabf5f5f74585e9100f399918f1421e66f7d7"

URI_aarch64_rust-linux-raw-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys-devel-0.9.4-1.el10_1.noarch.rpm;name=aarch64_rust-linux-raw-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys-devel}"
SRC_URI[aarch64_rust-linux-raw-sys-devel.sha256sum] = "80d4e70c43396959094f199125430b36abe94b0a3a7c7a3225d7e3c237975e2f"

RDEPENDS:rust-linux-raw-sys+bootparam-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+btrfs-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+default-devel = " \
 cargo \
 rust-linux-raw-sys+errno-devel \
 rust-linux-raw-sys+general-devel \
 rust-linux-raw-sys+std-devel \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+elf-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+elf_uapi-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+errno-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+general-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+if_arp-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+if_ether-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+if_packet-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+image-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+io_uring-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+ioctl-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+landlock-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+loop_device-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+mempolicy-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+net-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+netlink-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+no_std-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+prctl-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+ptrace-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+std-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+system-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+xdp-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys-devel = " \
 cargo \
 rust \
 "
