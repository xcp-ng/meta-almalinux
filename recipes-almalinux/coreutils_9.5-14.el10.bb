# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "coreutils"
PV = "9.5"
PR = "14.el10"
PACKAGES = " \
 coreutils \
 coreutils-common \
 coreutils-single \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/coreutils-9.5-14.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "076a17de46e5a674b6417da3bba735c1d62e578da0c70d4562d9fd34bf62da3a"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - coreutils-single: libcap.so.2()(64bit)
# - coreutils: libcap.so.2()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/coreutils-9.5-14.el10.x86_64_v2.rpm;name=x86_64_v2_coreutils;unpack=0"
SRC_URI[x86_64_v2_coreutils.sha256sum] = "46a8f0b4c2b0f0962615e6e560fc335bc96bd87658ae2910726d5818375c0786"
RPROVIDES:coreutils:append:x86_64_v2 = " virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/coreutils-common-9.5-14.el10.x86_64_v2.rpm;name=x86_64_v2_coreutils-common;unpack=0"
SRC_URI[x86_64_v2_coreutils-common.sha256sum] = "5d0e4d16127ee51e8cf59e40c8ce03e94572af54fa7760e30c8de05d38dc96ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/coreutils-single-9.5-14.el10.x86_64_v2.rpm;name=x86_64_v2_coreutils-single;unpack=0"
SRC_URI[x86_64_v2_coreutils-single.sha256sum] = "4deb0c792af92a40c72f3677912f93b4c155a89b28ba69e78f7999464fdf2312"
RPROVIDES:coreutils-single:append:x86_64_v2 = " virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/coreutils-9.5-14.el10.aarch64.rpm;name=aarch64_coreutils;unpack=0"
SRC_URI[aarch64_coreutils.sha256sum] = "de7d68859f3cfaf4cc0ecaccb0121c96726a657be4f547ca412e6a5f576ee153"
RPROVIDES:coreutils:append:aarch64 = " virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/coreutils-common-9.5-14.el10.aarch64.rpm;name=aarch64_coreutils-common;unpack=0"
SRC_URI[aarch64_coreutils-common.sha256sum] = "6d94673433a4c6caec8464f3eab9ed0d35fcb006ab144a3db79bcb2aa4453561"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/coreutils-single-9.5-14.el10.aarch64.rpm;name=aarch64_coreutils-single;unpack=0"
SRC_URI[aarch64_coreutils-single.sha256sum] = "9c00faab03160a250058492d3078fa15a129323c78e91e1c1aa37830bd248977"
RPROVIDES:coreutils-single:append:aarch64 = " virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

RDEPENDS:coreutils:x86_64_v2 = " \
 coreutils-common \
 glibc \
 gmp \
 libacl \
 libattr \
 libcap \
 libselinux \
 openssl-libs \
"
RDEPENDS:coreutils:aarch64 = " \
 coreutils-common \
 glibc \
 gmp \
 libacl \
 libattr \
 libselinux \
 openssl-libs \
"
RDEPENDS:coreutils-common = " \
 "
RDEPENDS:coreutils-single:x86_64_v2 = " \
 glibc \
 libacl \
 libattr \
 libcap \
 libselinux \
"
RDEPENDS:coreutils-single:aarch64 = " \
 glibc \
 libacl \
 libattr \
 libselinux \
"
