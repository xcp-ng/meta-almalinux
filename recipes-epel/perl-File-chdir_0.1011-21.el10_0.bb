# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-chdir"
PV = "0.1011"
PR = "21.el10_0"
PACKAGES = " \
 perl-File-chdir \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-chdir-0.1011-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81c55a5d27bc14e42fc0bd6344cae8d4b7b96fe047b957db85e2eefe9f2215f7"

URI_x86_64_v2_perl-File-chdir = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-chdir-0.1011-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-chdir;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-chdir}"
SRC_URI[x86_64_v2_perl-File-chdir.sha256sum] = "aa5c0ed99514eff405c5476f65b4fd78925b36f0a5d96e58714a3799ce3b527c"

URI_aarch64_perl-File-chdir = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-chdir-0.1011-21.el10_0.noarch.rpm;name=aarch64_perl-File-chdir;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-chdir}"
SRC_URI[aarch64_perl-File-chdir.sha256sum] = "bb72ba7bc494062e4557fd86e7e47a65763c18b5545f8e82f3095973b97654af"

RDEPENDS:perl-File-chdir = " \
 perl-Carp \
 perl-Exporter \
 perl-PathTools \
 perl-libs \
 perl-vars \
 "
