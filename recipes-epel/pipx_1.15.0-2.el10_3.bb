# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pipx"
PV = "1.15.0"
PR = "2.el10_3"
PACKAGES = " \
 pipx \
 pipx+uv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pipx-1.15.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e870289e71558f4101b504a482561694333119376ae7fc7c6a324ae17c26ec48"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - pipx+uv: python3.12dist(uv) >= 0.4

URI_x86_64_v2_pipx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pipx-1.15.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pipx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipx}"
SRC_URI[x86_64_v2_pipx.sha256sum] = "189b44509b21b0abb3959f2eaebc7cd13fb4eb11f4cc4776d567c7e56df01e2e"

URI_x86_64_v2_pipx+uv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pipx+uv-1.15.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pipx+uv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipx+uv}"
SRC_URI[x86_64_v2_pipx+uv.sha256sum] = "9d67dfec57e66ac0fdf4ba2f58545b451f3b584a0fdb28137ca6f9f9e83b1611"

URI_aarch64_pipx = "${EPEL_MIRROR}/aarch64/Packages/p/pipx-1.15.0-2.el10_3.noarch.rpm;name=aarch64_pipx;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipx}"
SRC_URI[aarch64_pipx.sha256sum] = "e9fbad1a06bbcb2be2b094fd6375ca9f3b5fb6519f7ffb12c7c84b83a148f42b"

URI_aarch64_pipx+uv = "${EPEL_MIRROR}/aarch64/Packages/p/pipx+uv-1.15.0-2.el10_3.noarch.rpm;name=aarch64_pipx+uv;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipx+uv}"
SRC_URI[aarch64_pipx+uv.sha256sum] = "923458fdea07efb9ff706907f3cdfdc4983fc8947b7f4cc0bcf8034fc50f653e"

RDEPENDS:pipx = " \
 python3 \
 python3-argcomplete \
 python3-packaging \
 python3-platformdirs \
 python3-userpath \
 "
RDEPENDS:pipx+uv:x86_64_v2 = " \
 pipx \
 python3 \
"
RDEPENDS:pipx+uv:aarch64 = " \
 pipx \
 python3 \
 python3-uv \
"
