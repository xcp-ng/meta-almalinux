# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-regex"
PV = "2024.11.6"
PR = "1.el10_1"
PACKAGES = " \
 python3-regex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-regex-2024.11.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99d480b2d278f74418c5fc110740891801c920eacd51d06b4dccea7d5b79dd5e"

URI_x86_64_v2_python3-regex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-regex-2024.11.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-regex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-regex}"
SRC_URI[x86_64_v2_python3-regex.sha256sum] = "8d8d7229b455b00980a8d8c36f4c7ff31b082374319c60ef46a3d29963041fe2"

URI_aarch64_python3-regex = "${EPEL_MIRROR}/aarch64/Packages/p/python3-regex-2024.11.6-1.el10_1.aarch64.rpm;name=aarch64_python3-regex;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-regex}"
SRC_URI[aarch64_python3-regex.sha256sum] = "d5ebbeed6560c7c5d3cb619d00e6adcbf3daad7672b0f20366d27dca79449ce4"

RDEPENDS:python3-regex = " \
 glibc \
 python3 \
 "
