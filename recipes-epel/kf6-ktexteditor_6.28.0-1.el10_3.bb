# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ktexteditor"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-ktexteditor \
 kf6-ktexteditor-devel \
 kf6-ktexteditor-doc \
 kf6-ktexteditor-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ktexteditor-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ed54b3744b3862f4b2c3be6e7ce9db4f61497094c3411bf5b6c9212a317d63d"

URI_x86_64_v2_kf6-ktexteditor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexteditor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexteditor}"
SRC_URI[x86_64_v2_kf6-ktexteditor.sha256sum] = "e5651df590ae5669498b183287d39e38b52232ccb39967cf4967407d9d10e644"

URI_x86_64_v2_kf6-ktexteditor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexteditor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexteditor-devel}"
SRC_URI[x86_64_v2_kf6-ktexteditor-devel.sha256sum] = "bc71f74e725db2763f187b9c6934b8917179d8705c638cabca062ccf0ce754a3"

URI_x86_64_v2_kf6-ktexteditor-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexteditor-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexteditor-doc}"
SRC_URI[x86_64_v2_kf6-ktexteditor-doc.sha256sum] = "b06873b1dfc450a4ec3561f106a14c5179cf58a40de81bcebc6387d6d56f816f"

URI_x86_64_v2_kf6-ktexteditor-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexteditor-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexteditor-html}"
SRC_URI[x86_64_v2_kf6-ktexteditor-html.sha256sum] = "45b1c5f4feda06e84ae3b3e16f3266d2582706ac51a99430ada9b997281ef5a5"

URI_aarch64_kf6-ktexteditor = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ktexteditor;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexteditor}"
SRC_URI[aarch64_kf6-ktexteditor.sha256sum] = "77b3c09b764809e18a4ae071aee6019791928a2037a65e6a0220a9f0b4d24c24"

URI_aarch64_kf6-ktexteditor-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ktexteditor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexteditor-devel}"
SRC_URI[aarch64_kf6-ktexteditor-devel.sha256sum] = "3bf03abb3e179398ddf5422e50b68758544f657ff092aacf32c979cac99d5e08"

URI_aarch64_kf6-ktexteditor-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ktexteditor-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexteditor-doc}"
SRC_URI[aarch64_kf6-ktexteditor-doc.sha256sum] = "d8cd4174d718ffb9b0fc4a682ccc21bb5594bdbaa0c6bc94a69a27d6b9bfa50c"

URI_aarch64_kf6-ktexteditor-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ktexteditor-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexteditor-html}"
SRC_URI[aarch64_kf6-ktexteditor-html.sha256sum] = "f24478acfb280d6ab0348c4c5922e3ff51ad4cfd211f8cd85fb59b300765f883"

RDEPENDS:kf6-ktexteditor = " \
 editorconfig-libs \
 git-core \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kauth \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 kf6-syntax-highlighting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtspeech \
 "
RDEPENDS:kf6-ktexteditor-devel = " \
 cmake-filesystem \
 kf6-kparts-devel \
 kf6-ktexteditor \
 kf6-syntax-highlighting-devel \
 "
RDEPENDS:kf6-ktexteditor-doc = " \
 "
RDEPENDS:kf6-ktexteditor-html = " \
 "
