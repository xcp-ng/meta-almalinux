# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-SSLeay"
PV = "1.94"
PR = "8.el10"
PACKAGES = " \
 perl-Net-SSLeay \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Net-SSLeay-1.94-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "517db521f1e30f9d9853e381611eb689107b59e1937b9e1e5c79e50c6107ca0f"

URI_x86_64_v2_perl-Net-SSLeay = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Net-SSLeay-1.94-8.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Net-SSLeay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-SSLeay}"
SRC_URI[x86_64_v2_perl-Net-SSLeay.sha256sum] = "c2f51fffa354fb9ed5b7b9e123832735763c0c2421a99181371177f4baaeca1a"

URI_aarch64_perl-Net-SSLeay = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Net-SSLeay-1.94-8.el10.aarch64.rpm;name=aarch64_perl-Net-SSLeay;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-SSLeay}"
SRC_URI[aarch64_perl-Net-SSLeay.sha256sum] = "0fc3c64c9ab190dfb7cb62235e69238b3440fc7bcb03208eb6dc1c9dbd6c53ab"

RDEPENDS:perl-Net-SSLeay = " \
 glibc \
 openssl-libs \
 perl-AutoLoader \
 perl-Carp \
 perl-Errno \
 perl-Exporter \
 perl-MIME-Base64 \
 perl-Net-SSLeay \
 perl-Socket \
 perl-libs \
 perl-vars \
 "
