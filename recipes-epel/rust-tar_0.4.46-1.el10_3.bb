# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tar"
PV = "0.4.46"
PR = "1.el10_3"
PACKAGES = " \
 rust-tar+default-devel \
 rust-tar+xattr-devel \
 rust-tar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tar-0.4.46-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d648517b605823320416c0460f1b9e0e8f90fcf85b5a58b2d50558ef3247850"

URI_x86_64_v2_rust-tar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar+default-devel-0.4.46-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tar+default-devel}"
SRC_URI[x86_64_v2_rust-tar+default-devel.sha256sum] = "5b47c8e979e5af81b8b22308fe1f1eac66aa72f4bc7a93896177a4fbd48e92ab"

URI_x86_64_v2_rust-tar+xattr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar+xattr-devel-0.4.46-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tar+xattr-devel}"
SRC_URI[x86_64_v2_rust-tar+xattr-devel.sha256sum] = "9a70acb6990f271e1fe3e6ef00cae50bef50c2832ae00c597a22321155fa1a8d"

URI_x86_64_v2_rust-tar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar-devel-0.4.46-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tar-devel}"
SRC_URI[x86_64_v2_rust-tar-devel.sha256sum] = "e3732a411d15306e750737c6515d9fcfff53238209921d7ec59730228337c785"

URI_aarch64_rust-tar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tar+default-devel-0.4.46-1.el10_3.noarch.rpm;name=aarch64_rust-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tar+default-devel}"
SRC_URI[aarch64_rust-tar+default-devel.sha256sum] = "5c821924c6de88a94eb5c27ad696cf2f8244fe4b9c22475bd97690227a93b043"

URI_aarch64_rust-tar+xattr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tar+xattr-devel-0.4.46-1.el10_3.noarch.rpm;name=aarch64_rust-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tar+xattr-devel}"
SRC_URI[aarch64_rust-tar+xattr-devel.sha256sum] = "f680c8d3df40c80026785ecc2321df4272712c438da4e96d454a1e374df53c95"

URI_aarch64_rust-tar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tar-devel-0.4.46-1.el10_3.noarch.rpm;name=aarch64_rust-tar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tar-devel}"
SRC_URI[aarch64_rust-tar-devel.sha256sum] = "9e27c4a3fff131bb2eeaf5e8dfd411009ae677080d5172ae368f2bc15e45ca98"

RDEPENDS:rust-tar+default-devel = " \
 cargo \
 rust-tar+xattr-devel \
 rust-tar-devel \
 "
RDEPENDS:rust-tar+xattr-devel = " \
 cargo \
 rust-tar-devel \
 rust-xattr+default-devel \
 "
RDEPENDS:rust-tar-devel = " \
 cargo \
 rust \
 rust-filetime+default-devel \
 rust-libc+default-devel \
 "
