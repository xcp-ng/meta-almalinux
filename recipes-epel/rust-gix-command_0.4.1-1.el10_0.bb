# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-command"
PV = "0.4.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-command+default-devel \
 rust-gix-command-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-command-0.4.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a543d40283900a3f687f987bfeaf56d27d959fb50ff268286832d3e3e1bc3af"

URI_x86_64_v2_rust-gix-command+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-command+default-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-command+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-command+default-devel}"
SRC_URI[x86_64_v2_rust-gix-command+default-devel.sha256sum] = "de59be2fbecfcec6a9ec419743b77fb5ea6a90efd653680e20bad14d26ede9a4"

URI_x86_64_v2_rust-gix-command-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-command-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-command-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-command-devel}"
SRC_URI[x86_64_v2_rust-gix-command-devel.sha256sum] = "37a787553d182389b362ea707a330fe4ad3114909c005398374ccc90cc938842"

URI_aarch64_rust-gix-command+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-command+default-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-gix-command+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-command+default-devel}"
SRC_URI[aarch64_rust-gix-command+default-devel.sha256sum] = "4f98918fae514f99fbfd3ba97ef8a75d1970f9dceee7e56eb889191229b6f146"

URI_aarch64_rust-gix-command-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-command-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-gix-command-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-command-devel}"
SRC_URI[aarch64_rust-gix-command-devel.sha256sum] = "c84a554aa78c6b31342b910dd8b834691f75d7ae7673919ea58a6028a03288ff"

RDEPENDS:rust-gix-command+default-devel = " \
 cargo \
 rust-gix-command-devel \
 "
RDEPENDS:rust-gix-command-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-path+default-devel \
 rust-gix-trace+default-devel \
 rust-shell-words+default-devel \
 "
