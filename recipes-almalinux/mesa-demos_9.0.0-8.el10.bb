# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mesa-demos"
PV = "9.0.0"
PR = "8.el10"
PACKAGES = " \
 egl-utils \
 glx-utils \
 mesa-demos \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mesa-demos-9.0.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "003cb657eebca179fc3ab04b368932831e34a3aea1e927d570b13cb887f06689"

URI_x86_64_v2_egl-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/egl-utils-9.0.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_egl-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_egl-utils}"
SRC_URI[x86_64_v2_egl-utils.sha256sum] = "9fe9f344f4565355981616d0868a9a3572cbddb4e359aa92ab48c9504bd177cd"

URI_x86_64_v2_glx-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glx-utils-9.0.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_glx-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glx-utils}"
SRC_URI[x86_64_v2_glx-utils.sha256sum] = "9731b36912f9a93350865e11f25959cd46d61ab6ab881ee080893eca2adcc383"

URI_x86_64_v2_mesa-demos = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-demos-9.0.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_mesa-demos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-demos}"
SRC_URI[x86_64_v2_mesa-demos.sha256sum] = "6c8000c3128b916c5a7715f60f50a96e3af74a96abd8dbc9b5bc3fb12d18235c"

URI_aarch64_egl-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/egl-utils-9.0.0-8.el10.aarch64.rpm;name=aarch64_egl-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_egl-utils}"
SRC_URI[aarch64_egl-utils.sha256sum] = "f1f65e9f10a7c6a34dcfa5afb157f9ba9eb6a882a90e62cfbffc65769cbe14e9"

URI_aarch64_glx-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glx-utils-9.0.0-8.el10.aarch64.rpm;name=aarch64_glx-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_glx-utils}"
SRC_URI[aarch64_glx-utils.sha256sum] = "85423eeda4987449dc052f5c16e0e0e06dd914c69618d6894d1535b7e2097306"

URI_aarch64_mesa-demos = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-demos-9.0.0-8.el10.aarch64.rpm;name=aarch64_mesa-demos;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-demos}"
SRC_URI[aarch64_mesa-demos.sha256sum] = "a946939c0319bf0c4658cf9f737fb35b5b90a5bdf729a4ae6abaef2a0467176f"

RDEPENDS:egl-utils = " \
 glibc \
 libX11 \
 libglvnd-egl \
 libglvnd-gles \
 "
RDEPENDS:glx-utils = " \
 glibc \
 libX11 \
 libglvnd-glx \
 "
RDEPENDS:mesa-demos = " \
 freeglut \
 glibc \
 libX11 \
 libXext \
 libdecor \
 libdrm \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 libglvnd-opengl \
 libwayland-client \
 libwayland-egl \
 libxcb \
 libxkbcommon \
 libxkbcommon-x11 \
 mesa-libGLU \
 mesa-libgbm \
 vulkan-loader \
 "
