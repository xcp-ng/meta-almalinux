# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bstr"
PV = "1.13.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-bstr+alloc-devel \
 rust-bstr+default-devel \
 rust-bstr+serde-devel \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-bstr-1.13.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "86f72896454520c48f260169eccf7065091cfeabfcc6b8202d32570151f0dffb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+alloc-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr+alloc-devel.sha256sum] = "a55accbba78c03b1e122427b8f161330d72a1e748002ec611408b7c542741d02"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+default-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr+default-devel.sha256sum] = "797dc2178953d491f15a7af3485c5434f126faa167e46068e486bc63c32772bd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+serde-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr+serde-devel.sha256sum] = "6193414c570a491bbe03f7d5d0e6aeda109ecb81e32f46c3768be41d68ed7f0f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+std-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr+std-devel.sha256sum] = "9c088dcf13d016f66001075e2e3696985ca664519df08982536c14ea839e2be5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+unicode-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+unicode-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr+unicode-devel.sha256sum] = "fdf27b0fb5d513bc6ee202cf3045555dbb52fa400c8fb2551009c68fb9ebffc7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr-devel.sha256sum] = "1e4fc687858259e13b8da23c90947acf75d8a2b737783ebd77c42c9398924ef8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+alloc-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-bstr+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-bstr+alloc-devel.sha256sum] = "dfc244cb7596441b1c346cd93b2d5a482ea60f803eb1e1934f65db65cf3bee0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+default-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-bstr+default-devel;unpack=0"
SRC_URI[aarch64_rust-bstr+default-devel.sha256sum] = "9d3f792e2568c2e2397d0eb24b410b9334f3b407ba2ff7d40e84d5eb3cbad6d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+serde-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-bstr+serde-devel;unpack=0"
SRC_URI[aarch64_rust-bstr+serde-devel.sha256sum] = "a9366487d8b52f14994f05b02346d6d511122327e21512acbb143d982020c183"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+std-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-bstr+std-devel;unpack=0"
SRC_URI[aarch64_rust-bstr+std-devel.sha256sum] = "4cdfa5abe13e4bde025126b4b5fda507fec157d50c0a877c596c0e9b696168df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+unicode-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-bstr+unicode-devel;unpack=0"
SRC_URI[aarch64_rust-bstr+unicode-devel.sha256sum] = "c29e1638def9fe2d6f490b37bd1d08bfa6b33fb13caea51d958ad919e5c53950"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-bstr-devel;unpack=0"
SRC_URI[aarch64_rust-bstr-devel.sha256sum] = "74c546e1a24031af629343f1cb53d13a2b8c8258db50cc25fa64ffa8c8319a8b"

RDEPENDS:rust-bstr+alloc-devel = " \
 cargo \
 rust-bstr-devel \
 rust-memchr+alloc-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bstr+default-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 "
RDEPENDS:rust-bstr+serde-devel = " \
 cargo \
 rust-bstr-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bstr+std-devel = " \
 cargo \
 rust-bstr+alloc-devel \
 rust-bstr-devel \
 rust-memchr+std-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bstr+unicode-devel = " \
 cargo \
 rust-bstr-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-bstr-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 "
