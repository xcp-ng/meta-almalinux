# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-keyboard"
PE = "1"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kcm-plasma-keyboard \
 plasma-keyboard \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-keyboard-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cd47de38870930640bf74ba5cfeb27d0576508bd3eade4db112250f87bc64726"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcm-plasma-keyboard-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcm-plasma-keyboard;unpack=0"
SRC_URI[x86_64_v2_kcm-plasma-keyboard.sha256sum] = "2a807fcc99d01908178b1b6fffdafba116d8e085bf26e1d96b7d2e5e87c4728b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-keyboard-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-keyboard;unpack=0"
SRC_URI[x86_64_v2_plasma-keyboard.sha256sum] = "0be7cb9b3dde06155e904a25a9e8d5e0e94030d812af5b9b432cf3c102e62f16"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kcm-plasma-keyboard-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kcm-plasma-keyboard;unpack=0"
SRC_URI[aarch64_kcm-plasma-keyboard.sha256sum] = "8ccbc6c296aad77611e136cfa389c718e77dd5b701b5b9ea920e94b857cb662a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-keyboard-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-keyboard;unpack=0"
SRC_URI[aarch64_plasma-keyboard.sha256sum] = "fef6edae0d296b55f83627ec50fdd7b43e339490fb1c7ed4225ea26775e38111"

RDEPENDS:kcm-plasma-keyboard = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 libstdc++ \
 plasma-keyboard \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-keyboard = " \
 glibc \
 kcm-plasma-keyboard \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 libstdc++ \
 libwayland-client \
 libxkbcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtvirtualkeyboard \
 "
