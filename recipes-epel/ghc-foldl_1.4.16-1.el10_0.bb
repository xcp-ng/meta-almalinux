# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-foldl"
PV = "1.4.16"
PR = "1.el10_0"
PACKAGES = " \
 ghc-foldl \
 ghc-foldl-devel \
 ghc-foldl-doc \
 ghc-foldl-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-foldl-1.4.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6ce3cf7201dfffbbf72d1b92b62f6c0004e55c61a36d93709d258aee9455f07"

URI_x86_64_v2_ghc-foldl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-foldl-1.4.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-foldl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-foldl}"
SRC_URI[x86_64_v2_ghc-foldl.sha256sum] = "a2ab898fce7004cc92775faa84d84c65bf1860afe35cf3a6e8a3e36603e925ea"

URI_x86_64_v2_ghc-foldl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-foldl-devel-1.4.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-foldl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-foldl-devel}"
SRC_URI[x86_64_v2_ghc-foldl-devel.sha256sum] = "cdfc6247b230ff31235294bff604a6dfc010b3e5084bec2f724f1e127f95963a"

URI_x86_64_v2_ghc-foldl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-foldl-doc-1.4.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-foldl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-foldl-doc}"
SRC_URI[x86_64_v2_ghc-foldl-doc.sha256sum] = "14c6d7115bb21ac55f7b4f50e408808d0b819a1be343756fe3a1fc928b8f147a"

URI_x86_64_v2_ghc-foldl-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-foldl-prof-1.4.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-foldl-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-foldl-prof}"
SRC_URI[x86_64_v2_ghc-foldl-prof.sha256sum] = "a9740fe81928bc563e0e36cab2cf10ba941d8196a1c9a046b119174d60911b4e"

URI_aarch64_ghc-foldl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-foldl-1.4.16-1.el10_0.aarch64.rpm;name=aarch64_ghc-foldl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-foldl}"
SRC_URI[aarch64_ghc-foldl.sha256sum] = "ecbb1307daff72f48407abce4e7784afbb416d77e708e32f0d669a07b60c310e"

URI_aarch64_ghc-foldl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-foldl-devel-1.4.16-1.el10_0.aarch64.rpm;name=aarch64_ghc-foldl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-foldl-devel}"
SRC_URI[aarch64_ghc-foldl-devel.sha256sum] = "628ddfcc90da3c69624db800b822d1772526aec0f1cda1237a75780983167942"

URI_aarch64_ghc-foldl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-foldl-doc-1.4.16-1.el10_0.noarch.rpm;name=aarch64_ghc-foldl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-foldl-doc}"
SRC_URI[aarch64_ghc-foldl-doc.sha256sum] = "9b5c4fe773a622a161ba11e2db0909c10a91190309e08f9b454c80a0f1b49bcf"

URI_aarch64_ghc-foldl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-foldl-prof-1.4.16-1.el10_0.aarch64.rpm;name=aarch64_ghc-foldl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-foldl-prof}"
SRC_URI[aarch64_ghc-foldl-prof.sha256sum] = "5147683f4220fbf5ccd2c0ae0d5afefbbfdacb3c8a716705b4f71f41be147745"

RDEPENDS:ghc-foldl = " \
 ghc-StateVar \
 ghc-array \
 ghc-assoc \
 ghc-base \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-deepseq \
 ghc-distributive \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-profunctors \
 ghc-random \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-th-abstraction \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-foldl-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-comonad-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-contravariant-devel \
 ghc-foldl \
 ghc-hashable-devel \
 ghc-primitive-devel \
 ghc-profunctors-devel \
 ghc-random-devel \
 ghc-semigroupoids-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-foldl-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-foldl-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-comonad-prof \
 ghc-containers-prof \
 ghc-contravariant-prof \
 ghc-foldl-devel \
 ghc-hashable-prof \
 ghc-primitive-prof \
 ghc-profunctors-prof \
 ghc-random-prof \
 ghc-semigroupoids-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
