# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Business-ISSN"
PV = "1.008"
PR = "3.el10_2"
PACKAGES = " \
 perl-Business-ISSN \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Business-ISSN-1.008-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5364e52a17672a5b884225953716a261e715de4374310b839a9e723209e62e5c"

URI_x86_64_v2_perl-Business-ISSN = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Business-ISSN-1.008-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Business-ISSN;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Business-ISSN}"
SRC_URI[x86_64_v2_perl-Business-ISSN.sha256sum] = "272981984e72168601fb8f29e1c257eb9f2371098ee745e66c03d584d4ce2b7c"

URI_aarch64_perl-Business-ISSN = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Business-ISSN-1.008-3.el10_2.noarch.rpm;name=aarch64_perl-Business-ISSN;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Business-ISSN}"
SRC_URI[aarch64_perl-Business-ISSN.sha256sum] = "cc2b6f541b20498d3cc234e7fdc9baa90019d1896a87ef24fe9ce64b7f0d9eae"

RDEPENDS:perl-Business-ISSN = " \
 perl-Exporter \
 perl-libs \
 perl-subs \
 "
