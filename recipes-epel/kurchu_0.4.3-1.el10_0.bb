# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kurchu"
PV = "0.4.3"
PR = "1.el10_0"
PACKAGES = " \
 kurchu \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kurchu-0.4.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b1281038b1a4e867429cc3e3ae5813ec17d1f6b75272d5542c3d57193d0e6d8"

URI_x86_64_v2_kurchu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kurchu-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kurchu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kurchu}"
SRC_URI[x86_64_v2_kurchu.sha256sum] = "9ae44dd82ef8f2f5c87fb5f0cf8e08eb3ee25405f2862abd126616692471b848"

URI_aarch64_kurchu = "${EPEL_MIRROR}/aarch64/Packages/k/kurchu-0.4.3-1.el10_0.noarch.rpm;name=aarch64_kurchu;unpack=0"
SRC_URI:append = " ${URI_aarch64_kurchu}"
SRC_URI[aarch64_kurchu.sha256sum] = "cf340dce6f9ea82b4b6ec04b49cb7bb54bf49a2072858d5f992adace4bdcc7e4"

RDEPENDS:kurchu = " \
 git-core \
 koji \
 lftp \
 python3 \
 python3-koji-cli-plugins \
 s3cmd \
 tree \
 "
