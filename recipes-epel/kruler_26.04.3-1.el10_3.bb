# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kruler"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kruler \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kruler-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "206931f958c84ab35dd7edd24c5027749fc0785b330b0f548a93bfceeccdc5bb"

URI_x86_64_v2_kruler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kruler-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kruler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kruler}"
SRC_URI[x86_64_v2_kruler.sha256sum] = "e06a2791280528830ce5ab30a1eda09d1e2a634a0f446e691aef2229d72031cf"

URI_aarch64_kruler = "${EPEL_MIRROR}/aarch64/Packages/k/kruler-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kruler;unpack=0"
SRC_URI:append = " ${URI_aarch64_kruler}"
SRC_URI[aarch64_kruler.sha256sum] = "a4a9e1976f8af14c1600c99281782d47191d6b490550e88513c429406a2b5c95"

RDEPENDS:kruler = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
