# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xevd"
PV = "0.5.0"
PR = "5.el10_1"
PACKAGES = " \
 xevd \
 xevd-devel \
 xevd-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xevd-0.5.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "598b6e5a706b3f8ab14ca7c5116171181f5d66beefcf1f3ab829407928248023"

URI_x86_64_v2_xevd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xevd-0.5.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xevd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xevd}"
SRC_URI[x86_64_v2_xevd.sha256sum] = "c51b7caf22b57485260fabfd0895ba4710570574e0eb3c232cd179f2651f22be"

URI_x86_64_v2_xevd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xevd-devel-0.5.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xevd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xevd-devel}"
SRC_URI[x86_64_v2_xevd-devel.sha256sum] = "aa3f6d54fbe3ae071b2de534cda319e9245c1c10e57988e8d90d654cb8747fa1"

URI_x86_64_v2_xevd-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xevd-libs-0.5.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xevd-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xevd-libs}"
SRC_URI[x86_64_v2_xevd-libs.sha256sum] = "b0f4680c9ec4faeab89ee3c23923a897ce123d2d32550cde42fc1a938bbea0dc"

URI_aarch64_xevd = "${EPEL_MIRROR}/aarch64/Packages/x/xevd-0.5.0-5.el10_1.aarch64.rpm;name=aarch64_xevd;unpack=0"
SRC_URI:append = " ${URI_aarch64_xevd}"
SRC_URI[aarch64_xevd.sha256sum] = "577c4d705dc982ec9ce4954050e7b846a6c3dc6d454f02c80048cdc0618dfd1f"

URI_aarch64_xevd-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xevd-devel-0.5.0-5.el10_1.aarch64.rpm;name=aarch64_xevd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xevd-devel}"
SRC_URI[aarch64_xevd-devel.sha256sum] = "6778f9357acc23c51795a466d56f98a0338eb82e34c30048e1204733ed7f7d0f"

URI_aarch64_xevd-libs = "${EPEL_MIRROR}/aarch64/Packages/x/xevd-libs-0.5.0-5.el10_1.aarch64.rpm;name=aarch64_xevd-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xevd-libs}"
SRC_URI[aarch64_xevd-libs.sha256sum] = "691d537a5234c97004f44225c0fb54a45988393347663340d4a11968a704d859"

RDEPENDS:xevd = " \
 glibc \
 xevd-libs \
 "
RDEPENDS:xevd-devel = " \
 pkgconf-pkg-config \
 xevd-libs \
 "
RDEPENDS:xevd-libs = " \
 glibc \
 "
