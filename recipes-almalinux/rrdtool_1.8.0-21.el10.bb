# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rrdtool"
PV = "1.8.0"
PR = "21.el10"
PACKAGES = " \
 python3-rrdtool \
 rrdtool \
 rrdtool-devel \
 rrdtool-doc \
 rrdtool-lua \
 rrdtool-perl \
 rrdtool-ruby \
 rrdtool-tcl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rrdtool-1.8.0-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf19b4b86287e36a91ae442b42eccee2336177d5483ecfb5320fc4420983d847"

URI_x86_64_v2_python3-rrdtool = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-rrdtool-1.8.0-21.el10.x86_64_v2.rpm;name=x86_64_v2_python3-rrdtool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rrdtool}"
SRC_URI[x86_64_v2_python3-rrdtool.sha256sum] = "76430b634de3ae1d543661ef72715e2e5c8e727fff9dbba2e34f7d7cd5142d1e"

URI_x86_64_v2_rrdtool = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rrdtool-1.8.0-21.el10.x86_64_v2.rpm;name=x86_64_v2_rrdtool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool}"
SRC_URI[x86_64_v2_rrdtool.sha256sum] = "0d37d160c3f1ccfbe82400483fcdcd2c54b573e6f405366d5df786c60832f8a1"

URI_x86_64_v2_rrdtool-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rrdtool-devel-1.8.0-21.el10.x86_64_v2.rpm;name=x86_64_v2_rrdtool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-devel}"
SRC_URI[x86_64_v2_rrdtool-devel.sha256sum] = "67d52e2eae433dcb8a8905ceeaf8c42ea93e0ec6c8b2e8d6e9d885a93b5b97d4"

URI_x86_64_v2_rrdtool-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rrdtool-doc-1.8.0-21.el10.x86_64_v2.rpm;name=x86_64_v2_rrdtool-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-doc}"
SRC_URI[x86_64_v2_rrdtool-doc.sha256sum] = "0b14cc925ce5ec664c665efd6b074d94d2b0ac5c353f86a612d484a10e0f1556"

URI_x86_64_v2_rrdtool-lua = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rrdtool-lua-1.8.0-21.el10.x86_64_v2.rpm;name=x86_64_v2_rrdtool-lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-lua}"
SRC_URI[x86_64_v2_rrdtool-lua.sha256sum] = "afa797944148d0f218ee14ae3191ab2e6d2338bab598f2c32bc3c04ef84591db"

URI_x86_64_v2_rrdtool-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rrdtool-perl-1.8.0-21.el10.x86_64_v2.rpm;name=x86_64_v2_rrdtool-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-perl}"
SRC_URI[x86_64_v2_rrdtool-perl.sha256sum] = "a217243f95e20035119743fa4d4adc55ad4e51db6740606187c44009bde3f4bd"

URI_x86_64_v2_rrdtool-ruby = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rrdtool-ruby-1.8.0-21.el10.x86_64_v2.rpm;name=x86_64_v2_rrdtool-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-ruby}"
SRC_URI[x86_64_v2_rrdtool-ruby.sha256sum] = "fb95550a0779600fd055bc0142697cb1d2e485ee6a324a4e9affcdab660244c2"

URI_x86_64_v2_rrdtool-tcl = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rrdtool-tcl-1.8.0-21.el10.x86_64_v2.rpm;name=x86_64_v2_rrdtool-tcl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-tcl}"
SRC_URI[x86_64_v2_rrdtool-tcl.sha256sum] = "5f8b3df5d04c4dd5dce84ef72431d421f27a889d42057bf98accf2234153863d"

URI_aarch64_python3-rrdtool = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-rrdtool-1.8.0-21.el10.aarch64.rpm;name=aarch64_python3-rrdtool;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rrdtool}"
SRC_URI[aarch64_python3-rrdtool.sha256sum] = "5fa4550eb86cae4a266bb20bdea16095a441fc6fd142277d50f72a8b80cb5899"

URI_aarch64_rrdtool = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rrdtool-1.8.0-21.el10.aarch64.rpm;name=aarch64_rrdtool;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool}"
SRC_URI[aarch64_rrdtool.sha256sum] = "cac2cf79a02a41fc5da848d91c9f368d09c51e32ad0fb0a6bded90779d31d8ec"

URI_aarch64_rrdtool-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rrdtool-devel-1.8.0-21.el10.aarch64.rpm;name=aarch64_rrdtool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-devel}"
SRC_URI[aarch64_rrdtool-devel.sha256sum] = "ffa12ea901a6a597b9c4d59eaacf503ce4b5f6684efd71b606c3718f00e52345"

URI_aarch64_rrdtool-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rrdtool-doc-1.8.0-21.el10.aarch64.rpm;name=aarch64_rrdtool-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-doc}"
SRC_URI[aarch64_rrdtool-doc.sha256sum] = "3af459d6eb60283c133953896d3d95d6152249fc0bf12cc0e09c3d53daf6f6e0"

URI_aarch64_rrdtool-lua = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rrdtool-lua-1.8.0-21.el10.aarch64.rpm;name=aarch64_rrdtool-lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-lua}"
SRC_URI[aarch64_rrdtool-lua.sha256sum] = "1de7244098fa34f84d964fbb2c36c73f932ba35ad2a5535a4107cbbaaa8852cc"

URI_aarch64_rrdtool-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rrdtool-perl-1.8.0-21.el10.aarch64.rpm;name=aarch64_rrdtool-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-perl}"
SRC_URI[aarch64_rrdtool-perl.sha256sum] = "35955a82ba7f3ab1ae2fc5908fe637f7e36b197b67523bffc543cdc379957ea4"

URI_aarch64_rrdtool-ruby = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rrdtool-ruby-1.8.0-21.el10.aarch64.rpm;name=aarch64_rrdtool-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-ruby}"
SRC_URI[aarch64_rrdtool-ruby.sha256sum] = "7f72443dc1d78c592f9201f0c5dfbac89d0b524654789395cd6f630f84833307"

URI_aarch64_rrdtool-tcl = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rrdtool-tcl-1.8.0-21.el10.aarch64.rpm;name=aarch64_rrdtool-tcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-tcl}"
SRC_URI[aarch64_rrdtool-tcl.sha256sum] = "ca8c81ea892337ff074a56692633e89a536c6da7d0524260689d5aa07bf3c740"

RDEPENDS:python3-rrdtool = " \
 glibc \
 python3 \
 rrdtool \
 "
RDEPENDS:rrdtool = " \
 bash \
 cairo \
 dejavu-sans-mono-fonts \
 glib2 \
 glibc \
 harfbuzz \
 libpng \
 libxml2 \
 pango \
 systemd \
 "
RDEPENDS:rrdtool-devel = " \
 pkgconf-pkg-config \
 rrdtool \
 "
RDEPENDS:rrdtool-doc = " \
 "
RDEPENDS:rrdtool-lua = " \
 cairo \
 glib2 \
 glibc \
 harfbuzz \
 libpng \
 libxml2 \
 lua-libs \
 pango \
 rrdtool \
 "
RDEPENDS:rrdtool-perl = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Fcntl \
 perl-IO \
 perl-IPC-Open3 \
 perl-libs \
 perl-vars \
 rrdtool \
 "
RDEPENDS:rrdtool-ruby = " \
 glibc \
 rrdtool \
 ruby-libs \
 "
RDEPENDS:rrdtool-tcl = " \
 glibc \
 rrdtool \
 tcl \
 "
