# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pytz"
PV = "2025.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-pytz \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pytz-2025.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2fd1c5e33d2e827582cd6e5b6b474b2a4cbb30d9495f2fc30ce81c6320cb8ef"

URI_x86_64_v2_python3-pytz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytz-2025.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytz}"
SRC_URI[x86_64_v2_python3-pytz.sha256sum] = "cfa8c057ce050ccf331ba02131a126f6e4293ec5c20d69526df20121cabe3682"

URI_aarch64_python3-pytz = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytz-2025.1-1.el10_1.noarch.rpm;name=aarch64_python3-pytz;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytz}"
SRC_URI[aarch64_python3-pytz.sha256sum] = "72097a77fb1144dc2c20143040821e4ac74af04581a4fbdadaa7f097b3a5b8cb"

RDEPENDS:python3-pytz = " \
 python3 \
 tzdata \
 "
