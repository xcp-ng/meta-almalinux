# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-JSON"
PV = "4.10"
PR = "7.el10"
PACKAGES = " \
 perl-JSON \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-JSON-4.10-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86caccd8adc963f45b43bcc5e0b8643acc2bf72ef144e969be79c67074fba57a"

URI_x86_64_v2_perl-JSON = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-JSON-4.10-7.el10.noarch.rpm;name=x86_64_v2_perl-JSON;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-JSON}"
SRC_URI[x86_64_v2_perl-JSON.sha256sum] = "ae083a79d5a059143a0b86a3c5e2788895f41e6833b5553b70440b4875e62c53"

URI_aarch64_perl-JSON = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-JSON-4.10-7.el10.noarch.rpm;name=aarch64_perl-JSON;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-JSON}"
SRC_URI[aarch64_perl-JSON.sha256sum] = "ae083a79d5a059143a0b86a3c5e2788895f41e6833b5553b70440b4875e62c53"

RDEPENDS:perl-JSON = " \
 perl-B \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-Math-BigInt \
 perl-constant \
 perl-libs \
 perl-overload \
 "
