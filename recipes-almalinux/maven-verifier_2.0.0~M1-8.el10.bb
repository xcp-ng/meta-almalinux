# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-verifier"
PV = "2.0.0~M1"
PR = "8.el10"
PACKAGES = " \
 maven-verifier \
 maven-verifier-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/maven-verifier-2.0.0~M1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e104c833ef888548be8f8ddbee24a3729cc23d072dc8c0792d1e5c9e1d8004f"

URI_x86_64_v2_maven-verifier = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-verifier-2.0.0~M1-8.el10.noarch.rpm;name=x86_64_v2_maven-verifier;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-verifier}"
SRC_URI[x86_64_v2_maven-verifier.sha256sum] = "9b7c8bc068af8563171cb1eac31e160d0ce2073bdbc52a7188fbfd78bdc988ad"

URI_x86_64_v2_maven-verifier-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-verifier-javadoc-2.0.0~M1-8.el10.noarch.rpm;name=x86_64_v2_maven-verifier-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-verifier-javadoc}"
SRC_URI[x86_64_v2_maven-verifier-javadoc.sha256sum] = "d507aee1a0cd113026d13dd20498faf90c0c92775b668d05ad3e44cd1164b0e6"

URI_aarch64_maven-verifier = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-verifier-2.0.0~M1-8.el10.noarch.rpm;name=aarch64_maven-verifier;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-verifier}"
SRC_URI[aarch64_maven-verifier.sha256sum] = "9b7c8bc068af8563171cb1eac31e160d0ce2073bdbc52a7188fbfd78bdc988ad"

URI_aarch64_maven-verifier-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-verifier-javadoc-2.0.0~M1-8.el10.noarch.rpm;name=aarch64_maven-verifier-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-verifier-javadoc}"
SRC_URI[aarch64_maven-verifier-javadoc.sha256sum] = "d507aee1a0cd113026d13dd20498faf90c0c92775b668d05ad3e44cd1164b0e6"

RDEPENDS:maven-verifier = " \
 javapackages-filesystem \
 maven-shared-utils \
 "
RDEPENDS:maven-verifier-javadoc = " \
 javapackages-filesystem \
 "
