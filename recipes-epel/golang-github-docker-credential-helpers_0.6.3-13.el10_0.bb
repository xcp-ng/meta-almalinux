# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-docker-credential-helpers"
PV = "0.6.3"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-docker-credential-helpers-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-docker-credential-helpers-0.6.3-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "741e3633844efb0bb51901e9e33f16a09dd16ce1691a661fe3d570864bdedd54"

URI_x86_64_v2_golang-github-docker-credential-helpers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-docker-credential-helpers-devel-0.6.3-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-docker-credential-helpers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-docker-credential-helpers-devel}"
SRC_URI[x86_64_v2_golang-github-docker-credential-helpers-devel.sha256sum] = "bcbc70a963d06bd1727d258224059c2e20e3eff5df6f715d0ff8b794be89d08f"

URI_aarch64_golang-github-docker-credential-helpers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-docker-credential-helpers-devel-0.6.3-13.el10_0.noarch.rpm;name=aarch64_golang-github-docker-credential-helpers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-docker-credential-helpers-devel}"
SRC_URI[aarch64_golang-github-docker-credential-helpers-devel.sha256sum] = "f320db188c7762b0a13f1b276fd3cf5d30977acda89863519356ce6d94b538ef"

RDEPENDS:golang-github-docker-credential-helpers-devel = " \
 go-filesystem \
 libsecret-devel \
 "
