# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-cv"
PV = "1.06"
PR = "18.el10"
PACKAGES = " \
 hunspell-cv \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-cv-1.06-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f319a50acc3eeda93f56597ae9d6a513dc189a391747b71f5bfe75405550821a"

URI_x86_64_v2_hunspell-cv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-cv-1.06-18.el10.noarch.rpm;name=x86_64_v2_hunspell-cv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-cv}"
SRC_URI[x86_64_v2_hunspell-cv.sha256sum] = "9d61e85ef9326e225efd72a7873d04d311c737a24425a4c8b50b26ba95155722"

URI_aarch64_hunspell-cv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-cv-1.06-18.el10.noarch.rpm;name=aarch64_hunspell-cv;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-cv}"
SRC_URI[aarch64_hunspell-cv.sha256sum] = "9d61e85ef9326e225efd72a7873d04d311c737a24425a4c8b50b26ba95155722"

RDEPENDS:hunspell-cv = " \
 hunspell-filesystem \
 "
