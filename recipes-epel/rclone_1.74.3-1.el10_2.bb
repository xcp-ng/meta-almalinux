# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rclone"
PV = "1.74.3"
PR = "1.el10_2"
PACKAGES = " \
 rclone \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rclone-1.74.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "156c98afd9fbbfd53682ae29cd949cab38eddb021170839d133394877516683a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rclone-1.74.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rclone;unpack=0"
SRC_URI[x86_64_v2_rclone.sha256sum] = "f73239a2e4e328f717d6d9547d8161e2344fcb629514ace80a5b1e788df9bac7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rclone-1.74.3-1.el10_2.aarch64.rpm;name=aarch64_rclone;unpack=0"
SRC_URI[aarch64_rclone.sha256sum] = "26a783e67995aa8a8a6ae34e81d3ba867f51085311bc2b7fcdfa1b059f64ec46"

RDEPENDS:rclone = " \
 glibc \
 "
