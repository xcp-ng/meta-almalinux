# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdisplay-info"
PV = "0.2.0"
PR = "2.el10"
PACKAGES = " \
 libdisplay-info \
 libdisplay-info-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libdisplay-info-0.2.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b55fc0645ccea6a774e0b24c291fc63c2036bac895e3c963d665e3f6da4045d5"

URI_x86_64_v2_libdisplay-info = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libdisplay-info-0.2.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libdisplay-info;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdisplay-info}"
SRC_URI[x86_64_v2_libdisplay-info.sha256sum] = "48ef394039932d360cba9f5dd1a396fa3ff04ba58254434953cf3a43d2c11003"

URI_x86_64_v2_libdisplay-info-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdisplay-info-devel-0.2.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libdisplay-info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdisplay-info-devel}"
SRC_URI[x86_64_v2_libdisplay-info-devel.sha256sum] = "63168dc56c5f7f5b44ec7ebbcf3faddce19129497d3e1e7a45b220c97894b76b"

URI_aarch64_libdisplay-info = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libdisplay-info-0.2.0-2.el10.aarch64.rpm;name=aarch64_libdisplay-info;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdisplay-info}"
SRC_URI[aarch64_libdisplay-info.sha256sum] = "16a7cf900e2b5f658721176f6cadc46f71ce108ed645f942b8b755844c9ccd03"

URI_aarch64_libdisplay-info-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdisplay-info-devel-0.2.0-2.el10.aarch64.rpm;name=aarch64_libdisplay-info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdisplay-info-devel}"
SRC_URI[aarch64_libdisplay-info-devel.sha256sum] = "447fa98180e5058b1c3f1ee62c6f58aac6ff43caba1bb7e1e2bb413f00c77ead"

RDEPENDS:libdisplay-info = " \
 glibc \
 "
RDEPENDS:libdisplay-info-devel = " \
 libdisplay-info \
 pkgconf-pkg-config \
 "
