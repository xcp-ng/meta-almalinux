# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpimtextedit"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kpimtextedit \
 kpimtextedit-devel \
 kpimtextedit-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpimtextedit-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29d9737dc2cd25107dd580034bfd7e1eca450390b71d03d45adae555028c5143"

URI_x86_64_v2_kpimtextedit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpimtextedit-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpimtextedit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpimtextedit}"
SRC_URI[x86_64_v2_kpimtextedit.sha256sum] = "5205223a26b163e98d5790f8cd41b4a761e52360a37c0339c230d92677905179"

URI_x86_64_v2_kpimtextedit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpimtextedit-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpimtextedit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpimtextedit-devel}"
SRC_URI[x86_64_v2_kpimtextedit-devel.sha256sum] = "369b89bb2d777abcea0cc965513557856d60daa3a13bf5be1addb64e47d13d6b"

URI_x86_64_v2_kpimtextedit-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpimtextedit-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kpimtextedit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpimtextedit-doc}"
SRC_URI[x86_64_v2_kpimtextedit-doc.sha256sum] = "4e4e4d8aac8dddaa8975eafe72adfb24bebc4d85c675d584459050ad821ed904"

URI_aarch64_kpimtextedit = "${EPEL_MIRROR}/aarch64/Packages/k/kpimtextedit-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kpimtextedit;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpimtextedit}"
SRC_URI[aarch64_kpimtextedit.sha256sum] = "f2f6b440e29d81e422988bac482800d39a974c600c47cb3821f0cbac35eb5ac1"

URI_aarch64_kpimtextedit-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpimtextedit-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kpimtextedit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpimtextedit-devel}"
SRC_URI[aarch64_kpimtextedit-devel.sha256sum] = "7970674e12659cbe02c900554c42f6fb1b8f420fed107713ea9139870fd7f553"

URI_aarch64_kpimtextedit-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kpimtextedit-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kpimtextedit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpimtextedit-doc}"
SRC_URI[aarch64_kpimtextedit-doc.sha256sum] = "213dba6bd55b98de4b4c6de8b9a910794b64cc0a77926887648fe8ceea916f0f"

RDEPENDS:kpimtextedit = " \
 glibc \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 kf6-syntax-highlighting \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kpimtextedit-devel = " \
 cmake-filesystem \
 kf6-ktextwidgets-devel \
 kpimtextedit \
 "
RDEPENDS:kpimtextedit-doc = " \
 "
