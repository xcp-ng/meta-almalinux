# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libm"
PV = "0.2.15"
PR = "1.el10_0"
PACKAGES = " \
 rust-libm+arch-devel \
 rust-libm+default-devel \
 rust-libm+force-soft-floats-devel \
 rust-libm+unstable-devel \
 rust-libm+unstable-float-devel \
 rust-libm+unstable-intrinsics-devel \
 rust-libm+unstable-public-internals-devel \
 rust-libm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libm-0.2.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78bb3f6b6971e8a5b7ec7475af329d377e3f166031c61b04453b6ace188a4ac4"

URI_x86_64_v2_rust-libm+arch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm+arch-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm+arch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm+arch-devel}"
SRC_URI[x86_64_v2_rust-libm+arch-devel.sha256sum] = "2d91e0a46ad7cf70b899a6e66482ec46ea45cfc00fa745da0f791b1e5c0ba577"

URI_x86_64_v2_rust-libm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm+default-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm+default-devel}"
SRC_URI[x86_64_v2_rust-libm+default-devel.sha256sum] = "4bd5227541578e093ce35a9f9d3342bb116fe73b133f25ec56812fae681f3c5a"

URI_x86_64_v2_rust-libm+force-soft-floats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm+force-soft-floats-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm+force-soft-floats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm+force-soft-floats-devel}"
SRC_URI[x86_64_v2_rust-libm+force-soft-floats-devel.sha256sum] = "3b65194b27f73d2edb95ddf8704b95481b0685fdbce1906726cb2f5277bc9900"

URI_x86_64_v2_rust-libm+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm+unstable-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm+unstable-devel}"
SRC_URI[x86_64_v2_rust-libm+unstable-devel.sha256sum] = "5770963456cdd739d7d660ba48bce070fd78f2195c776292109f015168f3ee71"

URI_x86_64_v2_rust-libm+unstable-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm+unstable-float-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm+unstable-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm+unstable-float-devel}"
SRC_URI[x86_64_v2_rust-libm+unstable-float-devel.sha256sum] = "9eab2942e715c29d7b39701b812752770441fccfb082d4cca47274029b5ecf4c"

URI_x86_64_v2_rust-libm+unstable-intrinsics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm+unstable-intrinsics-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm+unstable-intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm+unstable-intrinsics-devel}"
SRC_URI[x86_64_v2_rust-libm+unstable-intrinsics-devel.sha256sum] = "c9ffc1cf012e6975620f5b4a05119d861fd4d214119e8121562052ee84a6b9fa"

URI_x86_64_v2_rust-libm+unstable-public-internals-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm+unstable-public-internals-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm+unstable-public-internals-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm+unstable-public-internals-devel}"
SRC_URI[x86_64_v2_rust-libm+unstable-public-internals-devel.sha256sum] = "d60f9070762db9412a94f940c7b1376e4510e5791055d07c87bf75e209e611f3"

URI_x86_64_v2_rust-libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm-devel}"
SRC_URI[x86_64_v2_rust-libm-devel.sha256sum] = "2636e94d064163d3d60893b5290ea8b0f18113c7ebdce85147cb53b965480356"

URI_aarch64_rust-libm+arch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm+arch-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-libm+arch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm+arch-devel}"
SRC_URI[aarch64_rust-libm+arch-devel.sha256sum] = "8f594e4a6f5781da3fe38dd4890503cb63f2b727016b6a690ec8ad5727262169"

URI_aarch64_rust-libm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm+default-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-libm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm+default-devel}"
SRC_URI[aarch64_rust-libm+default-devel.sha256sum] = "2c34dac025e2ef4e5f0fa59c7c9eaaa9809ca4eab3aac145d9398efb404394d3"

URI_aarch64_rust-libm+force-soft-floats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm+force-soft-floats-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-libm+force-soft-floats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm+force-soft-floats-devel}"
SRC_URI[aarch64_rust-libm+force-soft-floats-devel.sha256sum] = "e84159ece49b7c2db46aa03c71ef578d640640bab48fcfac0f1e93eb2ba97a46"

URI_aarch64_rust-libm+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm+unstable-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-libm+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm+unstable-devel}"
SRC_URI[aarch64_rust-libm+unstable-devel.sha256sum] = "007ffe03aee1f82ec4833445a1b5e3ea8ae2a0bdd9b85337b6ee5a7b64a003b3"

URI_aarch64_rust-libm+unstable-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm+unstable-float-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-libm+unstable-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm+unstable-float-devel}"
SRC_URI[aarch64_rust-libm+unstable-float-devel.sha256sum] = "efd04af836c707739e8172cc9b6f4f504dbe6b5379aab6dab2f25f6f4d41b70e"

URI_aarch64_rust-libm+unstable-intrinsics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm+unstable-intrinsics-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-libm+unstable-intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm+unstable-intrinsics-devel}"
SRC_URI[aarch64_rust-libm+unstable-intrinsics-devel.sha256sum] = "684a74acd2f2a435509f4985548778c573df36866ed269ac8cbf2e622a397999"

URI_aarch64_rust-libm+unstable-public-internals-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm+unstable-public-internals-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-libm+unstable-public-internals-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm+unstable-public-internals-devel}"
SRC_URI[aarch64_rust-libm+unstable-public-internals-devel.sha256sum] = "aa36da5ab96e04a4b87c543fb0139982c10e09daf614ea9a18f87b9e4a6423b5"

URI_aarch64_rust-libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm-devel}"
SRC_URI[aarch64_rust-libm-devel.sha256sum] = "283df008e11af16788ee4a372f72d69484cba90ea94fae5eac9ea7590a185802"

RDEPENDS:rust-libm+arch-devel = " \
 cargo \
 rust-libm-devel \
 "
RDEPENDS:rust-libm+default-devel = " \
 cargo \
 rust-libm+arch-devel \
 rust-libm-devel \
 "
RDEPENDS:rust-libm+force-soft-floats-devel = " \
 cargo \
 rust-libm-devel \
 "
RDEPENDS:rust-libm+unstable-devel = " \
 cargo \
 rust-libm+unstable-float-devel \
 rust-libm+unstable-intrinsics-devel \
 rust-libm-devel \
 "
RDEPENDS:rust-libm+unstable-float-devel = " \
 cargo \
 rust-libm-devel \
 "
RDEPENDS:rust-libm+unstable-intrinsics-devel = " \
 cargo \
 rust-libm-devel \
 "
RDEPENDS:rust-libm+unstable-public-internals-devel = " \
 cargo \
 rust-libm-devel \
 "
RDEPENDS:rust-libm-devel = " \
 cargo \
 rust \
 "
