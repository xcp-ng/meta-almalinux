# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-myrepos-utils"
PV = "0.0.4.3"
PR = "1.el10_3"
PACKAGES = " \
 myrepos-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-myrepos-utils-0.0.4.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d0d28d00bb036d3a43d8481e3aa007de2b3c037cc7f8df9db332cc1842898cf"

URI_x86_64_v2_myrepos-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myrepos-utils-0.0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_myrepos-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myrepos-utils}"
SRC_URI[x86_64_v2_myrepos-utils.sha256sum] = "464c068b48d514dd31c9670e54dd2cd6c945b711f2b84aeffd5dcbe38b703a25"

URI_aarch64_myrepos-utils = "${EPEL_MIRROR}/aarch64/Packages/m/myrepos-utils-0.0.4.3-1.el10_3.noarch.rpm;name=aarch64_myrepos-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_myrepos-utils}"
SRC_URI[aarch64_myrepos-utils.sha256sum] = "9d48b3a7ec8f322fcc91b4aa78e95078e3ffd0fe80691e66421e75b4abf6a068"

RDEPENDS:myrepos-utils = " \
 myrepos \
 python3 \
 python3-click \
 "
