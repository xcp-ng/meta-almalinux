# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kollision"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kollision \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kollision-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd47d57f2f556ba571c7dcac7cad2631430e11e88fc088a5eb574e415adf3667"

URI_x86_64_v2_kollision = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kollision-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kollision;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kollision}"
SRC_URI[x86_64_v2_kollision.sha256sum] = "36feda475c49a23df642c5def9b650c3a56ca67366c7d7d5aec6013a3a22fef4"

URI_aarch64_kollision = "${EPEL_MIRROR}/aarch64/Packages/k/kollision-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kollision;unpack=0"
SRC_URI:append = " ${URI_aarch64_kollision}"
SRC_URI[aarch64_kollision.sha256sum] = "3f1e8dec3ffec52fc76a6db623c25bb7de1c989fbbd6b4b85792104c414e5563"

RDEPENDS:kollision = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
