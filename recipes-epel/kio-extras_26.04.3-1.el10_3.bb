# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kio-extras"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kio-extras \
 kio-extras-devel \
 kio-extras-info \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kio-extras-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8242b499e747e29a5281f785e81ca7ae6db978d3329cd6e8e5d9359fc3567eac"

URI_x86_64_v2_kio-extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-extras-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-extras}"
SRC_URI[x86_64_v2_kio-extras.sha256sum] = "e58ba063865d0ac95465e2c20f6df24b970561a036584860c2e13cf18cd0a189"

URI_x86_64_v2_kio-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-extras-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-extras-devel}"
SRC_URI[x86_64_v2_kio-extras-devel.sha256sum] = "40d4802beede9adedebac8debad91b28fb43260d5c80d0fb09e12447c3dfb020"

URI_x86_64_v2_kio-extras-info = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-extras-info-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-extras-info;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-extras-info}"
SRC_URI[x86_64_v2_kio-extras-info.sha256sum] = "bc2ae9d27cabdceae90cb7e6692430bb7c34ea4b2119851d53b313e5bbe152a5"

URI_aarch64_kio-extras = "${EPEL_MIRROR}/aarch64/Packages/k/kio-extras-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kio-extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-extras}"
SRC_URI[aarch64_kio-extras.sha256sum] = "a13a619d3d54c8dae6a79dadb719e55b410de6ba96ff6c854e26fe68183bf505"

URI_aarch64_kio-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kio-extras-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kio-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-extras-devel}"
SRC_URI[aarch64_kio-extras-devel.sha256sum] = "db15cd8a8fd0efa2089bc0e305f9576ebf85e18dcb5c69c9e47d493e43a27c3e"

URI_aarch64_kio-extras-info = "${EPEL_MIRROR}/aarch64/Packages/k/kio-extras-info-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kio-extras-info;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-extras-info}"
SRC_URI[aarch64_kio-extras-info.sha256sum] = "f671a4ec647ef6b8febe9b488b8bb9e01549cd7fcaccbe36f456b0e01bb1ebad"

RDEPENDS:kio-extras = " \
 bash \
 glibc \
 kdsoap-ws-discovery-client \
 kdsoap6 \
 kf6-karchive \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-solid \
 kf6-syntax-highlighting \
 libXcursor \
 libgcc \
 libimobiledevice \
 libkexiv2-qt6 \
 libmtp \
 libplist \
 libproxy \
 libsmbclient \
 libssh \
 libstdc++ \
 libtirpc \
 openexr-libs \
 plasma-activities \
 plasma-activities-stats \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 taglib \
 "
RDEPENDS:kio-extras-devel = " \
 cmake-filesystem \
 kio-extras \
 "
RDEPENDS:kio-extras-info = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 perl-interpreter \
 perl-libs \
 qt6-qtbase \
 "
