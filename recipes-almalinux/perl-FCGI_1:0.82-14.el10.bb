# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-FCGI"
PE = "1"
PV = "0.82"
PR = "14.el10"
PACKAGES = " \
 perl-FCGI \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-FCGI-0.82-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16b24e2a61b171639184fe428829cd6c7a601a5d0eb4f9609254eb3365f422f3"

URI_x86_64_v2_perl-FCGI = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-FCGI-0.82-14.el10.x86_64_v2.rpm;name=x86_64_v2_perl-FCGI;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-FCGI}"
SRC_URI[x86_64_v2_perl-FCGI.sha256sum] = "28dfc15d92aea7efdbc1bef495061455c9390b2764a0e9f785a395b71d7d7798"

URI_aarch64_perl-FCGI = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-FCGI-0.82-14.el10.aarch64.rpm;name=aarch64_perl-FCGI;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-FCGI}"
SRC_URI[aarch64_perl-FCGI.sha256sum] = "b96866938b50c6a4bae6d976b7e31017b025af1b1c6d4a5a077ae728707a1a43"

RDEPENDS:perl-FCGI = " \
 glibc \
 perl-Carp \
 perl-libs \
 "
