# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "umoci"
PV = "0.6.0"
PR = "1.el10_1"
PACKAGES = " \
 umoci \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/umoci-0.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31249b6a5dfb5df4b44e19652616f2768409d71df73ac6622e9b3c5e1c39bf45"

URI_x86_64_v2_umoci = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/umoci-0.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_umoci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_umoci}"
SRC_URI[x86_64_v2_umoci.sha256sum] = "68b916d34f83f2fe997eaa3c0891c2c56b48d8c757bfa7ba490466c54b4ed8cc"

URI_aarch64_umoci = "${EPEL_MIRROR}/aarch64/Packages/u/umoci-0.6.0-1.el10_1.aarch64.rpm;name=aarch64_umoci;unpack=0"
SRC_URI:append = " ${URI_aarch64_umoci}"
SRC_URI[aarch64_umoci.sha256sum] = "9ca179a04d1e64d22a549f1c1ef09f3a4994ea643ad51f5873a53b026717ff75"

RDEPENDS:umoci = " \
 glibc \
 "
