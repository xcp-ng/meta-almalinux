# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bootc"
PV = "1.16.13"
PR = "1.el10.alma.1"
PACKAGES = " \
 bootc \
 system-reinstall-bootc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bootc-1.16.13-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "957063edc1f2f8ba8c33e0f1fa61144e529489e0a743fb2dbaeecbcfde23382c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bootc-1.16.13-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_bootc;unpack=0"
SRC_URI[x86_64_v2_bootc.sha256sum] = "b1a63e30abdf9997dc85a00b8a31ff951c31bf1a77ccc278b6d0f067217a23c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/system-reinstall-bootc-1.16.13-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_system-reinstall-bootc;unpack=0"
SRC_URI[x86_64_v2_system-reinstall-bootc.sha256sum] = "6ea884a9135da395714a74cf1797b358113ebe326bb107f9448e656aacab1876"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bootc-1.16.13-1.el10.alma.1.aarch64.rpm;name=aarch64_bootc;unpack=0"
SRC_URI[aarch64_bootc.sha256sum] = "0430bf5f573759d6d7518a8eef3f29e94a14e42858d077248c3c3b7c0f467939"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/system-reinstall-bootc-1.16.13-1.el10.alma.1.aarch64.rpm;name=aarch64_system-reinstall-bootc;unpack=0"
SRC_URI[aarch64_system-reinstall-bootc.sha256sum] = "f78a1f878031950ce2930f649deb12c8e677d658a9ff55e1f8442c22e43c4638"

RDEPENDS:bootc = " \
 bash \
 composefs \
 glib2 \
 glibc \
 libgcc \
 libselinux \
 libzstd \
 openssl-libs \
 ostree \
 ostree-libs \
 pcre2 \
 podman \
 skopeo \
 util-linux-core \
 virtual//usr/bin/chcon \
 zlib-ng-compat \
 "
RDEPENDS:system-reinstall-bootc = " \
 bash \
 glibc \
 libgcc \
 "
