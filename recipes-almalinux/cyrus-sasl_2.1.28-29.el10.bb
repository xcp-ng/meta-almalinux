# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cyrus-sasl"
PV = "2.1.28"
PR = "29.el10"
PACKAGES = " \
 cyrus-sasl \
 cyrus-sasl-devel \
 cyrus-sasl-gs2 \
 cyrus-sasl-gssapi \
 cyrus-sasl-ldap \
 cyrus-sasl-lib \
 cyrus-sasl-md5 \
 cyrus-sasl-plain \
 cyrus-sasl-scram \
 cyrus-sasl-sql \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cyrus-sasl-2.1.28-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8c4ebe7809eb2015c4ebf1701357fc9079ae3b932b418f31156e326cb95ea4a"

URI_x86_64_v2_cyrus-sasl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-2.1.28-29.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl}"
SRC_URI[x86_64_v2_cyrus-sasl.sha256sum] = "61cc714fbde3bf642037db57f9286b6093a9c49dab5e36b7c93c7c97afbf30d4"

URI_x86_64_v2_cyrus-sasl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cyrus-sasl-devel-2.1.28-29.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-devel}"
SRC_URI[x86_64_v2_cyrus-sasl-devel.sha256sum] = "182e072f7ea6a86f67cdd42f7b630995964387ed9dcd99744f51fba7d5971420"

URI_x86_64_v2_cyrus-sasl-gs2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cyrus-sasl-gs2-2.1.28-29.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-gs2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-gs2}"
SRC_URI[x86_64_v2_cyrus-sasl-gs2.sha256sum] = "e657590dd83411d9c3d0a017d7d1441f594f3e28d89bfa04a5da430766ddccd1"

URI_x86_64_v2_cyrus-sasl-gssapi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-gssapi-2.1.28-29.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-gssapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-gssapi}"
SRC_URI[x86_64_v2_cyrus-sasl-gssapi.sha256sum] = "0da609b6058d427075b8c052c4601913cf6856be1ffa0946197831a9d3b6f53b"

URI_x86_64_v2_cyrus-sasl-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cyrus-sasl-ldap-2.1.28-29.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-ldap}"
SRC_URI[x86_64_v2_cyrus-sasl-ldap.sha256sum] = "cd42501eb7929323ac6bd042f78238fdd26a8bd68c958c6f674286bd0b52c60c"

URI_x86_64_v2_cyrus-sasl-lib = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-lib-2.1.28-29.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-lib}"
SRC_URI[x86_64_v2_cyrus-sasl-lib.sha256sum] = "90e0fb9de81d779077db1a3b91ad58122da4bf9232932f876aacaab18759bc78"

URI_x86_64_v2_cyrus-sasl-md5 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cyrus-sasl-md5-2.1.28-29.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-md5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-md5}"
SRC_URI[x86_64_v2_cyrus-sasl-md5.sha256sum] = "bb1f79b7761fee7bdbdf97c6e2b18ceeda3b58b6c5c1a73d6f29428f91b4fc4f"

URI_x86_64_v2_cyrus-sasl-plain = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-plain-2.1.28-29.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-plain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-plain}"
SRC_URI[x86_64_v2_cyrus-sasl-plain.sha256sum] = "aeeca8cd835ee9f8ee6bc7f8e8cbef8745452a0ce8bcfe6e2205096b9f9aaf78"

URI_x86_64_v2_cyrus-sasl-scram = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-scram-2.1.28-29.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-scram;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-scram}"
SRC_URI[x86_64_v2_cyrus-sasl-scram.sha256sum] = "de7d1f0cb15956258e23c0453fa21e1b12964e14c83d81988f13d51b7f6f386a"

URI_x86_64_v2_cyrus-sasl-sql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cyrus-sasl-sql-2.1.28-29.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-sql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-sql}"
SRC_URI[x86_64_v2_cyrus-sasl-sql.sha256sum] = "0adeb1bb039fea3d5c2c0d4c49bf9344614b8fff0f15062179e719b32cb214e3"

URI_aarch64_cyrus-sasl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cyrus-sasl-2.1.28-29.el10.aarch64.rpm;name=aarch64_cyrus-sasl;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl}"
SRC_URI[aarch64_cyrus-sasl.sha256sum] = "773a96ed2550e8e2d7ffa64dc03ada675ae4b3699a47e95ffba7e231c61d4ccb"

URI_aarch64_cyrus-sasl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cyrus-sasl-devel-2.1.28-29.el10.aarch64.rpm;name=aarch64_cyrus-sasl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-devel}"
SRC_URI[aarch64_cyrus-sasl-devel.sha256sum] = "cb7bb2ed9dd6d0acaae2c3ba0469914fbeab790e2545943e036962a3cccd1800"

URI_aarch64_cyrus-sasl-gs2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cyrus-sasl-gs2-2.1.28-29.el10.aarch64.rpm;name=aarch64_cyrus-sasl-gs2;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-gs2}"
SRC_URI[aarch64_cyrus-sasl-gs2.sha256sum] = "f16f4102972f6177cd61f2c8329be18d9b96c941d0a63437bb4f009e2a6a6d6b"

URI_aarch64_cyrus-sasl-gssapi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cyrus-sasl-gssapi-2.1.28-29.el10.aarch64.rpm;name=aarch64_cyrus-sasl-gssapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-gssapi}"
SRC_URI[aarch64_cyrus-sasl-gssapi.sha256sum] = "f2966f8f47b44d5b30da0081cdc0d525aa20e2be7057adae5fd8a7ba253786f8"

URI_aarch64_cyrus-sasl-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cyrus-sasl-ldap-2.1.28-29.el10.aarch64.rpm;name=aarch64_cyrus-sasl-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-ldap}"
SRC_URI[aarch64_cyrus-sasl-ldap.sha256sum] = "e5ab70e63c85c2bb5c2af60fbb2beefd68cb6811503bca6aef614202b9bd1a84"

URI_aarch64_cyrus-sasl-lib = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cyrus-sasl-lib-2.1.28-29.el10.aarch64.rpm;name=aarch64_cyrus-sasl-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-lib}"
SRC_URI[aarch64_cyrus-sasl-lib.sha256sum] = "1446c3fb9522c58f79252f61bc3ca40e547486104e090ce9db0e45b9d83ba193"

URI_aarch64_cyrus-sasl-md5 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cyrus-sasl-md5-2.1.28-29.el10.aarch64.rpm;name=aarch64_cyrus-sasl-md5;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-md5}"
SRC_URI[aarch64_cyrus-sasl-md5.sha256sum] = "1a25d622adb2fc451b0f3be50889dbaf0e460f01ebfb9845d55bdd63d01025fe"

URI_aarch64_cyrus-sasl-plain = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cyrus-sasl-plain-2.1.28-29.el10.aarch64.rpm;name=aarch64_cyrus-sasl-plain;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-plain}"
SRC_URI[aarch64_cyrus-sasl-plain.sha256sum] = "0ce54eaf7d23c08df6acc45d98f4217fb4e4ca64b7b48939ec4079230671ed68"

URI_aarch64_cyrus-sasl-scram = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cyrus-sasl-scram-2.1.28-29.el10.aarch64.rpm;name=aarch64_cyrus-sasl-scram;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-scram}"
SRC_URI[aarch64_cyrus-sasl-scram.sha256sum] = "de602c84e524595f7df890e97a810dd216336912f44c634b8bc44fc19c53d544"

URI_aarch64_cyrus-sasl-sql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cyrus-sasl-sql-2.1.28-29.el10.aarch64.rpm;name=aarch64_cyrus-sasl-sql;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-sql}"
SRC_URI[aarch64_cyrus-sasl-sql.sha256sum] = "c8c84f25c613618c6f43689f451fde0d58d810daaf8999805c7aae704ad3e218"

RDEPENDS:cyrus-sasl = " \
 bash \
 cyrus-sasl-lib \
 gdbm-libs \
 glibc \
 krb5-libs \
 libxcrypt \
 openldap \
 openssl-libs \
 pam-libs \
 shadow-utils \
 util-linux \
 "
RDEPENDS:cyrus-sasl-devel = " \
 cyrus-sasl \
 cyrus-sasl-lib \
 glibc \
 krb5-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:cyrus-sasl-gs2 = " \
 cyrus-sasl-lib \
 glibc \
 krb5-libs \
 libcom_err \
 libxcrypt \
 "
RDEPENDS:cyrus-sasl-gssapi = " \
 cyrus-sasl-lib \
 glibc \
 krb5-libs \
 libcom_err \
 libxcrypt \
 "
RDEPENDS:cyrus-sasl-ldap = " \
 cyrus-sasl-lib \
 glibc \
 libxcrypt \
 openldap \
 "
RDEPENDS:cyrus-sasl-lib = " \
 gdbm-libs \
 glibc \
 libxcrypt \
 "
RDEPENDS:cyrus-sasl-md5 = " \
 cyrus-sasl-lib \
 glibc \
 libxcrypt \
 openssl-libs \
 "
RDEPENDS:cyrus-sasl-plain = " \
 cyrus-sasl-lib \
 glibc \
 libxcrypt \
 "
RDEPENDS:cyrus-sasl-scram = " \
 cyrus-sasl-lib \
 glibc \
 libxcrypt \
 openssl-libs \
 "
RDEPENDS:cyrus-sasl-sql = " \
 cyrus-sasl-lib \
 glibc \
 libpq \
 libxcrypt \
 mariadb-connector-c \
 "
