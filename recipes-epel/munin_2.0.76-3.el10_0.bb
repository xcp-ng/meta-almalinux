# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "munin"
PV = "2.0.76"
PR = "3.el10_0"
PACKAGES = " \
 munin \
 munin-apache \
 munin-cgi \
 munin-common \
 munin-nginx \
 munin-node \
 munin-plugins-ruby \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/munin-2.0.76-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb99a3bdff01b40723dcbd3b3ebcb32039128940ff898439b58fd669fe253fb1"

URI_x86_64_v2_munin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/munin-2.0.76-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_munin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_munin}"
SRC_URI[x86_64_v2_munin.sha256sum] = "a7549f37babcc66e81ce70c0efc969207315aac458af41f299afb6cde492cc3c"

URI_x86_64_v2_munin-apache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/munin-apache-2.0.76-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_munin-apache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_munin-apache}"
SRC_URI[x86_64_v2_munin-apache.sha256sum] = "ecc20c34afbecfaf506454efd499b3d06099413c5f23a327ee172a6596201778"
RPROVIDES:munin-apache:append:x86_64_v2 = " virtual/munin-web-support"

URI_x86_64_v2_munin-cgi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/munin-cgi-2.0.76-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_munin-cgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_munin-cgi}"
SRC_URI[x86_64_v2_munin-cgi.sha256sum] = "8356122c2abdbdf552bd4856fb3472c7497df0f5214f4ec999db5280b039fe05"

URI_x86_64_v2_munin-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/munin-common-2.0.76-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_munin-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_munin-common}"
SRC_URI[x86_64_v2_munin-common.sha256sum] = "64a08862edee4932b51cb470e0d1f75a1b62074ca0d8b58c718fa3bbf14229fe"

URI_x86_64_v2_munin-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/munin-nginx-2.0.76-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_munin-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_munin-nginx}"
SRC_URI[x86_64_v2_munin-nginx.sha256sum] = "0aaf4c6696210d6d4101452bfe471051df32d49f5ee727943fd043b3ed8554da"
RPROVIDES:munin-nginx:append:x86_64_v2 = " virtual/munin-web-support"

URI_x86_64_v2_munin-node = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/munin-node-2.0.76-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_munin-node;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_munin-node}"
SRC_URI[x86_64_v2_munin-node.sha256sum] = "b44ca0547ef46c5a73c3969c95f1eb6a53a4bad5c333ee1e40963961616ed95e"

URI_x86_64_v2_munin-plugins-ruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/munin-plugins-ruby-2.0.76-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_munin-plugins-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_munin-plugins-ruby}"
SRC_URI[x86_64_v2_munin-plugins-ruby.sha256sum] = "674e3cc6d8e10cd67bb9c918a1f11206bd533d1f1aea572e10e2395d1ea08f99"

URI_aarch64_munin = "${EPEL_MIRROR}/aarch64/Packages/m/munin-2.0.76-3.el10_0.noarch.rpm;name=aarch64_munin;unpack=0"
SRC_URI:append = " ${URI_aarch64_munin}"
SRC_URI[aarch64_munin.sha256sum] = "1f43844be9b7d78e197071beb4c82df73f7248830f9cf211ec70fb5f47b8e88b"

URI_aarch64_munin-apache = "${EPEL_MIRROR}/aarch64/Packages/m/munin-apache-2.0.76-3.el10_0.noarch.rpm;name=aarch64_munin-apache;unpack=0"
SRC_URI:append = " ${URI_aarch64_munin-apache}"
SRC_URI[aarch64_munin-apache.sha256sum] = "44a436f1f9fe56e5e96d20ea569daf4907a0f9df3e6b805d66e75a9d2a0415e1"
RPROVIDES:munin-apache:append:aarch64 = " virtual/munin-web-support"

URI_aarch64_munin-cgi = "${EPEL_MIRROR}/aarch64/Packages/m/munin-cgi-2.0.76-3.el10_0.noarch.rpm;name=aarch64_munin-cgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_munin-cgi}"
SRC_URI[aarch64_munin-cgi.sha256sum] = "14d600299b46cfc23da7f28991d614ccd4fe0dd05be3914c4315440d6d73769c"

URI_aarch64_munin-common = "${EPEL_MIRROR}/aarch64/Packages/m/munin-common-2.0.76-3.el10_0.noarch.rpm;name=aarch64_munin-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_munin-common}"
SRC_URI[aarch64_munin-common.sha256sum] = "9841523995e57184b9f9930971265618f9f627860e3ed712e52e621dfa5d0e9f"

URI_aarch64_munin-nginx = "${EPEL_MIRROR}/aarch64/Packages/m/munin-nginx-2.0.76-3.el10_0.noarch.rpm;name=aarch64_munin-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_munin-nginx}"
SRC_URI[aarch64_munin-nginx.sha256sum] = "9228078fdfc3e0a3e10fbecf1bf9cf78fe0e4c7c292c5cf8ba1d52cf9e84aa5d"
RPROVIDES:munin-nginx:append:aarch64 = " virtual/munin-web-support"

URI_aarch64_munin-node = "${EPEL_MIRROR}/aarch64/Packages/m/munin-node-2.0.76-3.el10_0.noarch.rpm;name=aarch64_munin-node;unpack=0"
SRC_URI:append = " ${URI_aarch64_munin-node}"
SRC_URI[aarch64_munin-node.sha256sum] = "9e6ad1e7e4160bfd025563dc2b4f30ffe53cab5c7f7297094eb400abce951e16"

URI_aarch64_munin-plugins-ruby = "${EPEL_MIRROR}/aarch64/Packages/m/munin-plugins-ruby-2.0.76-3.el10_0.noarch.rpm;name=aarch64_munin-plugins-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_munin-plugins-ruby}"
SRC_URI[aarch64_munin-plugins-ruby.sha256sum] = "66246c69c72ed90595b5abc99e5844a5f578a1a8f471685d21386043cc8f3b22"

RDEPENDS:munin = " \
 bash \
 dejavu-sans-mono-fonts \
 logrotate \
 munin-common \
 munin-node \
 perl-CGI \
 perl-CGI-Fast \
 perl-Carp \
 perl-Data-Dumper \
 perl-DateTime \
 perl-Digest-MD5 \
 perl-Encode \
 perl-English \
 perl-Exporter \
 perl-FCGI \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy-Recursive \
 perl-File-Path \
 perl-Getopt-Long \
 perl-HTML-Template \
 perl-IO \
 perl-IO-Socket-INET6 \
 perl-IPC-Open3 \
 perl-Log-Log4perl \
 perl-Net-SNMP \
 perl-Net-SSLeay \
 perl-Net-Server \
 perl-POSIX \
 perl-Params-Validate \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Symbol \
 perl-Taint-Runtime \
 perl-Text-Balanced \
 perl-Text-ParseWords \
 perl-Time-HiRes \
 perl-TimeDate \
 perl-URI \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-overload \
 rrdtool \
 rrdtool-perl \
 s-nail \
 shadow-utils \
 systemd \
 virtual/munin-web-support \
 "
RDEPENDS:munin-apache = " \
 bash \
 httpd \
 mod_fcgid \
 munin \
 "
RDEPENDS:munin-cgi = " \
 bash \
 munin \
 nginx-filesystem \
 systemd \
 "
RDEPENDS:munin-common = " \
 acl \
 bash \
 perl-Carp \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-IO \
 perl-base \
 perl-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:munin-nginx = " \
 bash \
 munin \
 munin-cgi \
 nginx-filesystem \
 "
RDEPENDS:munin-node = " \
 bash \
 bc \
 conntrack-tools \
 firewalld-filesystem \
 hdparm \
 jo \
 munin-common \
 perl-Cache-Cache \
 perl-Carp \
 perl-DBD-Pg \
 perl-DBI \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-IO-Socket-INET6 \
 perl-MIME-Base64 \
 perl-Net-CIDR \
 perl-Net-Ping \
 perl-Net-SNMP \
 perl-Net-SSLeay \
 perl-Net-Server \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Perldoc \
 perl-Pod-Usage \
 perl-Scalar-List-Utils \
 perl-Socket \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Tie-File \
 perl-XML-LibXML \
 perl-base \
 perl-bignum \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 policycoreutils \
 policycoreutils-python-utils \
 procps-ng \
 shadow-utils \
 systemd \
 which \
 "
RDEPENDS:munin-plugins-ruby = " \
 munin-node \
 ruby \
 "
