# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zeroize_derive"
PV = "1.5.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-zeroize_derive+default-devel \
 rust-zeroize_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zeroize_derive-1.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e86dabacaf2f4fe28ff4628dfcb2a95a3813be25f6ce1cd54638ae0a010c513e"

URI_x86_64_v2_rust-zeroize_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize_derive+default-devel-1.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize_derive+default-devel}"
SRC_URI[x86_64_v2_rust-zeroize_derive+default-devel.sha256sum] = "e149cb1da05666ca96257f4322a433c9888a6524ca3108f9622bafb7e6c003c6"

URI_x86_64_v2_rust-zeroize_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize_derive-devel-1.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize_derive-devel}"
SRC_URI[x86_64_v2_rust-zeroize_derive-devel.sha256sum] = "0b3a60e1779b6bccf20b86b9ddab13eff07fd0bba4425d74e614404db11dadd2"

URI_aarch64_rust-zeroize_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize_derive+default-devel-1.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-zeroize_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize_derive+default-devel}"
SRC_URI[aarch64_rust-zeroize_derive+default-devel.sha256sum] = "711d771e4494f6b79d2f8b4bef3162dcbbb0083c19a0019b594e8851e12d6fe2"

URI_aarch64_rust-zeroize_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize_derive-devel-1.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize_derive-devel}"
SRC_URI[aarch64_rust-zeroize_derive-devel.sha256sum] = "f700198574a4151059348d981fe384870f34c0ad50009e44ff5258f0130d538b"

RDEPENDS:rust-zeroize_derive+default-devel = " \
 cargo \
 rust-zeroize_derive-devel \
 "
RDEPENDS:rust-zeroize_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+visit-devel \
 "
