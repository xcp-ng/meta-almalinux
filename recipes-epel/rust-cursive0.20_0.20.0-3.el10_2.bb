# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cursive0.20"
PV = "0.20.0"
PR = "3.el10_2"
PACKAGES = " \
 rust-cursive0.20+crossterm-backend-devel \
 rust-cursive0.20+crossterm-devel \
 rust-cursive0.20+default-devel \
 rust-cursive0.20+doc-cfg-devel \
 rust-cursive0.20+maplit-devel \
 rust-cursive0.20+term_size-devel \
 rust-cursive0.20+termion-backend-devel \
 rust-cursive0.20+termion-devel \
 rust-cursive0.20+toml-devel \
 rust-cursive0.20+unstable_scroll-devel \
 rust-cursive0.20-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cursive0.20-0.20.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbd899739caf81274279b915e9872fbc54182e3497fd401135d3b7171a94f77f"

URI_x86_64_v2_rust-cursive0.20+crossterm-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+crossterm-backend-devel-0.20.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+crossterm-backend-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+crossterm-backend-devel.sha256sum] = "36d41bcd11271957c26d55bf69453fd4ba9667865854399e76faec8231d83d18"

URI_x86_64_v2_rust-cursive0.20+crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+crossterm-devel-0.20.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+crossterm-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+crossterm-devel.sha256sum] = "8dd0d9904159e25d8fbe4cbb381f1c13f2ce02ea74ab2291c8f0d6d2fdf48538"

URI_x86_64_v2_rust-cursive0.20+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+default-devel-0.20.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+default-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+default-devel.sha256sum] = "add8a220ee44e0079b22735a84987f9ab61dbc51152de4cc100a31ca2506b1cf"

URI_x86_64_v2_rust-cursive0.20+doc-cfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+doc-cfg-devel-0.20.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+doc-cfg-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+doc-cfg-devel.sha256sum] = "eb494fdc36ef1b7af746d2cc90267ec8c56351fe06fd0b1a7135f5003e8dfa00"

URI_x86_64_v2_rust-cursive0.20+maplit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+maplit-devel-0.20.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+maplit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+maplit-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+maplit-devel.sha256sum] = "b328d97133290b6c879634a7c9790765096af83a4fb65ed7a7cc7e31349af1cd"

URI_x86_64_v2_rust-cursive0.20+term_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+term_size-devel-0.20.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+term_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+term_size-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+term_size-devel.sha256sum] = "27d242d6c876490bfbe814eed9fd4e492cb20979fd844565850713ccbb74483c"

URI_x86_64_v2_rust-cursive0.20+termion-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+termion-backend-devel-0.20.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+termion-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+termion-backend-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+termion-backend-devel.sha256sum] = "c4fb2d36ef50f9c8ddfc3d72b52b4cee03456fc5e2c96986d2f68f56f2562c32"

URI_x86_64_v2_rust-cursive0.20+termion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+termion-devel-0.20.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+termion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+termion-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+termion-devel.sha256sum] = "4a59fb8360f25f20c4aecca1046de44869eca340d537ef0a9249beea30101d3c"

URI_x86_64_v2_rust-cursive0.20+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+toml-devel-0.20.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+toml-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+toml-devel.sha256sum] = "24014fb0dc8f39df820022d674ca4638342c6a90e65195a151d4dcc2433a87c0"

URI_x86_64_v2_rust-cursive0.20+unstable_scroll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+unstable_scroll-devel-0.20.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+unstable_scroll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+unstable_scroll-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+unstable_scroll-devel.sha256sum] = "991b651df2e06ca6fda4c14efc04d56b315591748caa9476fe760a59deb33141"

URI_x86_64_v2_rust-cursive0.20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20-devel-0.20.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20-devel.sha256sum] = "83f765741f36c2507951dbf8d182f6a471468e476aea5fa75ba196f1663b8736"

URI_aarch64_rust-cursive0.20+crossterm-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+crossterm-backend-devel-0.20.0-3.el10_2.noarch.rpm;name=aarch64_rust-cursive0.20+crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+crossterm-backend-devel}"
SRC_URI[aarch64_rust-cursive0.20+crossterm-backend-devel.sha256sum] = "308ac8b74251aa3ec11b7d932b6a164f3e0cbb47550e8e9b45359ac5bf2bc2db"

URI_aarch64_rust-cursive0.20+crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+crossterm-devel-0.20.0-3.el10_2.noarch.rpm;name=aarch64_rust-cursive0.20+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+crossterm-devel}"
SRC_URI[aarch64_rust-cursive0.20+crossterm-devel.sha256sum] = "8b221cf22bf7a6aa1e832d5f1064aad328546ce656c99f009eabc65decf816bc"

URI_aarch64_rust-cursive0.20+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+default-devel-0.20.0-3.el10_2.noarch.rpm;name=aarch64_rust-cursive0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+default-devel}"
SRC_URI[aarch64_rust-cursive0.20+default-devel.sha256sum] = "90d1a3f4503fbbfb303ce286dfb29f82cb85fca9ef0a438749d59c5a1c623b15"

URI_aarch64_rust-cursive0.20+doc-cfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+doc-cfg-devel-0.20.0-3.el10_2.noarch.rpm;name=aarch64_rust-cursive0.20+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+doc-cfg-devel}"
SRC_URI[aarch64_rust-cursive0.20+doc-cfg-devel.sha256sum] = "39818e7c2e8e2074608ecafc23c25c5d7ef655b18c090cd876e0ccd8a86a9dca"

URI_aarch64_rust-cursive0.20+maplit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+maplit-devel-0.20.0-3.el10_2.noarch.rpm;name=aarch64_rust-cursive0.20+maplit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+maplit-devel}"
SRC_URI[aarch64_rust-cursive0.20+maplit-devel.sha256sum] = "2594bd038c4cb21c045c23e027f0d70dc6d24b285d095ac4d5f4749f1bfff576"

URI_aarch64_rust-cursive0.20+term_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+term_size-devel-0.20.0-3.el10_2.noarch.rpm;name=aarch64_rust-cursive0.20+term_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+term_size-devel}"
SRC_URI[aarch64_rust-cursive0.20+term_size-devel.sha256sum] = "c29d9507ee5192c9c4fd6beb2148d3d58cc5ec88858465d4c0c38912b5500d8a"

URI_aarch64_rust-cursive0.20+termion-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+termion-backend-devel-0.20.0-3.el10_2.noarch.rpm;name=aarch64_rust-cursive0.20+termion-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+termion-backend-devel}"
SRC_URI[aarch64_rust-cursive0.20+termion-backend-devel.sha256sum] = "fd6a3f7ebc5a7899b972a0adf600208da802414b41288d2ab368d4e4697eb652"

URI_aarch64_rust-cursive0.20+termion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+termion-devel-0.20.0-3.el10_2.noarch.rpm;name=aarch64_rust-cursive0.20+termion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+termion-devel}"
SRC_URI[aarch64_rust-cursive0.20+termion-devel.sha256sum] = "02e833972aaacebb1609144ba9ba7dced171063cc9dc7452b3c0f28f89d19516"

URI_aarch64_rust-cursive0.20+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+toml-devel-0.20.0-3.el10_2.noarch.rpm;name=aarch64_rust-cursive0.20+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+toml-devel}"
SRC_URI[aarch64_rust-cursive0.20+toml-devel.sha256sum] = "81d1ad80304e8b8ed84fc8fa9679e3bb2bc444afe0b481602304e819cb2253ab"

URI_aarch64_rust-cursive0.20+unstable_scroll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+unstable_scroll-devel-0.20.0-3.el10_2.noarch.rpm;name=aarch64_rust-cursive0.20+unstable_scroll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+unstable_scroll-devel}"
SRC_URI[aarch64_rust-cursive0.20+unstable_scroll-devel.sha256sum] = "f97dea33910100ecaa7c4035875e7e987b9cf399c48b12a7417f820b7b183c51"

URI_aarch64_rust-cursive0.20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20-devel-0.20.0-3.el10_2.noarch.rpm;name=aarch64_rust-cursive0.20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20-devel}"
SRC_URI[aarch64_rust-cursive0.20-devel.sha256sum] = "19fe29a07ae737083eca1b53d6525148208cbacb0628f70ee70ff725bfd17a8f"

RDEPENDS:rust-cursive0.20+crossterm-backend-devel = " \
 cargo \
 rust-cursive0.20+crossterm-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+crossterm-devel = " \
 cargo \
 rust-crossterm0.25+default-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+default-devel = " \
 cargo \
 rust-cursive0.20+crossterm-backend-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+doc-cfg-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-cursive_core0.3+doc-cfg-devel \
 "
RDEPENDS:rust-cursive0.20+maplit-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-maplit+default-devel \
 "
RDEPENDS:rust-cursive0.20+term_size-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-term_size+default-devel \
 "
RDEPENDS:rust-cursive0.20+termion-backend-devel = " \
 cargo \
 rust-cursive0.20+termion-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+termion-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-termion+default-devel \
 "
RDEPENDS:rust-cursive0.20+toml-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-cursive_core0.3+toml-devel \
 "
RDEPENDS:rust-cursive0.20+unstable_scroll-devel = " \
 cargo \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20-devel = " \
 cargo \
 rust-ahash+default-devel \
 rust-cfg-if+default-devel \
 rust-crossbeam-channel+default-devel \
 rust-cursive_core0.3+default-devel \
 rust-lazy_static+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-signal-hook+default-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width0.1+default-devel \
 "
