# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-wizards"
PV = "1.0.3"
PR = "27.el10_0"
PACKAGES = " \
 ghc-wizards \
 ghc-wizards-devel \
 ghc-wizards-doc \
 ghc-wizards-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-wizards-1.0.3-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "43b8522c7dbe2719d4c7450f4637a0b31a4b29c23c011ebfa269e30169405dd9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wizards-1.0.3-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wizards;unpack=0"
SRC_URI[x86_64_v2_ghc-wizards.sha256sum] = "73db0f28d5f4df669e58aacd9ac49745bb7e2c3bd6e03fb80cad86fcf24503d0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wizards-devel-1.0.3-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wizards-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-wizards-devel.sha256sum] = "1af69afb078e25ab4a003f2fa9cdb68753e314e60839c50bfb94dc2ccffa259b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wizards-doc-1.0.3-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-wizards-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-wizards-doc.sha256sum] = "522063d4ef58bd0867fcebcb5e7418750a9fe08c3c768921179fdfdecf9e1882"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wizards-prof-1.0.3-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wizards-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-wizards-prof.sha256sum] = "535da3b3323430f57885d290fce87da231fbeef1ce86dc43d12a62f73359f62a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-wizards-1.0.3-27.el10_0.aarch64.rpm;name=aarch64_ghc-wizards;unpack=0"
SRC_URI[aarch64_ghc-wizards.sha256sum] = "9128f0811d474cca2e26a4363ac501b9325e5f4ac4ab2870bcc3b7799ec92255"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-wizards-devel-1.0.3-27.el10_0.aarch64.rpm;name=aarch64_ghc-wizards-devel;unpack=0"
SRC_URI[aarch64_ghc-wizards-devel.sha256sum] = "9e1f942da51c660edcf7e17a5736580e836cef2938d7045fb8645652b5696029"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-wizards-doc-1.0.3-27.el10_0.noarch.rpm;name=aarch64_ghc-wizards-doc;unpack=0"
SRC_URI[aarch64_ghc-wizards-doc.sha256sum] = "562effb9342e55f4214ddf2daed03839ffc0113c569b4ee93eec525a6adb7e3c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-wizards-prof-1.0.3-27.el10_0.aarch64.rpm;name=aarch64_ghc-wizards-prof;unpack=0"
SRC_URI[aarch64_ghc-wizards-prof.sha256sum] = "61ec59a8d0ccbe66f030bcddf11eab3ded8c86015f46db5bd16f19635a13a682"

RDEPENDS:ghc-wizards = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-containers \
 ghc-control-monad-free \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-haskeline \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-terminfo \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc-wizards-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-control-monad-free-devel \
 ghc-haskeline-devel \
 ghc-mtl-devel \
 ghc-transformers-devel \
 ghc-wizards \
 "
RDEPENDS:ghc-wizards-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-wizards-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-control-monad-free-prof \
 ghc-haskeline-prof \
 ghc-mtl-prof \
 ghc-transformers-prof \
 ghc-wizards-devel \
 "
