# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-astral-version-ranges"
PV = "0.2.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-astral-version-ranges+default-devel \
 rust-astral-version-ranges+proptest-devel \
 rust-astral-version-ranges+semver-devel \
 rust-astral-version-ranges+serde-devel \
 rust-astral-version-ranges-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-astral-version-ranges-0.2.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a4ef35636a28b9663cb6a217140eb9e3b70300753a91776d26d3516b0da9a9d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-version-ranges+default-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-version-ranges+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-astral-version-ranges+default-devel.sha256sum] = "6688a2ef0904cc13e43716dce8a8715bb108e73f59a393dbebebcbbe29140390"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-version-ranges+proptest-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-version-ranges+proptest-devel;unpack=0"
SRC_URI[x86_64_v2_rust-astral-version-ranges+proptest-devel.sha256sum] = "e2ce8b5336b37ebffa0da77904242a8ef30e4bbca2bc1d41544a12472936bfef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-version-ranges+semver-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-version-ranges+semver-devel;unpack=0"
SRC_URI[x86_64_v2_rust-astral-version-ranges+semver-devel.sha256sum] = "4981f9da4b548f93af36c6f644d47b3f0d96a8fb3f4e03eb4a05d37db191d18a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-version-ranges+serde-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-version-ranges+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-astral-version-ranges+serde-devel.sha256sum] = "f062efc401571aa7eb52e5174c55175c8136d5aa1fb51d6d47bf2ce87ea851a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-version-ranges-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-version-ranges-devel;unpack=0"
SRC_URI[x86_64_v2_rust-astral-version-ranges-devel.sha256sum] = "113b049252d55a42c6052c70136d1f1677ffd57f43c73b6be309f2d7b249eaf4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-version-ranges+default-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-astral-version-ranges+default-devel;unpack=0"
SRC_URI[aarch64_rust-astral-version-ranges+default-devel.sha256sum] = "c4343fa8208512fd1b6303b185b5f120bc166cd805a396880181f8feea22a9be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-version-ranges+proptest-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-astral-version-ranges+proptest-devel;unpack=0"
SRC_URI[aarch64_rust-astral-version-ranges+proptest-devel.sha256sum] = "211ac899f0a0e94bb2d118aa94d0af3d92a5e61b76c90f44c54f8e508a6ebeb2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-version-ranges+semver-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-astral-version-ranges+semver-devel;unpack=0"
SRC_URI[aarch64_rust-astral-version-ranges+semver-devel.sha256sum] = "6b7b8529760536e194243daaf00e4ceadad2eb54388997d7ab48ecd0cb607478"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-version-ranges+serde-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-astral-version-ranges+serde-devel;unpack=0"
SRC_URI[aarch64_rust-astral-version-ranges+serde-devel.sha256sum] = "ddc900d7b2cf77560553cd2cb0a2a3b8dac68bdde9057d27737c21706cda22e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-version-ranges-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-astral-version-ranges-devel;unpack=0"
SRC_URI[aarch64_rust-astral-version-ranges-devel.sha256sum] = "c7abdaaba7c1b62637825f1bb64ee2035e7519279f0ecfe2a3e342f39d91694a"

RDEPENDS:rust-astral-version-ranges+default-devel = " \
 cargo \
 rust-astral-version-ranges-devel \
 "
RDEPENDS:rust-astral-version-ranges+proptest-devel = " \
 cargo \
 rust-astral-version-ranges-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-astral-version-ranges+semver-devel = " \
 cargo \
 rust-astral-version-ranges-devel \
 rust-semver+default-devel \
 "
RDEPENDS:rust-astral-version-ranges+serde-devel = " \
 cargo \
 rust-astral-version-ranges-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-smallvec+serde-devel \
 "
RDEPENDS:rust-astral-version-ranges-devel = " \
 cargo \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 "
