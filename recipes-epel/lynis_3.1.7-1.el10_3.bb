# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lynis"
PV = "3.1.7"
PR = "1.el10_3"
PACKAGES = " \
 lynis \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lynis-3.1.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c337a9a6cd92aadd2d7f9d0210d120b727a48d840408d136c369dfa98dfed971"

URI_x86_64_v2_lynis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lynis-3.1.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lynis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lynis}"
SRC_URI[x86_64_v2_lynis.sha256sum] = "2818383bbd1804c75f46f0a7c27fb3bbd30e533c3c6e1ef2d303895bb1294560"

URI_aarch64_lynis = "${EPEL_MIRROR}/aarch64/Packages/l/lynis-3.1.7-1.el10_3.noarch.rpm;name=aarch64_lynis;unpack=0"
SRC_URI:append = " ${URI_aarch64_lynis}"
SRC_URI[aarch64_lynis.sha256sum] = "aff85103aacde4eb2bbd62456debc0ad739ebeb011795309db48f7c9b9b8b15b"

RDEPENDS:lynis = " \
 audit \
 bash \
 e2fsprogs \
 kmod \
 "
