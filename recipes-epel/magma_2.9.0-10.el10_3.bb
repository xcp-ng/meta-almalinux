# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "magma"
PV = "2.9.0"
PR = "10.el10_3"
PACKAGES:x86_64_v2 = " \
 magma \
 magma-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/m/magma-2.9.0-10.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fef76e8664527d01bd20c8d3cb9c2f46c05ad2ac4a5766763066a4292279715"

URI_x86_64_v2_magma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/magma-2.9.0-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_magma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_magma}"
SRC_URI[x86_64_v2_magma.sha256sum] = "e1662c6fa2accd515505c628a3adb5eae42a31524a74dc63bc2f6be2f3d22b1a"

URI_x86_64_v2_magma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/magma-devel-2.9.0-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_magma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_magma-devel}"
SRC_URI[x86_64_v2_magma-devel.sha256sum] = "b48f36237c2c1b97480de91efae2a8d19c41ae655c29186f97326d246f904369"

RDEPENDS:magma = " \
 flexiblas-netlib \
 glibc \
 hipblas \
 hipsparse \
 libgcc \
 libstdc++ \
 rocm-hip \
 "
RDEPENDS:magma-devel = " \
 magma \
 pkgconf-pkg-config \
 "
