# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-yaml"
PV = "0.7.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-yaml+default-devel \
 rust-tree-sitter-yaml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-yaml-0.7.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa01f154b1a03fc53173044e5d85d8501a2ee0fe99e22e190d19454c60fbe14f"

URI_x86_64_v2_rust-tree-sitter-yaml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-yaml+default-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-yaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-yaml+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-yaml+default-devel.sha256sum] = "6dca50a61ab504842e1694c9e1e6cf24e09f38a2fe0ad459c0c4bd4a81ac4048"

URI_x86_64_v2_rust-tree-sitter-yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-yaml-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-yaml-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-yaml-devel.sha256sum] = "42f9d14119a849ca6c914e0a9d235c9e2b7db91081740e876528424098e26d4f"

URI_aarch64_rust-tree-sitter-yaml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-yaml+default-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-yaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-yaml+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-yaml+default-devel.sha256sum] = "042dd945e86fbb66b642c5e138a09059660b7a9f90499e3686b6eaa3567b50fe"

URI_aarch64_rust-tree-sitter-yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-yaml-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-yaml-devel}"
SRC_URI[aarch64_rust-tree-sitter-yaml-devel.sha256sum] = "23010f40d44d349414b7b8a9f8a26e555a0db19377c4b7b1cee7e01f020b7981"

RDEPENDS:rust-tree-sitter-yaml+default-devel = " \
 cargo \
 rust-tree-sitter-yaml-devel \
 "
RDEPENDS:rust-tree-sitter-yaml-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
