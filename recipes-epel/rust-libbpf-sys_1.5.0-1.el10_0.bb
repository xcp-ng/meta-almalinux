# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libbpf-sys"
PV = "1.5.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-libbpf-sys+bindgen-devel \
 rust-libbpf-sys+bindgen-source-devel \
 rust-libbpf-sys+default-devel \
 rust-libbpf-sys+novendor-devel \
 rust-libbpf-sys+static-devel \
 rust-libbpf-sys+static-libbpf-devel \
 rust-libbpf-sys+static-libelf-devel \
 rust-libbpf-sys+static-zlib-devel \
 rust-libbpf-sys+vendored-devel \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys+vendored-libelf-devel \
 rust-libbpf-sys+vendored-zlib-devel \
 rust-libbpf-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libbpf-sys-1.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f6df52a91e18f800d5766693a05d4ba1f3bdb8444e43afd6c2d4108e2d0d87f"

URI_x86_64_v2_rust-libbpf-sys+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+bindgen-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+bindgen-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+bindgen-devel.sha256sum] = "aac65433a911e9bcd1f0616618d56d6748e0a46506c2c5a2363465f0943a359e"

URI_x86_64_v2_rust-libbpf-sys+bindgen-source-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+bindgen-source-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+bindgen-source-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+bindgen-source-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+bindgen-source-devel.sha256sum] = "f5a01b3baba66ae3a6734d3ae4303226e0e668f3ac61c03ccd271f40413f335e"

URI_x86_64_v2_rust-libbpf-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+default-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+default-devel.sha256sum] = "1eb5fc296dc35e22e2d479cdc94e64fa45f4d0bf7c717e554462ab097ad1cac7"

URI_x86_64_v2_rust-libbpf-sys+novendor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+novendor-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+novendor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+novendor-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+novendor-devel.sha256sum] = "adbc3462ce9748156fd07ec35a49eb2241d118f5a8f922d4fc49b1420aedaa31"

URI_x86_64_v2_rust-libbpf-sys+static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+static-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+static-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+static-devel.sha256sum] = "486539d8faf555fcf74492ac341db498fe2c4073eaf7bc76b58fdae7d67fb9f6"

URI_x86_64_v2_rust-libbpf-sys+static-libbpf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+static-libbpf-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+static-libbpf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+static-libbpf-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+static-libbpf-devel.sha256sum] = "75079e9a30c0b083b1f972630047dbad335cc3e30ae9ff60c18ce1d19ecfa71b"

URI_x86_64_v2_rust-libbpf-sys+static-libelf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+static-libelf-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+static-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+static-libelf-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+static-libelf-devel.sha256sum] = "04687b847eee2b0d3f4957ce0beb9156e0b6df6bccec2474772de170a42e5237"

URI_x86_64_v2_rust-libbpf-sys+static-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+static-zlib-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+static-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+static-zlib-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+static-zlib-devel.sha256sum] = "abe3187bc261a8baf4b6d444f9a34ac5ad0e390ce07aa8345ae10c553d27e1fd"

URI_x86_64_v2_rust-libbpf-sys+vendored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+vendored-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+vendored-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+vendored-devel.sha256sum] = "0b9546c827f78c57df70f7061c589bcd508e9a6cb5c200946c4a562ca446efe7"

URI_x86_64_v2_rust-libbpf-sys+vendored-libbpf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+vendored-libbpf-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+vendored-libbpf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+vendored-libbpf-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+vendored-libbpf-devel.sha256sum] = "2507a0d5a19c7f7c71dc814b91345f7bdfd14400f296f36e86a771e41d83b6a3"

URI_x86_64_v2_rust-libbpf-sys+vendored-libelf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+vendored-libelf-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+vendored-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+vendored-libelf-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+vendored-libelf-devel.sha256sum] = "bc2d1b2174790fbbba703f36a59c50fdf48891e41ef5a231418472d9c63507b2"

URI_x86_64_v2_rust-libbpf-sys+vendored-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+vendored-zlib-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+vendored-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+vendored-zlib-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+vendored-zlib-devel.sha256sum] = "b2c6e4458f4f984e56ea2df90dc7d688b51ec3634e7e83cddca1561257b9d351"

URI_x86_64_v2_rust-libbpf-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys-devel.sha256sum] = "637778b25933fe06e52b96d38f32011c628c0f1cbc63c1ce13c202807d7a3285"

URI_aarch64_rust-libbpf-sys+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+bindgen-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-libbpf-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+bindgen-devel}"
SRC_URI[aarch64_rust-libbpf-sys+bindgen-devel.sha256sum] = "c8f24c2917df07da6e6a91d6b12723a252c218ec0d6e554ce1a81d3d2f148e3d"

URI_aarch64_rust-libbpf-sys+bindgen-source-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+bindgen-source-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-libbpf-sys+bindgen-source-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+bindgen-source-devel}"
SRC_URI[aarch64_rust-libbpf-sys+bindgen-source-devel.sha256sum] = "d195b610502ca8771f6cdffce23ce298d0d96be811da4b0e055ef990a48179f3"

URI_aarch64_rust-libbpf-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+default-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-libbpf-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+default-devel}"
SRC_URI[aarch64_rust-libbpf-sys+default-devel.sha256sum] = "4f4451e2ef962c94b8840755022556ffb2b483cbad8b5ea1dc6968252e3672a8"

URI_aarch64_rust-libbpf-sys+novendor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+novendor-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-libbpf-sys+novendor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+novendor-devel}"
SRC_URI[aarch64_rust-libbpf-sys+novendor-devel.sha256sum] = "a048d04630f3a919b6e6218d4b80f7b30de0fcea0424e46ccea624bd6b345c76"

URI_aarch64_rust-libbpf-sys+static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+static-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-libbpf-sys+static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+static-devel}"
SRC_URI[aarch64_rust-libbpf-sys+static-devel.sha256sum] = "2c9dea926b1c549cb339e6a8bdae4348a3db3804592271504d7610bb24f8cda1"

URI_aarch64_rust-libbpf-sys+static-libbpf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+static-libbpf-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-libbpf-sys+static-libbpf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+static-libbpf-devel}"
SRC_URI[aarch64_rust-libbpf-sys+static-libbpf-devel.sha256sum] = "c06b0afdb14fa56761224a55d29eca7fd7865c56d7d6dd92311715be478a2a7c"

URI_aarch64_rust-libbpf-sys+static-libelf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+static-libelf-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-libbpf-sys+static-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+static-libelf-devel}"
SRC_URI[aarch64_rust-libbpf-sys+static-libelf-devel.sha256sum] = "3894891cf0301680464fd2cd987c16e6282f627e3b180cb759650ed1da1676ac"

URI_aarch64_rust-libbpf-sys+static-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+static-zlib-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-libbpf-sys+static-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+static-zlib-devel}"
SRC_URI[aarch64_rust-libbpf-sys+static-zlib-devel.sha256sum] = "286caeb29b2c43e6545ba7ac6be0130ba902531c726df3ad46ad6829735273ed"

URI_aarch64_rust-libbpf-sys+vendored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+vendored-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-libbpf-sys+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+vendored-devel}"
SRC_URI[aarch64_rust-libbpf-sys+vendored-devel.sha256sum] = "6785a024bf640228ff04a060ab910d5ec63cd77df6fb3775db8587333a572983"

URI_aarch64_rust-libbpf-sys+vendored-libbpf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+vendored-libbpf-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-libbpf-sys+vendored-libbpf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+vendored-libbpf-devel}"
SRC_URI[aarch64_rust-libbpf-sys+vendored-libbpf-devel.sha256sum] = "3339770e00a3ab3e6532f62dba916f42120051d4abc92339102f53e62d6a6ece"

URI_aarch64_rust-libbpf-sys+vendored-libelf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+vendored-libelf-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-libbpf-sys+vendored-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+vendored-libelf-devel}"
SRC_URI[aarch64_rust-libbpf-sys+vendored-libelf-devel.sha256sum] = "f87c0ba69b5f965450d0b95053bd177feb9186fa4042fe206356a820897fddd8"

URI_aarch64_rust-libbpf-sys+vendored-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+vendored-zlib-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-libbpf-sys+vendored-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+vendored-zlib-devel}"
SRC_URI[aarch64_rust-libbpf-sys+vendored-zlib-devel.sha256sum] = "0d1dc13f59bea66579d36edd7e46bdd22a052e4fde8875475bee91e06f6ad6a1"

URI_aarch64_rust-libbpf-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-libbpf-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys-devel}"
SRC_URI[aarch64_rust-libbpf-sys-devel.sha256sum] = "c238756f2377d9345b303e86da7001a5ee759031759b275ec5706244f9ae8d1f"

RDEPENDS:rust-libbpf-sys+bindgen-devel = " \
 cargo \
 rust-bindgen+default-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+bindgen-source-devel = " \
 cargo \
 rust-libbpf-sys+bindgen-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+default-devel = " \
 cargo \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+novendor-devel = " \
 cargo \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+static-devel = " \
 cargo \
 rust-libbpf-sys+static-libbpf-devel \
 rust-libbpf-sys+static-libelf-devel \
 rust-libbpf-sys+static-zlib-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+static-libbpf-devel = " \
 cargo \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+static-libelf-devel = " \
 cargo \
 rust-libbpf-sys+static-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+static-zlib-devel = " \
 cargo \
 rust-libbpf-sys+static-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+vendored-devel = " \
 cargo \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys+vendored-libelf-devel \
 rust-libbpf-sys+vendored-zlib-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+vendored-libbpf-devel = " \
 cargo \
 rust-libbpf-sys+static-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+vendored-libelf-devel = " \
 cargo \
 rust-libbpf-sys+static-libelf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+vendored-zlib-devel = " \
 cargo \
 rust-libbpf-sys+static-zlib-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys-devel = " \
 bash \
 cargo \
 elfutils-libelf-devel \
 kernel-headers \
 rust-cc+default-devel \
 rust-nix+fs-devel \
 rust-nix-devel \
 rust-pkg-config+default-devel \
 zlib-ng-compat-devel \
 "
