# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "icon-naming-utils"
PV = "0.8.90"
PR = "33.el10_0"
PACKAGES = " \
 icon-naming-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/icon-naming-utils-0.8.90-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7690ff11ec5b6fc9d5cc4c9d4e1e237372ecd8a47cfd45a43e09a2d78d58d2a4"

URI_x86_64_v2_icon-naming-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icon-naming-utils-0.8.90-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_icon-naming-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icon-naming-utils}"
SRC_URI[x86_64_v2_icon-naming-utils.sha256sum] = "848892094400cff622647f3d59a05400e2f6d81428684c0bd911eb0651cc2146"

URI_aarch64_icon-naming-utils = "${EPEL_MIRROR}/aarch64/Packages/i/icon-naming-utils-0.8.90-33.el10_0.noarch.rpm;name=aarch64_icon-naming-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_icon-naming-utils}"
SRC_URI[aarch64_icon-naming-utils.sha256sum] = "644a7195be2bfc1711ebe059e625821c8349f9d466034de96da044259bd56605"

RDEPENDS:icon-naming-utils = " \
 perl-Getopt-Long \
 perl-XML-Simple \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 "
