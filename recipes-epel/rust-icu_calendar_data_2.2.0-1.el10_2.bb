# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_calendar_data"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_calendar_data+default-devel \
 rust-icu_calendar_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_calendar_data-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fcf0df09c000cd407c4a406674ce4dc65760c12575cce4a0bc853bdf22e4164"

URI_x86_64_v2_rust-icu_calendar_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar_data+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar_data+default-devel.sha256sum] = "fe48d255a6eaa1c4bde9fcc4ba2ea9d5e8f327ac9753318c53f06342c3a233c4"

URI_x86_64_v2_rust-icu_calendar_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar_data-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar_data-devel.sha256sum] = "f5da5d8301e1c4851f072cf2969d23d74c4c5afb85547f19f9f0a7550413ca27"

URI_aarch64_rust-icu_calendar_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar_data+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_calendar_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar_data+default-devel}"
SRC_URI[aarch64_rust-icu_calendar_data+default-devel.sha256sum] = "2a3bb4b2cf66cfd62c8e2a40453ea5a191c71a6cfc3f3d75f10578d82c7811a6"

URI_aarch64_rust-icu_calendar_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_calendar_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar_data-devel}"
SRC_URI[aarch64_rust-icu_calendar_data-devel.sha256sum] = "3c172e21d073ca65aab1103256c43665f793e60a34302c04b30f2e565dbaa0c9"

RDEPENDS:rust-icu_calendar_data+default-devel = " \
 cargo \
 rust-icu_calendar_data-devel \
 "
RDEPENDS:rust-icu_calendar_data-devel = " \
 cargo \
 rust \
 "
