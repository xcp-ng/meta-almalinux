# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-prost-reflect"
PV = "0.16.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-prost-reflect+default-devel \
 rust-prost-reflect+miette-devel \
 rust-prost-reflect+serde-devel \
 rust-prost-reflect+text-format-devel \
 rust-prost-reflect-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-prost-reflect-0.16.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1194589d456bba9747e2aee1e45c043e9d6ba4cca032d3e768ad045788a3199"

URI_x86_64_v2_rust-prost-reflect+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-reflect+default-devel-0.16.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-reflect+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-reflect+default-devel}"
SRC_URI[x86_64_v2_rust-prost-reflect+default-devel.sha256sum] = "bb0dade2ad73d7b16978942e0c80cf9d36e364f223dc673fc5bfe3877fcb3970"

URI_x86_64_v2_rust-prost-reflect+miette-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-reflect+miette-devel-0.16.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-reflect+miette-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-reflect+miette-devel}"
SRC_URI[x86_64_v2_rust-prost-reflect+miette-devel.sha256sum] = "523a7452a63c0c946fdcca8054abe0e063e4cda0b32bb6427474ff5fd64ae8c7"

URI_x86_64_v2_rust-prost-reflect+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-reflect+serde-devel-0.16.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-reflect+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-reflect+serde-devel}"
SRC_URI[x86_64_v2_rust-prost-reflect+serde-devel.sha256sum] = "bdcbd2ca6256b85e38f46fd0c7f00a63ec0248295453cb8b05034705da4e6e5a"

URI_x86_64_v2_rust-prost-reflect+text-format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-reflect+text-format-devel-0.16.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-reflect+text-format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-reflect+text-format-devel}"
SRC_URI[x86_64_v2_rust-prost-reflect+text-format-devel.sha256sum] = "a9d439b8763664f612a8c11f7338b577c8e00177827f871cbb343d1ca5ce167d"

URI_x86_64_v2_rust-prost-reflect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-reflect-devel-0.16.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-reflect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-reflect-devel}"
SRC_URI[x86_64_v2_rust-prost-reflect-devel.sha256sum] = "976ddafcf237aac1d40f26a3ec303d46b73536f962fd42c37e0180d54faef7a3"

URI_aarch64_rust-prost-reflect+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-reflect+default-devel-0.16.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost-reflect+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-reflect+default-devel}"
SRC_URI[aarch64_rust-prost-reflect+default-devel.sha256sum] = "2f6b07dee1c6851c9540a7e958a52c22ab05e22c0b25642ef2c03fc72be50352"

URI_aarch64_rust-prost-reflect+miette-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-reflect+miette-devel-0.16.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost-reflect+miette-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-reflect+miette-devel}"
SRC_URI[aarch64_rust-prost-reflect+miette-devel.sha256sum] = "0c80fc1b0b1ab0e6251e6488249ed3c3177831b03cd7d74a58df7d6ca5e73858"

URI_aarch64_rust-prost-reflect+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-reflect+serde-devel-0.16.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost-reflect+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-reflect+serde-devel}"
SRC_URI[aarch64_rust-prost-reflect+serde-devel.sha256sum] = "70b76ea861575364b8837df1154ba7d40c62e1ca26beea328a23c0a82f4268cf"

URI_aarch64_rust-prost-reflect+text-format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-reflect+text-format-devel-0.16.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost-reflect+text-format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-reflect+text-format-devel}"
SRC_URI[aarch64_rust-prost-reflect+text-format-devel.sha256sum] = "f815b11e0980a8143aafbf01af85f97cf8328101f3063f087e5647bca8d4de0d"

URI_aarch64_rust-prost-reflect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-reflect-devel-0.16.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost-reflect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-reflect-devel}"
SRC_URI[aarch64_rust-prost-reflect-devel.sha256sum] = "e12e9edb15548c2a7218971f034ec52674f78db4b55e4de17dfb8d5fe853d8df"

RDEPENDS:rust-prost-reflect+default-devel = " \
 cargo \
 rust-prost-reflect-devel \
 "
RDEPENDS:rust-prost-reflect+miette-devel = " \
 cargo \
 rust-miette+default-devel \
 rust-prost-reflect-devel \
 "
RDEPENDS:rust-prost-reflect+serde-devel = " \
 cargo \
 rust-base64_0.22+default-devel \
 rust-prost-reflect-devel \
 rust-serde+default-devel \
 rust-serde-value+default-devel \
 "
RDEPENDS:rust-prost-reflect+text-format-devel = " \
 cargo \
 rust-logos+default-devel \
 rust-prost-reflect-devel \
 "
RDEPENDS:rust-prost-reflect-devel = " \
 cargo \
 rust \
 rust-prost+default-devel \
 rust-prost-types+default-devel \
 "
