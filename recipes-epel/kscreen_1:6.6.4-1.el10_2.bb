# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kscreen"
PE = "1"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kscreen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kscreen-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28bc6ce1f612b1f91d637aa59b227e659c5ec592e8895427d47eefa51d3810e9"

URI_x86_64_v2_kscreen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kscreen-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kscreen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kscreen}"
SRC_URI[x86_64_v2_kscreen.sha256sum] = "f57610db3a18cb3d73e8ae3e991bb8acfa59e5a977c55ad01f50e628fd6ce524"

URI_aarch64_kscreen = "${EPEL_MIRROR}/aarch64/Packages/k/kscreen-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kscreen;unpack=0"
SRC_URI:append = " ${URI_aarch64_kscreen}"
SRC_URI[aarch64_kscreen.sha256sum] = "1d942415fdead8fd89c5ad7e894d8a6ae66b3cef4d389484177f57b57907ac6d"

RDEPENDS:kscreen = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwindowsystem \
 layer-shell-qt \
 libX11 \
 libXi \
 libkscreen \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
