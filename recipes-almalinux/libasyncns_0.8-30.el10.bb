# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libasyncns"
PV = "0.8"
PR = "30.el10"
PACKAGES = " \
 libasyncns \
 libasyncns-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libasyncns-0.8-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42f23752877467160c3cd501f2ce27c534ae9e12ff4a5cb775a0c85c5ae00bc7"

URI_x86_64_v2_libasyncns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libasyncns-0.8-30.el10.x86_64_v2.rpm;name=x86_64_v2_libasyncns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libasyncns}"
SRC_URI[x86_64_v2_libasyncns.sha256sum] = "1351e31f85e49b98b733f6e20ca34f53b12c8e28724be8d74bc6d77f9249ba6f"

URI_x86_64_v2_libasyncns-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libasyncns-devel-0.8-30.el10.x86_64_v2.rpm;name=x86_64_v2_libasyncns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libasyncns-devel}"
SRC_URI[x86_64_v2_libasyncns-devel.sha256sum] = "f9fd6b4b90944499129ea9ed795ee9d88999c8ab28af57eac83e956f90d51d0e"

URI_aarch64_libasyncns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libasyncns-0.8-30.el10.aarch64.rpm;name=aarch64_libasyncns;unpack=0"
SRC_URI:append = " ${URI_aarch64_libasyncns}"
SRC_URI[aarch64_libasyncns.sha256sum] = "0bdb42f5ba2ec0cea89cfaf2e04c99fd88c50c8ca1e617b6421ab22a0bf51b0e"

URI_aarch64_libasyncns-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libasyncns-devel-0.8-30.el10.aarch64.rpm;name=aarch64_libasyncns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libasyncns-devel}"
SRC_URI[aarch64_libasyncns-devel.sha256sum] = "897b3f355c894bef6d7e8ff8ecc18cd9110c3d8a6f7d1f11f0f9dfb9b842bfb0"

RDEPENDS:libasyncns = " \
 glibc \
 "
RDEPENDS:libasyncns-devel = " \
 libasyncns \
 pkgconf-pkg-config \
 "
