# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-h11"
PV = "0.14.0"
PR = "7.el10_1"
PACKAGES = " \
 python3-h11 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-h11-0.14.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a36cdf29d493522b41f4e02f90c37776a6c9026e693d1924ab847bb1dc59111c"

URI_x86_64_v2_python3-h11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-h11-0.14.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-h11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-h11}"
SRC_URI[x86_64_v2_python3-h11.sha256sum] = "b76aed7ed6790aa3e79ae8b8532066ad6509b7cb40da97f547f5db223ef94261"

URI_aarch64_python3-h11 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-h11-0.14.0-7.el10_1.noarch.rpm;name=aarch64_python3-h11;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-h11}"
SRC_URI[aarch64_python3-h11.sha256sum] = "ac0ab0d830c904b7bd09fd695f0acb0bbae16f3f31b72eefaad56d288611b222"

RDEPENDS:python3-h11 = " \
 python3 \
 "
