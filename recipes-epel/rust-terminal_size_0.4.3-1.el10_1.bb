# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-terminal_size"
PV = "0.4.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-terminal_size+default-devel \
 rust-terminal_size-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-terminal_size-0.4.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb9fc5a40b245b218f71a8a43fa39b2981d043a10bbe6b5d2cd3c40c47b2914a"

URI_x86_64_v2_rust-terminal_size+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal_size+default-devel-0.4.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal_size+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal_size+default-devel}"
SRC_URI[x86_64_v2_rust-terminal_size+default-devel.sha256sum] = "257a3e15ef7829c56ba632e9ae445c6e0af878d03ec53e8ce6f8b0fea78b8d38"

URI_x86_64_v2_rust-terminal_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal_size-devel-0.4.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal_size-devel}"
SRC_URI[x86_64_v2_rust-terminal_size-devel.sha256sum] = "fb1abb7ff0adb6bd892734bc503a5f75a5d3f16c0e014a4d82be220eeb080215"

URI_aarch64_rust-terminal_size+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal_size+default-devel-0.4.3-1.el10_1.noarch.rpm;name=aarch64_rust-terminal_size+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal_size+default-devel}"
SRC_URI[aarch64_rust-terminal_size+default-devel.sha256sum] = "4d0863222238622a2a7490bc5ea6b26a02a914be2b70fd0b4bd91aa99dc7b536"

URI_aarch64_rust-terminal_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal_size-devel-0.4.3-1.el10_1.noarch.rpm;name=aarch64_rust-terminal_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal_size-devel}"
SRC_URI[aarch64_rust-terminal_size-devel.sha256sum] = "f73305feecb21b415b20e1e831c1154d222719b9811e6840182771f16095e793"

RDEPENDS:rust-terminal_size+default-devel = " \
 cargo \
 rust-terminal_size-devel \
 "
RDEPENDS:rust-terminal_size-devel = " \
 cargo \
 rust \
 rust-rustix+default-devel \
 rust-rustix+termios-devel \
 "
