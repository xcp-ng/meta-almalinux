# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-crypton"
PV = "0.34"
PR = "4.el10_0"
PACKAGES = " \
 ghc-crypton \
 ghc-crypton-devel \
 ghc-crypton-doc \
 ghc-crypton-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-crypton-0.34-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71f1df42d24565c88533d68f62df893a98296edf5bc30fdd46013fa5ff9c8d95"

URI_x86_64_v2_ghc-crypton = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-0.34-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypton;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton}"
SRC_URI[x86_64_v2_ghc-crypton.sha256sum] = "733716354d5cf85938252005cd20109a3353ab3e428ec1970df78b8754d73cee"

URI_x86_64_v2_ghc-crypton-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-devel-0.34-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypton-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton-devel}"
SRC_URI[x86_64_v2_ghc-crypton-devel.sha256sum] = "7a9ba8bb9dad3d78a44259e418bea9b23608032746ef50bcf8cdeef225bb7c0e"

URI_x86_64_v2_ghc-crypton-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-doc-0.34-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypton-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton-doc}"
SRC_URI[x86_64_v2_ghc-crypton-doc.sha256sum] = "dba863bdb12ebf0f6075e77a23ad42e5fac8ee9e99f4eb401149a6b717f54046"

URI_x86_64_v2_ghc-crypton-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-prof-0.34-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypton-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton-prof}"
SRC_URI[x86_64_v2_ghc-crypton-prof.sha256sum] = "31deea4b858ff1e720e2d003ac8e2f46878d66cdc32820f212055906e89d009b"

URI_aarch64_ghc-crypton = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-0.34-4.el10_0.aarch64.rpm;name=aarch64_ghc-crypton;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton}"
SRC_URI[aarch64_ghc-crypton.sha256sum] = "b32622d1230a5037391ad86b83ea76fdff7097c9c243195cdea1dd7bc69b396d"

URI_aarch64_ghc-crypton-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-devel-0.34-4.el10_0.aarch64.rpm;name=aarch64_ghc-crypton-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton-devel}"
SRC_URI[aarch64_ghc-crypton-devel.sha256sum] = "fac2909c1689f90fec1e1842731de9676713a3474a3dfba3b8a1f836150b97fa"

URI_aarch64_ghc-crypton-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-doc-0.34-4.el10_0.aarch64.rpm;name=aarch64_ghc-crypton-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton-doc}"
SRC_URI[aarch64_ghc-crypton-doc.sha256sum] = "a687e490c5c060ebd738fcd7b8b7bf500c73e70fb5e4cd2879eb72801e16b672"

URI_aarch64_ghc-crypton-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-prof-0.34-4.el10_0.aarch64.rpm;name=aarch64_ghc-crypton-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton-prof}"
SRC_URI[aarch64_ghc-crypton-prof.sha256sum] = "8112e998b38a70afe03a6e7424ee66318b3a7aa4fb07c31a2111755cae84d8e8"

RDEPENDS:ghc-crypton = " \
 ghc-array \
 ghc-base \
 ghc-basement \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-memory \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-crypton-devel = " \
 ghc-base-devel \
 ghc-basement-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-crypton \
 ghc-deepseq-devel \
 ghc-memory-devel \
 "
RDEPENDS:ghc-crypton-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-crypton-prof = " \
 ghc-base-prof \
 ghc-basement-prof \
 ghc-bytestring-prof \
 ghc-crypton-devel \
 ghc-deepseq-prof \
 ghc-memory-prof \
 "
