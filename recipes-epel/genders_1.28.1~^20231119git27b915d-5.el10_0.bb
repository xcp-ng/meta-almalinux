# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "genders"
PV = "1.28.1~^20231119git27b915d"
PR = "5.el10_0"
PACKAGES = " \
 genders \
 genders-compat \
 genders-java \
 genders-java-devel \
 genders-javadoc \
 genders-perl \
 libgenders \
 libgenders-devel \
 libgendersplusplus \
 libgendersplusplus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/genders-1.28.1~^20231119git27b915d-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b14e5f3d4b7884e42bcb01d658f7635e6473a242219cab5426244f9915c6c961"

URI_x86_64_v2_genders = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-1.28.1~^20231119git27b915d-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genders;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders}"
SRC_URI[x86_64_v2_genders.sha256sum] = "0226a843a36fa88dc1a87e2ceb37a0ef66f079ad10c071f232139b5d5a12e315"

URI_x86_64_v2_genders-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-compat-1.28.1~^20231119git27b915d-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_genders-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders-compat}"
SRC_URI[x86_64_v2_genders-compat.sha256sum] = "3aca3b1071fcade2bffa3fd8c39688cc39e13598bc9fe3f58d560f9203df564e"

URI_x86_64_v2_genders-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-java-1.28.1~^20231119git27b915d-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genders-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders-java}"
SRC_URI[x86_64_v2_genders-java.sha256sum] = "ba0b677c71876816f43525bde5cdcad0938ff77c6e719a4cf69d0ee538bd7e92"

URI_x86_64_v2_genders-java-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-java-devel-1.28.1~^20231119git27b915d-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genders-java-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders-java-devel}"
SRC_URI[x86_64_v2_genders-java-devel.sha256sum] = "835fc601a15cf9c719b4989b627b0b332f75ee357c3bea6fbb14238314b092cb"

URI_x86_64_v2_genders-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-javadoc-1.28.1~^20231119git27b915d-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genders-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders-javadoc}"
SRC_URI[x86_64_v2_genders-javadoc.sha256sum] = "e229215e1e592d4eaf098f763ff1b6e10a692f8bf97661451342455cc9d3b787"

URI_x86_64_v2_genders-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-perl-1.28.1~^20231119git27b915d-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genders-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders-perl}"
SRC_URI[x86_64_v2_genders-perl.sha256sum] = "7d40b693528319a2fc2cfd60e6c6170ef5fa5d35b65b873b2cb7ce7e77255eab"

URI_x86_64_v2_libgenders = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgenders-1.28.1~^20231119git27b915d-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgenders;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgenders}"
SRC_URI[x86_64_v2_libgenders.sha256sum] = "777e7f681b33cb83f857623c68ad117c5f6ed4531740125407bf10f7e0760ca7"

URI_x86_64_v2_libgenders-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgenders-devel-1.28.1~^20231119git27b915d-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgenders-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgenders-devel}"
SRC_URI[x86_64_v2_libgenders-devel.sha256sum] = "1504a63283147f35120ba686a038ed386ed9a032e1848ac247622b8655c27053"

URI_x86_64_v2_libgendersplusplus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgendersplusplus-1.28.1~^20231119git27b915d-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgendersplusplus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgendersplusplus}"
SRC_URI[x86_64_v2_libgendersplusplus.sha256sum] = "c15b4c8de32e17593fa73b0e7b6662086ca980fd12b16553045de66a8d35a6ad"

URI_x86_64_v2_libgendersplusplus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgendersplusplus-devel-1.28.1~^20231119git27b915d-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgendersplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgendersplusplus-devel}"
SRC_URI[x86_64_v2_libgendersplusplus-devel.sha256sum] = "a8a548dddd859b16c3fe5f918136dca1cd488e59e849212a2ba281b14ef46145"

URI_aarch64_genders = "${EPEL_MIRROR}/aarch64/Packages/g/genders-1.28.1~^20231119git27b915d-5.el10_0.aarch64.rpm;name=aarch64_genders;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders}"
SRC_URI[aarch64_genders.sha256sum] = "a454cd244101a10e086c6774a4c4941c7209f64a01e9878d5ade6f33938cb2fb"

URI_aarch64_genders-compat = "${EPEL_MIRROR}/aarch64/Packages/g/genders-compat-1.28.1~^20231119git27b915d-5.el10_0.noarch.rpm;name=aarch64_genders-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders-compat}"
SRC_URI[aarch64_genders-compat.sha256sum] = "5c6cfddd0676f93f4db266f27fe4ab8607cc8cd90f95549edafe8250958a2a68"

URI_aarch64_genders-java = "${EPEL_MIRROR}/aarch64/Packages/g/genders-java-1.28.1~^20231119git27b915d-5.el10_0.aarch64.rpm;name=aarch64_genders-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders-java}"
SRC_URI[aarch64_genders-java.sha256sum] = "7df3ddbd62681103a11ab258b0e474eea280d4c775ba87fd5b61c955cd24da69"

URI_aarch64_genders-java-devel = "${EPEL_MIRROR}/aarch64/Packages/g/genders-java-devel-1.28.1~^20231119git27b915d-5.el10_0.aarch64.rpm;name=aarch64_genders-java-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders-java-devel}"
SRC_URI[aarch64_genders-java-devel.sha256sum] = "04a9652618e26e06b116ce94267942ca015ee70761e127bb1474d290d730024b"

URI_aarch64_genders-javadoc = "${EPEL_MIRROR}/aarch64/Packages/g/genders-javadoc-1.28.1~^20231119git27b915d-5.el10_0.aarch64.rpm;name=aarch64_genders-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders-javadoc}"
SRC_URI[aarch64_genders-javadoc.sha256sum] = "994207378d084ad5855c7531ac00484b6abcf144cd15dbdd7f10cc26136f1aee"

URI_aarch64_genders-perl = "${EPEL_MIRROR}/aarch64/Packages/g/genders-perl-1.28.1~^20231119git27b915d-5.el10_0.aarch64.rpm;name=aarch64_genders-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders-perl}"
SRC_URI[aarch64_genders-perl.sha256sum] = "efec71b23478714e13c0f7feab9309b3574892780447ec07e6bbed5cc21a3c3c"

URI_aarch64_libgenders = "${EPEL_MIRROR}/aarch64/Packages/l/libgenders-1.28.1~^20231119git27b915d-5.el10_0.aarch64.rpm;name=aarch64_libgenders;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgenders}"
SRC_URI[aarch64_libgenders.sha256sum] = "637e89b8345a32dd85b1776852dbdf811f5258fe29bc1dda25fedde7b4445852"

URI_aarch64_libgenders-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgenders-devel-1.28.1~^20231119git27b915d-5.el10_0.aarch64.rpm;name=aarch64_libgenders-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgenders-devel}"
SRC_URI[aarch64_libgenders-devel.sha256sum] = "421e06b4b014cece5067d403fb014735eba421c4e016b871a03a9a2eb2bd9d7d"

URI_aarch64_libgendersplusplus = "${EPEL_MIRROR}/aarch64/Packages/l/libgendersplusplus-1.28.1~^20231119git27b915d-5.el10_0.aarch64.rpm;name=aarch64_libgendersplusplus;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgendersplusplus}"
SRC_URI[aarch64_libgendersplusplus.sha256sum] = "0f294f6fc4397fdbcad2d5663fdcc0a640c7a95aae4b9759dc5078866fdd2c2c"

URI_aarch64_libgendersplusplus-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgendersplusplus-devel-1.28.1~^20231119git27b915d-5.el10_0.aarch64.rpm;name=aarch64_libgendersplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgendersplusplus-devel}"
SRC_URI[aarch64_libgendersplusplus-devel.sha256sum] = "d71a70abb664fe02f13b116ea5e43c18ff70a2c5fa04808f73f65277444d2080"

RDEPENDS:genders = " \
 glibc \
 libgenders \
 "
RDEPENDS:genders-compat = " \
 "
RDEPENDS:genders-java = " \
 glibc \
 libgenders \
 "
RDEPENDS:genders-java-devel = " \
 genders-java \
 "
RDEPENDS:genders-javadoc = " \
 "
RDEPENDS:genders-perl = " \
 genders-perl \
 glibc \
 libgenders \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:libgenders = " \
 glibc \
 "
RDEPENDS:libgenders-devel = " \
 libgenders \
 "
RDEPENDS:libgendersplusplus = " \
 glibc \
 libgcc \
 libgenders \
 libstdc++ \
 "
RDEPENDS:libgendersplusplus-devel = " \
 libgenders-devel \
 libgendersplusplus \
 "
