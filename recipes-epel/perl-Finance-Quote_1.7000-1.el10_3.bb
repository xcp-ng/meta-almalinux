# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Finance-Quote"
PV = "1.7000"
PR = "1.el10_3"
PACKAGES = " \
 perl-Finance-Quote \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Finance-Quote-1.7000-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "669686e256aee9757b24faf25bcc3e1b6f3e3b7401308e6203665e0b02c1db06"

URI_x86_64_v2_perl-Finance-Quote = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Finance-Quote-1.7000-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Finance-Quote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Finance-Quote}"
SRC_URI[x86_64_v2_perl-Finance-Quote.sha256sum] = "19711a52e86055701d72fbda787c55892dec530a4c58e03131f6332b842c73b0"

URI_aarch64_perl-Finance-Quote = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Finance-Quote-1.7000-1.el10_3.noarch.rpm;name=aarch64_perl-Finance-Quote;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Finance-Quote}"
SRC_URI[aarch64_perl-Finance-Quote.sha256sum] = "46528f90d9196443833bc7d12569935dd13a503a0cee6388989110870cdc9069"

RDEPENDS:perl-Finance-Quote = " \
 perl-Carp \
 perl-DateTime-Format-Strptime \
 perl-Encode \
 perl-Exporter \
 perl-Finance-Quote \
 perl-HTML-Parser \
 perl-HTML-TableExtract \
 perl-HTML-Tree \
 perl-HTML-TreeBuilder-XPath \
 perl-HTTP-CookieJar \
 perl-HTTP-Cookies \
 perl-HTTP-Message \
 perl-IO-Compress \
 perl-IO-String \
 perl-JSON \
 perl-LWP-Protocol-https \
 perl-Module-Load \
 perl-POSIX \
 perl-Readonly \
 perl-Scalar-List-Utils \
 perl-String-Util \
 perl-Text-Template \
 perl-Time-Piece \
 perl-TimeDate \
 perl-URI \
 perl-Web-Scraper \
 perl-XML-LibXML \
 perl-base \
 perl-constant \
 perl-if \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 "
