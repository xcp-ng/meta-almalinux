# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-rack"
PE = "1"
PV = "2.2.4"
PR = "7.el10_0"
PACKAGES = " \
 rubygem-rack \
 rubygem-rack-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-rack-2.2.4-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de871cea51e2ec33b402f6ea92b23a2838b3f36fe3925a10765fd14c21c64427"

URI_x86_64_v2_rubygem-rack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-rack-2.2.4-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-rack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rack}"
SRC_URI[x86_64_v2_rubygem-rack.sha256sum] = "774373a5180670f96d3a01d0062a8d6288ac8eada197b0ccfafad3ba753e59a2"

URI_x86_64_v2_rubygem-rack-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-rack-doc-2.2.4-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-rack-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rack-doc}"
SRC_URI[x86_64_v2_rubygem-rack-doc.sha256sum] = "28249b20851cacf62f4dfd2c44c4aecd8f6a3e758dcabddff741dc86ec11e143"

URI_aarch64_rubygem-rack = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-rack-2.2.4-7.el10_0.noarch.rpm;name=aarch64_rubygem-rack;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rack}"
SRC_URI[aarch64_rubygem-rack.sha256sum] = "c050284871f4ee91b1e6bc46bd11e9d665e9435023fcc14938a815591098f864"

URI_aarch64_rubygem-rack-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-rack-doc-2.2.4-7.el10_0.noarch.rpm;name=aarch64_rubygem-rack-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rack-doc}"
SRC_URI[aarch64_rubygem-rack-doc.sha256sum] = "ed6f30a38329ae0057a9bd98b3220aed21c219fa2af468c1172f7d3e0aeb6207"

RDEPENDS:rubygem-rack = " \
 ruby \
 rubygems \
 "
RDEPENDS:rubygem-rack-doc = " \
 rubygem-rack \
 "
