# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "trivy"
PV = "0.64.1"
PR = "2.el10_0"
PACKAGES = " \
 trivy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/trivy-0.64.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b968b5ccea2eca086abbfc14d1371321b3e4c5d7c7ef57b59ed217a8eda29127"

URI_x86_64_v2_trivy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trivy-0.64.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_trivy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_trivy}"
SRC_URI[x86_64_v2_trivy.sha256sum] = "fd85d6386ae6c6448b84a17fae8e1685714e2e73723b4a3f4b5337c5bd864459"

URI_aarch64_trivy = "${EPEL_MIRROR}/aarch64/Packages/t/trivy-0.64.1-2.el10_0.aarch64.rpm;name=aarch64_trivy;unpack=0"
SRC_URI:append = " ${URI_aarch64_trivy}"
SRC_URI[aarch64_trivy.sha256sum] = "0ace29b86dfe5e2ac598796b5949587e9c0a9f47a0f027a80528b16de798c13a"

RDEPENDS:trivy = " \
 glibc \
 sqlite-libs \
 "
