# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libyang"
PV = "2.1.148"
PR = "4.el10_2"
PACKAGES = " \
 libyang \
 libyang-devel \
 libyang-devel-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libyang-2.1.148-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "725b9251b1df4960c479befdab39d3ddfccc4ee30324ca15bab8857caae5fc4e"

URI_x86_64_v2_libyang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libyang-2.1.148-4.el10_2.x86_64_v2.rpm;name=x86_64_v2_libyang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libyang}"
SRC_URI[x86_64_v2_libyang.sha256sum] = "d2cc6334f49facc52a6ccbb3ea2c9292907efdcb222a73689f7b7095db5deac0"

URI_x86_64_v2_libyang-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libyang-devel-2.1.148-4.el10_2.x86_64_v2.rpm;name=x86_64_v2_libyang-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libyang-devel}"
SRC_URI[x86_64_v2_libyang-devel.sha256sum] = "918f1d76ccd495f70992911c2a44cf56136cd785a0180662d2793221658632e9"

URI_x86_64_v2_libyang-devel-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libyang-devel-doc-2.1.148-4.el10_2.x86_64_v2.rpm;name=x86_64_v2_libyang-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libyang-devel-doc}"
SRC_URI[x86_64_v2_libyang-devel-doc.sha256sum] = "5b3cdb19f40d694641b0680381f1a923daa678a3890e41a528df9133bba08559"

URI_aarch64_libyang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libyang-2.1.148-4.el10_2.aarch64.rpm;name=aarch64_libyang;unpack=0"
SRC_URI:append = " ${URI_aarch64_libyang}"
SRC_URI[aarch64_libyang.sha256sum] = "014a8f59b0efa44b37707fae662366cfd609f15851e5a078fe0c6429cc1046e3"

URI_aarch64_libyang-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libyang-devel-2.1.148-4.el10_2.aarch64.rpm;name=aarch64_libyang-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libyang-devel}"
SRC_URI[aarch64_libyang-devel.sha256sum] = "de437474855202bc29fcf4344078c688f0e7190309c8327de4067dddc7fa0a75"

URI_aarch64_libyang-devel-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libyang-devel-doc-2.1.148-4.el10_2.aarch64.rpm;name=aarch64_libyang-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libyang-devel-doc}"
SRC_URI[aarch64_libyang-devel-doc.sha256sum] = "4a39f7b66d01d3ff7cedd380280cb51e0ccca2a3ea3b47b57bb4d3abef072641"

RDEPENDS:libyang = " \
 glibc \
 pcre2 \
 "
RDEPENDS:libyang-devel = " \
 libyang \
 pcre2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libyang-devel-doc = " \
 libyang \
 "
