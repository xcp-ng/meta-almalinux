# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hyper-tls"
PV = "0.6.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-hyper-tls+alpn-devel \
 rust-hyper-tls+default-devel \
 rust-hyper-tls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hyper-tls-0.6.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "768ce97b47706fbae819d7cbbf6007259bb1765d52aef28eafb94a9e8729b772"

URI_x86_64_v2_rust-hyper-tls+alpn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-tls+alpn-devel-0.6.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-tls+alpn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-tls+alpn-devel}"
SRC_URI[x86_64_v2_rust-hyper-tls+alpn-devel.sha256sum] = "c9292dfa9c43569313254b16d139f4864fe3ae6221392fe76ec646054c796fae"

URI_x86_64_v2_rust-hyper-tls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-tls+default-devel-0.6.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-tls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-tls+default-devel}"
SRC_URI[x86_64_v2_rust-hyper-tls+default-devel.sha256sum] = "5d5f6ec4850ea9a9812c8c40a53039d8abe4e9caf14a21b290dcd355148a1ab6"

URI_x86_64_v2_rust-hyper-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-tls-devel-0.6.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-tls-devel}"
SRC_URI[x86_64_v2_rust-hyper-tls-devel.sha256sum] = "6b3770a7fd84b5a2b78c250ec0575541ad634e996a82b967ac1f5743a98dde20"

URI_aarch64_rust-hyper-tls+alpn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-tls+alpn-devel-0.6.0-2.el10_0.noarch.rpm;name=aarch64_rust-hyper-tls+alpn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-tls+alpn-devel}"
SRC_URI[aarch64_rust-hyper-tls+alpn-devel.sha256sum] = "4d8148a1182d96f656e75907e94c6fe54a8b6ca8c88c140d3b429f46187988bf"

URI_aarch64_rust-hyper-tls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-tls+default-devel-0.6.0-2.el10_0.noarch.rpm;name=aarch64_rust-hyper-tls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-tls+default-devel}"
SRC_URI[aarch64_rust-hyper-tls+default-devel.sha256sum] = "729660fc63525ac853fc77831ee9df0a95db7524a3444618f84668ae6bf5ecbc"

URI_aarch64_rust-hyper-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-tls-devel-0.6.0-2.el10_0.noarch.rpm;name=aarch64_rust-hyper-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-tls-devel}"
SRC_URI[aarch64_rust-hyper-tls-devel.sha256sum] = "a721e29a0c604f4301589ae70538d1586469da9354fb9e5c9860a8d1ff12ee8e"

RDEPENDS:rust-hyper-tls+alpn-devel = " \
 cargo \
 rust-hyper-tls-devel \
 rust-native-tls+alpn-devel \
 "
RDEPENDS:rust-hyper-tls+default-devel = " \
 cargo \
 rust-hyper-tls-devel \
 "
RDEPENDS:rust-hyper-tls-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-http-body-util+default-devel \
 rust-hyper+default-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+tokio-devel \
 rust-native-tls+default-devel \
 rust-tokio+default-devel \
 rust-tokio-native-tls+default-devel \
 rust-tower-service+default-devel \
 "
