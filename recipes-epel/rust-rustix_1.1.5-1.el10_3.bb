# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustix"
PV = "1.1.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-rustix+all-apis-devel \
 rust-rustix+alloc-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+io_uring-devel \
 rust-rustix+libc-devel \
 rust-rustix+libc_errno-devel \
 rust-rustix+linux_4_11-devel \
 rust-rustix+linux_5_1-devel \
 rust-rustix+linux_5_11-devel \
 rust-rustix+linux_latest-devel \
 rust-rustix+mm-devel \
 rust-rustix+mount-devel \
 rust-rustix+net-devel \
 rust-rustix+param-devel \
 rust-rustix+pipe-devel \
 rust-rustix+process-devel \
 rust-rustix+pty-devel \
 rust-rustix+rand-devel \
 rust-rustix+runtime-devel \
 rust-rustix+shm-devel \
 rust-rustix+std-devel \
 rust-rustix+stdio-devel \
 rust-rustix+system-devel \
 rust-rustix+termios-devel \
 rust-rustix+thread-devel \
 rust-rustix+time-devel \
 rust-rustix+try_close-devel \
 rust-rustix+use-explicitly-provided-auxv-devel \
 rust-rustix+use-libc-auxv-devel \
 rust-rustix+use-libc-devel \
 rust-rustix-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rustix-1.1.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "70229c2e87917050808dca04fe1cfcb5b287c33c4b81f468c39a6dbc45f36fef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+all-apis-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+all-apis-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+all-apis-devel.sha256sum] = "c0746f11e7844d7c5bf4fd6f34485ec5465d939d4d989ec92aab75479305618c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+alloc-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+alloc-devel.sha256sum] = "904a8ba9b83683f9a7c5e2de80dd9f629a51f796713266b50a32505cc541488a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+default-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+default-devel.sha256sum] = "433e5be851d30b44eeedf00920151f3a4113a93ba9fbf7a29a73b6cc63c24a08"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+event-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+event-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+event-devel.sha256sum] = "248e652e2d8d86152f06efda91f0165603315ddbaf6d628da1f285cc796b4d1c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+fs-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+fs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+fs-devel.sha256sum] = "31019ed93fbaff800f14b353cb72e0ba4a0a9f64d7dba20ac1343db18c41787c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+io_uring-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+io_uring-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+io_uring-devel.sha256sum] = "f11f6c586bd2b716c8bc1865143ba8d43a29626c4da35e744274c34faf75275e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+libc-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+libc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+libc-devel.sha256sum] = "77b1795c5db757d401e70b0eceaa9677041110cdc6b8746c52e14ae147aef3af"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+libc_errno-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+libc_errno-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+libc_errno-devel.sha256sum] = "c91a2e92d816aec5c141168d972ebb3b8e47ab9fbd1729f060d9e1a9a333a688"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_4_11-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_4_11-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+linux_4_11-devel.sha256sum] = "dba705067e74039eccb4ebbd8a1077bdadd3af55b8f3ba527f10cd8169171353"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_5_1-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_5_1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+linux_5_1-devel.sha256sum] = "48e84c1b3a98f58402d4b55911bbc037dce846b91aa91cca1fb80dc47ccb957c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_5_11-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_5_11-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+linux_5_11-devel.sha256sum] = "129f09abe7b6c80bd9beedf5c2f2894a26175a6170e49e5a5c83bdc60b774c3c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_latest-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_latest-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+linux_latest-devel.sha256sum] = "81afb84b6e0798b01a0a8b288c3dd11c95d99c02821882b6e9ec1c536ba36636"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+mm-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+mm-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+mm-devel.sha256sum] = "c68a83c0c5025e981459e4a468630503b37395a320c9678716f15c0976ee0224"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+mount-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+mount-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+mount-devel.sha256sum] = "05a7cb08afee56c358a47227ead8b5d5253046ce1d718b0d8db2f8f4917abbc5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+net-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+net-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+net-devel.sha256sum] = "d9f819ec1881d8145938cef2684265b8734cb77e79ef1187de7158386a767572"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+param-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+param-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+param-devel.sha256sum] = "931721ae4fd1082133e1f3f6b6c96f1ba0139b8d2ec48fc71f1801e8ffb232d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+pipe-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+pipe-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+pipe-devel.sha256sum] = "edc8f61c16cd17164a08218ca2b70345c63e9b99720996a1adcc189064ac482b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+process-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+process-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+process-devel.sha256sum] = "aa9dd23a724e9f185669d18ab86fb039ba2ef9713e6c3e0271127ecfecf127a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+pty-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+pty-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+pty-devel.sha256sum] = "6fe3aa840457504c746bf178cd54d40e4573e582f5eabd87c960f712cb91fef7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+rand-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+rand-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+rand-devel.sha256sum] = "4b0db892867d2d4708eea56afffeedc54d96837bb717cc357942a004e4df6889"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+runtime-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+runtime-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+runtime-devel.sha256sum] = "eed4b501edd02b4f7eb83eb1d99200d26b57e987297b45c599d8ee0a10e65879"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+shm-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+shm-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+shm-devel.sha256sum] = "a1fa37b9ab429110bb3cae94b8e326809f2e3651c825bd3893a96798e04eb70d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+std-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+std-devel.sha256sum] = "ffb13086cfe4634b43fa0514a619e7396135dd7de7f04f876dfe3891fdcea94e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+stdio-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+stdio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+stdio-devel.sha256sum] = "c5e6989616ae2a4806c4bc1f3975040678f02b591f2a9232e0b1ce8446eea0e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+system-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+system-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+system-devel.sha256sum] = "60bd72c497d5bd01111f1cc57cbacef7490e885844951adf570c56044bb4904f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+termios-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+termios-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+termios-devel.sha256sum] = "020e7b3a1dd2076e9c498cef6c268fa77b6c0518ddb09d0dbfc2a0bdfe48215f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+thread-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+thread-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+thread-devel.sha256sum] = "00b1cbaab832ba13575475a4ee0e802a7929eb8d4f6169b835e275f37682578c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+time-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+time-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+time-devel.sha256sum] = "907ecaf5486b729234fa9be0c29a0909771d06c548870722df9db146e90f9286"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+try_close-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+try_close-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+try_close-devel.sha256sum] = "0b1577c5f13b67f1112857b6b5f259463436a655aaafdd7c0cc177b21d09e80f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-explicitly-provided-auxv-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel.sha256sum] = "c4f335f252d3d3adfc385d16fd781a42ab92eeb8144d1c1f93ee1a148b847c00"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-libc-auxv-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-libc-auxv-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+use-libc-auxv-devel.sha256sum] = "cb4406e75680ae067c4a01597ede3b010978a464abe2c1c54900d33f84e8adfb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-libc-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-libc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+use-libc-devel.sha256sum] = "de9a4b8ff50e7dde4f4e569d77919e239cc8e47f55b8373a1ce12b4ca2b3afbb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix-devel.sha256sum] = "d87df13d4ab15ac20ce8e5feff15cc2340f09c9c7d445815c1163b427682bb3b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+all-apis-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+all-apis-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+all-apis-devel.sha256sum] = "e4df79059f1f5bdc04efda24610a4e7eb151c62e39cd1701d8c98b18ecf9a79b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+alloc-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+alloc-devel.sha256sum] = "eecbce16578c4801b39d15d89ec74272700fb254eed8b15162f0473ca68e762f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+default-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+default-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+default-devel.sha256sum] = "3407f808ff269daffba859896c02d9570d1a2a6e7c9905100decb1e0b903ea31"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+event-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+event-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+event-devel.sha256sum] = "b8296b8f512b5adfed9eabcf6b45494461786be4dac1594b980ed0a5c627035a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+fs-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+fs-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+fs-devel.sha256sum] = "f3f83e91ce1b11c1eee65c36068636c403e93723bb5e01a073c9a22ef76f3e1c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+io_uring-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+io_uring-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+io_uring-devel.sha256sum] = "c204cf0f9b6c8a64af4f3acbc3d55a82f8d9c3de806fe51f15b508f6bc624ee8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+libc-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+libc-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+libc-devel.sha256sum] = "091a2accbab342b782ad12b78f20f5fb5eaac3a649224fa687ba5ef8cf58d46d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+libc_errno-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+libc_errno-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+libc_errno-devel.sha256sum] = "42f87f54d7f7613ac0a1a481e3ae27d88a5c326f59eaef382dfbca1a2136c716"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_4_11-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+linux_4_11-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+linux_4_11-devel.sha256sum] = "e1a77f79c3393c64415eed3fe6f12004724012959fef7b10859e959840d6e450"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_5_1-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+linux_5_1-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+linux_5_1-devel.sha256sum] = "910c3e8ad3a5211ff3d4dfdba3fb2b4351a48a410500959d8836e40b27bbd63e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_5_11-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+linux_5_11-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+linux_5_11-devel.sha256sum] = "a89d32587d02eecea2273054e3aa21498258a163cb55395ced8e2cea50c8eae0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_latest-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+linux_latest-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+linux_latest-devel.sha256sum] = "c54d19aeaf0b6b5884c2ce962f5b9eb4edc020e00a5b39cbcb637aabbcad7bdf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+mm-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+mm-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+mm-devel.sha256sum] = "0a184018ef4f5e5a3e25df081638b691782373608b766ca5249701b53c53b3bd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+mount-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+mount-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+mount-devel.sha256sum] = "48075ad2dba30a916d162719aa3fcc1d124bc1152654bc5685bba8a8ddd6d734"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+net-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+net-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+net-devel.sha256sum] = "ccbae4a892c62c1576bac4245787227018cba1189c7daf8c6ea499e820651cd0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+param-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+param-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+param-devel.sha256sum] = "3e9a926dc40416590f3606edcd137f28e378e64156d9c587e2ada4407b6e6823"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+pipe-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+pipe-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+pipe-devel.sha256sum] = "43b15bffcba8d6c52c17d5f098147735d8fce2edba8ae87f5fa8ea4eefbe3e39"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+process-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+process-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+process-devel.sha256sum] = "9435516905e0ea94cc698f200238d8481a170f58357afed3b067f4bc3f91c302"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+pty-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+pty-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+pty-devel.sha256sum] = "a5b871c6375fe2fa9ab58fc6deaa6167873b98e8e7df98e858ce05b2873afa16"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+rand-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+rand-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+rand-devel.sha256sum] = "1d4e4c1a50b52f9e68bca8fdbc19d38209d9d2fd59ea5fb67aa9d40e408b44f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+runtime-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+runtime-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+runtime-devel.sha256sum] = "11f228690398d1df7193640e653e01095b3956252694cd9d9fd5a6f2a82f51c5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+shm-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+shm-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+shm-devel.sha256sum] = "e84953063479e4d10c76783cbebba480cbc1fbbcedbf1cc17435e2921c259427"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+std-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+std-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+std-devel.sha256sum] = "3a16cc0630d789a9d57855f9369283facd887367acf10ad6585f04dbabcdbf66"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+stdio-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+stdio-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+stdio-devel.sha256sum] = "b544da2c29bbffdf61974e79374338131ace5206544efc83de596450ee7cdc6a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+system-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+system-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+system-devel.sha256sum] = "5bd479402aa6d4f9b03a43e850fc64704a68ee557a587f34be8d3c367bf0fba5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+termios-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+termios-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+termios-devel.sha256sum] = "7269fbc36775279bd2f29dd7fd07372fe9c5449471b145fb91694768c0aca5e8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+thread-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+thread-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+thread-devel.sha256sum] = "78d818cc61230dc8d72ee5430dc8cb50b97a9648fe4f2bd7073d4bf2b681deaf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+time-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+time-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+time-devel.sha256sum] = "78189bdcb8fdeba65e70bd6dcc0ca044e1599c7284a3c3fd5261ee35521fb22d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+try_close-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+try_close-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+try_close-devel.sha256sum] = "99779f1e7d8e15fdee876f70139927a20694345fed8b218d00c74c425a053570"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-explicitly-provided-auxv-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+use-explicitly-provided-auxv-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+use-explicitly-provided-auxv-devel.sha256sum] = "d39abda5f6585981e33bd96b42a66641b918177dced18801646b1e4964d13e85"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-libc-auxv-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+use-libc-auxv-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+use-libc-auxv-devel.sha256sum] = "a0f5f8821768726331f67e94a3b6be9e26373be3fcd71d87bfed31d97a8c0d70"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-libc-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+use-libc-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+use-libc-devel.sha256sum] = "ee0fe96baa5e5f8c079b102ee1dcd5852e3418d55ed7018d20f241946491466a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustix-devel;unpack=0"
SRC_URI[aarch64_rust-rustix-devel.sha256sum] = "2dfcef0486436d24c3e2b80a06d7d3f240c595bf928cb6b928c31ebc1074f5a0"

RDEPENDS:rust-rustix+all-apis-devel = " \
 cargo \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+io_uring-devel \
 rust-rustix+mm-devel \
 rust-rustix+mount-devel \
 rust-rustix+net-devel \
 rust-rustix+param-devel \
 rust-rustix+pipe-devel \
 rust-rustix+process-devel \
 rust-rustix+pty-devel \
 rust-rustix+rand-devel \
 rust-rustix+runtime-devel \
 rust-rustix+shm-devel \
 rust-rustix+stdio-devel \
 rust-rustix+system-devel \
 rust-rustix+termios-devel \
 rust-rustix+thread-devel \
 rust-rustix+time-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+alloc-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+default-devel = " \
 cargo \
 rust-rustix+std-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+event-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+fs-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+io_uring-devel = " \
 cargo \
 rust-linux-raw-sys+io_uring-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+thread-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+libc-devel = " \
 cargo \
 rust-libc-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+libc_errno-devel = " \
 cargo \
 rust-errno-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_4_11-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_5_1-devel = " \
 cargo \
 rust-rustix+linux_4_11-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_5_11-devel = " \
 cargo \
 rust-rustix+linux_5_1-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_latest-devel = " \
 cargo \
 rust-rustix+linux_5_11-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+mm-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+mount-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+net-devel = " \
 cargo \
 rust-linux-raw-sys+if_ether-devel \
 rust-linux-raw-sys+net-devel \
 rust-linux-raw-sys+netlink-devel \
 rust-linux-raw-sys+xdp-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+param-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+pipe-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+process-devel = " \
 cargo \
 rust-linux-raw-sys+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+pty-devel = " \
 cargo \
 rust-rustix+fs-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+rand-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+runtime-devel = " \
 cargo \
 rust-linux-raw-sys+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+shm-devel = " \
 cargo \
 rust-rustix+fs-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+std-devel = " \
 cargo \
 rust-bitflags+std-devel \
 rust-errno+std-devel \
 rust-errno-devel \
 rust-libc+std-devel \
 rust-libc-devel \
 rust-rustix+alloc-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+stdio-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+system-devel = " \
 cargo \
 rust-linux-raw-sys+system-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+termios-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+thread-devel = " \
 cargo \
 rust-linux-raw-sys+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+time-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+try_close-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-explicitly-provided-auxv-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-libc-auxv-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-libc-devel = " \
 cargo \
 rust-rustix+libc-devel \
 rust-rustix+libc_errno-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix-devel = " \
 cargo \
 rust \
 rust-bitflags-devel \
 rust-errno-devel \
 rust-libc-devel \
 rust-linux-raw-sys+auxvec-devel \
 rust-linux-raw-sys+elf-devel \
 rust-linux-raw-sys+errno-devel \
 rust-linux-raw-sys+general-devel \
 rust-linux-raw-sys+ioctl-devel \
 rust-linux-raw-sys+no_std-devel \
 rust-linux-raw-sys-devel \
 "
