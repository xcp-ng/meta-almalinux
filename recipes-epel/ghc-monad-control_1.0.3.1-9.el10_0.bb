# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-monad-control"
PV = "1.0.3.1"
PR = "9.el10_0"
PACKAGES = " \
 ghc-monad-control \
 ghc-monad-control-devel \
 ghc-monad-control-doc \
 ghc-monad-control-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-monad-control-1.0.3.1-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ed1b91df8bc3525c9ccb55737a7e070abef78037744281df0f3acc2aa2ad8fd"

URI_x86_64_v2_ghc-monad-control = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-monad-control-1.0.3.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-monad-control;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-monad-control}"
SRC_URI[x86_64_v2_ghc-monad-control.sha256sum] = "7ec15c23f7d100041c0add4bd3483868beb2a606805f8b32bacc4d3685d40290"

URI_x86_64_v2_ghc-monad-control-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-monad-control-devel-1.0.3.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-monad-control-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-monad-control-devel}"
SRC_URI[x86_64_v2_ghc-monad-control-devel.sha256sum] = "79bf7f8eb5cef74b2ec12253912ae0a8317546143e0c92f03f4b2a6b8ab8b20b"

URI_x86_64_v2_ghc-monad-control-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-monad-control-doc-1.0.3.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-monad-control-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-monad-control-doc}"
SRC_URI[x86_64_v2_ghc-monad-control-doc.sha256sum] = "ca5a34567d8b2ef692ad4fb473235bc4cbadd013b3ec9c7e51ab401326467750"

URI_x86_64_v2_ghc-monad-control-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-monad-control-prof-1.0.3.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-monad-control-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-monad-control-prof}"
SRC_URI[x86_64_v2_ghc-monad-control-prof.sha256sum] = "c30f0eb531ebd290ac548c1f2d8d3214bc3ebed83bb91c1034bbd298a4e034f8"

URI_aarch64_ghc-monad-control = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-monad-control-1.0.3.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-monad-control;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-monad-control}"
SRC_URI[aarch64_ghc-monad-control.sha256sum] = "1cc913d7e9f7e7d8d28eb1a353a3d3b00c9ef95019912ceba7599e69071c1e22"

URI_aarch64_ghc-monad-control-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-monad-control-devel-1.0.3.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-monad-control-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-monad-control-devel}"
SRC_URI[aarch64_ghc-monad-control-devel.sha256sum] = "c29e75a040f07ab24fce1794565e426359161293c3d0e9f22e3de0d99de1b12c"

URI_aarch64_ghc-monad-control-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-monad-control-doc-1.0.3.1-9.el10_0.noarch.rpm;name=aarch64_ghc-monad-control-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-monad-control-doc}"
SRC_URI[aarch64_ghc-monad-control-doc.sha256sum] = "3e22b9b500145f217dac4d7e5fd01483736fcbe7a899eed180103d7ed7f79654"

URI_aarch64_ghc-monad-control-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-monad-control-prof-1.0.3.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-monad-control-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-monad-control-prof}"
SRC_URI[aarch64_ghc-monad-control-prof.sha256sum] = "91f35332567bca49a0de5a35fac50a8f88d92c2b4935ec8ee365d76499e5a205"

RDEPENDS:ghc-monad-control = " \
 ghc-array \
 ghc-base \
 ghc-base-orphans \
 ghc-ghc-bignum \
 ghc-stm \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 glibc \
 gmp \
 "
RDEPENDS:ghc-monad-control-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-monad-control \
 ghc-stm-devel \
 ghc-transformers-base-devel \
 ghc-transformers-compat-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-monad-control-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-monad-control-prof = " \
 ghc-base-prof \
 ghc-monad-control-devel \
 ghc-stm-prof \
 ghc-transformers-base-prof \
 ghc-transformers-compat-prof \
 ghc-transformers-prof \
 "
