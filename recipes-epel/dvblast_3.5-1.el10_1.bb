# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dvblast"
PV = "3.5"
PR = "1.el10_1"
PACKAGES = " \
 dvblast \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dvblast-3.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d611559368b3d3cc470e04a76ddf03d38b3711326e9d3562b5fe97b34c7c817"

URI_x86_64_v2_dvblast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dvblast-3.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dvblast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dvblast}"
SRC_URI[x86_64_v2_dvblast.sha256sum] = "c12d976f170692f5c0753d420d17f441c7662e6d9183f8302982d8cc4c81cd77"

URI_aarch64_dvblast = "${EPEL_MIRROR}/aarch64/Packages/d/dvblast-3.5-1.el10_1.aarch64.rpm;name=aarch64_dvblast;unpack=0"
SRC_URI:append = " ${URI_aarch64_dvblast}"
SRC_URI[aarch64_dvblast.sha256sum] = "e67bc3ae8470d6c5d9ba6fbfd91908ecd01b0c09591cbccca4b0f0483e129380"

RDEPENDS:dvblast = " \
 bash \
 glibc \
 libev \
 "
