# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ucx"
PV = "1.18.1"
PR = "1.el10"
PACKAGES = " \
 ucx \
 ucx-cma \
 ucx-devel \
 ucx-ib \
 ucx-rdmacm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ucx-1.18.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be4c5872b4115736262166dbae3c067b3336933a25faa0b73c2e061fe9005b3d"

URI_x86_64_v2_ucx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ucx-1.18.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_ucx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ucx}"
SRC_URI[x86_64_v2_ucx.sha256sum] = "80ad3bde5345d1c12cf9f1e08d07175419a5af3e9cd6a4e5cc01cf902610f80f"

URI_x86_64_v2_ucx-cma = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ucx-cma-1.18.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_ucx-cma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ucx-cma}"
SRC_URI[x86_64_v2_ucx-cma.sha256sum] = "467679fa828b2beffc956ccd000a78b63bfcf04b4ac21188f0cf5398bcb2a92f"

URI_x86_64_v2_ucx-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ucx-devel-1.18.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_ucx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ucx-devel}"
SRC_URI[x86_64_v2_ucx-devel.sha256sum] = "48fd81165491b4ae223b7a382b9d5bfdd950a39aa0a664fb582c28a0f44eee3e"

URI_x86_64_v2_ucx-ib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ucx-ib-1.18.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_ucx-ib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ucx-ib}"
SRC_URI[x86_64_v2_ucx-ib.sha256sum] = "b7221904de056328d693b04eb55e227d30f460a93f9f06c7f6585c75ae01d70b"

URI_x86_64_v2_ucx-rdmacm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ucx-rdmacm-1.18.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_ucx-rdmacm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ucx-rdmacm}"
SRC_URI[x86_64_v2_ucx-rdmacm.sha256sum] = "4822a3998654ebda4f652faab4ce355418aa8d337e75b6314e18aaee9e0fb481"

URI_aarch64_ucx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ucx-1.18.1-1.el10.aarch64.rpm;name=aarch64_ucx;unpack=0"
SRC_URI:append = " ${URI_aarch64_ucx}"
SRC_URI[aarch64_ucx.sha256sum] = "8fa5a0cda9c08eb18cd6de7499ffa2522225560d1371ac47aebdb5328bc6a46a"

URI_aarch64_ucx-cma = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ucx-cma-1.18.1-1.el10.aarch64.rpm;name=aarch64_ucx-cma;unpack=0"
SRC_URI:append = " ${URI_aarch64_ucx-cma}"
SRC_URI[aarch64_ucx-cma.sha256sum] = "360a4b0c589fd3ef5008a58c9c3d44fbe6cfe451d37c1eb6acd49155989ad1db"

URI_aarch64_ucx-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ucx-devel-1.18.1-1.el10.aarch64.rpm;name=aarch64_ucx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ucx-devel}"
SRC_URI[aarch64_ucx-devel.sha256sum] = "86fbbcb1935fe761253d8fa1f9a066385d0181f25010a20c7bbe046f839c98b7"

URI_aarch64_ucx-ib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ucx-ib-1.18.1-1.el10.aarch64.rpm;name=aarch64_ucx-ib;unpack=0"
SRC_URI:append = " ${URI_aarch64_ucx-ib}"
SRC_URI[aarch64_ucx-ib.sha256sum] = "14b44395b517d74772ff6870648255a6822effa3dffb95094096f2f1bca46e82"

URI_aarch64_ucx-rdmacm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ucx-rdmacm-1.18.1-1.el10.aarch64.rpm;name=aarch64_ucx-rdmacm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ucx-rdmacm}"
SRC_URI[aarch64_ucx-rdmacm.sha256sum] = "5dd708c0f58337d09d91552e4d577fa366c76a67875378a1dc714983a1b845a8"

RDEPENDS:ucx = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 "
RDEPENDS:ucx-cma = " \
 glibc \
 ucx \
 "
RDEPENDS:ucx-devel = " \
 pkgconf-pkg-config \
 rdma-core-devel \
 ucx \
 ucx-devel \
 "
RDEPENDS:ucx-ib = " \
 glibc \
 libibverbs \
 ucx \
 "
RDEPENDS:ucx-rdmacm = " \
 glibc \
 libibverbs \
 librdmacm \
 ucx \
 ucx-ib \
 "
