# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-catkin_pkg"
PV = "1.1.0"
PR = "1.el10_1"
PACKAGES = " \
 python-catkin_pkg-doc \
 python3-catkin_pkg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-catkin_pkg-1.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a922d8582362c4949180ca8c4b92e01cbda2a8990df38b004fcc91cc072f5313"

URI_x86_64_v2_python-catkin_pkg-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-catkin_pkg-doc-1.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-catkin_pkg-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-catkin_pkg-doc}"
SRC_URI[x86_64_v2_python-catkin_pkg-doc.sha256sum] = "ec6b03426705731c1f0d207532a3ca5a208f1e1258f174c8830a922f160d23e2"

URI_x86_64_v2_python3-catkin_pkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-catkin_pkg-1.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-catkin_pkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-catkin_pkg}"
SRC_URI[x86_64_v2_python3-catkin_pkg.sha256sum] = "0154f47052a389a0e101b36a14a1189e870a595cdc29f896b5efd6e1de9ebdda"

URI_aarch64_python-catkin_pkg-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-catkin_pkg-doc-1.1.0-1.el10_1.noarch.rpm;name=aarch64_python-catkin_pkg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-catkin_pkg-doc}"
SRC_URI[aarch64_python-catkin_pkg-doc.sha256sum] = "b46af1d5458e66c49b94bf4a1c9f69a0b53fa8c1afd8c63e6cca43008dd3a5fb"

URI_aarch64_python3-catkin_pkg = "${EPEL_MIRROR}/aarch64/Packages/p/python3-catkin_pkg-1.1.0-1.el10_1.noarch.rpm;name=aarch64_python3-catkin_pkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-catkin_pkg}"
SRC_URI[aarch64_python3-catkin_pkg.sha256sum] = "897d7ac43d3a61e16dc0bd328594467ca3e20163a1b2d15c53ef7e17ce746dcc"

RDEPENDS:python-catkin_pkg-doc = " \
 "
RDEPENDS:python3-catkin_pkg = " \
 python3 \
 python3-dateutil \
 python3-docutils \
 python3-packaging \
 python3-pyparsing \
 python3-setuptools \
 "
