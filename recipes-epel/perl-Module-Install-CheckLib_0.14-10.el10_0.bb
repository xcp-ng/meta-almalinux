# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Install-CheckLib"
PV = "0.14"
PR = "10.el10_0"
PACKAGES = " \
 perl-Module-Install-CheckLib \
 perl-Module-Install-CheckLib-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-Install-CheckLib-0.14-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f1001cb79b6e52bf87b6418d5d45a62b13c1612e05353f089fb6eb144be02ea"

URI_x86_64_v2_perl-Module-Install-CheckLib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Install-CheckLib-0.14-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Install-CheckLib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Install-CheckLib}"
SRC_URI[x86_64_v2_perl-Module-Install-CheckLib.sha256sum] = "fdf37da923095bfc9a430d61388c637e3e6814c8c63c262b772e12e109cbbb62"

URI_x86_64_v2_perl-Module-Install-CheckLib-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Install-CheckLib-tests-0.14-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Install-CheckLib-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Install-CheckLib-tests}"
SRC_URI[x86_64_v2_perl-Module-Install-CheckLib-tests.sha256sum] = "eec8fe0311ca72a46fc52e8a92d9a9bc4b488b6964532ffb7b748afc6d7a0e62"

URI_aarch64_perl-Module-Install-CheckLib = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Install-CheckLib-0.14-10.el10_0.noarch.rpm;name=aarch64_perl-Module-Install-CheckLib;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Install-CheckLib}"
SRC_URI[aarch64_perl-Module-Install-CheckLib.sha256sum] = "8bc63e82685ea85ea0cf12ff89db6f2e46f8cfc7bf60cc53c8b3264966a4c7da"

URI_aarch64_perl-Module-Install-CheckLib-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Install-CheckLib-tests-0.14-10.el10_0.noarch.rpm;name=aarch64_perl-Module-Install-CheckLib-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Install-CheckLib-tests}"
SRC_URI[aarch64_perl-Module-Install-CheckLib-tests.sha256sum] = "a0a00e6738399b8b84537a0a2843ca2b25e8f1f0c8a9250add5553d06c2e589a"

RDEPENDS:perl-Module-Install-CheckLib = " \
 perl-Devel-CheckLib \
 perl-Module-Install \
 perl-PathTools \
 perl-base \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Module-Install-CheckLib-tests = " \
 bash \
 perl-Capture-Tiny \
 perl-File-Path \
 perl-File-Temp \
 perl-Module-Install-CheckLib \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
