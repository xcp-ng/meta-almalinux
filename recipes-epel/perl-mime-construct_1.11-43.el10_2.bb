# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-mime-construct"
PV = "1.11"
PR = "43.el10_2"
PACKAGES = " \
 perl-mime-construct \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-mime-construct-1.11-43.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89f1e0c06e7466cc3a354faf877e873514f5083dad1b73b947025b537444cafe"

URI_x86_64_v2_perl-mime-construct = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-mime-construct-1.11-43.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-mime-construct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-mime-construct}"
SRC_URI[x86_64_v2_perl-mime-construct.sha256sum] = "a096e917cdac3e61605fc909dd65d6cf2c643e06d14d554be304275d31379263"

URI_aarch64_perl-mime-construct = "${EPEL_MIRROR}/aarch64/Packages/p/perl-mime-construct-1.11-43.el10_2.noarch.rpm;name=aarch64_perl-mime-construct;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-mime-construct}"
SRC_URI[aarch64_perl-mime-construct.sha256sum] = "ffa6318c47c74c557adb9eca05537baf66dd6e374dd7146cd9550d2d580d8f19"

RDEPENDS:perl-mime-construct = " \
 perl-Proc-WaitStat \
 perl-interpreter \
 perl-libs \
 "
