# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "arm-none-eabi-newlib"
PV = "4.5.0.20241231"
PR = "1.el10_1"
PACKAGES = " \
 arm-none-eabi-newlib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/arm-none-eabi-newlib-4.5.0.20241231-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46babd696ee3efa3c4a2614ceaee1a3e5e3aaa836761d054865b8a79c635fede"

URI_x86_64_v2_arm-none-eabi-newlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arm-none-eabi-newlib-4.5.0.20241231-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_arm-none-eabi-newlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_arm-none-eabi-newlib}"
SRC_URI[x86_64_v2_arm-none-eabi-newlib.sha256sum] = "489bee357194423bf6fa734b6f376f3930a541029f060a20de432a54652871b7"

URI_aarch64_arm-none-eabi-newlib = "${EPEL_MIRROR}/aarch64/Packages/a/arm-none-eabi-newlib-4.5.0.20241231-1.el10_1.noarch.rpm;name=aarch64_arm-none-eabi-newlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_arm-none-eabi-newlib}"
SRC_URI[aarch64_arm-none-eabi-newlib.sha256sum] = "1e25322e57d83fa505fd03a78026e28a862e89898eeea7c899137b94a5480465"

RDEPENDS:arm-none-eabi-newlib = " \
 "
