# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-schemars"
PV = "1.2.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-schemars+arrayvec07-devel \
 rust-schemars+bigdecimal04-devel \
 rust-schemars+bytes1-devel \
 rust-schemars+chrono04-devel \
 rust-schemars+default-devel \
 rust-schemars+derive-devel \
 rust-schemars+either1-devel \
 rust-schemars+indexmap2-devel \
 rust-schemars+jiff02-devel \
 rust-schemars+preserve_order-devel \
 rust-schemars+raw_value-devel \
 rust-schemars+rust_decimal1-devel \
 rust-schemars+schemars_derive-devel \
 rust-schemars+semver1-devel \
 rust-schemars+smallvec1-devel \
 rust-schemars+smol_str02-devel \
 rust-schemars+smol_str03-devel \
 rust-schemars+std-devel \
 rust-schemars+url2-devel \
 rust-schemars+uuid1-devel \
 rust-schemars-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-schemars-1.2.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9887328efa951be4912208612313190ac45231c2773e72b430cee7e982b9bf6f"

URI_x86_64_v2_rust-schemars+arrayvec07-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+arrayvec07-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+arrayvec07-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+arrayvec07-devel}"
SRC_URI[x86_64_v2_rust-schemars+arrayvec07-devel.sha256sum] = "d1b1f90fdda45213b85fe76338a09feffab0b5dfb6823d619d42c0a738885ed8"

URI_x86_64_v2_rust-schemars+bigdecimal04-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+bigdecimal04-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+bigdecimal04-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+bigdecimal04-devel}"
SRC_URI[x86_64_v2_rust-schemars+bigdecimal04-devel.sha256sum] = "714f74d0b04d50eb834b4055970a772ef6464d2d3b6d059a8ba0f1f7cb6e2ba8"

URI_x86_64_v2_rust-schemars+bytes1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+bytes1-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+bytes1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+bytes1-devel}"
SRC_URI[x86_64_v2_rust-schemars+bytes1-devel.sha256sum] = "d54bf744b3f1c76489ef8020edd31f84192bfb7b61d8e0a41c86a7c7c5d50d34"

URI_x86_64_v2_rust-schemars+chrono04-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+chrono04-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+chrono04-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+chrono04-devel}"
SRC_URI[x86_64_v2_rust-schemars+chrono04-devel.sha256sum] = "a2bdbe284b077accb5de76e06eae643a7cef430348d73be4dcc989befa9c2467"

URI_x86_64_v2_rust-schemars+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+default-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+default-devel}"
SRC_URI[x86_64_v2_rust-schemars+default-devel.sha256sum] = "d8539c09a9f0fe7c82d9f8dc09f748d586bb8817d9012adf8c67f51412d8dddd"

URI_x86_64_v2_rust-schemars+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+derive-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+derive-devel}"
SRC_URI[x86_64_v2_rust-schemars+derive-devel.sha256sum] = "11044d6d347cb10b39cfc66ecace421af5ecb1db1c32d3d00d17ec6ec50bbb34"

URI_x86_64_v2_rust-schemars+either1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+either1-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+either1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+either1-devel}"
SRC_URI[x86_64_v2_rust-schemars+either1-devel.sha256sum] = "279107234fe7036811102bc7eca468f979a3451ebb9ba8ff129aabf0ae15684e"

URI_x86_64_v2_rust-schemars+indexmap2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+indexmap2-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+indexmap2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+indexmap2-devel}"
SRC_URI[x86_64_v2_rust-schemars+indexmap2-devel.sha256sum] = "cff506b0a97c57ee958a219d39a1bd9c0c3e04cd0843b3a652a4158a01fd6025"

URI_x86_64_v2_rust-schemars+jiff02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+jiff02-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+jiff02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+jiff02-devel}"
SRC_URI[x86_64_v2_rust-schemars+jiff02-devel.sha256sum] = "936b4bfd389420efc025a23b2cd236e55367d0fae13cb52b78eca858fa884740"

URI_x86_64_v2_rust-schemars+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+preserve_order-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-schemars+preserve_order-devel.sha256sum] = "3a58e0e32035c9e5a9b858307c4e7d44fbe927472feb8c54e206258234efc5af"

URI_x86_64_v2_rust-schemars+raw_value-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+raw_value-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+raw_value-devel}"
SRC_URI[x86_64_v2_rust-schemars+raw_value-devel.sha256sum] = "d3efb8473454af0c8e22f630170bb5ac67a07a08b0ac622d6121992e435432a5"

URI_x86_64_v2_rust-schemars+rust_decimal1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+rust_decimal1-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+rust_decimal1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+rust_decimal1-devel}"
SRC_URI[x86_64_v2_rust-schemars+rust_decimal1-devel.sha256sum] = "478d060f80bc3a57358aba6b52691219c0dfbd80937f27d764089677133d2864"

URI_x86_64_v2_rust-schemars+schemars_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+schemars_derive-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+schemars_derive-devel}"
SRC_URI[x86_64_v2_rust-schemars+schemars_derive-devel.sha256sum] = "bfb33bdf6aba1f37023cae56d596206a9ff1127eb60cb5af6d2d9e90781f5d60"

URI_x86_64_v2_rust-schemars+semver1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+semver1-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+semver1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+semver1-devel}"
SRC_URI[x86_64_v2_rust-schemars+semver1-devel.sha256sum] = "53ce2eec938e218232ac6b78f8dc7ef09f21c9effc71335183dd605383a794ef"

URI_x86_64_v2_rust-schemars+smallvec1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+smallvec1-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+smallvec1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+smallvec1-devel}"
SRC_URI[x86_64_v2_rust-schemars+smallvec1-devel.sha256sum] = "75b99c3b692ce09e28e5eaf44161addf9401f963a48b14d28098df2fef6948e9"

URI_x86_64_v2_rust-schemars+smol_str02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+smol_str02-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+smol_str02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+smol_str02-devel}"
SRC_URI[x86_64_v2_rust-schemars+smol_str02-devel.sha256sum] = "46e1943769a54017eab5c1fe36755dd2f334d1f633761631e94e7002f6c3b79c"

URI_x86_64_v2_rust-schemars+smol_str03-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+smol_str03-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+smol_str03-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+smol_str03-devel}"
SRC_URI[x86_64_v2_rust-schemars+smol_str03-devel.sha256sum] = "7554b06cb7d7adbbac50e509a0d7658c1fff23690e06574d42e5b7334a2ea859"

URI_x86_64_v2_rust-schemars+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+std-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+std-devel}"
SRC_URI[x86_64_v2_rust-schemars+std-devel.sha256sum] = "5c41f6b49b57c7e344563ec4704ad55f0124779b4a0325365788773e7f426694"

URI_x86_64_v2_rust-schemars+url2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+url2-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+url2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+url2-devel}"
SRC_URI[x86_64_v2_rust-schemars+url2-devel.sha256sum] = "833ce8eeca33705d1cdcb76b4a103aaca999c85b0989b7fda5363789c56304ba"

URI_x86_64_v2_rust-schemars+uuid1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+uuid1-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+uuid1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+uuid1-devel}"
SRC_URI[x86_64_v2_rust-schemars+uuid1-devel.sha256sum] = "86d05ae4b18c1511e646514eca4140cbe5249be0c52210fbd6cc45edf237c9f1"

URI_x86_64_v2_rust-schemars-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars-devel-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars-devel}"
SRC_URI[x86_64_v2_rust-schemars-devel.sha256sum] = "dd1c55ea552ab477c32da12ce030d93c437a7d287b700b08e05773078de00412"

URI_aarch64_rust-schemars+arrayvec07-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+arrayvec07-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+arrayvec07-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+arrayvec07-devel}"
SRC_URI[aarch64_rust-schemars+arrayvec07-devel.sha256sum] = "528058a784db8c7c7e959703222f840e402d7b2005e484d73c42a5c6b88aed7c"

URI_aarch64_rust-schemars+bigdecimal04-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+bigdecimal04-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+bigdecimal04-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+bigdecimal04-devel}"
SRC_URI[aarch64_rust-schemars+bigdecimal04-devel.sha256sum] = "1fed428b56acfbbc84d525a298677b8c6f61897f393fab52856db36c2beafbdd"

URI_aarch64_rust-schemars+bytes1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+bytes1-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+bytes1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+bytes1-devel}"
SRC_URI[aarch64_rust-schemars+bytes1-devel.sha256sum] = "079e040de2fdf52c9d68392ced07877df1c504baa650926b01222ba0914d4eda"

URI_aarch64_rust-schemars+chrono04-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+chrono04-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+chrono04-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+chrono04-devel}"
SRC_URI[aarch64_rust-schemars+chrono04-devel.sha256sum] = "d8471dd65cedba1ba44c31fd6d2c7c3e3d2f8a4d0869ff4b5f4aa45245600809"

URI_aarch64_rust-schemars+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+default-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+default-devel}"
SRC_URI[aarch64_rust-schemars+default-devel.sha256sum] = "aba73bbb3b70939e844447d91f97bc54aa1a15bbc8ae2c4c8e425a1b50494754"

URI_aarch64_rust-schemars+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+derive-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+derive-devel}"
SRC_URI[aarch64_rust-schemars+derive-devel.sha256sum] = "38eee22732651d6b9dda88d5529768cd2609b917e6781d7d5dc729881bed0c1f"

URI_aarch64_rust-schemars+either1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+either1-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+either1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+either1-devel}"
SRC_URI[aarch64_rust-schemars+either1-devel.sha256sum] = "a1a9cd2abdf516ac3328963a17ff96f6ef5426e5fec5059de365046075390e56"

URI_aarch64_rust-schemars+indexmap2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+indexmap2-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+indexmap2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+indexmap2-devel}"
SRC_URI[aarch64_rust-schemars+indexmap2-devel.sha256sum] = "b79ecd23595c9d87fc964e6256e7e4f2855204472b8b758f761287cf00dad66e"

URI_aarch64_rust-schemars+jiff02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+jiff02-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+jiff02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+jiff02-devel}"
SRC_URI[aarch64_rust-schemars+jiff02-devel.sha256sum] = "6ad7bc428dd48fdd2112200eb63cb1ff92a4772829cd5063ca7a3511b17230d3"

URI_aarch64_rust-schemars+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+preserve_order-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+preserve_order-devel}"
SRC_URI[aarch64_rust-schemars+preserve_order-devel.sha256sum] = "e0ed4c3b5b21cf726b9b23557836e049e3281dab54943f9b27c44a61770a2a30"

URI_aarch64_rust-schemars+raw_value-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+raw_value-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+raw_value-devel}"
SRC_URI[aarch64_rust-schemars+raw_value-devel.sha256sum] = "b9261ab3b60cfd0eb65f00b9368f4848875a86d38d7ba5a0714395965d2156ba"

URI_aarch64_rust-schemars+rust_decimal1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+rust_decimal1-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+rust_decimal1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+rust_decimal1-devel}"
SRC_URI[aarch64_rust-schemars+rust_decimal1-devel.sha256sum] = "ea9ab852f890196feeb7fc3a6be1deca70eb572611ac35e7ad09e2dcac68976e"

URI_aarch64_rust-schemars+schemars_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+schemars_derive-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+schemars_derive-devel}"
SRC_URI[aarch64_rust-schemars+schemars_derive-devel.sha256sum] = "29a2bef212e0f913011fb8942f3bac7bdccbb32589f7f3a6ffe24a787e652885"

URI_aarch64_rust-schemars+semver1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+semver1-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+semver1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+semver1-devel}"
SRC_URI[aarch64_rust-schemars+semver1-devel.sha256sum] = "fdf7d4d1e5b9657ca7b08fb0ba788bc72fb56c4b64f371259bef7ddec779fe5a"

URI_aarch64_rust-schemars+smallvec1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+smallvec1-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+smallvec1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+smallvec1-devel}"
SRC_URI[aarch64_rust-schemars+smallvec1-devel.sha256sum] = "40c36d7869c8178349941f6e9fe481ff9952369b53c6569586e871e6fbabaa49"

URI_aarch64_rust-schemars+smol_str02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+smol_str02-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+smol_str02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+smol_str02-devel}"
SRC_URI[aarch64_rust-schemars+smol_str02-devel.sha256sum] = "3e4116d471e439618cbf3db76cd7c9f597bd25053987bd1d31e21971a050902d"

URI_aarch64_rust-schemars+smol_str03-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+smol_str03-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+smol_str03-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+smol_str03-devel}"
SRC_URI[aarch64_rust-schemars+smol_str03-devel.sha256sum] = "29e6dccfa199304e1c6149a3b36a068761f41bfe243c86cc18d09c24c0dc315b"

URI_aarch64_rust-schemars+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+std-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+std-devel}"
SRC_URI[aarch64_rust-schemars+std-devel.sha256sum] = "2b85a5f0a6ccfd5b880cc3921fb0f752849e4b7198d6e03e43afb8d7be76c325"

URI_aarch64_rust-schemars+url2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+url2-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+url2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+url2-devel}"
SRC_URI[aarch64_rust-schemars+url2-devel.sha256sum] = "c3c044a1c0e38aeb06fa42328284e7fd5154c320e7ce0e44023da9521c9dd550"

URI_aarch64_rust-schemars+uuid1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+uuid1-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars+uuid1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+uuid1-devel}"
SRC_URI[aarch64_rust-schemars+uuid1-devel.sha256sum] = "33f4bc305b25cf414cceb4071d8e4834c6c5ce95a6208a184b6f2ffeae48da6b"

URI_aarch64_rust-schemars-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars-devel-1.2.1-2.el10_2.noarch.rpm;name=aarch64_rust-schemars-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars-devel}"
SRC_URI[aarch64_rust-schemars-devel.sha256sum] = "1a57464c16aee35f2671a9d3f13e42aae3152da01ccb79d5bc725de3f1bd2991"

RDEPENDS:rust-schemars+arrayvec07-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+bigdecimal04-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+bytes1-devel = " \
 cargo \
 rust-bytes-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+chrono04-devel = " \
 cargo \
 rust-chrono-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+default-devel = " \
 cargo \
 rust-schemars+derive-devel \
 rust-schemars+std-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+derive-devel = " \
 cargo \
 rust-schemars+schemars_derive-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+either1-devel = " \
 cargo \
 rust-either-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+indexmap2-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+jiff02-devel = " \
 cargo \
 rust-jiff-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+preserve_order-devel = " \
 cargo \
 rust-schemars-devel \
 rust-serde_json+preserve_order-devel \
 "
RDEPENDS:rust-schemars+raw_value-devel = " \
 cargo \
 rust-schemars-devel \
 rust-serde_json+raw_value-devel \
 "
RDEPENDS:rust-schemars+rust_decimal1-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+schemars_derive-devel = " \
 cargo \
 rust-schemars-devel \
 rust-schemars_derive+default-devel \
 "
RDEPENDS:rust-schemars+semver1-devel = " \
 cargo \
 rust-schemars-devel \
 rust-semver-devel \
 "
RDEPENDS:rust-schemars+smallvec1-devel = " \
 cargo \
 rust-schemars-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-schemars+smol_str02-devel = " \
 cargo \
 rust-schemars-devel \
 rust-smol_str0.2-devel \
 "
RDEPENDS:rust-schemars+smol_str03-devel = " \
 cargo \
 rust-schemars-devel \
 rust-smol_str-devel \
 "
RDEPENDS:rust-schemars+std-devel = " \
 cargo \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+url2-devel = " \
 cargo \
 rust-schemars-devel \
 rust-url-devel \
 "
RDEPENDS:rust-schemars+uuid1-devel = " \
 cargo \
 rust-schemars-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-schemars-devel = " \
 cargo \
 rust \
 rust-dyn-clone+default-devel \
 rust-ref-cast+default-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-serde_json+alloc-devel \
 rust-serde_json-devel \
 "
