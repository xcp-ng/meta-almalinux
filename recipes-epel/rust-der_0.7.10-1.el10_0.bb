# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-der"
PV = "0.7.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-der+alloc-devel \
 rust-der+arbitrary-devel \
 rust-der+bytes-devel \
 rust-der+default-devel \
 rust-der+derive-devel \
 rust-der+flagset-devel \
 rust-der+oid-devel \
 rust-der+pem-devel \
 rust-der+real-devel \
 rust-der+std-devel \
 rust-der+time-devel \
 rust-der+zeroize-devel \
 rust-der-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-der-0.7.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e27c892a896b1faac7c88e3f154561909e6634a54783d8a52d6fde34c06c4dd6"

URI_x86_64_v2_rust-der+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+alloc-devel-0.7.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+alloc-devel}"
SRC_URI[x86_64_v2_rust-der+alloc-devel.sha256sum] = "47fb375b5381fda345dbea8b807148b8c06b1c8df352f5dceb783532b9e01d1f"

URI_x86_64_v2_rust-der+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+arbitrary-devel-0.7.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-der+arbitrary-devel.sha256sum] = "472d4efd21d0769dd6b54ba5668a6564f2823a0a2a7ae1c8b9d967e201318e13"

URI_x86_64_v2_rust-der+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+bytes-devel-0.7.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+bytes-devel}"
SRC_URI[x86_64_v2_rust-der+bytes-devel.sha256sum] = "c691f8fbc3db6aa81d96c3f1561b8f5448b6563a13e65be3b0bf388b4e02ca67"

URI_x86_64_v2_rust-der+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+default-devel-0.7.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+default-devel}"
SRC_URI[x86_64_v2_rust-der+default-devel.sha256sum] = "b2ac57008e953f84f5a37b09dc2529bc2d0d05dde1d7b2c516b539280c88b20d"

URI_x86_64_v2_rust-der+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+derive-devel-0.7.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+derive-devel}"
SRC_URI[x86_64_v2_rust-der+derive-devel.sha256sum] = "07dcc9e3f870ea69c09aaafed0906e4262782159c7a3a657f770e5a3294dd6f4"

URI_x86_64_v2_rust-der+flagset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+flagset-devel-0.7.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+flagset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+flagset-devel}"
SRC_URI[x86_64_v2_rust-der+flagset-devel.sha256sum] = "b4fd405a8be0d68c2a6ded5dc0a3b4e7bccca748986dd815b006ad1d91967581"

URI_x86_64_v2_rust-der+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+oid-devel-0.7.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+oid-devel}"
SRC_URI[x86_64_v2_rust-der+oid-devel.sha256sum] = "8fb803ae0cb56c24fdc9ead538ebb5bd399f8e7f329770e63028846a69269508"

URI_x86_64_v2_rust-der+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+pem-devel-0.7.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+pem-devel}"
SRC_URI[x86_64_v2_rust-der+pem-devel.sha256sum] = "478a285b9bbe9edd827b46cd44389423e24b9731bbc5c7379d3359c8a5494248"

URI_x86_64_v2_rust-der+real-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+real-devel-0.7.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+real-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+real-devel}"
SRC_URI[x86_64_v2_rust-der+real-devel.sha256sum] = "a18f029d0302e4b1f580e2bd9c5eaba4087b0faa007817beb9cd7cefdc1e4846"

URI_x86_64_v2_rust-der+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+std-devel-0.7.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+std-devel}"
SRC_URI[x86_64_v2_rust-der+std-devel.sha256sum] = "da011140ffb03df1adbe18f09312f41ce078a93f65082fb42deea481f443d404"

URI_x86_64_v2_rust-der+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+time-devel-0.7.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+time-devel}"
SRC_URI[x86_64_v2_rust-der+time-devel.sha256sum] = "0885bf2dfe519046ca9a449b71adf47862ced3ca49fe58e4dde801029af055fe"

URI_x86_64_v2_rust-der+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+zeroize-devel-0.7.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+zeroize-devel}"
SRC_URI[x86_64_v2_rust-der+zeroize-devel.sha256sum] = "960de5d2fa4fd9b1347d695b00826660602969f97a3c45883f9f802d7c678f70"

URI_x86_64_v2_rust-der-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-devel-0.7.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-devel}"
SRC_URI[x86_64_v2_rust-der-devel.sha256sum] = "28cb206bfe504db3bf00e2e3be18ba978a5101f9481ab7586dc60ef5b4b70392"

URI_aarch64_rust-der+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+alloc-devel-0.7.10-1.el10_0.noarch.rpm;name=aarch64_rust-der+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+alloc-devel}"
SRC_URI[aarch64_rust-der+alloc-devel.sha256sum] = "80eefe0f4bbc1cdd116e96c8bda0ff9519b0af67435779ba5c34fc905b25b07a"

URI_aarch64_rust-der+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+arbitrary-devel-0.7.10-1.el10_0.noarch.rpm;name=aarch64_rust-der+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+arbitrary-devel}"
SRC_URI[aarch64_rust-der+arbitrary-devel.sha256sum] = "8fdd161e996c4437b88b3c25dda7acf9ab8a189c2b993f2e7dc0509548a9684e"

URI_aarch64_rust-der+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+bytes-devel-0.7.10-1.el10_0.noarch.rpm;name=aarch64_rust-der+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+bytes-devel}"
SRC_URI[aarch64_rust-der+bytes-devel.sha256sum] = "c7f1ed1ce56e0bf32c4588bcea84723ceaf5ebb08e4375d7fcf49ae05fcef7e5"

URI_aarch64_rust-der+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+default-devel-0.7.10-1.el10_0.noarch.rpm;name=aarch64_rust-der+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+default-devel}"
SRC_URI[aarch64_rust-der+default-devel.sha256sum] = "ed81a7e08601cb4e1b02a93af94905468829f90c8b404bd6c6ffdf01ae13625f"

URI_aarch64_rust-der+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+derive-devel-0.7.10-1.el10_0.noarch.rpm;name=aarch64_rust-der+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+derive-devel}"
SRC_URI[aarch64_rust-der+derive-devel.sha256sum] = "7b7ae7ce6935bef3d006fe8a0ea2f3ac5f854df7d779783e00d43cabbc866236"

URI_aarch64_rust-der+flagset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+flagset-devel-0.7.10-1.el10_0.noarch.rpm;name=aarch64_rust-der+flagset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+flagset-devel}"
SRC_URI[aarch64_rust-der+flagset-devel.sha256sum] = "b9b1ba9fd92fc1fd653048de27705928d18d78b5ff480627022185da091cc719"

URI_aarch64_rust-der+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+oid-devel-0.7.10-1.el10_0.noarch.rpm;name=aarch64_rust-der+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+oid-devel}"
SRC_URI[aarch64_rust-der+oid-devel.sha256sum] = "42c9fb81dc69085536e5883b4b763e33c478b9633797025d55f611416bbecab6"

URI_aarch64_rust-der+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+pem-devel-0.7.10-1.el10_0.noarch.rpm;name=aarch64_rust-der+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+pem-devel}"
SRC_URI[aarch64_rust-der+pem-devel.sha256sum] = "9ba4c9fad933041b9e00f78d583893062b28c2ff4d60a5b071bb3bb901f9bf40"

URI_aarch64_rust-der+real-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+real-devel-0.7.10-1.el10_0.noarch.rpm;name=aarch64_rust-der+real-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+real-devel}"
SRC_URI[aarch64_rust-der+real-devel.sha256sum] = "17521c7512b222b42dba317cdfb7147df231e39de2f734f1104c71a91fc67aa2"

URI_aarch64_rust-der+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+std-devel-0.7.10-1.el10_0.noarch.rpm;name=aarch64_rust-der+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+std-devel}"
SRC_URI[aarch64_rust-der+std-devel.sha256sum] = "c50597bf0336a7260f4fbcf0cba23f6f180a490a3f9687368a8473a3512f2dec"

URI_aarch64_rust-der+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+time-devel-0.7.10-1.el10_0.noarch.rpm;name=aarch64_rust-der+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+time-devel}"
SRC_URI[aarch64_rust-der+time-devel.sha256sum] = "2e83497b55164823e90a1465f90f3015330462c85800b501d9f2618620022315"

URI_aarch64_rust-der+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+zeroize-devel-0.7.10-1.el10_0.noarch.rpm;name=aarch64_rust-der+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+zeroize-devel}"
SRC_URI[aarch64_rust-der+zeroize-devel.sha256sum] = "ff992df8a2beee467cb2b6aa90e5bb83dedf9066a2cb27fdb361199b94ca8d3a"

URI_aarch64_rust-der-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-devel-0.7.10-1.el10_0.noarch.rpm;name=aarch64_rust-der-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-devel}"
SRC_URI[aarch64_rust-der-devel.sha256sum] = "31b49801bc8f2192787707f9256467c22b0123f816cfa8e1be643f5439b18fa7"

RDEPENDS:rust-der+alloc-devel = " \
 cargo \
 rust-der-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-der+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-const-oid+arbitrary-devel \
 rust-const-oid+default-devel \
 rust-der+std-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+bytes-devel = " \
 cargo \
 rust-bytes-devel \
 rust-der+alloc-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+default-devel = " \
 cargo \
 rust-der-devel \
 "
RDEPENDS:rust-der+derive-devel = " \
 cargo \
 rust-der-devel \
 rust-der_derive+default-devel \
 "
RDEPENDS:rust-der+flagset-devel = " \
 cargo \
 rust-der-devel \
 rust-flagset+default-devel \
 "
RDEPENDS:rust-der+oid-devel = " \
 cargo \
 rust-const-oid+default-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+pem-devel = " \
 cargo \
 rust-der+alloc-devel \
 rust-der+zeroize-devel \
 rust-der-devel \
 rust-pem-rfc7468+alloc-devel \
 rust-pem-rfc7468+default-devel \
 "
RDEPENDS:rust-der+real-devel = " \
 cargo \
 rust-der-devel \
 "
RDEPENDS:rust-der+std-devel = " \
 cargo \
 rust-der+alloc-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+time-devel = " \
 cargo \
 rust-der-devel \
 rust-time-devel \
 "
RDEPENDS:rust-der+zeroize-devel = " \
 cargo \
 rust-der-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-der-devel = " \
 cargo \
 rust \
 "
