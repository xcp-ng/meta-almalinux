# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-os_str_bytes6"
PV = "6.6.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-os_str_bytes6+checked_conversions-devel \
 rust-os_str_bytes6+conversions-devel \
 rust-os_str_bytes6+default-devel \
 rust-os_str_bytes6+memchr-devel \
 rust-os_str_bytes6+raw_os_str-devel \
 rust-os_str_bytes6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-os_str_bytes6-6.6.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a12886c03c2174759198a8fe77c1822032475871970059d54227ded2f497691f"

URI_x86_64_v2_rust-os_str_bytes6+checked_conversions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes6+checked_conversions-devel-6.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes6+checked_conversions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes6+checked_conversions-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes6+checked_conversions-devel.sha256sum] = "13c27c8af045e4b2d98e6eb8a00dd79119c3fba618062abcfba04c0ffdcda51f"

URI_x86_64_v2_rust-os_str_bytes6+conversions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes6+conversions-devel-6.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes6+conversions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes6+conversions-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes6+conversions-devel.sha256sum] = "7eaa835fa1ccdbf6c15d3f8014d71f2d05cc68850f3b7d65bcf178c7ec172abe"

URI_x86_64_v2_rust-os_str_bytes6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes6+default-devel-6.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes6+default-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes6+default-devel.sha256sum] = "bb02ccacf5119965925fce4bb67f56c7b2b8cf513c7d7e3aeb3964965ef47e73"

URI_x86_64_v2_rust-os_str_bytes6+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes6+memchr-devel-6.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes6+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes6+memchr-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes6+memchr-devel.sha256sum] = "311664e6974f007968d85d466976b2b16aabb4fdf4967f74120a95a10d6bfd49"

URI_x86_64_v2_rust-os_str_bytes6+raw_os_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes6+raw_os_str-devel-6.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes6+raw_os_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes6+raw_os_str-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes6+raw_os_str-devel.sha256sum] = "cd8c164104ff98fb616ac580341b9b38d5fe6da88c07a5979a33dd783e2ec086"

URI_x86_64_v2_rust-os_str_bytes6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes6-devel-6.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes6-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes6-devel.sha256sum] = "2af511a98a48cf7276194aab47becdb226ca05af12adc8a910812ec039f2b510"

URI_aarch64_rust-os_str_bytes6+checked_conversions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes6+checked_conversions-devel-6.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-os_str_bytes6+checked_conversions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes6+checked_conversions-devel}"
SRC_URI[aarch64_rust-os_str_bytes6+checked_conversions-devel.sha256sum] = "018b07e735888d2aae83db157378814bd210a4cc587e052dbdb0327ca31c1cb4"

URI_aarch64_rust-os_str_bytes6+conversions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes6+conversions-devel-6.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-os_str_bytes6+conversions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes6+conversions-devel}"
SRC_URI[aarch64_rust-os_str_bytes6+conversions-devel.sha256sum] = "e7d631e4c3a4f99aa75249ad7d55968b9e5e1d1f5b5fa997dc6451c7eacb2613"

URI_aarch64_rust-os_str_bytes6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes6+default-devel-6.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-os_str_bytes6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes6+default-devel}"
SRC_URI[aarch64_rust-os_str_bytes6+default-devel.sha256sum] = "e9bbb1116166bbd7117fbdc165273958122183c73ee12f18d8b28feb680a422e"

URI_aarch64_rust-os_str_bytes6+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes6+memchr-devel-6.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-os_str_bytes6+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes6+memchr-devel}"
SRC_URI[aarch64_rust-os_str_bytes6+memchr-devel.sha256sum] = "d7007d5346d669d8493e8c7bae812ef2bf22d21d32728f46ed1cb85319cc6a8b"

URI_aarch64_rust-os_str_bytes6+raw_os_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes6+raw_os_str-devel-6.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-os_str_bytes6+raw_os_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes6+raw_os_str-devel}"
SRC_URI[aarch64_rust-os_str_bytes6+raw_os_str-devel.sha256sum] = "fb290ad456f8bbba46da5a7d0dc52664811c8f0255d35703336a5c166153d725"

URI_aarch64_rust-os_str_bytes6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes6-devel-6.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-os_str_bytes6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes6-devel}"
SRC_URI[aarch64_rust-os_str_bytes6-devel.sha256sum] = "55355cc4cb0ef47420fef8c48a87153105cc6761ba4742845d326169775ea321"

RDEPENDS:rust-os_str_bytes6+checked_conversions-devel = " \
 cargo \
 rust-os_str_bytes6+conversions-devel \
 rust-os_str_bytes6-devel \
 "
RDEPENDS:rust-os_str_bytes6+conversions-devel = " \
 cargo \
 rust-os_str_bytes6-devel \
 "
RDEPENDS:rust-os_str_bytes6+default-devel = " \
 cargo \
 rust-os_str_bytes6+memchr-devel \
 rust-os_str_bytes6+raw_os_str-devel \
 rust-os_str_bytes6-devel \
 "
RDEPENDS:rust-os_str_bytes6+memchr-devel = " \
 cargo \
 rust-memchr+default-devel \
 rust-os_str_bytes6-devel \
 "
RDEPENDS:rust-os_str_bytes6+raw_os_str-devel = " \
 cargo \
 rust-os_str_bytes6-devel \
 "
RDEPENDS:rust-os_str_bytes6-devel = " \
 cargo \
 rust \
 "
