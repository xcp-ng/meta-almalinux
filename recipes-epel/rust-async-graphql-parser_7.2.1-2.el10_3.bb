# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-graphql-parser"
PV = "7.2.1"
PR = "2.el10_3"
PACKAGES = " \
 rust-async-graphql-parser+default-devel \
 rust-async-graphql-parser-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-async-graphql-parser-7.2.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c979fd045cd01a9b6b97c16ef55fee5995337b42ce74a64777a74d9eaa2e5efd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-graphql-parser+default-devel-7.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-graphql-parser+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-async-graphql-parser+default-devel.sha256sum] = "09b29a661613f51f0ed1d6908a07367149b105c967fd7042aaf24cf41995601b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-graphql-parser-devel-7.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-graphql-parser-devel;unpack=0"
SRC_URI[x86_64_v2_rust-async-graphql-parser-devel.sha256sum] = "2f023b4b9c048f68cd391391db3164ee1b4f939611ffdf59831ad8e2949ad2e1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-async-graphql-parser+default-devel-7.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-async-graphql-parser+default-devel;unpack=0"
SRC_URI[aarch64_rust-async-graphql-parser+default-devel.sha256sum] = "ce6e61dcde19d7b9b77f83a2f9044f7914bbb5370f49d46a1da3c265c0e47164"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-async-graphql-parser-devel-7.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-async-graphql-parser-devel;unpack=0"
SRC_URI[aarch64_rust-async-graphql-parser-devel.sha256sum] = "84c3625d4c2b722b118d80add5aae35433346ea2021b9b967a545402f7be9db0"

RDEPENDS:rust-async-graphql-parser+default-devel = " \
 cargo \
 rust-async-graphql-parser-devel \
 "
RDEPENDS:rust-async-graphql-parser-devel = " \
 cargo \
 rust-async-graphql-value+default-devel \
 rust-pest+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
