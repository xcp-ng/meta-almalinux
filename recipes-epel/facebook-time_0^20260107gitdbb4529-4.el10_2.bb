# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "facebook-time"
PV = "0^20260107gitdbb4529"
PR = "4.el10_2"
PACKAGES = " \
 calnex \
 facebook-time-vendor-licenses \
 fbclock \
 ntpcheck \
 ntpresponder \
 pshark \
 ptp4u \
 ptpcheck \
 sptp \
 ziffy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/facebook-time-0^20260107gitdbb4529-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1e00fd8ae575bc093c67c356e8fbb81706c63510404e8586fa77e518d172455"

URI_x86_64_v2_calnex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calnex-0^20260107gitdbb4529-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calnex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calnex}"
SRC_URI[x86_64_v2_calnex.sha256sum] = "a4683370f590d1954f805e7328a9d7a734823af42dc4e08e64a6a93a359a9ceb"

URI_x86_64_v2_facebook-time-vendor-licenses = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/facebook-time-vendor-licenses-0^20260107gitdbb4529-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_facebook-time-vendor-licenses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_facebook-time-vendor-licenses}"
SRC_URI[x86_64_v2_facebook-time-vendor-licenses.sha256sum] = "b386a8cf8ecbbecd633839fedd28d487cd70ec2979ba63450470926b8ee25053"

URI_x86_64_v2_fbclock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fbclock-0^20260107gitdbb4529-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fbclock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fbclock}"
SRC_URI[x86_64_v2_fbclock.sha256sum] = "45bc843e70cf397bdfc5be2c08f83b8c248b0982ad98dd189f060b7a0546fb20"

URI_x86_64_v2_ntpcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntpcheck-0^20260107gitdbb4529-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntpcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntpcheck}"
SRC_URI[x86_64_v2_ntpcheck.sha256sum] = "4b2a0f67d975a223f1e64ce758d5f48bcc2d49b97ae7e00e852efca100eaf009"

URI_x86_64_v2_ntpresponder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntpresponder-0^20260107gitdbb4529-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntpresponder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntpresponder}"
SRC_URI[x86_64_v2_ntpresponder.sha256sum] = "50784a0be5a3a987474bd46c26b2f4ccff91ee5f7837d8f1d9f2e1b2b1abc6dd"

URI_x86_64_v2_pshark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pshark-0^20260107gitdbb4529-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pshark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pshark}"
SRC_URI[x86_64_v2_pshark.sha256sum] = "8d0de578ee54ac48b1896fac3231c83332d67c82e6c8be01bc450086843c1c3d"

URI_x86_64_v2_ptp4u = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptp4u-0^20260107gitdbb4529-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptp4u;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptp4u}"
SRC_URI[x86_64_v2_ptp4u.sha256sum] = "7a6fa9dc041adf1eab5af2f985f100cc422af839a6560fd3f9d77b05fb6387fc"

URI_x86_64_v2_ptpcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptpcheck-0^20260107gitdbb4529-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptpcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptpcheck}"
SRC_URI[x86_64_v2_ptpcheck.sha256sum] = "033fd27af404d915c799230d8dce68d15e97143e4da83ab3c46fea83630f8571"

URI_x86_64_v2_sptp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sptp-0^20260107gitdbb4529-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sptp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sptp}"
SRC_URI[x86_64_v2_sptp.sha256sum] = "073ee92c18391e167aa0b3c65c6d9b492dc3b361094c8be50260850868762718"

URI_x86_64_v2_ziffy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ziffy-0^20260107gitdbb4529-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ziffy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ziffy}"
SRC_URI[x86_64_v2_ziffy.sha256sum] = "4c9a2ebf5dab43a57043dc10cd8c41539a9468baf5bbd3924ceb1ab3aa37a2b6"

URI_aarch64_calnex = "${EPEL_MIRROR}/aarch64/Packages/c/calnex-0^20260107gitdbb4529-4.el10_2.aarch64.rpm;name=aarch64_calnex;unpack=0"
SRC_URI:append = " ${URI_aarch64_calnex}"
SRC_URI[aarch64_calnex.sha256sum] = "9dbc10000e97612873261d4d6c676b13570143c34fbe7a5f58f285c47f785eea"

URI_aarch64_facebook-time-vendor-licenses = "${EPEL_MIRROR}/aarch64/Packages/f/facebook-time-vendor-licenses-0^20260107gitdbb4529-4.el10_2.noarch.rpm;name=aarch64_facebook-time-vendor-licenses;unpack=0"
SRC_URI:append = " ${URI_aarch64_facebook-time-vendor-licenses}"
SRC_URI[aarch64_facebook-time-vendor-licenses.sha256sum] = "9fdd96c040cfb9127d8caf47d7b5f04ac380eacd641352abfb6a04165a5d01db"

URI_aarch64_fbclock = "${EPEL_MIRROR}/aarch64/Packages/f/fbclock-0^20260107gitdbb4529-4.el10_2.aarch64.rpm;name=aarch64_fbclock;unpack=0"
SRC_URI:append = " ${URI_aarch64_fbclock}"
SRC_URI[aarch64_fbclock.sha256sum] = "9c0166a6e70bce86a65373eeb0880a51328d504a42ea707819c57468e10d9a2b"

URI_aarch64_ntpcheck = "${EPEL_MIRROR}/aarch64/Packages/n/ntpcheck-0^20260107gitdbb4529-4.el10_2.aarch64.rpm;name=aarch64_ntpcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntpcheck}"
SRC_URI[aarch64_ntpcheck.sha256sum] = "38025619edf06218e705f6a9882f17c55db7e1c56cf73101d0bb7e3431a1221d"

URI_aarch64_ntpresponder = "${EPEL_MIRROR}/aarch64/Packages/n/ntpresponder-0^20260107gitdbb4529-4.el10_2.aarch64.rpm;name=aarch64_ntpresponder;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntpresponder}"
SRC_URI[aarch64_ntpresponder.sha256sum] = "990295f3bdcaf2edd54140fbb093c4783dea468127d72920b7f2584a5ce38cec"

URI_aarch64_pshark = "${EPEL_MIRROR}/aarch64/Packages/p/pshark-0^20260107gitdbb4529-4.el10_2.aarch64.rpm;name=aarch64_pshark;unpack=0"
SRC_URI:append = " ${URI_aarch64_pshark}"
SRC_URI[aarch64_pshark.sha256sum] = "b48eec86c3eda2425fb09d816ad1f7906a4704120f338c338bf27eaf71ee6006"

URI_aarch64_ptp4u = "${EPEL_MIRROR}/aarch64/Packages/p/ptp4u-0^20260107gitdbb4529-4.el10_2.aarch64.rpm;name=aarch64_ptp4u;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptp4u}"
SRC_URI[aarch64_ptp4u.sha256sum] = "0025f020677076254205681ab0c16b4f5f4040d5e537b95b78c1481d55060200"

URI_aarch64_ptpcheck = "${EPEL_MIRROR}/aarch64/Packages/p/ptpcheck-0^20260107gitdbb4529-4.el10_2.aarch64.rpm;name=aarch64_ptpcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptpcheck}"
SRC_URI[aarch64_ptpcheck.sha256sum] = "6194eff0919606080017c7f85e2422a25b4c1601df6592b3dbbfb7ff333d223f"

URI_aarch64_sptp = "${EPEL_MIRROR}/aarch64/Packages/s/sptp-0^20260107gitdbb4529-4.el10_2.aarch64.rpm;name=aarch64_sptp;unpack=0"
SRC_URI:append = " ${URI_aarch64_sptp}"
SRC_URI[aarch64_sptp.sha256sum] = "c184d466371cf403db598f229ff05353bad31ff84f7bc5a6d03b66732189a182"

URI_aarch64_ziffy = "${EPEL_MIRROR}/aarch64/Packages/z/ziffy-0^20260107gitdbb4529-4.el10_2.aarch64.rpm;name=aarch64_ziffy;unpack=0"
SRC_URI:append = " ${URI_aarch64_ziffy}"
SRC_URI[aarch64_ziffy.sha256sum] = "3b017a7b44dc003264710244837b50cbe67a21fdde49227d3186b2213ae28669"

RDEPENDS:calnex = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:facebook-time-vendor-licenses = " \
 "
RDEPENDS:fbclock = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ntpcheck = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ntpresponder = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:pshark = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ptp4u = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ptpcheck = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:sptp = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ziffy = " \
 facebook-time-vendor-licenses \
 glibc \
 libpcap \
 "
