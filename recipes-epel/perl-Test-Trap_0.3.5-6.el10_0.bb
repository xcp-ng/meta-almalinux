# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Trap"
PV = "0.3.5"
PR = "6.el10_0"
PACKAGES = " \
 perl-Test-Trap \
 perl-Test-Trap-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-Trap-0.3.5-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9fe14e6f35e85c6355244c9a315a7da625361884d14870b682d7f624ee566cc"

URI_x86_64_v2_perl-Test-Trap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Trap-0.3.5-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Trap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Trap}"
SRC_URI[x86_64_v2_perl-Test-Trap.sha256sum] = "fd1f22b7a81b9eb7cd2646cd35cec9e387c12f6bb49effcbf3d27c5678ac8e70"

URI_x86_64_v2_perl-Test-Trap-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Trap-tests-0.3.5-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Trap-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Trap-tests}"
SRC_URI[x86_64_v2_perl-Test-Trap-tests.sha256sum] = "b50945e9156c0bdb1f111af91731abdceaaa2683a172df8bdc3034294c28a55d"

URI_aarch64_perl-Test-Trap = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Trap-0.3.5-6.el10_0.noarch.rpm;name=aarch64_perl-Test-Trap;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Trap}"
SRC_URI[aarch64_perl-Test-Trap.sha256sum] = "57de120438c4c7d2e44d3aa94ae4c2048aebb0301ca9c07f1e6e53e48f8b76aa"

URI_aarch64_perl-Test-Trap-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Trap-tests-0.3.5-6.el10_0.noarch.rpm;name=aarch64_perl-Test-Trap-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Trap-tests}"
SRC_URI[aarch64_perl-Test-Trap-tests.sha256sum] = "99515e60a1aed9e5b27d46bb2a4dc39bba1401e3afc530de9cec492935f707d9"

RDEPENDS:perl-Test-Trap = " \
 perl-Carp \
 perl-Data-Dump \
 perl-Exporter \
 perl-File-Temp \
 perl-IO \
 perl-Test-Simple \
 perl-Test-Trap \
 perl-constant \
 perl-libs \
 perl-version \
 "
RDEPENDS:perl-Test-Trap-tests = " \
 bash \
 perl-Data-Dump \
 perl-File-Temp \
 perl-IO \
 perl-Test-Harness \
 perl-Test-Refcount \
 perl-Test-Simple \
 perl-Test-Trap \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
