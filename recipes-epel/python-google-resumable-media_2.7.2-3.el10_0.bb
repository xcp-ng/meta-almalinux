# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-google-resumable-media"
PV = "2.7.2"
PR = "3.el10_0"
PACKAGES = " \
 python3-google-resumable-media \
 python3-google-resumable-media+requests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-google-resumable-media-2.7.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69728795cfc23973aefadd31e99e9bee926885a2731c260ba750544cf2094a76"

URI_x86_64_v2_python3-google-resumable-media = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-resumable-media-2.7.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-resumable-media;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-resumable-media}"
SRC_URI[x86_64_v2_python3-google-resumable-media.sha256sum] = "f716fd8bdfc0c35d3b57baf6fb82c45dbe398e2dd8831a58c207db80dc2de128"

URI_x86_64_v2_python3-google-resumable-media+requests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-resumable-media+requests-2.7.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-resumable-media+requests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-resumable-media+requests}"
SRC_URI[x86_64_v2_python3-google-resumable-media+requests.sha256sum] = "86bbaa3211c737aa121d7d92fc50a1427eaaab83227d5a3fc5a26506af24fda8"

URI_aarch64_python3-google-resumable-media = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-resumable-media-2.7.2-3.el10_0.noarch.rpm;name=aarch64_python3-google-resumable-media;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-resumable-media}"
SRC_URI[aarch64_python3-google-resumable-media.sha256sum] = "834da5c30e164f7fb9ddefe09bb76bead6deced414ad05706aa7ff63f901e43d"

URI_aarch64_python3-google-resumable-media+requests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-resumable-media+requests-2.7.2-3.el10_0.noarch.rpm;name=aarch64_python3-google-resumable-media+requests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-resumable-media+requests}"
SRC_URI[aarch64_python3-google-resumable-media+requests.sha256sum] = "fa740d0742bfa38caf1d0c6fecbefc928f536df3aa887459a3562168fc54bcf0"

RDEPENDS:python3-google-resumable-media = " \
 python3 \
 python3-google-crc32c \
 "
RDEPENDS:python3-google-resumable-media+requests = " \
 python3 \
 python3-google-resumable-media \
 python3-requests \
 "
