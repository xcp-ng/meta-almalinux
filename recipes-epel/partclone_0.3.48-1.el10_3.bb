# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "partclone"
PV = "0.3.48"
PR = "1.el10_3"
PACKAGES = " \
 partclone \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/partclone-0.3.48-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0553a179a4ed83e05da36f54dca9be72cf433188ad4f50a130cb1f6b839d0d9"

URI_x86_64_v2_partclone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/partclone-0.3.48-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_partclone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_partclone}"
SRC_URI[x86_64_v2_partclone.sha256sum] = "884d888cca3eabaf05ee3f021246e7a8f20270fd5820d3d5ff6b130a88407cac"

URI_aarch64_partclone = "${EPEL_MIRROR}/aarch64/Packages/p/partclone-0.3.48-1.el10_3.aarch64.rpm;name=aarch64_partclone;unpack=0"
SRC_URI:append = " ${URI_aarch64_partclone}"
SRC_URI[aarch64_partclone.sha256sum] = "a8f31013d0e3475dd79873a686880c068806f968ae67b10dbba75d2ca4576abf"

RDEPENDS:partclone = " \
 e2fsprogs-libs \
 fuse3-libs \
 glibc \
 libblkid \
 libuuid \
 ncurses-libs \
 ntfs-3g-libs \
 openssl-libs \
 userspace-rcu \
 xxhash-libs \
 "
