# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ogr"
PV = "0.61.1"
PR = "1.el10_3"
PACKAGES = " \
 python3-ogr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ogr-0.61.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06cddf9f7036965ff5c79c2c1805001d318fde7228a2cbf85bb73427c15916e2"

URI_x86_64_v2_python3-ogr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ogr-0.61.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ogr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ogr}"
SRC_URI[x86_64_v2_python3-ogr.sha256sum] = "7964b12f4b4df2ae47c3e7dae12252c5353d92530df0deeee3899240ff9bef97"

URI_aarch64_python3-ogr = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ogr-0.61.1-1.el10_3.noarch.rpm;name=aarch64_python3-ogr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ogr}"
SRC_URI[aarch64_python3-ogr.sha256sum] = "a0b17e6b3162fd4eae3507a576b00ada62f005d780cda917a219ed494d421d36"

RDEPENDS:python3-ogr = " \
 python3 \
 python3-GitPython \
 python3-cryptography \
 python3-deprecated \
 python3-gitlab \
 python3-httpx \
 python3-pyforgejo \
 python3-pygithub \
 python3-pyyaml \
 python3-requests \
 python3-urllib3 \
 "
