# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdeplasma-addons"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kate-krunner-plugin \
 kdeplasma-addons \
 kdeplasma-addons-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdeplasma-addons-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d41a7eeefe8a0223c5fdeaa9ed016ee8661f217a3657d3a9f5cf4e2d3457cd8"

URI_x86_64_v2_kate-krunner-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-krunner-plugin-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate-krunner-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kate-krunner-plugin}"
SRC_URI[x86_64_v2_kate-krunner-plugin.sha256sum] = "7488a4df1f74a605ce49e743702a37a2975b84c3828e010bc3bedbb69641ecc4"

URI_x86_64_v2_kdeplasma-addons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeplasma-addons-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdeplasma-addons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdeplasma-addons}"
SRC_URI[x86_64_v2_kdeplasma-addons.sha256sum] = "f39b027735f4bb6edaec01e44acedcce418e509bb07a31aa7ca9df0f7336d3ec"

URI_x86_64_v2_kdeplasma-addons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeplasma-addons-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdeplasma-addons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdeplasma-addons-devel}"
SRC_URI[x86_64_v2_kdeplasma-addons-devel.sha256sum] = "a826a5f801c6cc78c4e61a053a8cd47246e094bfee473df5b3e929c24a6b3370"

URI_aarch64_kate-krunner-plugin = "${EPEL_MIRROR}/aarch64/Packages/k/kate-krunner-plugin-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kate-krunner-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kate-krunner-plugin}"
SRC_URI[aarch64_kate-krunner-plugin.sha256sum] = "da26df6cde5a537fb3b13c2247bb7d0beddbc99d87188de44e6ac1335647955f"

URI_aarch64_kdeplasma-addons = "${EPEL_MIRROR}/aarch64/Packages/k/kdeplasma-addons-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kdeplasma-addons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdeplasma-addons}"
SRC_URI[aarch64_kdeplasma-addons.sha256sum] = "b4f8f0afeb9db7dbd65672de40cbfbfbd2e1cd546eb2ffc0a2285f53586cbd3e"

URI_aarch64_kdeplasma-addons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdeplasma-addons-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kdeplasma-addons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdeplasma-addons-devel}"
SRC_URI[aarch64_kdeplasma-addons-devel.sha256sum] = "15f62ca79f3c1ff7a7506ef02d5014a82ac951ed473b77092c73bf4731e98cdd"

RDEPENDS:kate-krunner-plugin = " \
 glibc \
 kate \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-krunner \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kdeplasma-addons = " \
 glibc \
 hidapi \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kpackage \
 kf6-krunner \
 kf6-kservice \
 kf6-ksvg \
 kf6-kunitconversion \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libgcc \
 libicu \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 qt6-qtwebengine \
 "
RDEPENDS:kdeplasma-addons-devel = " \
 cmake-filesystem \
 kdeplasma-addons \
 kf6-kcoreaddons-devel \
 qt6-qtbase-devel \
 "
