# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "subversion"
PV = "1.14.3"
PR = "8.el10"
PACKAGES = " \
 mod_dav_svn \
 python3-subversion \
 subversion \
 subversion-devel \
 subversion-gnome \
 subversion-libs \
 subversion-perl \
 subversion-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/subversion-1.14.3-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7dbea22b423e7739370b8bff4f8a08fe6d729c7ae8693360939aa5d1c9a8fd1"

URI_x86_64_v2_mod_dav_svn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_dav_svn-1.14.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_mod_dav_svn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_dav_svn}"
SRC_URI[x86_64_v2_mod_dav_svn.sha256sum] = "f32ef891469163b01ab1a51af37fc2e7701099586967308c3d38bc41bb3e46de"

URI_x86_64_v2_python3-subversion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-subversion-1.14.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_python3-subversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-subversion}"
SRC_URI[x86_64_v2_python3-subversion.sha256sum] = "1b4afc7f198a4a833682010bb9b4bc6ec31c2799ab62fd67356f9548df931a37"

URI_x86_64_v2_subversion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/subversion-1.14.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_subversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subversion}"
SRC_URI[x86_64_v2_subversion.sha256sum] = "d62009331ab16730e3025a3e6b1966fc589d876cca41c1ae20b444f88ad012df"

URI_x86_64_v2_subversion-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/subversion-devel-1.14.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_subversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subversion-devel}"
SRC_URI[x86_64_v2_subversion-devel.sha256sum] = "28fc5535b58e002d20697018e57d921d9df446b43f6b3f9a922437913ac87b21"

URI_x86_64_v2_subversion-gnome = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/subversion-gnome-1.14.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_subversion-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subversion-gnome}"
SRC_URI[x86_64_v2_subversion-gnome.sha256sum] = "ffd2c72bfc16bf32c7520fd336b8cf6220f8f8daa79b11565d83988e803b369c"

URI_x86_64_v2_subversion-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/subversion-libs-1.14.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_subversion-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subversion-libs}"
SRC_URI[x86_64_v2_subversion-libs.sha256sum] = "203e0f418259a73fc7b02dbf33dd255d6bc434903e21a4067caaff41da00fb92"

URI_x86_64_v2_subversion-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/subversion-perl-1.14.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_subversion-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subversion-perl}"
SRC_URI[x86_64_v2_subversion-perl.sha256sum] = "93787a15375bbb99d93ee2dd33662e1cd0e5172274f205f395a54a1bc2d64cf1"

URI_x86_64_v2_subversion-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/subversion-tools-1.14.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_subversion-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subversion-tools}"
SRC_URI[x86_64_v2_subversion-tools.sha256sum] = "edefd91b6b0b7908bbf85c0f74f64e186465ce26b2c76cf4a30bab46c729fbe9"

URI_aarch64_mod_dav_svn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_dav_svn-1.14.3-8.el10.aarch64.rpm;name=aarch64_mod_dav_svn;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_dav_svn}"
SRC_URI[aarch64_mod_dav_svn.sha256sum] = "84c894935a8959f2365b3eaf6a716a2874abce3242062819136ef0deb466734b"

URI_aarch64_python3-subversion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-subversion-1.14.3-8.el10.aarch64.rpm;name=aarch64_python3-subversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-subversion}"
SRC_URI[aarch64_python3-subversion.sha256sum] = "9e5a37bdae7e7d30691eaf9b26feefb9a168b7b2481d68a2cb81c5da60c3d10e"

URI_aarch64_subversion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/subversion-1.14.3-8.el10.aarch64.rpm;name=aarch64_subversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_subversion}"
SRC_URI[aarch64_subversion.sha256sum] = "93196ad6f96cb51c7b880154ce4789af4c1ca4bf9cf89fa591f209fcda72aeab"

URI_aarch64_subversion-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/subversion-devel-1.14.3-8.el10.aarch64.rpm;name=aarch64_subversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_subversion-devel}"
SRC_URI[aarch64_subversion-devel.sha256sum] = "4e21cb20558d3dbadfbeb62bcb6a692076db297a2356a940feca0cd9bc5eb7c3"

URI_aarch64_subversion-gnome = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/subversion-gnome-1.14.3-8.el10.aarch64.rpm;name=aarch64_subversion-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_subversion-gnome}"
SRC_URI[aarch64_subversion-gnome.sha256sum] = "488bfa858a0234b2b902dded85abf69342b77fa87b6039b4091909bd6be46d2d"

URI_aarch64_subversion-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/subversion-libs-1.14.3-8.el10.aarch64.rpm;name=aarch64_subversion-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_subversion-libs}"
SRC_URI[aarch64_subversion-libs.sha256sum] = "b28cba560a2b4a7cf76d9b1d16060159fb8c780765f801bb96df0f96c57ebbe1"

URI_aarch64_subversion-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/subversion-perl-1.14.3-8.el10.aarch64.rpm;name=aarch64_subversion-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_subversion-perl}"
SRC_URI[aarch64_subversion-perl.sha256sum] = "a8492014d1d5bb81cd4700903932521903eb1187e9afcc2f928a4a1291a0b286"

URI_aarch64_subversion-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/subversion-tools-1.14.3-8.el10.aarch64.rpm;name=aarch64_subversion-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_subversion-tools}"
SRC_URI[aarch64_subversion-tools.sha256sum] = "08407dffd6744a2974eb410cc373816d10197507950bd75ec52b97a9119f5843"

RDEPENDS:mod_dav_svn = " \
 apr \
 apr-util \
 expat \
 file-libs \
 glibc \
 httpd-core \
 libxcrypt \
 lz4-libs \
 sqlite-libs \
 subversion-libs \
 utf8proc \
 zlib-ng-compat \
 "
RDEPENDS:python3-subversion = " \
 apr \
 apr-util \
 cyrus-sasl-lib \
 expat \
 file-libs \
 glibc \
 libserf \
 libxcrypt \
 lz4-libs \
 python3 \
 sqlite-libs \
 subversion-libs \
 utf8proc \
 zlib-ng-compat \
 "
RDEPENDS:subversion = " \
 apr \
 apr-util \
 bash \
 glibc \
 subversion-libs \
 systemd \
 "
RDEPENDS:subversion-devel = " \
 apr-devel \
 apr-util-devel \
 libsecret-devel \
 pkgconf-pkg-config \
 sqlite-devel \
 subversion-devel \
 subversion-libs \
 "
RDEPENDS:subversion-gnome = " \
 apr \
 apr-util \
 expat \
 file-libs \
 glib2 \
 glibc \
 libsecret \
 libxcrypt \
 lz4-libs \
 sqlite-libs \
 subversion-libs \
 utf8proc \
 zlib-ng-compat \
 "
RDEPENDS:subversion-libs = " \
 apr \
 apr-util \
 cyrus-sasl-lib \
 expat \
 file-libs \
 glibc \
 libserf \
 libxcrypt \
 lz4-libs \
 sqlite-libs \
 utf8proc \
 zlib-ng-compat \
 "
RDEPENDS:subversion-perl = " \
 apr \
 apr-util \
 expat \
 file-libs \
 glibc \
 libxcrypt \
 lz4-libs \
 perl-Carp \
 perl-DynaLoader \
 perl-File-Temp \
 perl-IO \
 perl-Scalar-List-Utils \
 perl-Symbol \
 perl-libs \
 perl-overload \
 sqlite-libs \
 subversion-libs \
 utf8proc \
 zlib-ng-compat \
 "
RDEPENDS:subversion-tools = " \
 apr \
 bash \
 glibc \
 subversion-libs \
 "
