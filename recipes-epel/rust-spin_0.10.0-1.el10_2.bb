# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-spin"
PV = "0.10.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-spin+barrier-devel \
 rust-spin+default-devel \
 rust-spin+fair_mutex-devel \
 rust-spin+lazy-devel \
 rust-spin+lock_api-devel \
 rust-spin+mutex-devel \
 rust-spin+once-devel \
 rust-spin+portable-atomic-devel \
 rust-spin+portable_atomic-devel \
 rust-spin+rwlock-devel \
 rust-spin+spin_mutex-devel \
 rust-spin+std-devel \
 rust-spin+ticket_mutex-devel \
 rust-spin+use_ticket_mutex-devel \
 rust-spin-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-spin-0.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "780cb5d3ad6140ec7be2e54d5924acf4ec5102f35a57e0f8848434e1b23a859f"

URI_x86_64_v2_rust-spin+barrier-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+barrier-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+barrier-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+barrier-devel}"
SRC_URI[x86_64_v2_rust-spin+barrier-devel.sha256sum] = "1a3e294a85278d67000f2c56f274a018805f528704ae201dcd5a7fa636cb7799"

URI_x86_64_v2_rust-spin+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+default-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+default-devel}"
SRC_URI[x86_64_v2_rust-spin+default-devel.sha256sum] = "ea35506f4375ef18a044e06130e5a710cdd8a8aa97dd21d404ce69944ebdec1b"

URI_x86_64_v2_rust-spin+fair_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+fair_mutex-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+fair_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+fair_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin+fair_mutex-devel.sha256sum] = "80307951f7e2798414d46e0d5dd90617a897e081a81bbee177873efa7a3046ac"

URI_x86_64_v2_rust-spin+lazy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+lazy-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+lazy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+lazy-devel}"
SRC_URI[x86_64_v2_rust-spin+lazy-devel.sha256sum] = "2c1923a01648559b2bda1ce90495989f0b81e93aeb0013aae826444823ceda56"

URI_x86_64_v2_rust-spin+lock_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+lock_api-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+lock_api-devel}"
SRC_URI[x86_64_v2_rust-spin+lock_api-devel.sha256sum] = "d1d6ea7c3f2ec87de7a12a92cf59a1412c795512d7c34f662ac5cef1364c096b"

URI_x86_64_v2_rust-spin+mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+mutex-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+mutex-devel}"
SRC_URI[x86_64_v2_rust-spin+mutex-devel.sha256sum] = "164e59d189bb040c62a55c7145ccd507a07eac6a412ae74d284e25d1baab8725"

URI_x86_64_v2_rust-spin+once-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+once-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+once-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+once-devel}"
SRC_URI[x86_64_v2_rust-spin+once-devel.sha256sum] = "d4d72bc19891243ea747c41ebd7aee87f1e578e26ebfb0134eb7d341cfbf1219"

URI_x86_64_v2_rust-spin+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+portable-atomic-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-spin+portable-atomic-devel.sha256sum] = "f12d57ad5d2f262914931707980cdabaff9047a9a75394ff68f99f1e560886a9"

URI_x86_64_v2_rust-spin+portable_atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+portable_atomic-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+portable_atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+portable_atomic-devel}"
SRC_URI[x86_64_v2_rust-spin+portable_atomic-devel.sha256sum] = "dcd9a4c0e7c0c5e0cdb90de8ea38071dd88d7d9d38748cdfbe19ee8c7967f14e"

URI_x86_64_v2_rust-spin+rwlock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+rwlock-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+rwlock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+rwlock-devel}"
SRC_URI[x86_64_v2_rust-spin+rwlock-devel.sha256sum] = "2786ad2b36a3e220974a132c611d4e3197603c0ac03eeeb06a3ed06b2313e5c7"

URI_x86_64_v2_rust-spin+spin_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+spin_mutex-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+spin_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+spin_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin+spin_mutex-devel.sha256sum] = "96c0146ebe2d6eeacec6e9e9c4038b3e6e2d3252ccba5ddcb131ca258d2df357"

URI_x86_64_v2_rust-spin+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+std-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+std-devel}"
SRC_URI[x86_64_v2_rust-spin+std-devel.sha256sum] = "ebc1bd18238d0aa9128e0bb6fd2c331ad964b40324d59d7fd0d84c9e040336cf"

URI_x86_64_v2_rust-spin+ticket_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+ticket_mutex-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+ticket_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin+ticket_mutex-devel.sha256sum] = "1fb691bad9e3e72b3bb6e399fe6abaaa9c62ebadc23e638b8fa770f1bda6157d"

URI_x86_64_v2_rust-spin+use_ticket_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+use_ticket_mutex-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+use_ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+use_ticket_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin+use_ticket_mutex-devel.sha256sum] = "9ad9f55ed76299f91aa6b339b6c2ebd9f9ace2280d5f226357472eb349f02496"

URI_x86_64_v2_rust-spin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin-devel}"
SRC_URI[x86_64_v2_rust-spin-devel.sha256sum] = "52babdfe908ec2c4289fc4d93e4240d615cbfa05a853df94484f5884d4b5a933"

URI_aarch64_rust-spin+barrier-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+barrier-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-spin+barrier-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+barrier-devel}"
SRC_URI[aarch64_rust-spin+barrier-devel.sha256sum] = "a1141efdbf062b3614a16ba48732d91800348402e5b5488eac5e1dd6b3ebac5d"

URI_aarch64_rust-spin+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+default-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-spin+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+default-devel}"
SRC_URI[aarch64_rust-spin+default-devel.sha256sum] = "937ac415a007bcfda00410470319058cb5d785a3b446427ddaed2d85e76201d8"

URI_aarch64_rust-spin+fair_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+fair_mutex-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-spin+fair_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+fair_mutex-devel}"
SRC_URI[aarch64_rust-spin+fair_mutex-devel.sha256sum] = "1a5e07697f6edb008bb4119e19008bb38ae6c8ad4bd9fa7079c452a91c2d4bc7"

URI_aarch64_rust-spin+lazy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+lazy-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-spin+lazy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+lazy-devel}"
SRC_URI[aarch64_rust-spin+lazy-devel.sha256sum] = "1e041c5be1ddf1e6f280e8a3c85bdf6e9bdee72a84702a88d387a604747212ca"

URI_aarch64_rust-spin+lock_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+lock_api-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-spin+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+lock_api-devel}"
SRC_URI[aarch64_rust-spin+lock_api-devel.sha256sum] = "366449c0f1b3349b006b37df2230e04b36b7db4aea2de9472411eb06bdb5f061"

URI_aarch64_rust-spin+mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+mutex-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-spin+mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+mutex-devel}"
SRC_URI[aarch64_rust-spin+mutex-devel.sha256sum] = "6164c5c1f0767804f96e58f54a8d9dc33fe27a71b43e114e2e9161166a74d3d0"

URI_aarch64_rust-spin+once-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+once-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-spin+once-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+once-devel}"
SRC_URI[aarch64_rust-spin+once-devel.sha256sum] = "3d395d1c29dea1c891d6c988dbb4e3467608f2489375843667ebe1903ce3279b"

URI_aarch64_rust-spin+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+portable-atomic-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-spin+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+portable-atomic-devel}"
SRC_URI[aarch64_rust-spin+portable-atomic-devel.sha256sum] = "e02ac1a24e95cd1e5f47f40e6b90553c5e6f046e0d4ac68c173ade87460d97ed"

URI_aarch64_rust-spin+portable_atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+portable_atomic-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-spin+portable_atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+portable_atomic-devel}"
SRC_URI[aarch64_rust-spin+portable_atomic-devel.sha256sum] = "a5f38dddd9d2cc6a553b9a14d53440a8551812ba996fac6d9c25f0c7f3821675"

URI_aarch64_rust-spin+rwlock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+rwlock-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-spin+rwlock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+rwlock-devel}"
SRC_URI[aarch64_rust-spin+rwlock-devel.sha256sum] = "55c01f19eec7269d4195cfa1537a6ad10faee67d0f51cfec9804339117ef3b87"

URI_aarch64_rust-spin+spin_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+spin_mutex-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-spin+spin_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+spin_mutex-devel}"
SRC_URI[aarch64_rust-spin+spin_mutex-devel.sha256sum] = "4f2e5532ee59f14e356186ccff221d6b0fb81b5dec50381ab359f112e1915339"

URI_aarch64_rust-spin+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+std-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-spin+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+std-devel}"
SRC_URI[aarch64_rust-spin+std-devel.sha256sum] = "aec4329ebf82b01d107c3cce42aca58680af07bd55a139fa0cf25c56a99cb9e3"

URI_aarch64_rust-spin+ticket_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+ticket_mutex-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-spin+ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+ticket_mutex-devel}"
SRC_URI[aarch64_rust-spin+ticket_mutex-devel.sha256sum] = "e2c660240914dd8f6ed38cd191ebca94ad60cc55208916475423c6f97ced1918"

URI_aarch64_rust-spin+use_ticket_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+use_ticket_mutex-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-spin+use_ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+use_ticket_mutex-devel}"
SRC_URI[aarch64_rust-spin+use_ticket_mutex-devel.sha256sum] = "6ad6e85f35a9287ec1ae9f6221a0b772d081ff7fcf76629b0eaa5edba899b8e9"

URI_aarch64_rust-spin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-spin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin-devel}"
SRC_URI[aarch64_rust-spin-devel.sha256sum] = "9ef8f062b9e0906f0698a86f44b079ddd8467ac78fce0851770963e685ba0de4"

RDEPENDS:rust-spin+barrier-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+default-devel = " \
 cargo \
 rust-spin+barrier-devel \
 rust-spin+lazy-devel \
 rust-spin+lock_api-devel \
 rust-spin+mutex-devel \
 rust-spin+once-devel \
 rust-spin+rwlock-devel \
 rust-spin+spin_mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+fair_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+lazy-devel = " \
 cargo \
 rust-spin+once-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+lock_api-devel = " \
 cargo \
 rust-lock_api+default-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+mutex-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+once-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+portable-atomic-devel = " \
 cargo \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+portable_atomic-devel = " \
 cargo \
 rust-spin+portable-atomic-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+rwlock-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+spin_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+std-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+ticket_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+use_ticket_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin+ticket_mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin-devel = " \
 cargo \
 rust \
 "
