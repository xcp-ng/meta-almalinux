# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ff0.13"
PV = "0.13.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-ff0.13+alloc-devel \
 rust-ff0.13+bits-devel \
 rust-ff0.13+bitvec-devel \
 rust-ff0.13+byteorder-devel \
 rust-ff0.13+default-devel \
 rust-ff0.13+std-devel \
 rust-ff0.13-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ff0.13-0.13.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b3f58e02295798d5b2b619e77bafb585d6a45c0b0fa996a41d2c6b7db20e2a0"

URI_x86_64_v2_rust-ff0.13+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff0.13+alloc-devel-0.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff0.13+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff0.13+alloc-devel}"
SRC_URI[x86_64_v2_rust-ff0.13+alloc-devel.sha256sum] = "5d8ece13d1ed73624eb331b5f94ff970cd54fefa5837271b0521cec70a57d503"

URI_x86_64_v2_rust-ff0.13+bits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff0.13+bits-devel-0.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff0.13+bits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff0.13+bits-devel}"
SRC_URI[x86_64_v2_rust-ff0.13+bits-devel.sha256sum] = "43120ab5b456dd34dd40baee3b107bc012440c67f9358b578e2794b3d9ddf813"

URI_x86_64_v2_rust-ff0.13+bitvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff0.13+bitvec-devel-0.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff0.13+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff0.13+bitvec-devel}"
SRC_URI[x86_64_v2_rust-ff0.13+bitvec-devel.sha256sum] = "70139b7be983f8fdbdfc44149a2fe2e86f6edeb750c4168e2cbbe18a5dba54eb"

URI_x86_64_v2_rust-ff0.13+byteorder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff0.13+byteorder-devel-0.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff0.13+byteorder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff0.13+byteorder-devel}"
SRC_URI[x86_64_v2_rust-ff0.13+byteorder-devel.sha256sum] = "697ddd076860c990e9efcca83c76e84b54f0f9ecd62d6e1482cd1ebfbb03cdd6"

URI_x86_64_v2_rust-ff0.13+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff0.13+default-devel-0.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff0.13+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff0.13+default-devel}"
SRC_URI[x86_64_v2_rust-ff0.13+default-devel.sha256sum] = "120b2388052c1add9a2fa28594160a196c9bd0cb0bd56c440f5b1b6ec51e715c"

URI_x86_64_v2_rust-ff0.13+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff0.13+std-devel-0.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff0.13+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff0.13+std-devel}"
SRC_URI[x86_64_v2_rust-ff0.13+std-devel.sha256sum] = "42b2b42e557afdb6414d3d49013e165ac9e8c51b5ddb967b03eea31e68306699"

URI_x86_64_v2_rust-ff0.13-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff0.13-devel-0.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff0.13-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff0.13-devel}"
SRC_URI[x86_64_v2_rust-ff0.13-devel.sha256sum] = "eb2215277de7ac21842dc86db04ca8b577e36f97369515031d1cd65a4b56507a"

URI_aarch64_rust-ff0.13+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff0.13+alloc-devel-0.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-ff0.13+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff0.13+alloc-devel}"
SRC_URI[aarch64_rust-ff0.13+alloc-devel.sha256sum] = "5158aec480c1bc4ed61309d01afb8cd3d3ab401d4866165143f8b3f578531b3b"

URI_aarch64_rust-ff0.13+bits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff0.13+bits-devel-0.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-ff0.13+bits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff0.13+bits-devel}"
SRC_URI[aarch64_rust-ff0.13+bits-devel.sha256sum] = "26bf4d9152d36c0420eb17f1b4e3add038396c8fd86fac44a5bbe959d15b7271"

URI_aarch64_rust-ff0.13+bitvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff0.13+bitvec-devel-0.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-ff0.13+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff0.13+bitvec-devel}"
SRC_URI[aarch64_rust-ff0.13+bitvec-devel.sha256sum] = "63c6d419b0610fb7c3452786d186146e5a678d65038313d9e4460650c9e025fc"

URI_aarch64_rust-ff0.13+byteorder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff0.13+byteorder-devel-0.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-ff0.13+byteorder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff0.13+byteorder-devel}"
SRC_URI[aarch64_rust-ff0.13+byteorder-devel.sha256sum] = "3397aaf2652a81a7bcf21a894149e6cc9ebbc8938e481886d7f20b82dc5c50d8"

URI_aarch64_rust-ff0.13+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff0.13+default-devel-0.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-ff0.13+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff0.13+default-devel}"
SRC_URI[aarch64_rust-ff0.13+default-devel.sha256sum] = "b511a9c7f1cd5bfb9d29cc50039598133fe9e31cc78fd9713b354989656535a5"

URI_aarch64_rust-ff0.13+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff0.13+std-devel-0.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-ff0.13+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff0.13+std-devel}"
SRC_URI[aarch64_rust-ff0.13+std-devel.sha256sum] = "8b9c4d0ad45a229733e4d52334a8d7cb707b19954f53780eeaa0ddc4fd3b64d5"

URI_aarch64_rust-ff0.13-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff0.13-devel-0.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-ff0.13-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff0.13-devel}"
SRC_URI[aarch64_rust-ff0.13-devel.sha256sum] = "81fcccbbd952e16f13dc39d971e513c09f3ac1ec026f5226ea6fa4aa1dcf2215"

RDEPENDS:rust-ff0.13+alloc-devel = " \
 cargo \
 rust-ff0.13-devel \
 "
RDEPENDS:rust-ff0.13+bits-devel = " \
 cargo \
 rust-ff0.13+bitvec-devel \
 rust-ff0.13-devel \
 "
RDEPENDS:rust-ff0.13+bitvec-devel = " \
 cargo \
 rust-bitvec-devel \
 rust-ff0.13-devel \
 "
RDEPENDS:rust-ff0.13+byteorder-devel = " \
 cargo \
 rust-byteorder-devel \
 rust-ff0.13-devel \
 "
RDEPENDS:rust-ff0.13+default-devel = " \
 cargo \
 rust-ff0.13+bits-devel \
 rust-ff0.13+std-devel \
 rust-ff0.13-devel \
 "
RDEPENDS:rust-ff0.13+std-devel = " \
 cargo \
 rust-ff0.13+alloc-devel \
 rust-ff0.13-devel \
 "
RDEPENDS:rust-ff0.13-devel = " \
 cargo \
 rust \
 rust-rand_core0.6-devel \
 rust-subtle+i128-devel \
 rust-subtle-devel \
 "
