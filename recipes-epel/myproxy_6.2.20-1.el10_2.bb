# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "myproxy"
PV = "6.2.20"
PR = "1.el10_2"
PACKAGES = " \
 myproxy \
 myproxy-admin \
 myproxy-devel \
 myproxy-doc \
 myproxy-libs \
 myproxy-server \
 myproxy-voms \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/myproxy-6.2.20-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "088358f825f882197531daa3c9e2e13f88a7d18c7d09a99d7f271749b3730559"

URI_x86_64_v2_myproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-6.2.20-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy}"
SRC_URI[x86_64_v2_myproxy.sha256sum] = "166747686e69712eadc45ec07b5ee6875de0408bd939dece16c7ecdaca01db23"

URI_x86_64_v2_myproxy-admin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-admin-6.2.20-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy-admin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-admin}"
SRC_URI[x86_64_v2_myproxy-admin.sha256sum] = "2e124dcdba06251e5377c6e6fb52adc17a7b245eaa03ea3ecab133728ea00cdb"

URI_x86_64_v2_myproxy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-devel-6.2.20-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-devel}"
SRC_URI[x86_64_v2_myproxy-devel.sha256sum] = "528f7d9ba4c07c2531df1dee648ae816500f11c3c194f5bb419cd05c345b78a7"

URI_x86_64_v2_myproxy-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-doc-6.2.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_myproxy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-doc}"
SRC_URI[x86_64_v2_myproxy-doc.sha256sum] = "ff94e7f3ab4196d3e39a7e99d171175fe0df5f49607fe8986c197744cb772353"

URI_x86_64_v2_myproxy-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-libs-6.2.20-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-libs}"
SRC_URI[x86_64_v2_myproxy-libs.sha256sum] = "e3c62be69b7ff6629fda3247ac23b773fd545fba425f05f699679de911303a6f"

URI_x86_64_v2_myproxy-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-server-6.2.20-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-server}"
SRC_URI[x86_64_v2_myproxy-server.sha256sum] = "a2d86d166719adb10ed97d22ed1e47f7cce8aec18aea8ddd2396c2092f403711"

URI_x86_64_v2_myproxy-voms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-voms-6.2.20-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy-voms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-voms}"
SRC_URI[x86_64_v2_myproxy-voms.sha256sum] = "a901be768b2fa31c3612b4b2a71f20965c24376c3cf14365763e39fb589f2efb"

URI_aarch64_myproxy = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-6.2.20-1.el10_2.aarch64.rpm;name=aarch64_myproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy}"
SRC_URI[aarch64_myproxy.sha256sum] = "bfe7d838565b674fbf015499f59f7d7ac3c3d09e0d6b1d20d98cb181fb81e4d9"

URI_aarch64_myproxy-admin = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-admin-6.2.20-1.el10_2.aarch64.rpm;name=aarch64_myproxy-admin;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-admin}"
SRC_URI[aarch64_myproxy-admin.sha256sum] = "655182cab233f00ebff63dfd250c1ddace9e361f765de9c98c73b0d8e4ea69b0"

URI_aarch64_myproxy-devel = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-devel-6.2.20-1.el10_2.aarch64.rpm;name=aarch64_myproxy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-devel}"
SRC_URI[aarch64_myproxy-devel.sha256sum] = "dfa928eaddfcf3091b8c44e9a7340787312e9da551aa99e26155a5bd4bf66c64"

URI_aarch64_myproxy-doc = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-doc-6.2.20-1.el10_2.noarch.rpm;name=aarch64_myproxy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-doc}"
SRC_URI[aarch64_myproxy-doc.sha256sum] = "18e0e50126e84f0f764527c729f654e1465c6dc5b99320c0697e70b0f5de7713"

URI_aarch64_myproxy-libs = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-libs-6.2.20-1.el10_2.aarch64.rpm;name=aarch64_myproxy-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-libs}"
SRC_URI[aarch64_myproxy-libs.sha256sum] = "2c5d5023c4c8f7c3f67738888c416b046b0f21fe85ba46c045287f2a2be42f47"

URI_aarch64_myproxy-server = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-server-6.2.20-1.el10_2.aarch64.rpm;name=aarch64_myproxy-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-server}"
SRC_URI[aarch64_myproxy-server.sha256sum] = "9dc92522e4186152994ec0e208ee05892b5df2d2198fc0c1477df4d4b7c9cf55"

URI_aarch64_myproxy-voms = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-voms-6.2.20-1.el10_2.aarch64.rpm;name=aarch64_myproxy-voms;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-voms}"
SRC_URI[aarch64_myproxy-voms.sha256sum] = "2a8587f8e5f46cf3c3ce2dde7e80ef1b5f587e54d7148b488f7e48c1d78d66c0"

RDEPENDS:myproxy = " \
 glibc \
 globus-common \
 globus-gsi-cert-utils \
 globus-gsi-sysconfig \
 myproxy-libs \
 openssl-libs \
 "
RDEPENDS:myproxy-admin = " \
 glibc \
 globus-gsi-cert-utils-progs \
 myproxy \
 myproxy-libs \
 myproxy-server \
 perl-Data-Dumper \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Temp \
 perl-File-stat \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-Pod-Usage \
 perl-Socket \
 perl-Time-Local \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:myproxy-devel = " \
 globus-common-devel \
 globus-gsi-callback-devel \
 globus-gsi-cert-utils-devel \
 globus-gsi-credential-devel \
 globus-gsi-proxy-core-devel \
 globus-gsi-sysconfig-devel \
 globus-gss-assist-devel \
 globus-gssapi-gsi-devel \
 myproxy-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:myproxy-doc = " \
 "
RDEPENDS:myproxy-libs = " \
 cyrus-sasl-lib \
 glibc \
 globus-common \
 globus-gsi-callback \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gsi-proxy-core \
 globus-gsi-sysconfig \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-proxy-utils \
 openldap \
 openssl-libs \
 pam-libs \
 "
RDEPENDS:myproxy-server = " \
 bash \
 glibc \
 myproxy-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:myproxy-voms = " \
 glibc \
 globus-gssapi-gsi \
 myproxy-libs \
 openssl-libs \
 virtual/voms-clients \
 voms \
 "
