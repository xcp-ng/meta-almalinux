# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "egl-x11"
PV = "1.0.5"
PR = "1.el10_1"
PACKAGES = " \
 egl-x11 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/egl-x11-1.0.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "854627d8ef99c966cbf3cf3f464727afe28be67a2ea7a291753f2dcafb41d052"

URI_x86_64_v2_egl-x11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-x11-1.0.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_egl-x11}"
SRC_URI[x86_64_v2_egl-x11.sha256sum] = "f22d8faf061e193598b99c4de5234cfee7aa12e6aba9a3d61c5b85d8323d6123"

URI_aarch64_egl-x11 = "${EPEL_MIRROR}/aarch64/Packages/e/egl-x11-1.0.5-1.el10_1.aarch64.rpm;name=aarch64_egl-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_egl-x11}"
SRC_URI[aarch64_egl-x11.sha256sum] = "8a997544ac9cbbad08236fff46e641bb2a36fd0c8887294749c9b73088c1d186"

RDEPENDS:egl-x11 = " \
 glibc \
 libX11 \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libxcb \
 mesa-libgbm \
 "
