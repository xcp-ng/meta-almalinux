# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-tungstenite"
PV = "0.28.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tokio-tungstenite+__rustls-tls-devel \
 rust-tokio-tungstenite+connect-devel \
 rust-tokio-tungstenite+default-devel \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+native-tls-crate-devel \
 rust-tokio-tungstenite+native-tls-devel \
 rust-tokio-tungstenite+rustls-devel \
 rust-tokio-tungstenite+rustls-native-certs-devel \
 rust-tokio-tungstenite+rustls-pki-types-devel \
 rust-tokio-tungstenite+rustls-tls-native-roots-devel \
 rust-tokio-tungstenite+rustls-tls-webpki-roots-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite+tokio-native-tls-devel \
 rust-tokio-tungstenite+tokio-rustls-devel \
 rust-tokio-tungstenite+url-devel \
 rust-tokio-tungstenite+webpki-roots-devel \
 rust-tokio-tungstenite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-tungstenite-0.28.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bd8ce2cd816d3ba63fe4c51356c9f65f7f0d135c5d5a7e30a8ed2b2de471543"

URI_x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+__rustls-tls-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel.sha256sum] = "79b352915b52e0bb81b6026064033eb56cf30db6771414af310dc179340a23eb"

URI_x86_64_v2_rust-tokio-tungstenite+connect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+connect-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+connect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+connect-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+connect-devel.sha256sum] = "9d102de70f172267f34688df0a9e9f74350301cebfede26e15390bce7c04c4f7"

URI_x86_64_v2_rust-tokio-tungstenite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+default-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+default-devel.sha256sum] = "0e038ba825f2dd2c5e8754cb137958058176847113c84433ac7d02542add0e09"

URI_x86_64_v2_rust-tokio-tungstenite+handshake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+handshake-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+handshake-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+handshake-devel.sha256sum] = "b99a33a390388a2dea727756828845f61351216a0246357670f26ed21b2cf03e"

URI_x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+native-tls-crate-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel.sha256sum] = "12c0937d159720d65e3d396c7e4dd7c1b709eea3c6584dd66bbc22c9ecee0daa"

URI_x86_64_v2_rust-tokio-tungstenite+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+native-tls-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+native-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+native-tls-devel.sha256sum] = "2410eca3b46318624bcba10e3a95f0fa7b8b4c7964308b03ca7dd103ccb1eab8"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-devel.sha256sum] = "306c479b4bbad37d4c56a01fba2bea174826de1ea8ac94b0781e8a28076f5636"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-native-certs-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel.sha256sum] = "fb783a96def1b390f3b761ec72da69615308e01df4de3bf5bf67a32530a11cc1"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-pki-types-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel.sha256sum] = "8f310bd2380cab31e4fc85ab360dd9062650fbd43b4bc3087e3e966dc5162d32"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-tls-native-roots-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "f20054e4e0728c1268d1474f688c228debe877888ebff0f052924ce198b44c29"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-tls-webpki-roots-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "fdb9ae9fe080be00af1a5b27a0f62f38eb121be6f56b98313630e67f3bcf6d16"

URI_x86_64_v2_rust-tokio-tungstenite+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+stream-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+stream-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+stream-devel.sha256sum] = "7186d2c49a0101c0221d939179a70c847ec5a0776ce74c6315baa5623ba47927"

URI_x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+tokio-native-tls-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel.sha256sum] = "1c14d1180937db636ea5e77d538948de44cd12cfcef2bf002938a8e90aab52c9"

URI_x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+tokio-rustls-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel.sha256sum] = "135c343fa509a3ffb25377ab879c2a3e1e1bbd32a7e6834d679b1f8607bca6e1"

URI_x86_64_v2_rust-tokio-tungstenite+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+url-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+url-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+url-devel.sha256sum] = "ff1761194c71dbfc2c89137f40603381a09f242cf74cc83a8dfbde7c267ce408"

URI_x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+webpki-roots-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel.sha256sum] = "11c2b517df186a0604baa8cf73b2016a128de9a9a04795ff80db4daec28faef7"

URI_x86_64_v2_rust-tokio-tungstenite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite-devel.sha256sum] = "2826fd9978531e13b49cef7103f9eeaab11254f488d50c34afee27cec15a1bc6"

URI_aarch64_rust-tokio-tungstenite+__rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+__rustls-tls-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+__rustls-tls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+__rustls-tls-devel.sha256sum] = "21113027eadc1438b9738efa0a7c4a290574440cd88829919f8b2e4b9b7cf796"

URI_aarch64_rust-tokio-tungstenite+connect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+connect-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+connect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+connect-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+connect-devel.sha256sum] = "d92b2245dc7fdbd875d95ee5c32a467e929b428f089bbf74f034e77e76b7b524"

URI_aarch64_rust-tokio-tungstenite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+default-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+default-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+default-devel.sha256sum] = "47956b1a334f872f031e9cd0f962e1009ab2b485493959a083dc706ead763ab6"

URI_aarch64_rust-tokio-tungstenite+handshake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+handshake-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+handshake-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+handshake-devel.sha256sum] = "bf71a28569beae40c3eeed46bce45edbdd804135f58078e96bb009fd1973c23d"

URI_aarch64_rust-tokio-tungstenite+native-tls-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+native-tls-crate-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+native-tls-crate-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+native-tls-crate-devel.sha256sum] = "f18368bcb8d966357a4785908b415d0949682e7a85cc54e55d131dc30e1be1a2"

URI_aarch64_rust-tokio-tungstenite+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+native-tls-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+native-tls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+native-tls-devel.sha256sum] = "354bf755526c0ccd1106b09ec990696360f96162245ac4a77f0eabbc55364195"

URI_aarch64_rust-tokio-tungstenite+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-devel.sha256sum] = "b887013a82714001b7bfcfa0f878249c9899d8dd037987ef83d88b4aa7f6ac4e"

URI_aarch64_rust-tokio-tungstenite+rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-native-certs-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-native-certs-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-native-certs-devel.sha256sum] = "6115719e77b2665bfb14b85d5c6e2bb7b5f54d9c2983b97ca16819eb307ae54e"

URI_aarch64_rust-tokio-tungstenite+rustls-pki-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-pki-types-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-pki-types-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-pki-types-devel.sha256sum] = "0f5d278cdcdce7d132595f7f33a197f9d3281a8a10ef567ce748cc0a1197b86b"

URI_aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-tls-native-roots-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "e91a91bb90c1b9f5e2b7eaf25a217fee17d1ddb5d1707254e647654e69db10b5"

URI_aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-tls-webpki-roots-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "56fcb1ccff55079641a360eb92795dd812f6ce76d5dcbf0476eb1d337ea0220f"

URI_aarch64_rust-tokio-tungstenite+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+stream-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+stream-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+stream-devel.sha256sum] = "00abac4eadc6a6c1d06af4d1c7d50b162eb7c8a8841602f1dd4db1e1ed1f1d4b"

URI_aarch64_rust-tokio-tungstenite+tokio-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+tokio-native-tls-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+tokio-native-tls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+tokio-native-tls-devel.sha256sum] = "f861038ddf3e538b47018f7541be09efbc3bd956accf41f3bb70d06796b52aac"

URI_aarch64_rust-tokio-tungstenite+tokio-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+tokio-rustls-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+tokio-rustls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+tokio-rustls-devel.sha256sum] = "fbfabd7df6ed938da8b89cfbf1cb1e802649c242a5f637e7a16da6ddb66f27f2"

URI_aarch64_rust-tokio-tungstenite+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+url-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+url-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+url-devel.sha256sum] = "a13b0d5a4823462997d2e68816a0f469f14a3150dac9ffd5a17836d36712f444"

URI_aarch64_rust-tokio-tungstenite+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+webpki-roots-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+webpki-roots-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+webpki-roots-devel.sha256sum] = "fb295f539d4e3da3c6140dee16786a15f130841f62c33a58d384756949a9dd64"

URI_aarch64_rust-tokio-tungstenite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite-devel.sha256sum] = "ddba2807974e1b4e9d85e90b00f7ae718c4142573232b174340ead63c57af045"

RDEPENDS:rust-tokio-tungstenite+__rustls-tls-devel = " \
 cargo \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+rustls-devel \
 rust-tokio-tungstenite+rustls-pki-types-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite+tokio-rustls-devel \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+__rustls-tls-devel \
 "
RDEPENDS:rust-tokio-tungstenite+connect-devel = " \
 cargo \
 rust-tokio+net-devel \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+default-devel = " \
 cargo \
 rust-tokio-tungstenite+connect-devel \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+handshake-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+handshake-devel \
 "
RDEPENDS:rust-tokio-tungstenite+native-tls-crate-devel = " \
 cargo \
 rust-native-tls+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+native-tls-devel = " \
 cargo \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+native-tls-crate-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite+tokio-native-tls-devel \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+native-tls-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-devel = " \
 cargo \
 rust-rustls-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-native-certs-devel = " \
 cargo \
 rust-rustls-native-certs+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-pki-types-devel = " \
 cargo \
 rust-rustls-pki-types+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-tls-native-roots-devel = " \
 cargo \
 rust-tokio-tungstenite+__rustls-tls-devel \
 rust-tokio-tungstenite+rustls-native-certs-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-tls-webpki-roots-devel = " \
 cargo \
 rust-tokio-tungstenite+__rustls-tls-devel \
 rust-tokio-tungstenite+webpki-roots-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+stream-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+tokio-native-tls-devel = " \
 cargo \
 rust-tokio-native-tls+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+tokio-rustls-devel = " \
 cargo \
 rust-tokio-rustls-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+url-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+url-devel \
 "
RDEPENDS:rust-tokio-tungstenite+webpki-roots-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 rust-webpki-roots0.26+default-devel \
 "
RDEPENDS:rust-tokio-tungstenite-devel = " \
 cargo \
 rust \
 rust-futures-util+sink-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-log+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 rust-tungstenite-devel \
 "
