# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bcvk"
PV = "0.10.0"
PR = "1.el10_1"
PACKAGES = " \
 bcvk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bcvk-0.10.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66c1944d46ab61e5b81c357b83afc916140ad82b28a481c7877f137d54adca2a"

URI_x86_64_v2_bcvk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bcvk-0.10.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bcvk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcvk}"
SRC_URI[x86_64_v2_bcvk.sha256sum] = "b4f7665dc3df2e617c56aee1eadb07fbf0c187632022b13dddcc41bd2bff7bf5"

URI_aarch64_bcvk = "${EPEL_MIRROR}/aarch64/Packages/b/bcvk-0.10.0-1.el10_1.aarch64.rpm;name=aarch64_bcvk;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcvk}"
SRC_URI[aarch64_bcvk.sha256sum] = "ab361c92a80647ace383bfd56cb17a0acedf509b8e861de1c665093f470c23c7"

RDEPENDS:bcvk = " \
 glibc \
 libgcc \
 "
