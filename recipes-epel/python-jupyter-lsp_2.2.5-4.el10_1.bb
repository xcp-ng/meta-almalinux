# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jupyter-lsp"
PV = "2.2.5"
PR = "4.el10_1"
PACKAGES = " \
 python3-jupyter-lsp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jupyter-lsp-2.2.5-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fbcd7112821af3f4395f866feed577bf1dd1d9535266046f547b5b1928a8abc"

URI_x86_64_v2_python3-jupyter-lsp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jupyter-lsp-2.2.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jupyter-lsp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jupyter-lsp}"
SRC_URI[x86_64_v2_python3-jupyter-lsp.sha256sum] = "b892c7d2d938f12065ea494a81084435a2cf2776058ec693e914af90a54347e3"

URI_aarch64_python3-jupyter-lsp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jupyter-lsp-2.2.5-4.el10_1.noarch.rpm;name=aarch64_python3-jupyter-lsp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jupyter-lsp}"
SRC_URI[aarch64_python3-jupyter-lsp.sha256sum] = "6b1061d4bfad38feb2d3ece98ccb23c2bb455b79c3da3453f4ad68e10d349cb3"

RDEPENDS:python3-jupyter-lsp = " \
 python-jupyter-filesystem \
 python3 \
 python3-jupyter-server \
 "
