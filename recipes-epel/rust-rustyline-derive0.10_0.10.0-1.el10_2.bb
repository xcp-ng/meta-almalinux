# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustyline-derive0.10"
PV = "0.10.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustyline-derive0.10+default-devel \
 rust-rustyline-derive0.10-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustyline-derive0.10-0.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84a0c95232ff873567ae7c19947dd47a78511d8068b705873bcef8608466eec0"

URI_x86_64_v2_rust-rustyline-derive0.10+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline-derive0.10+default-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline-derive0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline-derive0.10+default-devel}"
SRC_URI[x86_64_v2_rust-rustyline-derive0.10+default-devel.sha256sum] = "8ba7eb9a4dd0b75fb28efff41f54ae5cbdae72cb14cbbd3d546c84b0ba1ccc16"

URI_x86_64_v2_rust-rustyline-derive0.10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline-derive0.10-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline-derive0.10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline-derive0.10-devel}"
SRC_URI[x86_64_v2_rust-rustyline-derive0.10-devel.sha256sum] = "91415cf7b5787cc7a87b8747af990f0d524f6f3e6ceb8f1854e6815735fd22ba"

URI_aarch64_rust-rustyline-derive0.10+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline-derive0.10+default-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline-derive0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline-derive0.10+default-devel}"
SRC_URI[aarch64_rust-rustyline-derive0.10+default-devel.sha256sum] = "2c741520ee2bf6fafaab26b143fa4d1bc17b91e13b6c471a5a3965e2d05d8a50"

URI_aarch64_rust-rustyline-derive0.10-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline-derive0.10-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline-derive0.10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline-derive0.10-devel}"
SRC_URI[aarch64_rust-rustyline-derive0.10-devel.sha256sum] = "eb8fabd05338878ae0c847c623a8be7ae7998c77093b1722a2d62ecaa3ff2427"

RDEPENDS:rust-rustyline-derive0.10+default-devel = " \
 cargo \
 rust-rustyline-derive0.10-devel \
 "
RDEPENDS:rust-rustyline-derive0.10-devel = " \
 cargo \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn2+derive-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2+proc-macro-devel \
 rust-syn2-devel \
 "
