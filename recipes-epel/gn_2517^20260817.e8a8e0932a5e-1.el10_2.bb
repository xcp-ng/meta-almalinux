# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gn"
PV = "2517^20260817.e8a8e0932a5e"
PR = "1.el10_2"
PACKAGES = " \
 gn \
 gn-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gn-2517^20260817.e8a8e0932a5e-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c7fa30759dfc458e17c475095549eef7bc379bc54b25ed4877ce5ec1334c6bc7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gn-2517^20260817.e8a8e0932a5e-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gn;unpack=0"
SRC_URI[x86_64_v2_gn.sha256sum] = "b6438617d4336d52cc5a77fd2046975e52002af74c9d58459bf7eaed86b9bdae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gn-doc-2517^20260817.e8a8e0932a5e-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gn-doc;unpack=0"
SRC_URI[x86_64_v2_gn-doc.sha256sum] = "672df0e26dc82e8f4c837797a847f1412a5728c81446349064a4d078f58d54c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gn-2517^20260817.e8a8e0932a5e-1.el10_2.aarch64.rpm;name=aarch64_gn;unpack=0"
SRC_URI[aarch64_gn.sha256sum] = "c4ca3cc674dba414aeca64523887d5875ae7aa4e104453c55acce11f20f0ad68"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gn-doc-2517^20260817.e8a8e0932a5e-1.el10_2.noarch.rpm;name=aarch64_gn-doc;unpack=0"
SRC_URI[aarch64_gn-doc.sha256sum] = "fb8f7532744f0eaf57904b364f13cad2d167cd4c73149d00aa4cc6ef6db0d6e2"

RDEPENDS:gn = " \
 emacs-filesystem \
 glibc \
 libstdc++ \
 python3 \
 vim-filesystem \
 "
RDEPENDS:gn-doc = " \
 "
