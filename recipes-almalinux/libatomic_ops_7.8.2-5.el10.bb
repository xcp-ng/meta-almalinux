# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libatomic_ops"
PV = "7.8.2"
PR = "5.el10"
PACKAGES = " \
 libatomic_ops \
 libatomic_ops-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/libatomic_ops-7.8.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a3e374bd5aa3debfca1081cbb064323d1637088f6d6c273d9221971cc45c63f"

URI_x86_64_v2_libatomic_ops = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libatomic_ops-7.8.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libatomic_ops;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libatomic_ops}"
SRC_URI[x86_64_v2_libatomic_ops.sha256sum] = "74bd16fc0425bbb680de6a3ed9d5ac78d2cfb290a956fbc2cac8063a5f488dc9"

URI_x86_64_v2_libatomic_ops-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libatomic_ops-devel-7.8.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libatomic_ops-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libatomic_ops-devel}"
SRC_URI[x86_64_v2_libatomic_ops-devel.sha256sum] = "4fc55f973d53bb8e94f8fc428647842bed452a291b8b0c455187c4201233855c"

URI_aarch64_libatomic_ops = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libatomic_ops-7.8.2-5.el10.aarch64.rpm;name=aarch64_libatomic_ops;unpack=0"
SRC_URI:append = " ${URI_aarch64_libatomic_ops}"
SRC_URI[aarch64_libatomic_ops.sha256sum] = "0f98170e3adb9014a912c29d9838c8ee4fe39af3cd9235aa6a038bc7a2a6f545"

URI_aarch64_libatomic_ops-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libatomic_ops-devel-7.8.2-5.el10.aarch64.rpm;name=aarch64_libatomic_ops-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libatomic_ops-devel}"
SRC_URI[aarch64_libatomic_ops-devel.sha256sum] = "83c52c16c90a35e9ddd7ddd22d235d8ecc6f7f6f937ff78e25122107c86f8b48"

RDEPENDS:libatomic_ops = " \
 glibc \
 "
RDEPENDS:libatomic_ops-devel = " \
 libatomic_ops \
 pkgconf-pkg-config \
 "
