# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cfg-expr"
PV = "0.20.9"
PR = "1.el10_3"
PACKAGES = " \
 rust-cfg-expr+default-devel \
 rust-cfg-expr+target-lexicon-devel \
 rust-cfg-expr+targets-devel \
 rust-cfg-expr-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cfg-expr-0.20.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5c7284b270c62fc1ea2246cc3e6386a2020a8a8a4835b352b8cc3b9ec0904a20"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr+default-devel-0.20.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cfg-expr+default-devel.sha256sum] = "042dfa3cf30c11e814b229b63f88f0ab4644d4d3eeb9884956ae8cd7126f2388"
RPROVIDES:rust-cfg-expr+default-devel:append:x86_64_v2 = " virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr+target-lexicon-devel-0.20.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr+target-lexicon-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cfg-expr+target-lexicon-devel.sha256sum] = "0a1455db97f869cb62b04bf88cb18c5fea9838be1ec5c29e2d43c043c1a8d014"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr+targets-devel-0.20.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr+targets-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cfg-expr+targets-devel.sha256sum] = "9da1f16d04042413dbc0b7d2d4171c3622830bebcab5767116c632cacc1ce374"
RPROVIDES:rust-cfg-expr+targets-devel:append:x86_64_v2 = " virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr-devel-0.20.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cfg-expr-devel.sha256sum] = "149e33e35484684b6045f12227d3175365038958e081584964cc0ca418108528"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr+default-devel-0.20.9-1.el10_3.noarch.rpm;name=aarch64_rust-cfg-expr+default-devel;unpack=0"
SRC_URI[aarch64_rust-cfg-expr+default-devel.sha256sum] = "b02381c746007c59a73b4267021ed1d27e2ae39290fd1bf3ab8a94596f437bae"
RPROVIDES:rust-cfg-expr+default-devel:append:aarch64 = " virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr+target-lexicon-devel-0.20.9-1.el10_3.noarch.rpm;name=aarch64_rust-cfg-expr+target-lexicon-devel;unpack=0"
SRC_URI[aarch64_rust-cfg-expr+target-lexicon-devel.sha256sum] = "683143fbb4e44831d5197a6f2faebc50678a02a2ea09d412f2bdc05312b982df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr+targets-devel-0.20.9-1.el10_3.noarch.rpm;name=aarch64_rust-cfg-expr+targets-devel;unpack=0"
SRC_URI[aarch64_rust-cfg-expr+targets-devel.sha256sum] = "c45529a4881f4e54f4227ce70a4097bfbc7b4b1df89edb5e032efef4898f57d9"
RPROVIDES:rust-cfg-expr+targets-devel:append:aarch64 = " virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr-devel-0.20.9-1.el10_3.noarch.rpm;name=aarch64_rust-cfg-expr-devel;unpack=0"
SRC_URI[aarch64_rust-cfg-expr-devel.sha256sum] = "1f0c1cdb3252c0b641e586a33d62708e98f1869369b893d8b8defeab9caff4a5"

RDEPENDS:rust-cfg-expr+default-devel = " \
 cargo \
 rust-cfg-expr-devel \
 "
RDEPENDS:rust-cfg-expr+target-lexicon-devel = " \
 cargo \
 rust-cfg-expr-devel \
 rust-target-lexicon+default-devel \
 "
RDEPENDS:rust-cfg-expr+targets-devel = " \
 cargo \
 rust-cfg-expr+target-lexicon-devel \
 rust-cfg-expr-devel \
 "
RDEPENDS:rust-cfg-expr-devel = " \
 cargo \
 rust \
 rust-smallvec+default-devel \
 "
