# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-go"
PV = "0.23.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter-go+default-devel \
 rust-tree-sitter-go-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-go-0.23.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a95d8cf2e3226f0cfceef05d4e77955a6585273d765bc9863ad5709593735dc6"

URI_x86_64_v2_rust-tree-sitter-go+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-go+default-devel-0.23.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-go+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-go+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-go+default-devel.sha256sum] = "f673d76273b169074156d6b2735999758c37a8dc72602715b1e6848810b79456"

URI_x86_64_v2_rust-tree-sitter-go-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-go-devel-0.23.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-go-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-go-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-go-devel.sha256sum] = "90b59018a0cfbaed6fcdb7b9ecb1d7260869269daa585788a119ca7bccb0825b"

URI_aarch64_rust-tree-sitter-go+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-go+default-devel-0.23.4-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-go+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-go+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-go+default-devel.sha256sum] = "ee5725c807e9b48f1f7a9dcfc7dc9a8fc422a3f8fe43a54da558d93ed2f8293d"

URI_aarch64_rust-tree-sitter-go-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-go-devel-0.23.4-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-go-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-go-devel}"
SRC_URI[aarch64_rust-tree-sitter-go-devel.sha256sum] = "69e3ad0b72df9fe3c9e1106478bd2aac5414f9d013cac0fdfb70262edab15a2f"

RDEPENDS:rust-tree-sitter-go+default-devel = " \
 cargo \
 rust-tree-sitter-go-devel \
 "
RDEPENDS:rust-tree-sitter-go-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
