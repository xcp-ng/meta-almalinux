# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tabulate"
PV = "0.9.0"
PR = "10.el10_0"
PACKAGES = " \
 python3-tabulate \
 python3-tabulate+widechars \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tabulate-0.9.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0316e50b42af9c15ae0a6550e2172424d7945fd35d9dff3e6b78d26462a75b7"

URI_x86_64_v2_python3-tabulate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tabulate-0.9.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tabulate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tabulate}"
SRC_URI[x86_64_v2_python3-tabulate.sha256sum] = "d08ca7e80d6c7067de43bc8efd7f57e01f54f0d13e8c809b80d1e3b48174a53d"

URI_x86_64_v2_python3-tabulate+widechars = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tabulate+widechars-0.9.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tabulate+widechars;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tabulate+widechars}"
SRC_URI[x86_64_v2_python3-tabulate+widechars.sha256sum] = "8a8a48a7ae1838a031664e31a2dc9bda9fd7ce79a22c8c64e4a5c4d96eb66120"

URI_aarch64_python3-tabulate = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tabulate-0.9.0-10.el10_0.noarch.rpm;name=aarch64_python3-tabulate;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tabulate}"
SRC_URI[aarch64_python3-tabulate.sha256sum] = "e232128eed910060d8b1dcc7412a6375c6052712ea0ab362b30b0b0337d2a375"

URI_aarch64_python3-tabulate+widechars = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tabulate+widechars-0.9.0-10.el10_0.noarch.rpm;name=aarch64_python3-tabulate+widechars;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tabulate+widechars}"
SRC_URI[aarch64_python3-tabulate+widechars.sha256sum] = "47ddfb42195bbeb058a1bbd6ecb9849db9a3da2fd67161ddfbd7efda6a8abf91"

RDEPENDS:python3-tabulate = " \
 python3 \
 "
RDEPENDS:python3-tabulate+widechars = " \
 python3 \
 python3-tabulate \
 python3-wcwidth \
 "
