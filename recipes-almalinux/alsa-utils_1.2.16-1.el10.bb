# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alsa-utils"
PV = "1.2.16"
PR = "1.el10"
PACKAGES = " \
 alsa-ucm-utils \
 alsa-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/alsa-utils-1.2.16-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f73e961b6c5ed923fb8d75fbfe3f1c39a7639d4c32b3bb9700fd9304643135bf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-ucm-utils-1.2.16-1.el10.x86_64_v2.rpm;name=x86_64_v2_alsa-ucm-utils;unpack=0"
SRC_URI[x86_64_v2_alsa-ucm-utils.sha256sum] = "0e0368b1f6696557442e397ae91880697e88b03c655d18ab2d11aa0bdc39cfda"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-utils-1.2.16-1.el10.x86_64_v2.rpm;name=x86_64_v2_alsa-utils;unpack=0"
SRC_URI[x86_64_v2_alsa-utils.sha256sum] = "8e087bdbf3ead57bf23adc369f51a7b64df1ee95cd7bc206fe0b97664196596c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-ucm-utils-1.2.16-1.el10.aarch64.rpm;name=aarch64_alsa-ucm-utils;unpack=0"
SRC_URI[aarch64_alsa-ucm-utils.sha256sum] = "6ab8f165f457788f6657e561421d398d3765acda0ae664f316e3725bd470f174"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-utils-1.2.16-1.el10.aarch64.rpm;name=aarch64_alsa-utils;unpack=0"
SRC_URI[aarch64_alsa-utils.sha256sum] = "7d84a2c64d65526c7cd7639d75512320706498f75a713eaab21e3b700e188561"

RDEPENDS:alsa-ucm-utils = " \
 alsa-lib \
 glibc \
 "
RDEPENDS:alsa-utils = " \
 alsa-lib \
 alsa-ucm \
 bash \
 glibc \
 libsamplerate \
 ncurses-libs \
 systemd \
 "
