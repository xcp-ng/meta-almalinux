# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "upower"
PV = "1.90.6"
PR = "2.el10"
PACKAGES = " \
 upower \
 upower-devel \
 upower-devel-docs \
 upower-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/upower-1.90.6-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cd187151b1ae1614debcd58188cb7354b84713cbaffcc64b863d52655b83553"

URI_x86_64_v2_upower = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/upower-1.90.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_upower;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_upower}"
SRC_URI[x86_64_v2_upower.sha256sum] = "b63455b954b158adb7f0bedb49b6935d0bf06568c58be2dce2e806e8fdb8171a"

URI_x86_64_v2_upower-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/upower-devel-1.90.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_upower-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_upower-devel}"
SRC_URI[x86_64_v2_upower-devel.sha256sum] = "24b9f054e4d517c084bd0c85e0e097cbba43d7c258bee17da09e13bac5d36033"

URI_x86_64_v2_upower-devel-docs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/upower-devel-docs-1.90.6-2.el10.noarch.rpm;name=x86_64_v2_upower-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_upower-devel-docs}"
SRC_URI[x86_64_v2_upower-devel-docs.sha256sum] = "6359bff843c2a04435760d1989abebada902735896500d9d671d74e08d558b71"

URI_x86_64_v2_upower-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/upower-libs-1.90.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_upower-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_upower-libs}"
SRC_URI[x86_64_v2_upower-libs.sha256sum] = "1599a5d384e3e2ea3a632906ea7c70c7c66c392d77ec563a7d2d67e1f62799c3"

URI_aarch64_upower = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/upower-1.90.6-2.el10.aarch64.rpm;name=aarch64_upower;unpack=0"
SRC_URI:append = " ${URI_aarch64_upower}"
SRC_URI[aarch64_upower.sha256sum] = "27804f04d1c822629442eec3863bbb4415ebedf6c1c9dfa24954c2236ae46006"

URI_aarch64_upower-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/upower-devel-1.90.6-2.el10.aarch64.rpm;name=aarch64_upower-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_upower-devel}"
SRC_URI[aarch64_upower-devel.sha256sum] = "2bf415518f134d7b266a706bdcba9038fff77075783d833ba195738957f736ae"

URI_aarch64_upower-devel-docs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/upower-devel-docs-1.90.6-2.el10.noarch.rpm;name=aarch64_upower-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_upower-devel-docs}"
SRC_URI[aarch64_upower-devel-docs.sha256sum] = "6359bff843c2a04435760d1989abebada902735896500d9d671d74e08d558b71"

URI_aarch64_upower-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/upower-libs-1.90.6-2.el10.aarch64.rpm;name=aarch64_upower-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_upower-libs}"
SRC_URI[aarch64_upower-libs.sha256sum] = "1c97cff1cacb499c6b4a57b7e030ef8d6e80caee5b5b68bada01fe025d125655"

RDEPENDS:upower = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libgudev \
 polkit-libs \
 python3 \
 systemd-udev \
 upower-libs \
 "
RDEPENDS:upower-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 polkit-devel \
 upower-libs \
 "
RDEPENDS:upower-devel-docs = " \
 upower-libs \
 "
RDEPENDS:upower-libs = " \
 glib2 \
 glibc \
 gobject-introspection \
 libgcc \
 "
