# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdeclarative"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kdeclarative \
 kf6-kdeclarative-devel \
 kf6-kdeclarative-doc \
 kf6-kdeclarative-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kdeclarative-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "900e649c807feec843b1185c147ceceaa9757f0adbb6a6a5cd7e97c6d992fb2e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdeclarative;unpack=0"
SRC_URI[x86_64_v2_kf6-kdeclarative.sha256sum] = "cf13f3c0cc71a00d7cf197c95602179f99c9753b54e1f521dcf100693f66118a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdeclarative-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kdeclarative-devel.sha256sum] = "449c74000ee2fc1f10e5d5ab118b74e0eec188bac2a56bd53ce5593b1decad99"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdeclarative-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kdeclarative-doc.sha256sum] = "1927ddb21120012f0321547f3af406546cdaf560b6120a7cf59951b6e55a7c0e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdeclarative-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kdeclarative-html.sha256sum] = "76cfdb780483118204f3d50fb4cf6651197e520066c730d796edc9f4218f4505"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdeclarative;unpack=0"
SRC_URI[aarch64_kf6-kdeclarative.sha256sum] = "e0ec6ce2993e55b85cf231b3ca01cfe2fe8d6ad2ba7a88b74524fe63d79f04ee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdeclarative-devel;unpack=0"
SRC_URI[aarch64_kf6-kdeclarative-devel.sha256sum] = "858b78b118501ac2077cd8adfe1c86d445cabe43f8b9dab6eca796b88483b92d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdeclarative-doc;unpack=0"
SRC_URI[aarch64_kf6-kdeclarative-doc.sha256sum] = "7f7163d0337e875542e8c157e422e4819d7ba9f5c58c86690759e8a808494616"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdeclarative-html;unpack=0"
SRC_URI[aarch64_kf6-kdeclarative-html.sha256sum] = "af3f9698b2d8702e89c4b3d064e14963ea34f3a29d8541b98ce71fc47e839baa"

RDEPENDS:kf6-kdeclarative = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kdeclarative-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kdeclarative \
 kf6-kpackage-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:kf6-kdeclarative-doc = " \
 "
RDEPENDS:kf6-kdeclarative-html = " \
 "
