# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-qrcode"
PV = "8.0"
PR = "1.el10"
PACKAGES = " \
 python3-qrcode \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-qrcode-8.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc4f736fd990efee20eff3980db20c92ed64742ed99d308be3b76a39d1a6cb63"

URI_x86_64_v2_python3-qrcode = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-qrcode-8.0-1.el10.noarch.rpm;name=x86_64_v2_python3-qrcode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-qrcode}"
SRC_URI[x86_64_v2_python3-qrcode.sha256sum] = "ab261be5634e225918b507964809f20145f7074ef46e137b5f3996930fb31fae"

URI_aarch64_python3-qrcode = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-qrcode-8.0-1.el10.noarch.rpm;name=aarch64_python3-qrcode;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-qrcode}"
SRC_URI[aarch64_python3-qrcode.sha256sum] = "ab261be5634e225918b507964809f20145f7074ef46e137b5f3996930fb31fae"

RDEPENDS:python3-qrcode = " \
 python3 \
 "
