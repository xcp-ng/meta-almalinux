# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-get-size2"
PV = "0.10.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-get-size2+bytes-devel \
 rust-get-size2+chrono-devel \
 rust-get-size2+chrono-tz-devel \
 rust-get-size2+compact-str-devel \
 rust-get-size2+dashmap-devel \
 rust-get-size2+default-devel \
 rust-get-size2+derive-devel \
 rust-get-size2+get-size-derive2-devel \
 rust-get-size2+half-devel \
 rust-get-size2+hashbrown-devel \
 rust-get-size2+indexmap-devel \
 rust-get-size2+ordermap-devel \
 rust-get-size2+parking_lot-devel \
 rust-get-size2+portable-atomic-devel \
 rust-get-size2+smallvec-devel \
 rust-get-size2+thin-vec-devel \
 rust-get-size2+url-devel \
 rust-get-size2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-get-size2-0.10.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "773848aef343dca4890ca8c5fb9dd49e9dc049e56bfca2fcbecd570f65e1e206"

URI_x86_64_v2_rust-get-size2+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+bytes-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+bytes-devel}"
SRC_URI[x86_64_v2_rust-get-size2+bytes-devel.sha256sum] = "6b37541d77b09d6039ebb859cb158ab77e5eba1b6e4ad914e99817628ad17e50"

URI_x86_64_v2_rust-get-size2+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+chrono-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+chrono-devel}"
SRC_URI[x86_64_v2_rust-get-size2+chrono-devel.sha256sum] = "98fcddcc3ee970c1ee4a89da62d57e46d18539e1cdb3ba93affb77f643e8282b"

URI_x86_64_v2_rust-get-size2+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+chrono-tz-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-get-size2+chrono-tz-devel.sha256sum] = "2e9a1d1874d5b3df46328b651cb313b4dea5841706fe3313e459c834a9d3be79"

URI_x86_64_v2_rust-get-size2+compact-str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+compact-str-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+compact-str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+compact-str-devel}"
SRC_URI[x86_64_v2_rust-get-size2+compact-str-devel.sha256sum] = "a5b5587fa9ff4121c9c722d97df616f5ffaef5bc50cbacef5a2fe814d0775a3f"

URI_x86_64_v2_rust-get-size2+dashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+dashmap-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+dashmap-devel}"
SRC_URI[x86_64_v2_rust-get-size2+dashmap-devel.sha256sum] = "efc34a639b2bfdbe80ef9698039db4dc9ba4e0b3fa5ca1a71da08b5bcc54a0ff"

URI_x86_64_v2_rust-get-size2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+default-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+default-devel}"
SRC_URI[x86_64_v2_rust-get-size2+default-devel.sha256sum] = "7f23aacab96edbe612f7675dc63b904f623b8309ddcdfd08a6f59ed0ddd6752d"

URI_x86_64_v2_rust-get-size2+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+derive-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+derive-devel}"
SRC_URI[x86_64_v2_rust-get-size2+derive-devel.sha256sum] = "45bd1a95c4ae755e7c4197aec99efcb44580b53e5be478736c96b1988cf0b4df"

URI_x86_64_v2_rust-get-size2+get-size-derive2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+get-size-derive2-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+get-size-derive2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+get-size-derive2-devel}"
SRC_URI[x86_64_v2_rust-get-size2+get-size-derive2-devel.sha256sum] = "b76d0a76234cb348f63523901c464a0c092a2f69efd7ee84c69a778adfb000a8"

URI_x86_64_v2_rust-get-size2+half-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+half-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+half-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+half-devel}"
SRC_URI[x86_64_v2_rust-get-size2+half-devel.sha256sum] = "28d87c55c2e48abf998776a9b0f51f0e2e9b8b605b1e5d828177018cc03c04f8"

URI_x86_64_v2_rust-get-size2+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+hashbrown-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-get-size2+hashbrown-devel.sha256sum] = "2130661bd60969f5342acefc8a0aaf0a08c43a547f9ac05f55cabe32cbfdfd31"

URI_x86_64_v2_rust-get-size2+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+indexmap-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+indexmap-devel}"
SRC_URI[x86_64_v2_rust-get-size2+indexmap-devel.sha256sum] = "97d543a4b65704ca076f895355eb540318120f10273672ac2b2cf0fee65b7848"

URI_x86_64_v2_rust-get-size2+ordermap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+ordermap-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+ordermap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+ordermap-devel}"
SRC_URI[x86_64_v2_rust-get-size2+ordermap-devel.sha256sum] = "ea30bc1660f4fdb35911a26373af2e737d86d43bfb83c5a01b3873f1b19bd78d"

URI_x86_64_v2_rust-get-size2+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+parking_lot-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-get-size2+parking_lot-devel.sha256sum] = "5f92981a1cf85ecd10887f9bfee7c82234ae8a6f725aa06e9702bca0ded4b43d"

URI_x86_64_v2_rust-get-size2+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+portable-atomic-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-get-size2+portable-atomic-devel.sha256sum] = "c44863949a516fbf1d4fb30bf674b1895a10c818bc082d032b784380f83da83a"

URI_x86_64_v2_rust-get-size2+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+smallvec-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+smallvec-devel}"
SRC_URI[x86_64_v2_rust-get-size2+smallvec-devel.sha256sum] = "a976cdbbc6d29824a5ce4b077b1a123e5a8abe8e17f0383452e816073c48b43c"

URI_x86_64_v2_rust-get-size2+thin-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+thin-vec-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+thin-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+thin-vec-devel}"
SRC_URI[x86_64_v2_rust-get-size2+thin-vec-devel.sha256sum] = "b7b96b7ebf4f319f6988ee693a00c7397e0bcd0df01c4136b95617dbdd3fc979"

URI_x86_64_v2_rust-get-size2+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+url-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+url-devel}"
SRC_URI[x86_64_v2_rust-get-size2+url-devel.sha256sum] = "7da143b2e86916b259f45af6c3de3a9de1de010745c6b4093aa93bdd78f416f2"

URI_x86_64_v2_rust-get-size2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2-devel}"
SRC_URI[x86_64_v2_rust-get-size2-devel.sha256sum] = "da1517697ea7b77f1380db003a18705b423552123eccf3a9ec10bd1f7efaf472"

URI_aarch64_rust-get-size2+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+bytes-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+bytes-devel}"
SRC_URI[aarch64_rust-get-size2+bytes-devel.sha256sum] = "e7d12ffbbd812a8d71c04899c15b0693c0231e8c53f9b3da3684f4ac6652c0db"

URI_aarch64_rust-get-size2+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+chrono-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+chrono-devel}"
SRC_URI[aarch64_rust-get-size2+chrono-devel.sha256sum] = "ddc28472f057177f2f709101bdf72f1b287ba1b4af8aa023eb919f3f6ebe4c79"

URI_aarch64_rust-get-size2+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+chrono-tz-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+chrono-tz-devel}"
SRC_URI[aarch64_rust-get-size2+chrono-tz-devel.sha256sum] = "b19e6a74782223b6151450de37b0d5d526934eaeb624e07ebb187ab26dc80d61"

URI_aarch64_rust-get-size2+compact-str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+compact-str-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+compact-str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+compact-str-devel}"
SRC_URI[aarch64_rust-get-size2+compact-str-devel.sha256sum] = "c9f48f5db6fc3e3a61521e6b9a1c03c7dd9a3a9e840da21b0716987d87568403"

URI_aarch64_rust-get-size2+dashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+dashmap-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+dashmap-devel}"
SRC_URI[aarch64_rust-get-size2+dashmap-devel.sha256sum] = "edef7b8e2dc39d8d43450322116c0d5b1d6077d90d303f403d1b31d459997062"

URI_aarch64_rust-get-size2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+default-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+default-devel}"
SRC_URI[aarch64_rust-get-size2+default-devel.sha256sum] = "4081ebc4108c5355c344818c864990aa2190b533ce51f6472cc0c3c11b753d4d"

URI_aarch64_rust-get-size2+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+derive-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+derive-devel}"
SRC_URI[aarch64_rust-get-size2+derive-devel.sha256sum] = "0eafe787c91ac49f42e40ce68dff02a8688c1c96d34c388a1aee5f9261029bfa"

URI_aarch64_rust-get-size2+get-size-derive2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+get-size-derive2-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+get-size-derive2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+get-size-derive2-devel}"
SRC_URI[aarch64_rust-get-size2+get-size-derive2-devel.sha256sum] = "9155422ce2c28bf83a8dd8347a54cc9120e7296c91f31e5ee38c2600c6ae0306"

URI_aarch64_rust-get-size2+half-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+half-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+half-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+half-devel}"
SRC_URI[aarch64_rust-get-size2+half-devel.sha256sum] = "d0a696ee2dcfc1aabbc639d6c4a31e4e6cfa3fa35dd5fbae2afe6f7cfc7d576f"

URI_aarch64_rust-get-size2+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+hashbrown-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+hashbrown-devel}"
SRC_URI[aarch64_rust-get-size2+hashbrown-devel.sha256sum] = "ea0205fbe0da85e26080302c9e52c57413fe9ed6ff1787de2b16ee654d228fc3"

URI_aarch64_rust-get-size2+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+indexmap-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+indexmap-devel}"
SRC_URI[aarch64_rust-get-size2+indexmap-devel.sha256sum] = "9bc9a737e238f727ed007fb1c22cb9ec802a1198e640c8bff5c73821cff03f5b"

URI_aarch64_rust-get-size2+ordermap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+ordermap-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+ordermap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+ordermap-devel}"
SRC_URI[aarch64_rust-get-size2+ordermap-devel.sha256sum] = "8618f6788704c4b35b1fab42336dbf79ae75e24cbf029764126176c2287685bf"

URI_aarch64_rust-get-size2+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+parking_lot-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+parking_lot-devel}"
SRC_URI[aarch64_rust-get-size2+parking_lot-devel.sha256sum] = "a86efcc745921089f2b3c7b88fb78a484db766dd840edfb86b483500e77c5c26"

URI_aarch64_rust-get-size2+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+portable-atomic-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+portable-atomic-devel}"
SRC_URI[aarch64_rust-get-size2+portable-atomic-devel.sha256sum] = "a5a523beb73fd78a697a498d8f3a2877bf1f0385d7e4e605d3a011ab1e21ee16"

URI_aarch64_rust-get-size2+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+smallvec-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+smallvec-devel}"
SRC_URI[aarch64_rust-get-size2+smallvec-devel.sha256sum] = "83f2f541963b375ddc17aa3bc9e5348e0e954b6ffac026ed48bad4d0b6e619fb"

URI_aarch64_rust-get-size2+thin-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+thin-vec-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+thin-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+thin-vec-devel}"
SRC_URI[aarch64_rust-get-size2+thin-vec-devel.sha256sum] = "4ded99bc0bdf2987587203e0231a2257ac8fb83eb09a43c00dfb2cd1211b269e"

URI_aarch64_rust-get-size2+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+url-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+url-devel}"
SRC_URI[aarch64_rust-get-size2+url-devel.sha256sum] = "1b973e3f0ae56b38b34d1e8387de772b8af028cee7c247830f4669a0fc9a6f5b"

URI_aarch64_rust-get-size2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2-devel}"
SRC_URI[aarch64_rust-get-size2-devel.sha256sum] = "4b7492ed0493fbf6ece35c89fd978b6e84eb335fe814cac081a9b59cf5ccff8c"

RDEPENDS:rust-get-size2+bytes-devel = " \
 cargo \
 rust-bytes-devel \
 rust-get-size2-devel \
 "
RDEPENDS:rust-get-size2+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-get-size2-devel \
 "
RDEPENDS:rust-get-size2+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-get-size2-devel \
 "
RDEPENDS:rust-get-size2+compact-str-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-get-size2-devel \
 "
RDEPENDS:rust-get-size2+dashmap-devel = " \
 cargo \
 rust-dashmap-devel \
 rust-get-size2-devel \
 "
RDEPENDS:rust-get-size2+default-devel = " \
 cargo \
 rust-get-size2-devel \
 "
RDEPENDS:rust-get-size2+derive-devel = " \
 cargo \
 rust-get-size2+get-size-derive2-devel \
 rust-get-size2-devel \
 "
RDEPENDS:rust-get-size2+get-size-derive2-devel = " \
 cargo \
 rust-get-size-derive2+default-devel \
 rust-get-size2-devel \
 "
RDEPENDS:rust-get-size2+half-devel = " \
 cargo \
 rust-get-size2-devel \
 rust-half-devel \
 "
RDEPENDS:rust-get-size2+hashbrown-devel = " \
 cargo \
 rust-get-size2-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-get-size2+indexmap-devel = " \
 cargo \
 rust-get-size2-devel \
 rust-indexmap-devel \
 "
RDEPENDS:rust-get-size2+ordermap-devel = " \
 cargo \
 rust-get-size2-devel \
 rust-ordermap-devel \
 "
RDEPENDS:rust-get-size2+parking_lot-devel = " \
 cargo \
 rust-get-size2-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-get-size2+portable-atomic-devel = " \
 cargo \
 rust-get-size2-devel \
 rust-portable-atomic+fallback-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-get-size2+smallvec-devel = " \
 cargo \
 rust-get-size2-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-get-size2+thin-vec-devel = " \
 cargo \
 rust-get-size2-devel \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-get-size2+url-devel = " \
 cargo \
 rust-get-size2-devel \
 rust-url-devel \
 "
RDEPENDS:rust-get-size2-devel = " \
 cargo \
 "
