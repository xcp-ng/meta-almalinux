# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "afflib"
PV = "3.7.20"
PR = "12.el10_0"
PACKAGES = " \
 afflib \
 afflib-devel \
 afftools \
 python3-pyaff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/afflib-3.7.20-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0295700e7ee28ea5c6c99e989f613e3762fac55f41a652ba4475e140b6cfb397"

URI_x86_64_v2_afflib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/afflib-3.7.20-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_afflib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_afflib}"
SRC_URI[x86_64_v2_afflib.sha256sum] = "e33bfa285cc35be8efb67af290fc7b2bc8e46f9b6a5288f636acf8a8820e0ba6"

URI_x86_64_v2_afflib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/afflib-devel-3.7.20-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_afflib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_afflib-devel}"
SRC_URI[x86_64_v2_afflib-devel.sha256sum] = "0bb8fbe2eed334e1b78ae8b020074880a40a38d778255a378d82527524daf302"

URI_x86_64_v2_afftools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/afftools-3.7.20-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_afftools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_afftools}"
SRC_URI[x86_64_v2_afftools.sha256sum] = "11da40e7d40b2c3d18786914f4d9b639a582feec1f9609297d326adff410a0b1"

URI_x86_64_v2_python3-pyaff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyaff-3.7.20-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyaff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyaff}"
SRC_URI[x86_64_v2_python3-pyaff.sha256sum] = "3bb88229aac1244edc82c235e296d065810d02d1059f9b568a54894209abaf4c"

URI_aarch64_afflib = "${EPEL_MIRROR}/aarch64/Packages/a/afflib-3.7.20-12.el10_0.aarch64.rpm;name=aarch64_afflib;unpack=0"
SRC_URI:append = " ${URI_aarch64_afflib}"
SRC_URI[aarch64_afflib.sha256sum] = "c4acf6b2604edb9f91c61d8ab032c650f9bec9a112498d391b4fb088728f7e24"

URI_aarch64_afflib-devel = "${EPEL_MIRROR}/aarch64/Packages/a/afflib-devel-3.7.20-12.el10_0.aarch64.rpm;name=aarch64_afflib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_afflib-devel}"
SRC_URI[aarch64_afflib-devel.sha256sum] = "357b1aa157f746a6b561ae27d0cc443731d858269f84307b952db5e186c24035"

URI_aarch64_afftools = "${EPEL_MIRROR}/aarch64/Packages/a/afftools-3.7.20-12.el10_0.aarch64.rpm;name=aarch64_afftools;unpack=0"
SRC_URI:append = " ${URI_aarch64_afftools}"
SRC_URI[aarch64_afftools.sha256sum] = "e7c828a40acd4c9bb909049b2956acffb7848055e67a22eb531ffb9b301a27e6"

URI_aarch64_python3-pyaff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyaff-3.7.20-12.el10_0.aarch64.rpm;name=aarch64_python3-pyaff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyaff}"
SRC_URI[aarch64_python3-pyaff.sha256sum] = "0c1feef836a9d27dbfdc929ced7712a598f4e5c9d267a90d5247b0795137ccc2"

RDEPENDS:afflib = " \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:afflib-devel = " \
 afflib \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:afftools = " \
 afflib \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 "
RDEPENDS:python3-pyaff = " \
 afflib \
 glibc \
 python3 \
 "
