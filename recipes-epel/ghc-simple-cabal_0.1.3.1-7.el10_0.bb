# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-simple-cabal"
PV = "0.1.3.1"
PR = "7.el10_0"
PACKAGES = " \
 ghc-simple-cabal \
 ghc-simple-cabal-devel \
 ghc-simple-cabal-doc \
 ghc-simple-cabal-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-simple-cabal-0.1.3.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b533a01f5549e39355a4e333e57647f38c978c1bf153b19512f622d78307a02"

URI_x86_64_v2_ghc-simple-cabal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-simple-cabal-0.1.3.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-simple-cabal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-simple-cabal}"
SRC_URI[x86_64_v2_ghc-simple-cabal.sha256sum] = "41f6e00bbb5436dcbb42b01a102fb7ebc184b3274d62c017b1f06e83764fef75"

URI_x86_64_v2_ghc-simple-cabal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-simple-cabal-devel-0.1.3.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-simple-cabal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-simple-cabal-devel}"
SRC_URI[x86_64_v2_ghc-simple-cabal-devel.sha256sum] = "cd62e664a28939f26196595c7633883d23c89519cefa33063046cd2efce5bf30"

URI_x86_64_v2_ghc-simple-cabal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-simple-cabal-doc-0.1.3.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-simple-cabal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-simple-cabal-doc}"
SRC_URI[x86_64_v2_ghc-simple-cabal-doc.sha256sum] = "768c529f3cf20decbb3bf89d432f8de31bba3131117cece04c91813fe53d1883"

URI_x86_64_v2_ghc-simple-cabal-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-simple-cabal-prof-0.1.3.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-simple-cabal-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-simple-cabal-prof}"
SRC_URI[x86_64_v2_ghc-simple-cabal-prof.sha256sum] = "f5b412895df86f4b17e1b942e751964a8a787e9c43ea4c6b2f415c5463f8a36f"

URI_aarch64_ghc-simple-cabal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cabal-0.1.3.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-simple-cabal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cabal}"
SRC_URI[aarch64_ghc-simple-cabal.sha256sum] = "fdafc039ef269582f218542b2f0675c1fcc998193c24f32985fdebfe9bc9414a"

URI_aarch64_ghc-simple-cabal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cabal-devel-0.1.3.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-simple-cabal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cabal-devel}"
SRC_URI[aarch64_ghc-simple-cabal-devel.sha256sum] = "d8ce6b19811d997fd8667d1062941b84b3885ce717b4a6e8c44e9ab78dab7940"

URI_aarch64_ghc-simple-cabal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cabal-doc-0.1.3.1-7.el10_0.noarch.rpm;name=aarch64_ghc-simple-cabal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cabal-doc}"
SRC_URI[aarch64_ghc-simple-cabal-doc.sha256sum] = "531914c4c6824a57bfa166731daab376f8d9d7ecbabc906cff00a759a4e9c94f"

URI_aarch64_ghc-simple-cabal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cabal-prof-0.1.3.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-simple-cabal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cabal-prof}"
SRC_URI[aarch64_ghc-simple-cabal-prof.sha256sum] = "240fc8c4e369ad70728b79f3a8de0c852505b2929f3ee8b59f1617d9831a31ba"

RDEPENDS:ghc-simple-cabal = " \
 ghc-Cabal \
 ghc-Cabal-syntax \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-simple-cabal-devel = " \
 ghc-Cabal-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-simple-cabal \
 "
RDEPENDS:ghc-simple-cabal-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-simple-cabal-prof = " \
 ghc-Cabal-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-simple-cabal-devel \
 "
