# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-threadpool"
PV = "1.8.1"
PR = "15.el10_1"
PACKAGES = " \
 rust-threadpool+default-devel \
 rust-threadpool-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-threadpool-1.8.1-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "384ce3001d94ad59a85513ff7edf8fabe0e623089c789389bbbbbf0e59569fd7"

URI_x86_64_v2_rust-threadpool+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-threadpool+default-devel-1.8.1-15.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-threadpool+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-threadpool+default-devel}"
SRC_URI[x86_64_v2_rust-threadpool+default-devel.sha256sum] = "aabe3cb51c6d82226534fc3ad0f739e0ffbe424853c0c26cb0b24684cc83ac30"

URI_x86_64_v2_rust-threadpool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-threadpool-devel-1.8.1-15.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-threadpool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-threadpool-devel}"
SRC_URI[x86_64_v2_rust-threadpool-devel.sha256sum] = "a78ead1b129f010baea301cb12e9242eed0d55b82f076715f91a1a86c2e30aa3"

URI_aarch64_rust-threadpool+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-threadpool+default-devel-1.8.1-15.el10_1.noarch.rpm;name=aarch64_rust-threadpool+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-threadpool+default-devel}"
SRC_URI[aarch64_rust-threadpool+default-devel.sha256sum] = "12094a007d59ffb0d61e6add87ed0bc728c6a0d76b6f8e56b493c019fcba12fe"

URI_aarch64_rust-threadpool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-threadpool-devel-1.8.1-15.el10_1.noarch.rpm;name=aarch64_rust-threadpool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-threadpool-devel}"
SRC_URI[aarch64_rust-threadpool-devel.sha256sum] = "c04e177fd14420cd5111c2ee9ff3bb5016ac00c7f0e518aae1a27aa5331a81b6"

RDEPENDS:rust-threadpool+default-devel = " \
 cargo \
 rust-threadpool-devel \
 "
RDEPENDS:rust-threadpool-devel = " \
 cargo \
 rust-num_cpus+default-devel \
 "
