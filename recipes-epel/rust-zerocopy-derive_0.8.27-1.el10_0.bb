# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerocopy-derive"
PV = "0.8.27"
PR = "1.el10_0"
PACKAGES = " \
 rust-zerocopy-derive+default-devel \
 rust-zerocopy-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerocopy-derive-0.8.27-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "230f0433dfc9628bade6b04a236704cd18fd71e2d6583b3b49e4f569c25b5147"

URI_x86_64_v2_rust-zerocopy-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-derive+default-devel-0.8.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy-derive+default-devel}"
SRC_URI[x86_64_v2_rust-zerocopy-derive+default-devel.sha256sum] = "7b410e8c7450ebc46f16c2d29c2fa9b9fe962fe0c664e27cf16d8086f447b503"

URI_x86_64_v2_rust-zerocopy-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-derive-devel-0.8.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy-derive-devel}"
SRC_URI[x86_64_v2_rust-zerocopy-derive-devel.sha256sum] = "8e6f9c0e444b1fb990461fdb6cd1004ff144016d7bf94eed0cc8bdba788132e1"

URI_aarch64_rust-zerocopy-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-derive+default-devel-0.8.27-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy-derive+default-devel}"
SRC_URI[aarch64_rust-zerocopy-derive+default-devel.sha256sum] = "68d3feffad3cb079b97783cc039aa79c4baf4e68376aae07be3dc6a5b27a9e73"

URI_aarch64_rust-zerocopy-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-derive-devel-0.8.27-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy-derive-devel}"
SRC_URI[aarch64_rust-zerocopy-derive-devel.sha256sum] = "9132de461859ffa3acac381da6c9897efc0ff1ae8c749a7296a76d1b224368cf"

RDEPENDS:rust-zerocopy-derive+default-devel = " \
 cargo \
 rust-zerocopy-derive-devel \
 "
RDEPENDS:rust-zerocopy-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
