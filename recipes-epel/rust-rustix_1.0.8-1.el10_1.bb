# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustix"
PV = "1.0.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-rustix+all-apis-devel \
 rust-rustix+alloc-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+io_uring-devel \
 rust-rustix+libc-devel \
 rust-rustix+libc_errno-devel \
 rust-rustix+linux_4_11-devel \
 rust-rustix+linux_5_1-devel \
 rust-rustix+linux_5_11-devel \
 rust-rustix+linux_latest-devel \
 rust-rustix+mm-devel \
 rust-rustix+mount-devel \
 rust-rustix+net-devel \
 rust-rustix+param-devel \
 rust-rustix+pipe-devel \
 rust-rustix+process-devel \
 rust-rustix+pty-devel \
 rust-rustix+rand-devel \
 rust-rustix+runtime-devel \
 rust-rustix+shm-devel \
 rust-rustix+std-devel \
 rust-rustix+stdio-devel \
 rust-rustix+system-devel \
 rust-rustix+termios-devel \
 rust-rustix+thread-devel \
 rust-rustix+time-devel \
 rust-rustix+try_close-devel \
 rust-rustix+use-explicitly-provided-auxv-devel \
 rust-rustix+use-libc-auxv-devel \
 rust-rustix+use-libc-devel \
 rust-rustix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustix-1.0.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ef64cdfa5579a735f149095b9694fdd1f6df696875fedccb1a64cf8ae3439d4"

URI_x86_64_v2_rust-rustix+all-apis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+all-apis-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+all-apis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+all-apis-devel}"
SRC_URI[x86_64_v2_rust-rustix+all-apis-devel.sha256sum] = "729120325e7cc38b541a20b587167d98b45c764884e923d31f7bca6d292422da"

URI_x86_64_v2_rust-rustix+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+alloc-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+alloc-devel}"
SRC_URI[x86_64_v2_rust-rustix+alloc-devel.sha256sum] = "37211bf20fcee6fb208456f0a954f30839d2e16c18a259ad8c790f460d9ec195"

URI_x86_64_v2_rust-rustix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+default-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+default-devel}"
SRC_URI[x86_64_v2_rust-rustix+default-devel.sha256sum] = "d19a43ff71e1160a285aaae1ab9ca3835ae6fdff0c7d1216d6882db0c91b6162"

URI_x86_64_v2_rust-rustix+event-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+event-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+event-devel}"
SRC_URI[x86_64_v2_rust-rustix+event-devel.sha256sum] = "c0adc507cc91cefb27d6f56b33fd76d1430859a93ca2befae37fb7f370207dcf"

URI_x86_64_v2_rust-rustix+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+fs-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+fs-devel}"
SRC_URI[x86_64_v2_rust-rustix+fs-devel.sha256sum] = "6600289e11d25c64435f0fcdfe55bf5d7fcfa2c09ab5fd97352910569aba07cd"

URI_x86_64_v2_rust-rustix+io_uring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+io_uring-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+io_uring-devel}"
SRC_URI[x86_64_v2_rust-rustix+io_uring-devel.sha256sum] = "c6c2b72ec6945f571c6d689d69a0ba5c46a6c871cc89445133661dc618a4fac3"

URI_x86_64_v2_rust-rustix+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+libc-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+libc-devel}"
SRC_URI[x86_64_v2_rust-rustix+libc-devel.sha256sum] = "dffcd01942b2a8c63be437b0a4b50b54331641ce7c0ea2f7f262320fc6656f62"

URI_x86_64_v2_rust-rustix+libc_errno-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+libc_errno-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+libc_errno-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+libc_errno-devel}"
SRC_URI[x86_64_v2_rust-rustix+libc_errno-devel.sha256sum] = "a6054a6893bc7245aa18c8826ea56c65c7297ef62c8f4cb14876379ef3646033"

URI_x86_64_v2_rust-rustix+linux_4_11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_4_11-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_4_11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+linux_4_11-devel}"
SRC_URI[x86_64_v2_rust-rustix+linux_4_11-devel.sha256sum] = "34596b32715073239c3095d3aa1341a16d262fda72de930c92ffdc7f6a6bf4c5"

URI_x86_64_v2_rust-rustix+linux_5_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_5_1-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_5_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+linux_5_1-devel}"
SRC_URI[x86_64_v2_rust-rustix+linux_5_1-devel.sha256sum] = "093a5e4eafe40ccf6bf351a670b0e509f678c3913504b5532f74dd474eec0933"

URI_x86_64_v2_rust-rustix+linux_5_11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_5_11-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_5_11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+linux_5_11-devel}"
SRC_URI[x86_64_v2_rust-rustix+linux_5_11-devel.sha256sum] = "4a8d40241f011be18649575515d7c8e1693b955a09f00fa5c85bfdd4655d8241"

URI_x86_64_v2_rust-rustix+linux_latest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_latest-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_latest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+linux_latest-devel}"
SRC_URI[x86_64_v2_rust-rustix+linux_latest-devel.sha256sum] = "b42414963b2bc2087ab4681e6fb3618d1d96eea8720230e649d6eba94a78de9c"

URI_x86_64_v2_rust-rustix+mm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+mm-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+mm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+mm-devel}"
SRC_URI[x86_64_v2_rust-rustix+mm-devel.sha256sum] = "d225a0d81b092aea0aeb717e819c4424b86a2852427652b2a289bdcb43c4dd01"

URI_x86_64_v2_rust-rustix+mount-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+mount-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+mount-devel}"
SRC_URI[x86_64_v2_rust-rustix+mount-devel.sha256sum] = "75488f7b51122d6aa71c626953de3c5468f6dc8799a89d9792423c8fc49141d6"

URI_x86_64_v2_rust-rustix+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+net-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+net-devel}"
SRC_URI[x86_64_v2_rust-rustix+net-devel.sha256sum] = "0237079f4ae013ae058dba7465774e141af5faae340099feb4cb6cf5a983c2e4"

URI_x86_64_v2_rust-rustix+param-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+param-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+param-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+param-devel}"
SRC_URI[x86_64_v2_rust-rustix+param-devel.sha256sum] = "2fe7b4ac69a5b4c83ad76b21772cfce6fa6cbf26caee8b1577d0a1aaca741bed"

URI_x86_64_v2_rust-rustix+pipe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+pipe-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+pipe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+pipe-devel}"
SRC_URI[x86_64_v2_rust-rustix+pipe-devel.sha256sum] = "a82359de1badc848132c0c1dd59a3d3e82c7a14755d46f80eabbdbfeafc9bb90"

URI_x86_64_v2_rust-rustix+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+process-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+process-devel}"
SRC_URI[x86_64_v2_rust-rustix+process-devel.sha256sum] = "88bca689d920d6c6c9b819e38e5301b011c3ca8931792783b42ec0c1d405a2b2"

URI_x86_64_v2_rust-rustix+pty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+pty-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+pty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+pty-devel}"
SRC_URI[x86_64_v2_rust-rustix+pty-devel.sha256sum] = "4cc09d18a23ee25e4d2638ce6703e0ddce6f087a891e4699e9a7a0a9921b3de2"

URI_x86_64_v2_rust-rustix+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+rand-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+rand-devel}"
SRC_URI[x86_64_v2_rust-rustix+rand-devel.sha256sum] = "c973bbccd3f3583d106a2a99413f5883de50f77cd5871b2acbbbc389aac29876"

URI_x86_64_v2_rust-rustix+runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+runtime-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+runtime-devel}"
SRC_URI[x86_64_v2_rust-rustix+runtime-devel.sha256sum] = "24bd5e25a18fb1812c9b08dc8770c6d801eb2c7a2fa2feb5ce9a3bd43fef7963"

URI_x86_64_v2_rust-rustix+shm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+shm-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+shm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+shm-devel}"
SRC_URI[x86_64_v2_rust-rustix+shm-devel.sha256sum] = "9f3d3608396c397486bdef5d206c979d08a064b036f5980c033448080f1581ad"

URI_x86_64_v2_rust-rustix+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+std-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+std-devel}"
SRC_URI[x86_64_v2_rust-rustix+std-devel.sha256sum] = "475fc33d8f3eb63a79c9154fe1243abbcae0bb817e60ff335909ea6079e412b3"

URI_x86_64_v2_rust-rustix+stdio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+stdio-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+stdio-devel}"
SRC_URI[x86_64_v2_rust-rustix+stdio-devel.sha256sum] = "87de9c88d00204630bdebf8f412aaa1a8a28682522b288464260a73a4018cf91"

URI_x86_64_v2_rust-rustix+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+system-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+system-devel}"
SRC_URI[x86_64_v2_rust-rustix+system-devel.sha256sum] = "5b6832b01e249b84a4aa2d0790625f69f1280e23cf97fbfba8fe689309ac41c6"

URI_x86_64_v2_rust-rustix+termios-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+termios-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+termios-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+termios-devel}"
SRC_URI[x86_64_v2_rust-rustix+termios-devel.sha256sum] = "8e288355ced2832f1bf53bc705468bb2ac60cbb0e2101f24cacc8fcc46126198"

URI_x86_64_v2_rust-rustix+thread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+thread-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+thread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+thread-devel}"
SRC_URI[x86_64_v2_rust-rustix+thread-devel.sha256sum] = "ebdc0cb10ecacfc80be0cdee37160beef63844388a1651386d9d5718670036fa"

URI_x86_64_v2_rust-rustix+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+time-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+time-devel}"
SRC_URI[x86_64_v2_rust-rustix+time-devel.sha256sum] = "976b2a1c429d09c41575e9906d0a048e9bd671fc2f61f0212b2bb24bed297dcf"

URI_x86_64_v2_rust-rustix+try_close-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+try_close-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+try_close-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+try_close-devel}"
SRC_URI[x86_64_v2_rust-rustix+try_close-devel.sha256sum] = "ca6af644972dab945e2fa81533bbafb520a0ac73536965120cc64a92d6c7ea00"

URI_x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-explicitly-provided-auxv-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel}"
SRC_URI[x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel.sha256sum] = "6e675fb78e590f4e9e35f53f9a697db5d8f4e0546bffc8c58152b7dee1b7fe6b"

URI_x86_64_v2_rust-rustix+use-libc-auxv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-libc-auxv-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-libc-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+use-libc-auxv-devel}"
SRC_URI[x86_64_v2_rust-rustix+use-libc-auxv-devel.sha256sum] = "3270b3bdd144bb31d0f69dbb68328de766a74b6c681946e06b2bc9b32437f4c6"

URI_x86_64_v2_rust-rustix+use-libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-libc-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+use-libc-devel}"
SRC_URI[x86_64_v2_rust-rustix+use-libc-devel.sha256sum] = "b112153bea139785c92df1908e0d756244570d87fb5693ad238029ba67132210"

URI_x86_64_v2_rust-rustix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix-devel-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix-devel}"
SRC_URI[x86_64_v2_rust-rustix-devel.sha256sum] = "bdf8414b26200c38f93ba196b7055fb4ea452f37103676c644b0878a0fb1564f"

URI_aarch64_rust-rustix+all-apis-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+all-apis-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+all-apis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+all-apis-devel}"
SRC_URI[aarch64_rust-rustix+all-apis-devel.sha256sum] = "b7a88732ec07f27d525975b876a33d274a6a303bb61e4b0b00a08cf4c6230100"

URI_aarch64_rust-rustix+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+alloc-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+alloc-devel}"
SRC_URI[aarch64_rust-rustix+alloc-devel.sha256sum] = "9fe2630aa69953798f8ad46b94e002d811a2987d591a5a51a0a7b6e67bcc3c87"

URI_aarch64_rust-rustix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+default-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+default-devel}"
SRC_URI[aarch64_rust-rustix+default-devel.sha256sum] = "213424499567493e9f2443a24548f75c21cc6a75dbf96cf53d45c34d79feecd4"

URI_aarch64_rust-rustix+event-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+event-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+event-devel}"
SRC_URI[aarch64_rust-rustix+event-devel.sha256sum] = "bcca5b978073dd10f1da3ad596925cdbe583ddb108a8720645405d40815036e4"

URI_aarch64_rust-rustix+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+fs-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+fs-devel}"
SRC_URI[aarch64_rust-rustix+fs-devel.sha256sum] = "3d62868066793836ba5be2650c0f38b4696b28292ec5bae026bd9f5c5bc747f9"

URI_aarch64_rust-rustix+io_uring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+io_uring-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+io_uring-devel}"
SRC_URI[aarch64_rust-rustix+io_uring-devel.sha256sum] = "ab4b901a78faae88e7f34a761ecca648a89f1dd1e9964003e93729b593cf15aa"

URI_aarch64_rust-rustix+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+libc-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+libc-devel}"
SRC_URI[aarch64_rust-rustix+libc-devel.sha256sum] = "b05399a6c2b2fa71432d0361b7c27296deb4f6d5934adfc409e2de303c3bb1e6"

URI_aarch64_rust-rustix+libc_errno-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+libc_errno-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+libc_errno-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+libc_errno-devel}"
SRC_URI[aarch64_rust-rustix+libc_errno-devel.sha256sum] = "65ee1e7f0a789eb6db96923af5d0d35d710efb7eac3cc446b039c6e88786f980"

URI_aarch64_rust-rustix+linux_4_11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_4_11-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+linux_4_11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+linux_4_11-devel}"
SRC_URI[aarch64_rust-rustix+linux_4_11-devel.sha256sum] = "7b4627289451f1a5b262b2feb33a4a742565cee528c9e493585afe7010ce0281"

URI_aarch64_rust-rustix+linux_5_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_5_1-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+linux_5_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+linux_5_1-devel}"
SRC_URI[aarch64_rust-rustix+linux_5_1-devel.sha256sum] = "96bc854e581d8f93743b58122339a06164085e5fd96a7613625ccd156424ce72"

URI_aarch64_rust-rustix+linux_5_11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_5_11-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+linux_5_11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+linux_5_11-devel}"
SRC_URI[aarch64_rust-rustix+linux_5_11-devel.sha256sum] = "37377265a1784aaeddf6828346af0a7d6bfca6c35f580451ef68c9b0a57f399c"

URI_aarch64_rust-rustix+linux_latest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_latest-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+linux_latest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+linux_latest-devel}"
SRC_URI[aarch64_rust-rustix+linux_latest-devel.sha256sum] = "e695b4f1b8fb0c1ba539db9217997b1af52353e561e263eb7ce6728b9315ce19"

URI_aarch64_rust-rustix+mm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+mm-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+mm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+mm-devel}"
SRC_URI[aarch64_rust-rustix+mm-devel.sha256sum] = "a1f863f3be19f5ca08581bac1683f30e1ec2fdd3bf18efcb8ebbf86f8140d66d"

URI_aarch64_rust-rustix+mount-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+mount-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+mount-devel}"
SRC_URI[aarch64_rust-rustix+mount-devel.sha256sum] = "6f76f00d59e39b124c3a245e09f13c416c359767980289dc5c19e5e1a814314f"

URI_aarch64_rust-rustix+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+net-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+net-devel}"
SRC_URI[aarch64_rust-rustix+net-devel.sha256sum] = "80c3ed37e179682e7da6c89fd7edf589b31a15e3fa79ff292981ab9cfa22f4c8"

URI_aarch64_rust-rustix+param-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+param-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+param-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+param-devel}"
SRC_URI[aarch64_rust-rustix+param-devel.sha256sum] = "30eb9f4dc47b42a9703636712d829c323717969368d7ccb9c833b74fa13d203d"

URI_aarch64_rust-rustix+pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+pipe-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+pipe-devel}"
SRC_URI[aarch64_rust-rustix+pipe-devel.sha256sum] = "6109377c48a58020a71e78ed95756edb8f95b6af0beaa0ff70d815ffd1dabe22"

URI_aarch64_rust-rustix+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+process-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+process-devel}"
SRC_URI[aarch64_rust-rustix+process-devel.sha256sum] = "38d972927010e0f453b9787c9aa78ddaa1ad12f9cd9fd10c35b01a72d6ae024c"

URI_aarch64_rust-rustix+pty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+pty-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+pty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+pty-devel}"
SRC_URI[aarch64_rust-rustix+pty-devel.sha256sum] = "04d1a13ab64251eaea110b2cbb60ebb04a4b2a05d0fb5394c2fbc08c904b2fb3"

URI_aarch64_rust-rustix+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+rand-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+rand-devel}"
SRC_URI[aarch64_rust-rustix+rand-devel.sha256sum] = "c67a682f91e8860d9a241219dcac484252f5a1811707d36e61f1d68aec176302"

URI_aarch64_rust-rustix+runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+runtime-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+runtime-devel}"
SRC_URI[aarch64_rust-rustix+runtime-devel.sha256sum] = "f2d48661467e9bed4f204504ac9dee91064561ab179d8e87c31196cab121c375"

URI_aarch64_rust-rustix+shm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+shm-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+shm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+shm-devel}"
SRC_URI[aarch64_rust-rustix+shm-devel.sha256sum] = "47606411f9e2d4a00b500d9681c2b13b5728ca55c965b5d3c867a81946174286"

URI_aarch64_rust-rustix+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+std-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+std-devel}"
SRC_URI[aarch64_rust-rustix+std-devel.sha256sum] = "ebdacec854d89d4abe7bf207edb3f4d178defb856fb50c0e687b285a5c3fb887"

URI_aarch64_rust-rustix+stdio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+stdio-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+stdio-devel}"
SRC_URI[aarch64_rust-rustix+stdio-devel.sha256sum] = "d95c17d833c8f8eccbecb4afd3c1d84100e9970d9f344b39cb48251b55a19e20"

URI_aarch64_rust-rustix+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+system-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+system-devel}"
SRC_URI[aarch64_rust-rustix+system-devel.sha256sum] = "576f7437987302341e8647189f7e0962d618af975c8b9e548294d9fd5861f5e1"

URI_aarch64_rust-rustix+termios-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+termios-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+termios-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+termios-devel}"
SRC_URI[aarch64_rust-rustix+termios-devel.sha256sum] = "dfdfc456b3cae8b41712bcd4729e8071d97e6affa34efb4ad8e4663529ace9b0"

URI_aarch64_rust-rustix+thread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+thread-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+thread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+thread-devel}"
SRC_URI[aarch64_rust-rustix+thread-devel.sha256sum] = "0972631bff29249d8328eebe16189f6079e506ac1dbf5585a4906785019c9184"

URI_aarch64_rust-rustix+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+time-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+time-devel}"
SRC_URI[aarch64_rust-rustix+time-devel.sha256sum] = "4b35fa3c8cbcb64da6f47d0eefe42aef89754b587bfba5ab0fe8d094b69ebb7e"

URI_aarch64_rust-rustix+try_close-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+try_close-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+try_close-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+try_close-devel}"
SRC_URI[aarch64_rust-rustix+try_close-devel.sha256sum] = "aa71b22b6dca87bdf1aea36524176680e0ed73f919b2737cd433124a8aee9425"

URI_aarch64_rust-rustix+use-explicitly-provided-auxv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-explicitly-provided-auxv-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+use-explicitly-provided-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+use-explicitly-provided-auxv-devel}"
SRC_URI[aarch64_rust-rustix+use-explicitly-provided-auxv-devel.sha256sum] = "b9769a5de6220534a43706f6c1ecaeca73e7cda84becf0dcba352caa113236f1"

URI_aarch64_rust-rustix+use-libc-auxv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-libc-auxv-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+use-libc-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+use-libc-auxv-devel}"
SRC_URI[aarch64_rust-rustix+use-libc-auxv-devel.sha256sum] = "4aac861a649093461b48d2d34f941c06ac084e387c7ebab6be8e6d8156803788"

URI_aarch64_rust-rustix+use-libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-libc-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix+use-libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+use-libc-devel}"
SRC_URI[aarch64_rust-rustix+use-libc-devel.sha256sum] = "525e98ed492560e815b37042bb59b4956d150b3383817fa34bb1c150d4e89cdc"

URI_aarch64_rust-rustix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix-devel-1.0.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix-devel}"
SRC_URI[aarch64_rust-rustix-devel.sha256sum] = "e17cb76af474764063a1b1524d985787dc4197409ef8158266310a63a295d996"

RDEPENDS:rust-rustix+all-apis-devel = " \
 cargo \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+io_uring-devel \
 rust-rustix+mm-devel \
 rust-rustix+mount-devel \
 rust-rustix+net-devel \
 rust-rustix+param-devel \
 rust-rustix+pipe-devel \
 rust-rustix+process-devel \
 rust-rustix+pty-devel \
 rust-rustix+rand-devel \
 rust-rustix+runtime-devel \
 rust-rustix+shm-devel \
 rust-rustix+stdio-devel \
 rust-rustix+system-devel \
 rust-rustix+termios-devel \
 rust-rustix+thread-devel \
 rust-rustix+time-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+alloc-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+default-devel = " \
 cargo \
 rust-rustix+std-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+event-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+fs-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+io_uring-devel = " \
 cargo \
 rust-linux-raw-sys+io_uring-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+thread-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+libc-devel = " \
 cargo \
 rust-libc-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+libc_errno-devel = " \
 cargo \
 rust-errno-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_4_11-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_5_1-devel = " \
 cargo \
 rust-rustix+linux_4_11-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_5_11-devel = " \
 cargo \
 rust-rustix+linux_5_1-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_latest-devel = " \
 cargo \
 rust-rustix+linux_5_11-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+mm-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+mount-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+net-devel = " \
 cargo \
 rust-linux-raw-sys+if_ether-devel \
 rust-linux-raw-sys+net-devel \
 rust-linux-raw-sys+netlink-devel \
 rust-linux-raw-sys+xdp-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+param-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+pipe-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+process-devel = " \
 cargo \
 rust-linux-raw-sys+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+pty-devel = " \
 cargo \
 rust-rustix+fs-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+rand-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+runtime-devel = " \
 cargo \
 rust-linux-raw-sys+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+shm-devel = " \
 cargo \
 rust-rustix+fs-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+std-devel = " \
 cargo \
 rust-bitflags+std-devel \
 rust-errno+std-devel \
 rust-errno-devel \
 rust-libc+std-devel \
 rust-libc-devel \
 rust-rustix+alloc-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+stdio-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+system-devel = " \
 cargo \
 rust-linux-raw-sys+system-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+termios-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+thread-devel = " \
 cargo \
 rust-linux-raw-sys+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+time-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+try_close-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-explicitly-provided-auxv-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-libc-auxv-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-libc-devel = " \
 cargo \
 rust-rustix+libc-devel \
 rust-rustix+libc_errno-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix-devel = " \
 cargo \
 rust \
 rust-bitflags-devel \
 rust-errno-devel \
 rust-libc-devel \
 rust-linux-raw-sys+elf-devel \
 rust-linux-raw-sys+errno-devel \
 rust-linux-raw-sys+general-devel \
 rust-linux-raw-sys+ioctl-devel \
 rust-linux-raw-sys+no_std-devel \
 rust-linux-raw-sys-devel \
 "
