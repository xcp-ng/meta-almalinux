# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam_script"
PV = "1.1.9"
PR = "19.el10_1"
PACKAGES = " \
 pam_script \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam_script-1.1.9-19.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8de49b15663b460272e4247321c9ff807d90cd24e327f22d07662c0de5e0024a"

URI_x86_64_v2_pam_script = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_script-1.1.9-19.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_script;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_script}"
SRC_URI[x86_64_v2_pam_script.sha256sum] = "40672a12d6ef24869729d8c2ad285f55c9f3a525b2470f7031a45c05855d2cc2"

URI_aarch64_pam_script = "${EPEL_MIRROR}/aarch64/Packages/p/pam_script-1.1.9-19.el10_1.aarch64.rpm;name=aarch64_pam_script;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_script}"
SRC_URI[aarch64_pam_script.sha256sum] = "3677c7a241ada3e1dae83cbbfbccfa15f76e288fc1cafa207774c8872702d9cb"

RDEPENDS:pam_script = " \
 bash \
 glibc \
 pam-libs \
 "
