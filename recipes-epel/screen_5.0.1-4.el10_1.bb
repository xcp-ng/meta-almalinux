# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "screen"
PV = "5.0.1"
PR = "4.el10_1"
PACKAGES = " \
 screen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/screen-5.0.1-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d238a5b4ae39c736d3080d318814caa81eb436405bfdd3775df173196abca96"

URI_x86_64_v2_screen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/screen-5.0.1-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_screen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_screen}"
SRC_URI[x86_64_v2_screen.sha256sum] = "9eabd4da20910f27fdb836996889d0342c71600c290d420745045b2dccf525c3"

URI_aarch64_screen = "${EPEL_MIRROR}/aarch64/Packages/s/screen-5.0.1-4.el10_1.aarch64.rpm;name=aarch64_screen;unpack=0"
SRC_URI:append = " ${URI_aarch64_screen}"
SRC_URI[aarch64_screen.sha256sum] = "38aa95e6b97d07289063115f7e5dfbe8ed03eb9d066b59d84a39123932f4af1d"

RDEPENDS:screen = " \
 glibc \
 ncurses-libs \
 pam-libs \
 "
