# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-atomic"
PV = "0.6.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-atomic+default-devel \
 rust-atomic+fallback-devel \
 rust-atomic+nightly-devel \
 rust-atomic+serde-devel \
 rust-atomic+std-devel \
 rust-atomic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-atomic-0.6.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f3bcb7c8333d21a5c0d1d6f6719de7314bc1e2a0c9ac6404eb5a8fba723cb2e"

URI_x86_64_v2_rust-atomic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic+default-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic+default-devel}"
SRC_URI[x86_64_v2_rust-atomic+default-devel.sha256sum] = "7d878813481137fec1fd85fe4ae42f382f08f6c42418120e191c6c7c4602565f"

URI_x86_64_v2_rust-atomic+fallback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic+fallback-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic+fallback-devel}"
SRC_URI[x86_64_v2_rust-atomic+fallback-devel.sha256sum] = "99e7a5d6659c2e14903a6abc37c7b192575777467da65fcf6af4128d4f1aff4c"

URI_x86_64_v2_rust-atomic+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic+nightly-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic+nightly-devel}"
SRC_URI[x86_64_v2_rust-atomic+nightly-devel.sha256sum] = "a4205467adae439ae98dfe6cef41c218f8bf796dc97e42e82d7a1c1526bed836"

URI_x86_64_v2_rust-atomic+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic+serde-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic+serde-devel}"
SRC_URI[x86_64_v2_rust-atomic+serde-devel.sha256sum] = "cad0071ca795fe13b33ed1322fd42d819045e1d4d5967118ee7a9d589cc6d9ea"

URI_x86_64_v2_rust-atomic+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic+std-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic+std-devel}"
SRC_URI[x86_64_v2_rust-atomic+std-devel.sha256sum] = "2c92ec31128c8d2779c99f38fc489a5e741242b45e837c2572a12a89db62402c"

URI_x86_64_v2_rust-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic-devel-0.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic-devel}"
SRC_URI[x86_64_v2_rust-atomic-devel.sha256sum] = "8808b5b2fb59ffb744e8f75d3bdd94a7ecf75d9f08cf077031f316c1e7a47bad"

URI_aarch64_rust-atomic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic+default-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-atomic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic+default-devel}"
SRC_URI[aarch64_rust-atomic+default-devel.sha256sum] = "18f2a67e4c768162e1afdc0b2da7c5d3e6e85e2cf1b14aa50ed80e348152189b"

URI_aarch64_rust-atomic+fallback-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic+fallback-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-atomic+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic+fallback-devel}"
SRC_URI[aarch64_rust-atomic+fallback-devel.sha256sum] = "90645069f15145b3a14bfb00134ee3a62d130ba03e81f6054d5ee12b59d78341"

URI_aarch64_rust-atomic+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic+nightly-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-atomic+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic+nightly-devel}"
SRC_URI[aarch64_rust-atomic+nightly-devel.sha256sum] = "34910d7a9d29fb7075074071b9fa112c0cb63ee1043c4107fd666c4a2905651c"

URI_aarch64_rust-atomic+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic+serde-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-atomic+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic+serde-devel}"
SRC_URI[aarch64_rust-atomic+serde-devel.sha256sum] = "765e8ca804e35ed3f36ec81ed742ee6a6e0962dc5706a0033e1b2b81e285f62e"

URI_aarch64_rust-atomic+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic+std-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-atomic+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic+std-devel}"
SRC_URI[aarch64_rust-atomic+std-devel.sha256sum] = "3f52919ecb6c12bfc8378d97f8d9f569052a95f086b9b82685b884a565a04e7d"

URI_aarch64_rust-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic-devel-0.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic-devel}"
SRC_URI[aarch64_rust-atomic-devel.sha256sum] = "a660ce3c80fa0b5f0f6f419427d49cc02d8ad439110af336ad9b1f2055ac41e2"

RDEPENDS:rust-atomic+default-devel = " \
 cargo \
 rust-atomic+fallback-devel \
 rust-atomic-devel \
 "
RDEPENDS:rust-atomic+fallback-devel = " \
 cargo \
 rust-atomic-devel \
 "
RDEPENDS:rust-atomic+nightly-devel = " \
 cargo \
 rust-atomic-devel \
 "
RDEPENDS:rust-atomic+serde-devel = " \
 cargo \
 rust-atomic-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-atomic+std-devel = " \
 cargo \
 rust-atomic-devel \
 "
RDEPENDS:rust-atomic-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 "
