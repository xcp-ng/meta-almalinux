# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-multi_json"
PV = "1.15.0"
PR = "13.el10_2"
PACKAGES = " \
 rubygem-multi_json \
 rubygem-multi_json-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-multi_json-1.15.0-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7f35e54027aea1849f1db5565a7f36fc6e2e2ebb56f12895cee056bc1ef57e1"

URI_x86_64_v2_rubygem-multi_json = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-multi_json-1.15.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-multi_json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-multi_json}"
SRC_URI[x86_64_v2_rubygem-multi_json.sha256sum] = "338754a739dbd463aaba9a5ad5e549d68e7339767146e9e45320be4096fc5bcd"

URI_x86_64_v2_rubygem-multi_json-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-multi_json-doc-1.15.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-multi_json-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-multi_json-doc}"
SRC_URI[x86_64_v2_rubygem-multi_json-doc.sha256sum] = "eb19cabc0ba6013ecbdd67d3ea2e951dacbc3c7ad10ff70e1ae230b8e92726be"

URI_aarch64_rubygem-multi_json = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-multi_json-1.15.0-13.el10_2.noarch.rpm;name=aarch64_rubygem-multi_json;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-multi_json}"
SRC_URI[aarch64_rubygem-multi_json.sha256sum] = "9372e4b68c8e900e6dc55887ea2f4d0c9641bb34d055e6624308a9154fb1379e"

URI_aarch64_rubygem-multi_json-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-multi_json-doc-1.15.0-13.el10_2.noarch.rpm;name=aarch64_rubygem-multi_json-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-multi_json-doc}"
SRC_URI[aarch64_rubygem-multi_json-doc.sha256sum] = "c5ec26df0a892ba2e785a348c82c005fd08e8b34e3e27b531ad279f6b3e8f73a"

RDEPENDS:rubygem-multi_json = " \
 rubygems \
 "
RDEPENDS:rubygem-multi_json-doc = " \
 rubygem-multi_json \
 "
