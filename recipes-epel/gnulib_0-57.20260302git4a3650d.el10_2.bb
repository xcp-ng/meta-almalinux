# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnulib"
PV = "0"
PR = "57.20260302git4a3650d.el10_2"
PACKAGES = " \
 gnulib-devel \
 gnulib-docs \
 gnulib-javaversion \
 python3-gnulib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnulib-0-57.20260302git4a3650d.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bb2bdbbf842623d8229b7780af35c5776550d279b1887bbb74edffc092573ad"

URI_x86_64_v2_gnulib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnulib-devel-0-57.20260302git4a3650d.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gnulib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnulib-devel}"
SRC_URI[x86_64_v2_gnulib-devel.sha256sum] = "a3627e1b152fc6573da9f980b3497e5c9c331ffef4c1d50e9fb393459e34c1c9"

URI_x86_64_v2_gnulib-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnulib-docs-0-57.20260302git4a3650d.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gnulib-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnulib-docs}"
SRC_URI[x86_64_v2_gnulib-docs.sha256sum] = "1ed9dcb1d7b937e45a4d7f0fdce4b487f90b6c7cdf7a1afe3ede5bb80ef9bbe1"

URI_x86_64_v2_gnulib-javaversion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnulib-javaversion-0-57.20260302git4a3650d.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnulib-javaversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnulib-javaversion}"
SRC_URI[x86_64_v2_gnulib-javaversion.sha256sum] = "4c1537eb07b7b7a5c3eb8383e9699139e5bfed0118e2dc8dedd922a949ed754f"

URI_x86_64_v2_python3-gnulib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gnulib-0-57.20260302git4a3650d.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gnulib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gnulib}"
SRC_URI[x86_64_v2_python3-gnulib.sha256sum] = "f706c0b2140f591737212e7791bb5597afea47a37e9709c783c9ea712b2b2314"

URI_aarch64_gnulib-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gnulib-devel-0-57.20260302git4a3650d.el10_2.noarch.rpm;name=aarch64_gnulib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnulib-devel}"
SRC_URI[aarch64_gnulib-devel.sha256sum] = "5e54399ecd2db3e77de85cf42f4d14e5791ffe3503bc72a53225a1779081542a"

URI_aarch64_gnulib-docs = "${EPEL_MIRROR}/aarch64/Packages/g/gnulib-docs-0-57.20260302git4a3650d.el10_2.noarch.rpm;name=aarch64_gnulib-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnulib-docs}"
SRC_URI[aarch64_gnulib-docs.sha256sum] = "2ad08f2546d71ac5d0d20e3ded4d6fb81ef5a153e53389d247e7509c57a3e811"

URI_aarch64_gnulib-javaversion = "${EPEL_MIRROR}/aarch64/Packages/g/gnulib-javaversion-0-57.20260302git4a3650d.el10_2.aarch64.rpm;name=aarch64_gnulib-javaversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnulib-javaversion}"
SRC_URI[aarch64_gnulib-javaversion.sha256sum] = "452e787c8c22cb902105c07caaab65d35a47ceeb8d7c80cd23eef1f925152cc8"

URI_aarch64_python3-gnulib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gnulib-0-57.20260302git4a3650d.el10_2.noarch.rpm;name=aarch64_python3-gnulib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gnulib}"
SRC_URI[aarch64_python3-gnulib.sha256sum] = "4566cb2320bbac05fe8761b3b8305626c6de9813716bb52b564b41cee092ee44"

RDEPENDS:gnulib-devel = " \
 autoconf \
 automake \
 bash \
 bison \
 diffutils \
 gawk \
 gcc \
 gettext-devel \
 gperf \
 grep \
 libtool \
 m4 \
 make \
 patch \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-constant \
 perl-interpreter \
 perl-libs \
 python3 \
 python3-gnulib \
 texinfo \
 virtual/coreutils \
 "
RDEPENDS:gnulib-docs = " \
 gnulib-devel \
 "
RDEPENDS:gnulib-javaversion = " \
 gnulib-devel \
 "
RDEPENDS:python3-gnulib = " \
 gnulib-devel \
 python3 \
 "
