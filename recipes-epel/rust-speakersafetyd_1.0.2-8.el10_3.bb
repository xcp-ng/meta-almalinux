# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-speakersafetyd"
PV = "1.0.2"
PR = "8.el10_3"
PACKAGES = " \
 speakersafetyd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-speakersafetyd-1.0.2-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f9cacf47a753040a2e99dd18e9d051fa7cd86a7dc3986394ac8c4e088f28aef"

URI_x86_64_v2_speakersafetyd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/speakersafetyd-1.0.2-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_speakersafetyd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_speakersafetyd}"
SRC_URI[x86_64_v2_speakersafetyd.sha256sum] = "c2bf20890b6f40e6e381f224ff8303669746de42b997120b31a7ceaa71dccb28"

URI_aarch64_speakersafetyd = "${EPEL_MIRROR}/aarch64/Packages/s/speakersafetyd-1.0.2-8.el10_3.aarch64.rpm;name=aarch64_speakersafetyd;unpack=0"
SRC_URI:append = " ${URI_aarch64_speakersafetyd}"
SRC_URI[aarch64_speakersafetyd.sha256sum] = "d16c80341b7973b9403544c1821376cef4736276bc2b84475cdac628e90dedcc"

RDEPENDS:speakersafetyd = " \
 alsa-lib \
 bash \
 glibc \
 libgcc \
 systemd-udev \
 "
