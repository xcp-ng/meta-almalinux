# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-mongodb2"
PV = "2.1.0"
PR = "1.el10_0"
PACKAGES = " \
 php-pecl-mongodb2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-mongodb2-2.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31e83bf375ef0aed065341850ee394eab118262d430714bb08cd399125480ca5"

URI_x86_64_v2_php-pecl-mongodb2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-mongodb2-2.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-mongodb2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-mongodb2}"
SRC_URI[x86_64_v2_php-pecl-mongodb2.sha256sum] = "63a4f89eb84002d5afb3d0f490193fc8b10ffca26a5fff860cdb318d83fa102e"

URI_aarch64_php-pecl-mongodb2 = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-mongodb2-2.1.0-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-mongodb2;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-mongodb2}"
SRC_URI[aarch64_php-pecl-mongodb2.sha256sum] = "6be6f43e61629e8f2ab032d008477454dda08128a1aebaf0d2ba775271d490c5"

RDEPENDS:php-pecl-mongodb2 = " \
 glibc \
 libbson \
 libmongocrypt \
 mongo-c-driver-libs \
 php-common \
 "
