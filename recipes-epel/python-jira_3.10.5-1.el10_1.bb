# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jira"
PV = "3.10.5"
PR = "1.el10_1"
PACKAGES = " \
 jirashell \
 python3-jira \
 python3-jira+async \
 python3-jira+cli \
 python3-jira+docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jira-3.10.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee183fc3d4ccfaf90b24b317d96bbd1a33d116ba15f2af374e091f44cef4ca9e"

URI_x86_64_v2_jirashell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jirashell-3.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_jirashell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jirashell}"
SRC_URI[x86_64_v2_jirashell.sha256sum] = "4996c4ad0e460cf5df85902dbd2813fa6ba96e545398b3cbf5363d07e999eadd"

URI_x86_64_v2_python3-jira = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jira-3.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jira;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jira}"
SRC_URI[x86_64_v2_python3-jira.sha256sum] = "f564d53a4db6d7575da67c9979bb1c89814fc602d353f254d322a237812576a1"

URI_x86_64_v2_python3-jira+async = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jira+async-3.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jira+async;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jira+async}"
SRC_URI[x86_64_v2_python3-jira+async.sha256sum] = "20376928323e267a05406fc1bb4df0af5bce19c55f9db2810b48ae8ed3f6f51e"

URI_x86_64_v2_python3-jira+cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jira+cli-3.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jira+cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jira+cli}"
SRC_URI[x86_64_v2_python3-jira+cli.sha256sum] = "566f2340a79d403894c22048eb56e28a204037cabac2a593af9e22b5f65d5e2e"

URI_x86_64_v2_python3-jira+docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jira+docs-3.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jira+docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jira+docs}"
SRC_URI[x86_64_v2_python3-jira+docs.sha256sum] = "6973c5500b6e70b375fde72800b53761931c0e902f84f1fd5f31088aa6eb3ee0"

URI_aarch64_jirashell = "${EPEL_MIRROR}/aarch64/Packages/j/jirashell-3.10.5-1.el10_1.noarch.rpm;name=aarch64_jirashell;unpack=0"
SRC_URI:append = " ${URI_aarch64_jirashell}"
SRC_URI[aarch64_jirashell.sha256sum] = "4f183c5d949d4d9f0f4cb7e3373004cb5fc96b50f550ba77758e145bfa10fed8"

URI_aarch64_python3-jira = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jira-3.10.5-1.el10_1.noarch.rpm;name=aarch64_python3-jira;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jira}"
SRC_URI[aarch64_python3-jira.sha256sum] = "509599233fb7eb50890ebfbf1c13c8db8c8d72113e7ee1f5fc7537d969d093b2"

URI_aarch64_python3-jira+async = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jira+async-3.10.5-1.el10_1.noarch.rpm;name=aarch64_python3-jira+async;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jira+async}"
SRC_URI[aarch64_python3-jira+async.sha256sum] = "d29bcf3d85c6b29290c5bd2770b23777ad417669bcaaa56a6cdb4b346b49fabb"

URI_aarch64_python3-jira+cli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jira+cli-3.10.5-1.el10_1.noarch.rpm;name=aarch64_python3-jira+cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jira+cli}"
SRC_URI[aarch64_python3-jira+cli.sha256sum] = "616f31f814a7ac594658121f0159dddb2277b3455fe824b96f3559836c6adcdd"

URI_aarch64_python3-jira+docs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jira+docs-3.10.5-1.el10_1.noarch.rpm;name=aarch64_python3-jira+docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jira+docs}"
SRC_URI[aarch64_python3-jira+docs.sha256sum] = "005b192269f26d50e6236c43900357fd472ca6ba206a2e010ea58ed7590353e8"

RDEPENDS:jirashell = " \
 python3 \
 python3-ipython \
 python3-jira \
 python3-keyring \
 "
RDEPENDS:python3-jira = " \
 python3 \
 python3-defusedxml \
 python3-packaging \
 python3-requests \
 python3-requests-oauthlib \
 python3-requests-toolbelt \
 python3-typing-extensions \
 "
RDEPENDS:python3-jira+async = " \
 python3 \
 python3-jira \
 python3-requests-futures \
 "
RDEPENDS:python3-jira+cli = " \
 python3 \
 python3-ipython \
 python3-jira \
 python3-keyring \
 "
RDEPENDS:python3-jira+docs = " \
 python3 \
 python3-furo \
 python3-jira \
 python3-sphinx \
 python3-sphinx-copybutton \
 "
