# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glycin-loaders"
PV = "1.0.1"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 glycin-loaders \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/glycin-loaders-1.0.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bc40b63bcc98790ecfc56bc77dd1202018029e9dcc32ca5f4ee858f21f9f8e6d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glycin-loaders-1.0.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_glycin-loaders;unpack=0"
SRC_URI[x86_64_v2_glycin-loaders.sha256sum] = "4612ff396aa06624f90072d28d69f9da40af159219e227e6922d23ba1c0379bc"

RDEPENDS:glycin-loaders = " \
 cairo \
 glib2 \
 glibc \
 libgcc \
 libxml2 \
 pango \
 "
