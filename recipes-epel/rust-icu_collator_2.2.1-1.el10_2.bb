# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_collator"
PV = "2.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_collator+compiled_data-devel \
 rust-icu_collator+datagen-devel \
 rust-icu_collator+default-devel \
 rust-icu_collator+latin1-devel \
 rust-icu_collator+serde-devel \
 rust-icu_collator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_collator-2.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c64e78c9ee555a4143fbab35cceb16061fe35d6bf7a281329333e08145f5da6"

URI_x86_64_v2_rust-icu_collator+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator+compiled_data-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_collator+compiled_data-devel.sha256sum] = "a38cb07eaaad7d523154e6b39508130ddb35e22c1d9bc95197032435e8dfa6a6"

URI_x86_64_v2_rust-icu_collator+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator+datagen-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_collator+datagen-devel.sha256sum] = "832fa604340150745d4f832adfc64bd71b19502b08b72c7e7a488fa939221f91"

URI_x86_64_v2_rust-icu_collator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator+default-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator+default-devel}"
SRC_URI[x86_64_v2_rust-icu_collator+default-devel.sha256sum] = "1345ce7f3e5480da193b23cffd972d1809c78dd4101c487a004825a8bbfdc180"

URI_x86_64_v2_rust-icu_collator+latin1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator+latin1-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator+latin1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator+latin1-devel}"
SRC_URI[x86_64_v2_rust-icu_collator+latin1-devel.sha256sum] = "a301f2b946cfd0d5b2b0bfdb43facbebeb53197ffb8203e3b96dfe192fcf812e"

URI_x86_64_v2_rust-icu_collator+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator+serde-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_collator+serde-devel.sha256sum] = "0ce4525487e2fbe053a2a1fe4048898f92db13fb6be3c7914c628d001189aebf"

URI_x86_64_v2_rust-icu_collator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator-devel}"
SRC_URI[x86_64_v2_rust-icu_collator-devel.sha256sum] = "89605721d0bb0d7334bda742eac4e5ce773e89e43ed6c3863494e21cfb70d124"

URI_aarch64_rust-icu_collator+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator+compiled_data-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_collator+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_collator+compiled_data-devel.sha256sum] = "1f403a4cc5abea39a7f446c976035db1fe745bb5faf89566c60987d92111db0e"

URI_aarch64_rust-icu_collator+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator+datagen-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_collator+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator+datagen-devel}"
SRC_URI[aarch64_rust-icu_collator+datagen-devel.sha256sum] = "c14af32ffb7c13875d41e241be46b0a999feb4e52b7edd6c5fc7f89b305e2003"

URI_aarch64_rust-icu_collator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator+default-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_collator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator+default-devel}"
SRC_URI[aarch64_rust-icu_collator+default-devel.sha256sum] = "4b158be20e4ba099c8a66a1d49214f466c8c77ce79be64adf29471ff95cb9bf1"

URI_aarch64_rust-icu_collator+latin1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator+latin1-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_collator+latin1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator+latin1-devel}"
SRC_URI[aarch64_rust-icu_collator+latin1-devel.sha256sum] = "83f602198850a8d484a6a73ce72cb95770ca3867c158ff3180b084754e5fe974"

URI_aarch64_rust-icu_collator+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator+serde-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_collator+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator+serde-devel}"
SRC_URI[aarch64_rust-icu_collator+serde-devel.sha256sum] = "0ef2cda3a34bdbc6e022498f5342a7793ad2ce91fbd10e62f905a043d2839d0f"

URI_aarch64_rust-icu_collator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_collator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator-devel}"
SRC_URI[aarch64_rust-icu_collator-devel.sha256sum] = "63d2c9d12698e9c62b74375ea1e09dbbb2c6ba3d94215b8a268a7e88b51dcf55"

RDEPENDS:rust-icu_collator+compiled_data-devel = " \
 cargo \
 rust-icu_collator-devel \
 rust-icu_collator_data-devel \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale-devel \
 rust-icu_normalizer+compiled_data-devel \
 rust-icu_provider+baked-devel \
 "
RDEPENDS:rust-icu_collator+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collator+serde-devel \
 rust-icu_collator-devel \
 rust-icu_collections+databake-devel \
 rust-icu_normalizer+datagen-devel \
 rust-icu_properties+datagen-devel \
 rust-icu_provider+export-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_collator+default-devel = " \
 cargo \
 rust-icu_collator+compiled_data-devel \
 rust-icu_collator-devel \
 "
RDEPENDS:rust-icu_collator+latin1-devel = " \
 cargo \
 rust-icu_collator-devel \
 "
RDEPENDS:rust-icu_collator+serde-devel = " \
 cargo \
 rust-icu_collator-devel \
 rust-icu_collections+serde-devel \
 rust-icu_normalizer+serde-devel \
 rust-icu_properties+serde-devel \
 rust-icu_provider+serde-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_collator-devel = " \
 cargo \
 rust \
 rust-icu_collections-devel \
 rust-icu_locale_core+alloc-devel \
 rust-icu_locale_core-devel \
 rust-icu_normalizer+utf16_iter-devel \
 rust-icu_normalizer+utf8_iter-devel \
 rust-icu_normalizer-devel \
 rust-icu_properties-devel \
 rust-icu_provider-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+union-devel \
 rust-smallvec-devel \
 rust-utf16_iter-devel \
 rust-utf8_iter-devel \
 rust-zerovec-devel \
 "
