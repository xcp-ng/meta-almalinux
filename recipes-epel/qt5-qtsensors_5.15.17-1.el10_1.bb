# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtsensors"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtsensors \
 qt5-qtsensors-devel \
 qt5-qtsensors-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtsensors-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e1a59d438bc51a91e228bdac34bb47ed87857ad96e48c4807b13cb748919316"

URI_x86_64_v2_qt5-qtsensors = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsensors-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsensors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsensors}"
SRC_URI[x86_64_v2_qt5-qtsensors.sha256sum] = "baf7aec7ecaad206257636ba13f9495aacedcfff6d977f69057a79420f7837f7"

URI_x86_64_v2_qt5-qtsensors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsensors-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsensors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsensors-devel}"
SRC_URI[x86_64_v2_qt5-qtsensors-devel.sha256sum] = "8cca8b965090173165d9ca02910926e80daeecc023b0232b3e6b4bdd0150f49c"

URI_x86_64_v2_qt5-qtsensors-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsensors-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsensors-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsensors-examples}"
SRC_URI[x86_64_v2_qt5-qtsensors-examples.sha256sum] = "c086653bf6906fb0ea4e84a7500438bca81f4f233899b10b95ed18b1bac32044"

URI_aarch64_qt5-qtsensors = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsensors-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtsensors;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsensors}"
SRC_URI[aarch64_qt5-qtsensors.sha256sum] = "c108d6a46c22216dda29123521cc72cfb5c5ccbf406862b82aec20ebd2025607"

URI_aarch64_qt5-qtsensors-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsensors-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtsensors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsensors-devel}"
SRC_URI[aarch64_qt5-qtsensors-devel.sha256sum] = "4d874bf2e0ce2f6fe254aa57f2763124c96706b714eb10d41c520be3404f2886"

URI_aarch64_qt5-qtsensors-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsensors-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtsensors-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsensors-examples}"
SRC_URI[aarch64_qt5-qtsensors-examples.sha256sum] = "bb37deaf166642ad0d1c332d72bdaa4e3d8cfab715d7031820d8526148f874d0"

RDEPENDS:qt5-qtsensors = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtsensors-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtsensors \
 "
RDEPENDS:qt5-qtsensors-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtsensors \
 "
