# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_groups"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_groups+default-devel \
 rust-uu_groups-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_groups-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53a60dc953cc83ef11a7ee436f88a7a5e947bbe994d56330620fff402ef7b93a"

URI_x86_64_v2_rust-uu_groups+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_groups+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_groups+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_groups+default-devel}"
SRC_URI[x86_64_v2_rust-uu_groups+default-devel.sha256sum] = "3fe6c926c7f8803da86f1413698244a9a01616fe18a6762a4a7e28e9ec0f2cb0"

URI_x86_64_v2_rust-uu_groups-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_groups-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_groups-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_groups-devel}"
SRC_URI[x86_64_v2_rust-uu_groups-devel.sha256sum] = "014a48f01c4c6da9e4ad0e456a4f219c628ca08f43c36fcb266d328e6e73a200"

URI_aarch64_rust-uu_groups+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_groups+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_groups+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_groups+default-devel}"
SRC_URI[aarch64_rust-uu_groups+default-devel.sha256sum] = "a2cac3c23cd91f13ef078a699e9ab74adcd2c4d70aac407be5d2dc64b4a14c49"

URI_aarch64_rust-uu_groups-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_groups-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_groups-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_groups-devel}"
SRC_URI[aarch64_rust-uu_groups-devel.sha256sum] = "c33f3e852f890e05b14bbe66dce1e090ea1796fbccfb0b50f7fe7fd5696fa2c4"

RDEPENDS:rust-uu_groups+default-devel = " \
 cargo \
 rust-uu_groups-devel \
 "
RDEPENDS:rust-uu_groups-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+process-devel \
 "
