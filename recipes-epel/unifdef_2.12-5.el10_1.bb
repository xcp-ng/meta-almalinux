# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unifdef"
PV = "2.12"
PR = "5.el10_1"
PACKAGES = " \
 unifdef \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/u/unifdef-2.12-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e75962c41ba1ddbe3b1fec51403a4bcbd6546be6edc2938335f598901057ef75"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unifdef-2.12-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unifdef;unpack=0"
SRC_URI[x86_64_v2_unifdef.sha256sum] = "f342e25f80e56324a012c8e89f67477b0597257d649929d3e1f90a06f3e81a1b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/unifdef-2.12-5.el10_1.aarch64.rpm;name=aarch64_unifdef;unpack=0"
SRC_URI[aarch64_unifdef.sha256sum] = "9ef1784e32054e8e852c4707fb1596f2eb063dfcdec5c4fb142d3400272055f3"

RDEPENDS:unifdef = " \
 bash \
 glibc \
 "
