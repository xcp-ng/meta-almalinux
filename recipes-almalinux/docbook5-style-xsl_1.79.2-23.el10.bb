# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "docbook5-style-xsl"
PV = "1.79.2"
PR = "23.el10"
PACKAGES = " \
 docbook5-style-xsl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/docbook5-style-xsl-1.79.2-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b741db87958f20a6e77313c68533ff9da4a48ab0e898f9ab9794d11854fbecf0"

URI_x86_64_v2_docbook5-style-xsl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/docbook5-style-xsl-1.79.2-23.el10.noarch.rpm;name=x86_64_v2_docbook5-style-xsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_docbook5-style-xsl}"
SRC_URI[x86_64_v2_docbook5-style-xsl.sha256sum] = "5ded3f392e3ac66f1252a8c1690c6d4bb98d7b1b53774441d46237b83c07abc7"

URI_aarch64_docbook5-style-xsl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/docbook5-style-xsl-1.79.2-23.el10.noarch.rpm;name=aarch64_docbook5-style-xsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_docbook5-style-xsl}"
SRC_URI[aarch64_docbook5-style-xsl.sha256sum] = "5ded3f392e3ac66f1252a8c1690c6d4bb98d7b1b53774441d46237b83c07abc7"

RDEPENDS:docbook5-style-xsl = " \
 bash \
 libxml2 \
 perl-interpreter \
 ruby \
 xml-common \
 "
