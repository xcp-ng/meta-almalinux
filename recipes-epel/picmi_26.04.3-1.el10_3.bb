# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "picmi"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 picmi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/picmi-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8df180785f918ba814eb05f0ba0be7e2861d70beeed16ca2e797a682fad62cff"

URI_x86_64_v2_picmi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/picmi-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_picmi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_picmi}"
SRC_URI[x86_64_v2_picmi.sha256sum] = "5f69d52a993b499a27def8264485d044013696c56e269393e0b4074046212503"

URI_aarch64_picmi = "${EPEL_MIRROR}/aarch64/Packages/p/picmi-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_picmi;unpack=0"
SRC_URI:append = " ${URI_aarch64_picmi}"
SRC_URI[aarch64_picmi.sha256sum] = "a4ea0f00dfd9ad0f4361f5f88a15d6d1637ca7ca9b7f2e1f50dd5bd9c515df11"

RDEPENDS:picmi = " \
 glibc \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
