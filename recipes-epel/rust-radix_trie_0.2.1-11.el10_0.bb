# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-radix_trie"
PV = "0.2.1"
PR = "11.el10_0"
PACKAGES = " \
 rust-radix_trie+default-devel \
 rust-radix_trie+serde-devel \
 rust-radix_trie-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-radix_trie-0.2.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "354bc761b9014848a851f2859adde648e2f557ccd32e8605c9eb05d25f8a228c"

URI_x86_64_v2_rust-radix_trie+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-radix_trie+default-devel-0.2.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-radix_trie+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-radix_trie+default-devel}"
SRC_URI[x86_64_v2_rust-radix_trie+default-devel.sha256sum] = "6d29545328b8650f122d85e79d8ddf4f6ed33f6b6770491b3c548ae1b9e178e5"

URI_x86_64_v2_rust-radix_trie+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-radix_trie+serde-devel-0.2.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-radix_trie+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-radix_trie+serde-devel}"
SRC_URI[x86_64_v2_rust-radix_trie+serde-devel.sha256sum] = "9777a38376ae393ca499f4507116641b64bcc7dc872d2d2985b8315b773322ed"

URI_x86_64_v2_rust-radix_trie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-radix_trie-devel-0.2.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-radix_trie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-radix_trie-devel}"
SRC_URI[x86_64_v2_rust-radix_trie-devel.sha256sum] = "c8b6dbbb85b05c7f9197e58ca0e1fa5d68c5cfa81e33d309ea64b50dc6c13908"

URI_aarch64_rust-radix_trie+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-radix_trie+default-devel-0.2.1-11.el10_0.noarch.rpm;name=aarch64_rust-radix_trie+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-radix_trie+default-devel}"
SRC_URI[aarch64_rust-radix_trie+default-devel.sha256sum] = "fcbe1200009368279cee2200ce132fd3fe6f7b3828cddb106efad8d5f82a79eb"

URI_aarch64_rust-radix_trie+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-radix_trie+serde-devel-0.2.1-11.el10_0.noarch.rpm;name=aarch64_rust-radix_trie+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-radix_trie+serde-devel}"
SRC_URI[aarch64_rust-radix_trie+serde-devel.sha256sum] = "10ca053335b5314d11a021620a61ab091a0e98f129b5fe29f03e4fa6e484be84"

URI_aarch64_rust-radix_trie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-radix_trie-devel-0.2.1-11.el10_0.noarch.rpm;name=aarch64_rust-radix_trie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-radix_trie-devel}"
SRC_URI[aarch64_rust-radix_trie-devel.sha256sum] = "865500ef5faf2c104e8e3cadf4dd18ed4dbefda3b60fc40a8cdbd351d36e2806"

RDEPENDS:rust-radix_trie+default-devel = " \
 cargo \
 rust-radix_trie-devel \
 "
RDEPENDS:rust-radix_trie+serde-devel = " \
 cargo \
 rust-radix_trie-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-radix_trie-devel = " \
 cargo \
 rust-endian-type+default-devel \
 rust-nibble_vec+default-devel \
 "
