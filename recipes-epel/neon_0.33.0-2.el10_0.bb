# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "neon"
PV = "0.33.0"
PR = "2.el10_0"
PACKAGES = " \
 neon \
 neon-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/neon-0.33.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9210c04c2b20c6af6d49ce9a4209f56e37af306cccd182aaaba0f834bfa4c9e7"

URI_x86_64_v2_neon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/neon-0.33.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_neon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_neon}"
SRC_URI[x86_64_v2_neon.sha256sum] = "836dd7865d092ff4ac44068d19bb45ae094860970680ec3a515cab5e525d6cda"

URI_x86_64_v2_neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/neon-devel-0.33.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_neon-devel}"
SRC_URI[x86_64_v2_neon-devel.sha256sum] = "418a11d0a12b45fc0d63cd69018c151d10e1dbce0184703e3751db03f2006985"

URI_aarch64_neon = "${EPEL_MIRROR}/aarch64/Packages/n/neon-0.33.0-2.el10_0.aarch64.rpm;name=aarch64_neon;unpack=0"
SRC_URI:append = " ${URI_aarch64_neon}"
SRC_URI[aarch64_neon.sha256sum] = "32d098bd9dac092778d38da1d46dd681d24bb8cf6f474af7df59519c31f90ef9"

URI_aarch64_neon-devel = "${EPEL_MIRROR}/aarch64/Packages/n/neon-devel-0.33.0-2.el10_0.aarch64.rpm;name=aarch64_neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_neon-devel}"
SRC_URI[aarch64_neon-devel.sha256sum] = "8fcb6540cdd6f299a062dca4cf36265369047767f7d5266a0d07dfe24b97868a"

RDEPENDS:neon = " \
 expat \
 glibc \
 krb5-libs \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:neon-devel = " \
 bash \
 expat-devel \
 neon \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
