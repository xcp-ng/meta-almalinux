# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-login-manager"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kcm-plasmalogin \
 plasma-login-manager \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-login-manager-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "eab59e5cdecd2138a7c5002c2b49e28162825b7f6cfc621790e990f00585eb4d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcm-plasmalogin-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcm-plasmalogin;unpack=0"
SRC_URI[x86_64_v2_kcm-plasmalogin.sha256sum] = "5249381ba9408f20de352bc226ecd441deba97b5fa0bbf585480f6be431f6259"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-login-manager-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-login-manager;unpack=0"
SRC_URI[x86_64_v2_plasma-login-manager.sha256sum] = "c717a935f1f3de7a6b75bfabf5b6c517bfbc99d480b6436a8c7c13590345e880"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kcm-plasmalogin-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kcm-plasmalogin;unpack=0"
SRC_URI[aarch64_kcm-plasmalogin.sha256sum] = "6039bdf5417534a217dde888853b7e5eb1c18e2d9f64195f0eb7a3b24e0f177d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-login-manager-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-login-manager;unpack=0"
SRC_URI[aarch64_plasma-login-manager.sha256sum] = "80388bf4964e3a299e88c899903acb6b83067d797c66c56400c5acddf90a0d9d"

RDEPENDS:kcm-plasmalogin = " \
 dbus-common \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kpackage \
 kf6-kservice \
 libstdc++ \
 plasma-login-manager \
 plasma-systemsettings \
 polkit \
 qt6-filesystem \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-login-manager = " \
 bash \
 glibc \
 kcm-plasmalogin \
 kde-settings-plasma \
 kf6-filesystem \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kimageformats \
 kf6-kpackage \
 kf6-kwindowsystem \
 kwin \
 layer-shell-qt \
 libXau \
 libkscreen \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 pam-libs \
 plasma-workspace-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 shadow-utils \
 systemd \
 systemd-libs \
 "
