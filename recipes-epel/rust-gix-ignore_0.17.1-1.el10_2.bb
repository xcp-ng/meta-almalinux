# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-ignore"
PV = "0.17.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-ignore+default-devel \
 rust-gix-ignore+document-features-devel \
 rust-gix-ignore+serde-devel \
 rust-gix-ignore-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-gix-ignore-0.17.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bd25cce54be3fc4790afcfdbc588472636403fbd554d74c180201da79c4115f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore+default-devel-0.17.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gix-ignore+default-devel.sha256sum] = "29497774c62fe77bd3c01cd7031f0cb0a1cca32b3930bcba010d7119c94a1684"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore+document-features-devel-0.17.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore+document-features-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gix-ignore+document-features-devel.sha256sum] = "d7791831434829b2105502b4a280f2cca09f7b52a0b91147d5689ce28a295dd5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore+serde-devel-0.17.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gix-ignore+serde-devel.sha256sum] = "a28bf5608c1ee05e58c1a24c49799432c6198d5b8aaf5c6f2d8bde498b4cef15"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore-devel-0.17.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gix-ignore-devel.sha256sum] = "65c42e507484ecf146a9ee00537e13a2eb9e221d068ecf50ce360262ea2984e8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore+default-devel-0.17.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-ignore+default-devel;unpack=0"
SRC_URI[aarch64_rust-gix-ignore+default-devel.sha256sum] = "f417bbfbb4a1320e55f51a41c9c162cb71951a465ce16ecaf93d0e457c8d9ba9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore+document-features-devel-0.17.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-ignore+document-features-devel;unpack=0"
SRC_URI[aarch64_rust-gix-ignore+document-features-devel.sha256sum] = "b71be956b9771549299dd8b0eebfd655b13193f9e66be399073a49b881a8fbd7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore+serde-devel-0.17.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-ignore+serde-devel;unpack=0"
SRC_URI[aarch64_rust-gix-ignore+serde-devel.sha256sum] = "bd31cd6244952586ad76c28cdf7b57d0d1ea3e2cbbceb3614b7da52c6a2f8f8d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore-devel-0.17.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-ignore-devel;unpack=0"
SRC_URI[aarch64_rust-gix-ignore-devel.sha256sum] = "47a729e7a9dacbc6c5899f6d03a3c578f8f630e652e161d6b444fdd930c4be98"

RDEPENDS:rust-gix-ignore+default-devel = " \
 cargo \
 rust-gix-ignore-devel \
 "
RDEPENDS:rust-gix-ignore+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-ignore-devel \
 "
RDEPENDS:rust-gix-ignore+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-glob+serde-devel \
 rust-gix-ignore-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-ignore-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-glob+default-devel \
 rust-gix-path+default-devel \
 rust-gix-trace+default-devel \
 rust-unicode-bom+default-devel \
 "
