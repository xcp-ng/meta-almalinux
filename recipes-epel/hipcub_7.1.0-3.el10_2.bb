# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipcub"
PV = "7.1.0"
PR = "3.el10_2"
PACKAGES:x86_64_v2 = " \
 hipcub-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipcub-7.1.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c509a1114de895740f019ba3a9ce3d53c4205a9db31da8d51af28ea58820045"

URI_x86_64_v2_hipcub-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipcub-devel-7.1.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipcub-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipcub-devel}"
SRC_URI[x86_64_v2_hipcub-devel.sha256sum] = "8593456884093e0efa090f4bb077d3bfe6f35e13d3d2d985fc62a97b6bd86755"

RDEPENDS:hipcub-devel = " \
 cmake-filesystem \
 rocprim-devel \
 "
