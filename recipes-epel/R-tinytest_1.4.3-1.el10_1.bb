# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-tinytest"
PV = "1.4.3"
PR = "1.el10_1"
PACKAGES = " \
 R-tinytest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-tinytest-1.4.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55bcc12970fd505cd9bb17210a96fc5b6a959aeee217c5d9070387e74906b730"

URI_x86_64_v2_R-tinytest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-tinytest-1.4.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_R-tinytest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-tinytest}"
SRC_URI[x86_64_v2_R-tinytest.sha256sum] = "e7fe25469f8c39f3b09bbe081911b5ed9a6131f7dd30e64afc2e5546d8bd9586"

URI_aarch64_R-tinytest = "${EPEL_MIRROR}/aarch64/Packages/r/R-tinytest-1.4.3-1.el10_1.noarch.rpm;name=aarch64_R-tinytest;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-tinytest}"
SRC_URI[aarch64_R-tinytest.sha256sum] = "03441942774c632e83cd142f9819a3a0317dd8d7332f52ac4143174219f04386"

RDEPENDS:R-tinytest = " \
 R-core \
 "
