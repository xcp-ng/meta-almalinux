# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-target-triple"
PV = "0.1.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-target-triple+default-devel \
 rust-target-triple-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-target-triple-0.1.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25b5cc0a9a138a1e692d6167d0ae0ebe154d666d351216cdb7ac54d19fdcbf1c"

URI_x86_64_v2_rust-target-triple+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-triple+default-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-triple+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-triple+default-devel}"
SRC_URI[x86_64_v2_rust-target-triple+default-devel.sha256sum] = "109038b536392862660e3549e11b1130ca0acafe075b5525e18b1580cfa9d4bf"

URI_x86_64_v2_rust-target-triple-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-triple-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-triple-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-triple-devel}"
SRC_URI[x86_64_v2_rust-target-triple-devel.sha256sum] = "cd988f3c1791dbbc450eb88cbb0e509f6b1814c854f29b2f1edf90ea0a656f00"

URI_aarch64_rust-target-triple+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-triple+default-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-target-triple+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-triple+default-devel}"
SRC_URI[aarch64_rust-target-triple+default-devel.sha256sum] = "33bbdb4c08c19944ca6307dcb7e3d9b706838e55c1429816b40b6c8a69cd7a1f"

URI_aarch64_rust-target-triple-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-triple-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-target-triple-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-triple-devel}"
SRC_URI[aarch64_rust-target-triple-devel.sha256sum] = "b5af0840787b663af8548f681358c6026485c13f72afce67aaa16f6ec57554b5"

RDEPENDS:rust-target-triple+default-devel = " \
 cargo \
 rust-target-triple-devel \
 "
RDEPENDS:rust-target-triple-devel = " \
 cargo \
 rust \
 "
