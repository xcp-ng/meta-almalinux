# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-tools"
PV = "1.4.313.0"
PR = "1.el10"
PACKAGES = " \
 vulkan-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-tools-1.4.313.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bb95b22f4f9cfb0433aefc4db5f4c45b9fd2a7a8f9b7fafa1f7f2c3f94f86ae"

URI_x86_64_v2_vulkan-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-tools-1.4.313.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-tools}"
SRC_URI[x86_64_v2_vulkan-tools.sha256sum] = "42a7fc0ce3b2f71d3af9e6d603c2308e513aa3be6e33054f83c2cec34afa2dcb"

URI_aarch64_vulkan-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-tools-1.4.313.0-1.el10.aarch64.rpm;name=aarch64_vulkan-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-tools}"
SRC_URI[aarch64_vulkan-tools.sha256sum] = "72d88dcdf8f25a0b1df8da412dc172ee445f5a48103bba0e49e8dca0bee0ef9a"

RDEPENDS:vulkan-tools = " \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 "
