# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-iproute"
PV = "1.7.14"
PR = "1.el10_0"
PACKAGES = " \
 ghc-iproute \
 ghc-iproute-devel \
 ghc-iproute-doc \
 ghc-iproute-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-iproute-1.7.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3a7f2d865bf94d38c8c9a6dd254a1f66518afbb62ecc27f519d2de2c5136748"

URI_x86_64_v2_ghc-iproute = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-iproute-1.7.14-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-iproute;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-iproute}"
SRC_URI[x86_64_v2_ghc-iproute.sha256sum] = "0c1d2fe4e92351f52afcce867a007abb3785416af602ec615bbce91a5a739c79"

URI_x86_64_v2_ghc-iproute-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-iproute-devel-1.7.14-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-iproute-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-iproute-devel}"
SRC_URI[x86_64_v2_ghc-iproute-devel.sha256sum] = "6075acd391482ffd434b852fa41b836c514316051a7c063ae95cc452c1cc2267"

URI_x86_64_v2_ghc-iproute-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-iproute-doc-1.7.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-iproute-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-iproute-doc}"
SRC_URI[x86_64_v2_ghc-iproute-doc.sha256sum] = "496ddf8680cf18c9346023b568fbe6c763cfcbac83fb208660c281678721dd30"

URI_x86_64_v2_ghc-iproute-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-iproute-prof-1.7.14-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-iproute-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-iproute-prof}"
SRC_URI[x86_64_v2_ghc-iproute-prof.sha256sum] = "6e642e05d03d04d3c663659597cd8c438c8ed6fd66296537680b0bb7a1918272"

URI_aarch64_ghc-iproute = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-iproute-1.7.14-1.el10_0.aarch64.rpm;name=aarch64_ghc-iproute;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-iproute}"
SRC_URI[aarch64_ghc-iproute.sha256sum] = "515c1ce9c6098226b9004523e416f366b84937400ca766e87156a83f5a42b088"

URI_aarch64_ghc-iproute-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-iproute-devel-1.7.14-1.el10_0.aarch64.rpm;name=aarch64_ghc-iproute-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-iproute-devel}"
SRC_URI[aarch64_ghc-iproute-devel.sha256sum] = "a18a987ec38de75be1b828ed7726a8e478def8ff716b883804c5b2fe26787dea"

URI_aarch64_ghc-iproute-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-iproute-doc-1.7.14-1.el10_0.noarch.rpm;name=aarch64_ghc-iproute-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-iproute-doc}"
SRC_URI[aarch64_ghc-iproute-doc.sha256sum] = "508ebbf6eb1187c219d84e0a1f7678505a6362b9379709f2a70d5db3707f853a"

URI_aarch64_ghc-iproute-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-iproute-prof-1.7.14-1.el10_0.aarch64.rpm;name=aarch64_ghc-iproute-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-iproute-prof}"
SRC_URI[aarch64_ghc-iproute-prof.sha256sum] = "5242cc63d65237a9f2bb8dd92d804ba3559a5c67f556ab790138b82520316d6a"

RDEPENDS:ghc-iproute = " \
 ghc-appar \
 ghc-array \
 ghc-base \
 ghc-byteorder \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-network \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-iproute-devel = " \
 ghc-appar-devel \
 ghc-base-devel \
 ghc-byteorder-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-iproute \
 ghc-network-devel \
 "
RDEPENDS:ghc-iproute-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-iproute-prof = " \
 ghc-appar-prof \
 ghc-base-prof \
 ghc-byteorder-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-iproute-devel \
 ghc-network-prof \
 "
