# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-attributes"
PV = "0.1.30"
PR = "1.el10_0"
PACKAGES = " \
 rust-tracing-attributes+async-await-devel \
 rust-tracing-attributes+default-devel \
 rust-tracing-attributes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-attributes-0.1.30-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5ba5d842f611510f13da7caeaa62b344ae1b595d2155c538273c05225b27d76"

URI_x86_64_v2_rust-tracing-attributes+async-await-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-attributes+async-await-devel-0.1.30-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-attributes+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-attributes+async-await-devel}"
SRC_URI[x86_64_v2_rust-tracing-attributes+async-await-devel.sha256sum] = "051ca6b37ca6e8fa041db9791a7d91ed7481f98c62b9d63423873d26cf2dff64"

URI_x86_64_v2_rust-tracing-attributes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-attributes+default-devel-0.1.30-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-attributes+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-attributes+default-devel.sha256sum] = "b02a87cd3b5acf05592a3c3951ca1826e3471c770bca47e606b116793fe214a6"

URI_x86_64_v2_rust-tracing-attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-attributes-devel-0.1.30-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-attributes-devel}"
SRC_URI[x86_64_v2_rust-tracing-attributes-devel.sha256sum] = "2a16d8c947a6258e996a61f1d7561c61f40c669063beee3872c00220cc4e8639"

URI_aarch64_rust-tracing-attributes+async-await-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-attributes+async-await-devel-0.1.30-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-attributes+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-attributes+async-await-devel}"
SRC_URI[aarch64_rust-tracing-attributes+async-await-devel.sha256sum] = "5b7fd416abedffbe33821eb534062caed1661876a16b520344ca13d9ef879f27"

URI_aarch64_rust-tracing-attributes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-attributes+default-devel-0.1.30-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-attributes+default-devel}"
SRC_URI[aarch64_rust-tracing-attributes+default-devel.sha256sum] = "d39a7e56618748d5421ee488c1f4f950b28988f94f995b84539455703a793d0a"

URI_aarch64_rust-tracing-attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-attributes-devel-0.1.30-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-attributes-devel}"
SRC_URI[aarch64_rust-tracing-attributes-devel.sha256sum] = "f4bb0bd970c4e9ddcc3396296da09fcdc5855ff8b531446a043ea32c8198a263"

RDEPENDS:rust-tracing-attributes+async-await-devel = " \
 cargo \
 rust-tracing-attributes-devel \
 "
RDEPENDS:rust-tracing-attributes+default-devel = " \
 cargo \
 rust-tracing-attributes-devel \
 "
RDEPENDS:rust-tracing-attributes-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "
