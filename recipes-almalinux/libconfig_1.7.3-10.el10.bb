# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libconfig"
PV = "1.7.3"
PR = "10.el10"
PACKAGES = " \
 libconfig \
 libconfig-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libconfig-1.7.3-10.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "13b829ca635604b51afebd889d3431ca5258882ff68998d6d29528687c7ee220"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libconfig-1.7.3-10.el10.x86_64_v2.rpm;name=x86_64_v2_libconfig;unpack=0"
SRC_URI[x86_64_v2_libconfig.sha256sum] = "1cde43f4f490fe36a3036444e58e3f22d7b9fdcbf6564ca2201811d51cc23e7a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libconfig-devel-1.7.3-10.el10.x86_64_v2.rpm;name=x86_64_v2_libconfig-devel;unpack=0"
SRC_URI[x86_64_v2_libconfig-devel.sha256sum] = "31e158b85e5043dcd2bac93a37717e4fd734b34a45b5b8020aeba372429db399"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libconfig-1.7.3-10.el10.aarch64.rpm;name=aarch64_libconfig;unpack=0"
SRC_URI[aarch64_libconfig.sha256sum] = "86f7976ead40da2cafbd8235bdbd155722954ec4fbb1dbf2974a35f4b92392ef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libconfig-devel-1.7.3-10.el10.aarch64.rpm;name=aarch64_libconfig-devel;unpack=0"
SRC_URI[aarch64_libconfig-devel.sha256sum] = "e6764129d3e3979ce26146d6883703556e8fed6ea88296ba4ae2b95b8f7952f4"

RDEPENDS:libconfig = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libconfig-devel = " \
 libconfig \
 pkgconf-pkg-config \
 "
