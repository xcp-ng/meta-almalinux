# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mutter"
PV = "49.4"
PR = "4.el10_2"
PACKAGES = " \
 mutter \
 mutter-common \
 mutter-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mutter-49.4-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27befec1033f043f70a939009c206ae83922508d4993d931137b474086ea8299"

URI_x86_64_v2_mutter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mutter-49.4-4.el10_2.x86_64_v2.rpm;name=x86_64_v2_mutter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mutter}"
SRC_URI[x86_64_v2_mutter.sha256sum] = "844aa3fd8c19cfb2cc3ae8a2b8fff6aeb6777a6fe7289534813dad043e6383ba"
RPROVIDES:mutter:x86_64_v2 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_x86_64_v2_mutter-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mutter-common-49.4-4.el10_2.noarch.rpm;name=x86_64_v2_mutter-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mutter-common}"
SRC_URI[x86_64_v2_mutter-common.sha256sum] = "492d71a14c7e7c30d36394e56ed740743e899cb3242450738e6f0325ccae1dbd"

URI_x86_64_v2_mutter-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mutter-devel-49.4-4.el10_2.x86_64_v2.rpm;name=x86_64_v2_mutter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mutter-devel}"
SRC_URI[x86_64_v2_mutter-devel.sha256sum] = "0058bfe96c3bbba3d71def361c37bb1ec880a3eea5a28dcf2deb5ddc994a040d"

URI_aarch64_mutter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mutter-49.4-4.el10_2.aarch64.rpm;name=aarch64_mutter;unpack=0"
SRC_URI:append = " ${URI_aarch64_mutter}"
SRC_URI[aarch64_mutter.sha256sum] = "5ceb9a11d2ee383c9c2ee548d43d9b5c7f77123653c3e38901c1e6a8a4de888b"
RPROVIDES:mutter:aarch64 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_aarch64_mutter-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mutter-common-49.4-4.el10_2.noarch.rpm;name=aarch64_mutter-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_mutter-common}"
SRC_URI[aarch64_mutter-common.sha256sum] = "492d71a14c7e7c30d36394e56ed740743e899cb3242450738e6f0325ccae1dbd"

URI_aarch64_mutter-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mutter-devel-49.4-4.el10_2.aarch64.rpm;name=aarch64_mutter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mutter-devel}"
SRC_URI[aarch64_mutter-devel.sha256sum] = "1a08b7bf1de3e3dfb45efc1206672601709d68acefd4f010ec1212b84e98015c"

RDEPENDS:mutter = " \
 atk \
 cairo \
 colord-libs \
 dbus \
 fribidi \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-control-center-filesystem \
 gnome-desktop4 \
 gnome-settings-daemon \
 graphene \
 gsettings-desktop-schemas \
 gtk4 \
 harfbuzz \
 lcms2 \
 libX11 \
 libX11-xcb \
 libXau \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libXtst \
 libcanberra \
 libdisplay-info \
 libdrm \
 libeis \
 libgcc \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 libgudev \
 libinput \
 libwacom \
 libwayland-server \
 libxcb \
 libxkbcommon \
 libxkbcommon-x11 \
 libxkbfile \
 mesa-libgbm \
 mutter-common \
 pango \
 pipewire \
 pipewire-libs \
 pixman \
 python3 \
 python3-argcomplete \
 startup-notification \
 systemd-libs \
 "
RDEPENDS:mutter-common = " \
 "
RDEPENDS:mutter-devel = " \
 atk-devel \
 cairo \
 cairo-devel \
 colord-devel \
 fribidi-devel \
 gdk-pixbuf2-devel \
 glib2 \
 glib2-devel \
 glibc \
 gnome-desktop4-devel \
 gnome-settings-daemon-devel \
 gobject-introspection-devel \
 graphene-devel \
 gsettings-desktop-schemas-devel \
 gtk4 \
 harfbuzz-devel \
 lcms2-devel \
 libX11-devel \
 libXau-devel \
 libXcomposite-devel \
 libXcursor-devel \
 libXdamage-devel \
 libXext \
 libXext-devel \
 libXfixes-devel \
 libXi-devel \
 libXinerama-devel \
 libXrandr-devel \
 libXtst-devel \
 libadwaita \
 libcanberra-devel \
 libdisplay-info-devel \
 libdrm-devel \
 libei \
 libeis-devel \
 libevdev \
 libgcc \
 libglvnd-devel \
 libglvnd-gles \
 libgudev \
 libgudev-devel \
 libinput-devel \
 libwacom-devel \
 libwayland-client \
 libxcb \
 libxcb-devel \
 libxkbcommon-devel \
 libxkbcommon-x11-devel \
 libxkbfile-devel \
 mesa-libEGL-devel \
 mesa-libgbm-devel \
 mutter \
 mutter-devel \
 pango-devel \
 pipewire-devel \
 pipewire-libs \
 pixman-devel \
 pkgconf-pkg-config \
 startup-notification-devel \
 sysprof-capture-devel \
 systemd-devel \
 wayland-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

PROVIDES:append:aarch64 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"
