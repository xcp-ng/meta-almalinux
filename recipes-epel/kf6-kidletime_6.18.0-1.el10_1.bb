# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kidletime"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kidletime \
 kf6-kidletime-devel \
 kf6-kidletime-doc \
 kf6-kidletime-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kidletime-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b06632d2eac61727ee1d683b879847185b035ba482a6a51c014ec62e009be3be"

URI_x86_64_v2_kf6-kidletime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kidletime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kidletime}"
SRC_URI[x86_64_v2_kf6-kidletime.sha256sum] = "41286a52e0ee6d93477d33d540e82964458b063d5b4f3431f465a5e3b1551ad8"

URI_x86_64_v2_kf6-kidletime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kidletime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kidletime-devel}"
SRC_URI[x86_64_v2_kf6-kidletime-devel.sha256sum] = "8f707d8d4e0615426b1029e823225b17845c8ebccff5072747587485d60861e1"

URI_x86_64_v2_kf6-kidletime-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kidletime-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kidletime-doc}"
SRC_URI[x86_64_v2_kf6-kidletime-doc.sha256sum] = "97ead7a4c1f293aa5b41e7c955eede6c94fcf9cf9c2bb637f7a7603ea93b1052"

URI_x86_64_v2_kf6-kidletime-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kidletime-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kidletime-html}"
SRC_URI[x86_64_v2_kf6-kidletime-html.sha256sum] = "44b5341094237dbc990d01d7ef3597200e0f892c673f1c75f6976c9ffca07a3a"

URI_aarch64_kf6-kidletime = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kidletime;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kidletime}"
SRC_URI[aarch64_kf6-kidletime.sha256sum] = "4707b752799ce757d5e50a49fd84f746257396ab19961fea7b919bb7de47261c"

URI_aarch64_kf6-kidletime-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kidletime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kidletime-devel}"
SRC_URI[aarch64_kf6-kidletime-devel.sha256sum] = "b8826bd4dd8e368fbbdfad8a2c4c41fe279dd6e72c4a456ad79daf76ccf6a31f"

URI_aarch64_kf6-kidletime-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kidletime-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kidletime-doc}"
SRC_URI[aarch64_kf6-kidletime-doc.sha256sum] = "846d0cd2727c1011b423cb8d34dd489368fa75ef498d71083bf9e4bbb78aa9aa"

URI_aarch64_kf6-kidletime-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kidletime-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kidletime-html}"
SRC_URI[aarch64_kf6-kidletime-html.sha256sum] = "aee80214a8d5669a9921c9ac29b8c76f0907c39244f45a2d63673a52ab9a1f89"

RDEPENDS:kf6-kidletime = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwayland \
 "
RDEPENDS:kf6-kidletime-devel = " \
 cmake-filesystem \
 kf6-kidletime \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kidletime-doc = " \
 "
RDEPENDS:kf6-kidletime-html = " \
 "
