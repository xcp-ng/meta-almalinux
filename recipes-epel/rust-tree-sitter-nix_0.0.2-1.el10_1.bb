# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-nix"
PV = "0.0.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-nix+default-devel \
 rust-tree-sitter-nix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-nix-0.0.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "522f5b7947bdb917fa26d8e9f709dd1a48b03c7b9b2ed7c1d2710a14dea0f376"

URI_x86_64_v2_rust-tree-sitter-nix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-nix+default-devel-0.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-nix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-nix+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-nix+default-devel.sha256sum] = "ddf22bdd4a6e6f914ccb41c1e65696c3b7b3dfa52780782d92d3d19bcd31ac02"

URI_x86_64_v2_rust-tree-sitter-nix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-nix-devel-0.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-nix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-nix-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-nix-devel.sha256sum] = "866d489f03e9895a906cc69b8dd264144da04faaab8d48fc804a485b6b8ce614"

URI_aarch64_rust-tree-sitter-nix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-nix+default-devel-0.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-nix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-nix+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-nix+default-devel.sha256sum] = "0482c3970b051e9941e6a486a4829f9cb671a4ae60cf8c777d3ec565fc949ac1"

URI_aarch64_rust-tree-sitter-nix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-nix-devel-0.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-nix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-nix-devel}"
SRC_URI[aarch64_rust-tree-sitter-nix-devel.sha256sum] = "7e1f04eb40912bcb7e543ffa18b9880eec735ff322bb3d85d54dc12e30b5983b"

RDEPENDS:rust-tree-sitter-nix+default-devel = " \
 cargo \
 rust-tree-sitter-nix-devel \
 "
RDEPENDS:rust-tree-sitter-nix-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
