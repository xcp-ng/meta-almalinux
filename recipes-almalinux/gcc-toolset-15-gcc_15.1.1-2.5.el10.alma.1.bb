# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc-toolset-15-gcc"
PV = "15.1.1"
PR = "2.5.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 gcc-toolset-15-gcc \
 gcc-toolset-15-gcc-c++ \
 gcc-toolset-15-gcc-gfortran \
 gcc-toolset-15-gcc-plugin-annobin \
 gcc-toolset-15-gcc-plugin-devel \
 gcc-toolset-15-libasan-devel \
 gcc-toolset-15-libatomic-devel \
 gcc-toolset-15-libgccjit \
 gcc-toolset-15-libgccjit-devel \
 gcc-toolset-15-libitm-devel \
 gcc-toolset-15-liblsan-devel \
 gcc-toolset-15-libquadmath-devel \
 gcc-toolset-15-libstdc++-devel \
 gcc-toolset-15-libstdc++-docs \
 gcc-toolset-15-libtsan-devel \
 gcc-toolset-15-libubsan-devel \
 gcc-toolset-15-offload-nvptx \
"
PACKAGES:aarch64 = " \
 gcc-toolset-15-gcc \
 gcc-toolset-15-gcc-c++ \
 gcc-toolset-15-gcc-gfortran \
 gcc-toolset-15-gcc-plugin-annobin \
 gcc-toolset-15-gcc-plugin-devel \
 gcc-toolset-15-libasan-devel \
 gcc-toolset-15-libatomic-devel \
 gcc-toolset-15-libgccjit \
 gcc-toolset-15-libgccjit-devel \
 gcc-toolset-15-libitm-devel \
 gcc-toolset-15-liblsan-devel \
 gcc-toolset-15-libstdc++-devel \
 gcc-toolset-15-libstdc++-docs \
 gcc-toolset-15-libtsan-devel \
 gcc-toolset-15-libubsan-devel \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gcc-toolset-15-gcc-15.1.1-2.5.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b55eabebfe687584428c670c830bfa14d0092c769e20b33082711fc3121dbc4"

URI_x86_64_v2_gcc-toolset-15-gcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-gcc-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-gcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-gcc}"
SRC_URI[x86_64_v2_gcc-toolset-15-gcc.sha256sum] = "a112d814ecf6091966b953681b1500aa98a7bc2e6e6659697e738078ba630256"

URI_x86_64_v2_gcc-toolset-15-gcc-c++ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-gcc-c++-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-gcc-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-gcc-c++}"
SRC_URI[x86_64_v2_gcc-toolset-15-gcc-c++.sha256sum] = "20a7ced5d52278aca509805a3b4ab2c940ef3e1c4bfbc6ebc71c2c6a1df73998"

URI_x86_64_v2_gcc-toolset-15-gcc-gfortran = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-gcc-gfortran-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-gcc-gfortran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-gcc-gfortran}"
SRC_URI[x86_64_v2_gcc-toolset-15-gcc-gfortran.sha256sum] = "6c354bafaf9a20fdfcea73eb96393466ff9c89bf1372e50bcc92a4bfb0679846"

URI_x86_64_v2_gcc-toolset-15-gcc-plugin-annobin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-gcc-plugin-annobin-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-gcc-plugin-annobin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-gcc-plugin-annobin}"
SRC_URI[x86_64_v2_gcc-toolset-15-gcc-plugin-annobin.sha256sum] = "1a08bca5dfd420002740e7a67861c9daa4ad2bd5b9e9ead3343768404312e33d"

URI_x86_64_v2_gcc-toolset-15-gcc-plugin-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-gcc-plugin-devel-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-gcc-plugin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-gcc-plugin-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-gcc-plugin-devel.sha256sum] = "9683afe633d3d0828e0ad415e002d3f6bc9136da400cf413630764e526fc19ad"

URI_x86_64_v2_gcc-toolset-15-libasan-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libasan-devel-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libasan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libasan-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libasan-devel.sha256sum] = "51a36858cf7d5d2c91e51b971afef73a261200ff0c639553b7f11809b317ec1f"

URI_x86_64_v2_gcc-toolset-15-libatomic-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libatomic-devel-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libatomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libatomic-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libatomic-devel.sha256sum] = "dc5015febeeac4d6824bcf714158fe03ff303ef12b24abb0638092da49e72509"

URI_x86_64_v2_gcc-toolset-15-libgccjit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libgccjit-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libgccjit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libgccjit}"
SRC_URI[x86_64_v2_gcc-toolset-15-libgccjit.sha256sum] = "cb2b8f007d6e8785953900531b95722e774555dc4988b49226ba0d636b6bb18f"
RPROVIDES:gcc-toolset-15-libgccjit:append:x86_64_v2 = " virtual/libgccjit.so.0___64bit_"

URI_x86_64_v2_gcc-toolset-15-libgccjit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libgccjit-devel-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libgccjit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libgccjit-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libgccjit-devel.sha256sum] = "9701c0378fd4943a4dc1ed21418b93d332f73f02096074a43093c54ea4c638f4"

URI_x86_64_v2_gcc-toolset-15-libitm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libitm-devel-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libitm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libitm-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libitm-devel.sha256sum] = "108335ba9d5874568f949107e8e57dc6742099a5f3c67afe5c01d9cc7b3030ef"

URI_x86_64_v2_gcc-toolset-15-liblsan-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-liblsan-devel-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-liblsan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-liblsan-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-liblsan-devel.sha256sum] = "27b5c48e5d46eeac7ed98947af1bc63dccbdd5601bd6a9c4ff80f78cf2a80627"

URI_x86_64_v2_gcc-toolset-15-libquadmath-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libquadmath-devel-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libquadmath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libquadmath-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libquadmath-devel.sha256sum] = "b8228da79a20c558c83c65c8998b16752293db8d5fdaca7cbf5df21fe3b6783a"

URI_x86_64_v2_gcc-toolset-15-libstdc++-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libstdc++-devel-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libstdc++-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libstdc++-devel.sha256sum] = "20f5de47b734a8d704ad6b3a83b6efa18ffda3a0fb6a1694ec6dbdb10e2e4563"

URI_x86_64_v2_gcc-toolset-15-libstdc++-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libstdc++-docs-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libstdc++-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libstdc++-docs}"
SRC_URI[x86_64_v2_gcc-toolset-15-libstdc++-docs.sha256sum] = "68ea55217c919721279a413599bfb74f4724be5c8cd3a1d53b47991c593fab6f"

URI_x86_64_v2_gcc-toolset-15-libtsan-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libtsan-devel-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libtsan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libtsan-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libtsan-devel.sha256sum] = "22878a105167202f88d7d8c19f43069d73bc2b52fbb8911af336cf6eaeb6b82c"

URI_x86_64_v2_gcc-toolset-15-libubsan-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libubsan-devel-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libubsan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libubsan-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libubsan-devel.sha256sum] = "833dc5d259ab9831209c7515202a3858098a524b402d31b8915def0c3811b79a"

URI_x86_64_v2_gcc-toolset-15-offload-nvptx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-offload-nvptx-15.1.1-2.5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-offload-nvptx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-offload-nvptx}"
SRC_URI[x86_64_v2_gcc-toolset-15-offload-nvptx.sha256sum] = "2dbdc83ba66fa88505c2048a169c58322eb83662211b8a472e34c4f702e99ce8"

URI_aarch64_gcc-toolset-15-gcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-gcc-15.1.1-2.5.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-gcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-gcc}"
SRC_URI[aarch64_gcc-toolset-15-gcc.sha256sum] = "e3f48b7803cc3a72381d75e97f30015c1c896b0ae677057a8a4832d4d22bfa6a"

URI_aarch64_gcc-toolset-15-gcc-c++ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-gcc-c++-15.1.1-2.5.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-gcc-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-gcc-c++}"
SRC_URI[aarch64_gcc-toolset-15-gcc-c++.sha256sum] = "ae3ae3c990f9924dab71b8cf9ff724796ef0e2307a1c586360f8b941650b471f"

URI_aarch64_gcc-toolset-15-gcc-gfortran = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-gcc-gfortran-15.1.1-2.5.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-gcc-gfortran;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-gcc-gfortran}"
SRC_URI[aarch64_gcc-toolset-15-gcc-gfortran.sha256sum] = "18c37fef56864aabfd4fee5c1e1d18c105b772cf4f5f80a733901a55ca48450d"

URI_aarch64_gcc-toolset-15-gcc-plugin-annobin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-gcc-plugin-annobin-15.1.1-2.5.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-gcc-plugin-annobin;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-gcc-plugin-annobin}"
SRC_URI[aarch64_gcc-toolset-15-gcc-plugin-annobin.sha256sum] = "2dc8d86dcd31da474f5a25eb5ddd44bffe363922983c048936d30a3dca8337f7"

URI_aarch64_gcc-toolset-15-gcc-plugin-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-gcc-plugin-devel-15.1.1-2.5.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-gcc-plugin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-gcc-plugin-devel}"
SRC_URI[aarch64_gcc-toolset-15-gcc-plugin-devel.sha256sum] = "30ae23824700ff4518ecf0b8f168e8dac18033ce172198c122c6ddb76e87dd7d"

URI_aarch64_gcc-toolset-15-libasan-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libasan-devel-15.1.1-2.5.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libasan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libasan-devel}"
SRC_URI[aarch64_gcc-toolset-15-libasan-devel.sha256sum] = "df681e15ba1cb70ecfc6a497bc508418df6933fc9005fee4b1c0684febb4a349"

URI_aarch64_gcc-toolset-15-libatomic-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libatomic-devel-15.1.1-2.5.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libatomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libatomic-devel}"
SRC_URI[aarch64_gcc-toolset-15-libatomic-devel.sha256sum] = "ef2aa990d37282a373efcda9300f08a312962f55a0c3f8ed873bcd64e7b27361"

URI_aarch64_gcc-toolset-15-libgccjit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libgccjit-15.1.1-2.5.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libgccjit;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libgccjit}"
SRC_URI[aarch64_gcc-toolset-15-libgccjit.sha256sum] = "4c9bdaa6440b5b5b41d8fd1ca05c94bf7c97ad5bf0179a24fc5efe2d4e7d7efb"
RPROVIDES:gcc-toolset-15-libgccjit:append:aarch64 = " virtual/libgccjit.so.0___64bit_"

URI_aarch64_gcc-toolset-15-libgccjit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libgccjit-devel-15.1.1-2.5.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libgccjit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libgccjit-devel}"
SRC_URI[aarch64_gcc-toolset-15-libgccjit-devel.sha256sum] = "cadd078e6dd6a2cc286cee6a3b3c529982e9b8a7ad8d098c232b987203d614cf"

URI_aarch64_gcc-toolset-15-libitm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libitm-devel-15.1.1-2.5.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libitm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libitm-devel}"
SRC_URI[aarch64_gcc-toolset-15-libitm-devel.sha256sum] = "589d78df63f22f1b08478da5191fc684a37918b99e8ce3be44f60712cc6194bf"

URI_aarch64_gcc-toolset-15-liblsan-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-liblsan-devel-15.1.1-2.5.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-liblsan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-liblsan-devel}"
SRC_URI[aarch64_gcc-toolset-15-liblsan-devel.sha256sum] = "6b9102f56ab136492a2346e0ceb08769cd6de76e3e1340c2ec219585031b172b"

URI_aarch64_gcc-toolset-15-libstdc++-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libstdc++-devel-15.1.1-2.5.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libstdc++-devel}"
SRC_URI[aarch64_gcc-toolset-15-libstdc++-devel.sha256sum] = "ef970f63bf6ee8338d9906809dbe516a0226a4afb8ade4cf7f4395872efbd31b"

URI_aarch64_gcc-toolset-15-libstdc++-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libstdc++-docs-15.1.1-2.5.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libstdc++-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libstdc++-docs}"
SRC_URI[aarch64_gcc-toolset-15-libstdc++-docs.sha256sum] = "6c0c295ffff5b3064d1ef68697e8999d2ce835c778749802900f37cba4e046d2"

URI_aarch64_gcc-toolset-15-libtsan-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libtsan-devel-15.1.1-2.5.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libtsan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libtsan-devel}"
SRC_URI[aarch64_gcc-toolset-15-libtsan-devel.sha256sum] = "a740562e79cb85380848880e9e8ebaa282c6384088328b6a574e37dad4dd94fa"

URI_aarch64_gcc-toolset-15-libubsan-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libubsan-devel-15.1.1-2.5.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-15-libubsan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libubsan-devel}"
SRC_URI[aarch64_gcc-toolset-15-libubsan-devel.sha256sum] = "d65d25ce1a0b8418960ce583d94a980e145b033043cea18141f5e4e83c11fba3"

RDEPENDS:gcc-toolset-15-gcc:x86_64_v2 = " \
 bash \
 gcc-toolset-15-binutils \
 gcc-toolset-15-runtime \
 glibc \
 glibc-devel \
 gmp \
 libgcc \
 libgomp \
 libmpc \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-15-gcc:aarch64 = " \
 gcc-toolset-15-binutils \
 gcc-toolset-15-runtime \
 glibc \
 glibc-devel \
 gmp \
 libgcc \
 libgomp \
 libmpc \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-15-gcc-c++ = " \
 gcc-toolset-15-gcc \
 gcc-toolset-15-libstdc++-devel \
 glibc \
 gmp \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-15-gcc-gfortran:x86_64_v2 = " \
 bash \
 gcc-toolset-15-gcc \
 gcc-toolset-15-libquadmath-devel \
 glibc \
 gmp \
 info \
 libgfortran \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-15-gcc-gfortran:aarch64 = " \
 bash \
 gcc-toolset-15-gcc \
 glibc \
 gmp \
 info \
 libgfortran \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-15-gcc-plugin-annobin = " \
 gcc-toolset-15-gcc \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gcc-toolset-15-gcc-plugin-devel = " \
 gcc-toolset-15-gcc \
 glibc \
 gmp-devel \
 libmpc-devel \
 mpfr-devel \
 "
RDEPENDS:gcc-toolset-15-libasan-devel = " \
 libasan \
 "
RDEPENDS:gcc-toolset-15-libatomic-devel = " \
 libatomic \
 "
RDEPENDS:gcc-toolset-15-libgccjit = " \
 gcc-toolset-15-gcc \
 glibc \
 gmp \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-15-libgccjit-devel = " \
 gcc-toolset-15-libgccjit \
 "
RDEPENDS:gcc-toolset-15-libitm-devel = " \
 gcc-toolset-15-gcc \
 libitm \
 "
RDEPENDS:gcc-toolset-15-liblsan-devel = " \
 liblsan \
 "
RDEPENDS:gcc-toolset-15-libquadmath-devel = " \
 gcc-toolset-15-gcc \
 libquadmath \
 "
RDEPENDS:gcc-toolset-15-libstdc++-devel = " \
 libstdc++ \
 "
RDEPENDS:gcc-toolset-15-libstdc++-docs = " \
 "
RDEPENDS:gcc-toolset-15-libtsan-devel = " \
 libtsan \
 "
RDEPENDS:gcc-toolset-15-libubsan-devel = " \
 libubsan \
 "
RDEPENDS:gcc-toolset-15-offload-nvptx = " \
 gcc \
 glibc \
 gmp \
 libgcc \
 libgomp-offload-nvptx \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
