# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtimageformats"
PV = "6.9.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtimageformats \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtimageformats-6.9.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bda100a0d8ffed9aa0c6f75809e52bf82bad10cfd849607b2f2b737d07c78ba0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtimageformats-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtimageformats;unpack=0"
SRC_URI[x86_64_v2_qt6-qtimageformats.sha256sum] = "7c7d6ee25296e772cf4359142d54b3abb8971db1341f6ff1debd7eadae457e04"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtimageformats-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtimageformats;unpack=0"
SRC_URI[aarch64_qt6-qtimageformats.sha256sum] = "ffc5c9cbc82e3a5d003b58cca339b22157dede9d6bf986f2ae0a0c32d3455bf7"

RDEPENDS:qt6-qtimageformats = " \
 cmake-filesystem \
 glibc \
 jasper-libs \
 libmng \
 libstdc++ \
 libtiff \
 libwebp \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
