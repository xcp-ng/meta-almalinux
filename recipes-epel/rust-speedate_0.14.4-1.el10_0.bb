# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-speedate"
PV = "0.14.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-speedate+default-devel \
 rust-speedate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-speedate-0.14.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e1579102a023dbae200ef3c2610265a438595aabec09fe6f21c833f9a6b24f0"

URI_x86_64_v2_rust-speedate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-speedate+default-devel-0.14.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-speedate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-speedate+default-devel}"
SRC_URI[x86_64_v2_rust-speedate+default-devel.sha256sum] = "5a32cbbf7bdd1958342a14a086eaf10dcbdfb8bd127c4e3a22396ceb52f6c041"

URI_x86_64_v2_rust-speedate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-speedate-devel-0.14.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-speedate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-speedate-devel}"
SRC_URI[x86_64_v2_rust-speedate-devel.sha256sum] = "93d08fc967adf5c309af7269e9f4bc2f599c0f9166205e17d5f1f144d996e799"

URI_aarch64_rust-speedate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-speedate+default-devel-0.14.4-1.el10_0.noarch.rpm;name=aarch64_rust-speedate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-speedate+default-devel}"
SRC_URI[aarch64_rust-speedate+default-devel.sha256sum] = "583b004101ed1f7d6b8d5e99b9405047c15f2229e237838491e5ac5b20d038f3"

URI_aarch64_rust-speedate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-speedate-devel-0.14.4-1.el10_0.noarch.rpm;name=aarch64_rust-speedate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-speedate-devel}"
SRC_URI[aarch64_rust-speedate-devel.sha256sum] = "0b7264b2a34d7925619c22392471e2c035bb04394da304fea056d12ca1a7fc9f"

RDEPENDS:rust-speedate+default-devel = " \
 cargo \
 rust-speedate-devel \
 "
RDEPENDS:rust-speedate-devel = " \
 cargo \
 rust-strum+default-devel \
 rust-strum+derive-devel \
 rust-strum_macros+default-devel \
 "
