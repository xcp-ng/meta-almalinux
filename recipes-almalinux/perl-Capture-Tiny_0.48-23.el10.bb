# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Capture-Tiny"
PV = "0.48"
PR = "23.el10"
PACKAGES = " \
 perl-Capture-Tiny \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Capture-Tiny-0.48-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ff57b9b10a913a4624351b7eed75c5c74d570ed93271e0843399736428fa309"

URI_x86_64_v2_perl-Capture-Tiny = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Capture-Tiny-0.48-23.el10.noarch.rpm;name=x86_64_v2_perl-Capture-Tiny;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Capture-Tiny}"
SRC_URI[x86_64_v2_perl-Capture-Tiny.sha256sum] = "ab4c3a78c468a19f14ae22aeeee3e9c44e214e145ab5b4ef0d35e8438f8585d2"

URI_aarch64_perl-Capture-Tiny = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Capture-Tiny-0.48-23.el10.noarch.rpm;name=aarch64_perl-Capture-Tiny;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Capture-Tiny}"
SRC_URI[aarch64_perl-Capture-Tiny.sha256sum] = "ab4c3a78c468a19f14ae22aeeee3e9c44e214e145ab5b4ef0d35e8438f8585d2"

RDEPENDS:perl-Capture-Tiny = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Temp \
 perl-IO \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-libs \
 "
