# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter"
PV = "0.24.7"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter+default-devel \
 rust-tree-sitter+std-devel \
 rust-tree-sitter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-0.24.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f1f977b49c759dd3df1e04e277186b3dbb6aa73049e7e8839730cae2293cb51"

URI_x86_64_v2_rust-tree-sitter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter+default-devel-0.24.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter+default-devel.sha256sum] = "d64fc54b522c1c1a66635fa65cb644fcc86678ff95b65781e9af5b93f1ff3a6e"

URI_x86_64_v2_rust-tree-sitter+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter+std-devel-0.24.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter+std-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter+std-devel.sha256sum] = "1ec5c370bae220d04df48925a0d1535f4adc34412902096d0a252001cb9b0538"

URI_x86_64_v2_rust-tree-sitter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-devel-0.24.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-devel.sha256sum] = "5c811cb90ad173edb60adfc535a309279e4487e8958f544fd1b88e05d32c936c"

URI_aarch64_rust-tree-sitter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter+default-devel-0.24.7-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter+default-devel}"
SRC_URI[aarch64_rust-tree-sitter+default-devel.sha256sum] = "d4948610d0b706c59e391de1672ce88810f3127844ff0eb9767308c62b4f2974"

URI_aarch64_rust-tree-sitter+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter+std-devel-0.24.7-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter+std-devel}"
SRC_URI[aarch64_rust-tree-sitter+std-devel.sha256sum] = "54df6dbb0d49433004f1655de52557a79b82c6b54bbbf7d3b82da4a9e5ef1134"

URI_aarch64_rust-tree-sitter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-devel-0.24.7-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-devel}"
SRC_URI[aarch64_rust-tree-sitter-devel.sha256sum] = "b5f4f65a520fae6515df02ae81d34b1e5b63cb89300ffeed62ed1055651b1caf"

RDEPENDS:rust-tree-sitter+default-devel = " \
 cargo \
 rust-tree-sitter+std-devel \
 rust-tree-sitter-devel \
 "
RDEPENDS:rust-tree-sitter+std-devel = " \
 cargo \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-syntax+unicode-devel \
 rust-tree-sitter-devel \
 "
RDEPENDS:rust-tree-sitter-devel = " \
 cargo \
 rust \
 rust-bindgen+default-devel \
 rust-cc+default-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 rust-regex-syntax-devel \
 rust-streaming-iterator+default-devel \
 rust-tree-sitter-language+default-devel \
 "
