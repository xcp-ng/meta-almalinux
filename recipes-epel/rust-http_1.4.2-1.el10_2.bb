# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http"
PV = "1.4.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-http+default-devel \
 rust-http+std-devel \
 rust-http-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-1.4.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a476c12a8244a070ba4200cbf9af9bbb2c48f787abd6d279a6cc527180fc32f1"

URI_x86_64_v2_rust-http+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http+default-devel-1.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http+default-devel}"
SRC_URI[x86_64_v2_rust-http+default-devel.sha256sum] = "e4f40918843094a3447b4369fdff468bcc6ba4d4d3819595abea6faf8062812a"

URI_x86_64_v2_rust-http+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http+std-devel-1.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http+std-devel}"
SRC_URI[x86_64_v2_rust-http+std-devel.sha256sum] = "a9d09e181bd134faf198bc206f50b13c23b18855bbe14637e26656b3d3506782"

URI_x86_64_v2_rust-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-devel-1.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-devel}"
SRC_URI[x86_64_v2_rust-http-devel.sha256sum] = "dcde51c45c53476a45bb9b1d24a6e10d3f490891ddbb775ba136733d8adc5b74"

URI_aarch64_rust-http+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http+default-devel-1.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-http+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http+default-devel}"
SRC_URI[aarch64_rust-http+default-devel.sha256sum] = "c0e8cbeb671e9481770d53893d0070a342f72c629308196d5d816b568aa3d5f6"

URI_aarch64_rust-http+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http+std-devel-1.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-http+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http+std-devel}"
SRC_URI[aarch64_rust-http+std-devel.sha256sum] = "f4b0a982be92d5afee3bfe1b6116ad9cd45432a37c5723504069a440668da7b9"

URI_aarch64_rust-http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-devel-1.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-devel}"
SRC_URI[aarch64_rust-http-devel.sha256sum] = "35336b9f7179195b1c816b5299221304834f5c97b171a94191fd3a838027e302"

RDEPENDS:rust-http+default-devel = " \
 cargo \
 rust-http+std-devel \
 rust-http-devel \
 "
RDEPENDS:rust-http+std-devel = " \
 cargo \
 rust-http-devel \
 "
RDEPENDS:rust-http-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-itoa+default-devel \
 "
