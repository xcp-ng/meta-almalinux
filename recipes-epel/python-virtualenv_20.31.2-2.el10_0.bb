# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-virtualenv"
PV = "20.31.2"
PR = "2.el10_0"
PACKAGES = " \
 python3-virtualenv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-virtualenv-20.31.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e76d9440a497838d1d162c826f6b25730ed417ce73b99a94952d54bd5ec17432"

URI_x86_64_v2_python3-virtualenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-virtualenv-20.31.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-virtualenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-virtualenv}"
SRC_URI[x86_64_v2_python3-virtualenv.sha256sum] = "1a5abdd8961d94fc07cc804fc1751993123260c62737b28b17b3d31e79d0956e"

URI_aarch64_python3-virtualenv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-virtualenv-20.31.2-2.el10_0.noarch.rpm;name=aarch64_python3-virtualenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-virtualenv}"
SRC_URI[aarch64_python3-virtualenv.sha256sum] = "d43669a352d045c35f157b6386d9f32dcf09964414ed993879fb303e6dd9da77"

RDEPENDS:python3-virtualenv = " \
 python3 \
 python3-distlib \
 python3-filelock \
 python3-pip-wheel \
 python3-platformdirs \
 python3-setuptools-wheel \
 python3-wheel-wheel \
 python3.13-pip-wheel \
 python3.13-setuptools-wheel \
 "
