# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-sc"
PV = "0.20081101"
PR = "37.el10"
PACKAGES = " \
 hunspell-sc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-sc-0.20081101-37.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6c39ebb429007ea8e7e659575d501959954904f9328f228bfc460dc22c0c9f4"

URI_x86_64_v2_hunspell-sc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-sc-0.20081101-37.el10.noarch.rpm;name=x86_64_v2_hunspell-sc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-sc}"
SRC_URI[x86_64_v2_hunspell-sc.sha256sum] = "ede87c3f26935a8ba6a442b2381a0cbba19e180fd0ae4469b9910c280eba7fcf"

URI_aarch64_hunspell-sc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-sc-0.20081101-37.el10.noarch.rpm;name=aarch64_hunspell-sc;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-sc}"
SRC_URI[aarch64_hunspell-sc.sha256sum] = "ede87c3f26935a8ba6a442b2381a0cbba19e180fd0ae4469b9910c280eba7fcf"

RDEPENDS:hunspell-sc = " \
 hunspell \
 "
