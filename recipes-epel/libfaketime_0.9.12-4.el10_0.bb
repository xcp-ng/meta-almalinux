# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libfaketime"
PV = "0.9.12"
PR = "4.el10_0"
PACKAGES = " \
 libfaketime \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libfaketime-0.9.12-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ff6a072cbb0c1fb9ec043e9ef04922e9f73fd77f3aeadc4b7943b7c43dd2b52"

URI_x86_64_v2_libfaketime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfaketime-0.9.12-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libfaketime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfaketime}"
SRC_URI[x86_64_v2_libfaketime.sha256sum] = "542ff010fb2c21baf3d410e67fa5001cf4e211ee5cf7c4580b6b68a68b1a9a7e"

URI_aarch64_libfaketime = "${EPEL_MIRROR}/aarch64/Packages/l/libfaketime-0.9.12-4.el10_0.aarch64.rpm;name=aarch64_libfaketime;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfaketime}"
SRC_URI[aarch64_libfaketime.sha256sum] = "74388f4b48e11ec641caba352f429e8393ce4009f10a479848effaf5cd6ca675"

RDEPENDS:libfaketime = " \
 glibc \
 libgcc \
 "
