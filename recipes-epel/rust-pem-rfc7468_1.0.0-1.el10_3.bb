# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pem-rfc7468"
PV = "1.0.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-pem-rfc7468+alloc-devel \
 rust-pem-rfc7468+default-devel \
 rust-pem-rfc7468+std-devel \
 rust-pem-rfc7468-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pem-rfc7468-1.0.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7ac497d8659bf8c064d4c7c3f264b7882d85cb4a2f95b650c9e1752b83bafbc"

URI_x86_64_v2_rust-pem-rfc7468+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-rfc7468+alloc-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-rfc7468+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem-rfc7468+alloc-devel}"
SRC_URI[x86_64_v2_rust-pem-rfc7468+alloc-devel.sha256sum] = "d97603c72a4d7110d441434cad58757f961f0035cd45f2c9e99fc3008ec29211"

URI_x86_64_v2_rust-pem-rfc7468+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-rfc7468+default-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-rfc7468+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem-rfc7468+default-devel}"
SRC_URI[x86_64_v2_rust-pem-rfc7468+default-devel.sha256sum] = "3cb73aa9ccaad583a3fa7d0f9c5420de45fe5178ec294fc82e6d94761a7659a5"

URI_x86_64_v2_rust-pem-rfc7468+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-rfc7468+std-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-rfc7468+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem-rfc7468+std-devel}"
SRC_URI[x86_64_v2_rust-pem-rfc7468+std-devel.sha256sum] = "2a2903ed2f42a459867e57e618910a350e65015a59b605710939609f816e966b"

URI_x86_64_v2_rust-pem-rfc7468-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-rfc7468-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-rfc7468-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem-rfc7468-devel}"
SRC_URI[x86_64_v2_rust-pem-rfc7468-devel.sha256sum] = "7a0a387f3ec2a4a921ae659751ae680852dc25fe885110475ed9f498caf83100"

URI_aarch64_rust-pem-rfc7468+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-rfc7468+alloc-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-pem-rfc7468+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem-rfc7468+alloc-devel}"
SRC_URI[aarch64_rust-pem-rfc7468+alloc-devel.sha256sum] = "ed196672d08fe599b36951267a92e05433b0b59086bf5a524b7ec28ebe369538"

URI_aarch64_rust-pem-rfc7468+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-rfc7468+default-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-pem-rfc7468+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem-rfc7468+default-devel}"
SRC_URI[aarch64_rust-pem-rfc7468+default-devel.sha256sum] = "378db49aba7c77d723892a7531af4a1e567e7281aa79fd02ce9d471c03a3a329"

URI_aarch64_rust-pem-rfc7468+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-rfc7468+std-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-pem-rfc7468+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem-rfc7468+std-devel}"
SRC_URI[aarch64_rust-pem-rfc7468+std-devel.sha256sum] = "8ac9db45f675ac6699ecb8bc8b030ed3d564d8fe307fdab186d51057d1c188f6"

URI_aarch64_rust-pem-rfc7468-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-rfc7468-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-pem-rfc7468-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem-rfc7468-devel}"
SRC_URI[aarch64_rust-pem-rfc7468-devel.sha256sum] = "725a299190b5efaf0123e997022a22b19f4594db9aa595f8e2b7ae3cde4ef97a"

RDEPENDS:rust-pem-rfc7468+alloc-devel = " \
 cargo \
 rust-base64ct+alloc-devel \
 rust-pem-rfc7468-devel \
 "
RDEPENDS:rust-pem-rfc7468+default-devel = " \
 cargo \
 rust-pem-rfc7468-devel \
 "
RDEPENDS:rust-pem-rfc7468+std-devel = " \
 cargo \
 rust-base64ct+std-devel \
 rust-pem-rfc7468+alloc-devel \
 rust-pem-rfc7468-devel \
 "
RDEPENDS:rust-pem-rfc7468-devel = " \
 cargo \
 rust \
 rust-base64ct+default-devel \
 "
