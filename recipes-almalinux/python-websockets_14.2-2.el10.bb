# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-websockets"
PV = "14.2"
PR = "2.el10"
PACKAGES = " \
 python3-websockets \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-websockets-14.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "676bed1cab82caee07ff9a8cec63d5d48979befe5cb22bb0f8be6ed44ef39a93"

URI_x86_64_v2_python3-websockets = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-websockets-14.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-websockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-websockets}"
SRC_URI[x86_64_v2_python3-websockets.sha256sum] = "a7d678cd8008c4d0c5bfa2317577706ca1575af3b485f3919bc941125bc67c95"

URI_aarch64_python3-websockets = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-websockets-14.2-2.el10.aarch64.rpm;name=aarch64_python3-websockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-websockets}"
SRC_URI[aarch64_python3-websockets.sha256sum] = "44b516b0ca87973a638c72204bf7a086bf99b0dacab39a84d996ce73e5015e6d"

RDEPENDS:python3-websockets = " \
 glibc \
 python3 \
 "
