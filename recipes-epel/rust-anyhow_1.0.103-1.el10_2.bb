# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anyhow"
PV = "1.0.103"
PR = "1.el10_2"
PACKAGES = " \
 rust-anyhow+backtrace-devel \
 rust-anyhow+default-devel \
 rust-anyhow+std-devel \
 rust-anyhow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anyhow-1.0.103-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e93f6fbb7de589e6e13ffba0f36bdddb903680532677c5896102f055865f5497"

URI_x86_64_v2_rust-anyhow+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow+backtrace-devel-1.0.103-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow+backtrace-devel}"
SRC_URI[x86_64_v2_rust-anyhow+backtrace-devel.sha256sum] = "c5a1d2183d07edd1c35ed32e4bdd0ad12c9b6838d087aa6a224803d8e539f2a7"

URI_x86_64_v2_rust-anyhow+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow+default-devel-1.0.103-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow+default-devel}"
SRC_URI[x86_64_v2_rust-anyhow+default-devel.sha256sum] = "a6eec540bc86b946c2189a6af106131f20bdb3bf93e5dc4d8e23e073fee52d76"

URI_x86_64_v2_rust-anyhow+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow+std-devel-1.0.103-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow+std-devel}"
SRC_URI[x86_64_v2_rust-anyhow+std-devel.sha256sum] = "e956b3330ea715df31e5efad98fed5bea7419fb04a9f184086267a8b948c634a"

URI_x86_64_v2_rust-anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow-devel-1.0.103-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow-devel}"
SRC_URI[x86_64_v2_rust-anyhow-devel.sha256sum] = "4d3ea390199c9fccf3cd6fec33c0e18ed6aaf9f4bf887cc34b96b20668f5c659"

URI_aarch64_rust-anyhow+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow+backtrace-devel-1.0.103-1.el10_2.noarch.rpm;name=aarch64_rust-anyhow+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow+backtrace-devel}"
SRC_URI[aarch64_rust-anyhow+backtrace-devel.sha256sum] = "71ba478498effd9deb989a0d9dd7bf68ad3101c25ab4187b98f49c40f1e030e9"

URI_aarch64_rust-anyhow+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow+default-devel-1.0.103-1.el10_2.noarch.rpm;name=aarch64_rust-anyhow+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow+default-devel}"
SRC_URI[aarch64_rust-anyhow+default-devel.sha256sum] = "9830a7ecd0d95ad389ec729e08cd9e79fdd9e481805c8f3986b316b45f949a68"

URI_aarch64_rust-anyhow+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow+std-devel-1.0.103-1.el10_2.noarch.rpm;name=aarch64_rust-anyhow+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow+std-devel}"
SRC_URI[aarch64_rust-anyhow+std-devel.sha256sum] = "51cee1808c0d9dc70d00eea0141d35693e3b021d9177a3a223dd49119bcc5381"

URI_aarch64_rust-anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow-devel-1.0.103-1.el10_2.noarch.rpm;name=aarch64_rust-anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow-devel}"
SRC_URI[aarch64_rust-anyhow-devel.sha256sum] = "f3c836820e51f457187e5978676d0eb86d35c3bd1ba01beabc838f19369cf135"

RDEPENDS:rust-anyhow+backtrace-devel = " \
 cargo \
 rust-anyhow-devel \
 "
RDEPENDS:rust-anyhow+default-devel = " \
 cargo \
 rust-anyhow+std-devel \
 rust-anyhow-devel \
 "
RDEPENDS:rust-anyhow+std-devel = " \
 cargo \
 rust-anyhow-devel \
 "
RDEPENDS:rust-anyhow-devel = " \
 cargo \
 rust \
 "
