# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_provider_macros"
PV = "1.5.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-icu_provider_macros+default-devel \
 rust-icu_provider_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_provider_macros-1.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04ed3dcbc83951f8f9eb52c99aab087ade463666424d252edbe583adab279ccf"

URI_x86_64_v2_rust-icu_provider_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider_macros+default-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider_macros+default-devel}"
SRC_URI[x86_64_v2_rust-icu_provider_macros+default-devel.sha256sum] = "9dd509831d296622a188d336140ae66a009d3f6e9d43d8673f6efd8e12ef12b5"

URI_x86_64_v2_rust-icu_provider_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider_macros-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider_macros-devel}"
SRC_URI[x86_64_v2_rust-icu_provider_macros-devel.sha256sum] = "e95ca82de8341f322e4ef258c3ccab26dfb9df862dc28bdee7f12c0655efb463"

URI_aarch64_rust-icu_provider_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider_macros+default-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_provider_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider_macros+default-devel}"
SRC_URI[aarch64_rust-icu_provider_macros+default-devel.sha256sum] = "a0a84a53c1febd7954bf2b09d2223b14e8d161be9232ed0a6084be0df52fa312"

URI_aarch64_rust-icu_provider_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider_macros-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_provider_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider_macros-devel}"
SRC_URI[aarch64_rust-icu_provider_macros-devel.sha256sum] = "66ba9c7b5fd32cb704f9254260af06f5eb5e24fafa73c068c0920a47a2079b9c"

RDEPENDS:rust-icu_provider_macros+default-devel = " \
 cargo \
 rust-icu_provider_macros-devel \
 "
RDEPENDS:rust-icu_provider_macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
