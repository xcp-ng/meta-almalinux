# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libksieve"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 libksieve \
 libksieve-devel \
 libksieve-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libksieve-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1997ebf1dbd12c7ff2b55dd65f8de4378e389ca7ae3193881e54cadf019681fb"

URI_x86_64_v2_libksieve = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksieve-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksieve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksieve}"
SRC_URI[x86_64_v2_libksieve.sha256sum] = "ea5acb9049c7f63d98e68fae30e5500cabb19240600c28e2d0f0cdb13256aedf"

URI_x86_64_v2_libksieve-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksieve-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksieve-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksieve-devel}"
SRC_URI[x86_64_v2_libksieve-devel.sha256sum] = "7f96fea19999e54133a3675c632b37d7791cb5fe4a521d28aec8663f191bf150"

URI_x86_64_v2_libksieve-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksieve-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libksieve-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksieve-doc}"
SRC_URI[x86_64_v2_libksieve-doc.sha256sum] = "fae5f9edb6d0630c99e02d0d94125aeb81638d880243cb6d57e8a6f6f4b9d602"

URI_aarch64_libksieve = "${EPEL_MIRROR}/aarch64/Packages/l/libksieve-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libksieve;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksieve}"
SRC_URI[aarch64_libksieve.sha256sum] = "11bd05e5cfcad283e40429f2810eef19f8d73a6eefbc1808207748659281c49d"

URI_aarch64_libksieve-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libksieve-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libksieve-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksieve-devel}"
SRC_URI[aarch64_libksieve-devel.sha256sum] = "d9b634108c7bb403a1636035c534c510aea46be9cdc305075df061646cce9985"

URI_aarch64_libksieve-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libksieve-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_libksieve-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksieve-doc}"
SRC_URI[aarch64_libksieve-doc.sha256sum] = "a8c9413fea77c9f564a402f46fc5e2006cc5c6856e1c8db3b0722fe072fbde97"

RDEPENDS:libksieve = " \
 cyrus-sasl-lib \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-sonnet \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kmime \
 ktextaddons-qt6 \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:libksieve-devel = " \
 cmake-filesystem \
 kf6-syntax-highlighting-devel \
 libksieve \
 "
RDEPENDS:libksieve-doc = " \
 "
