# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kruler"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kruler \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kruler-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d93326e5a83662b384a66715176f92bc3f7b12de4bc6d1960b0c8b19083d2056"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kruler-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kruler;unpack=0"
SRC_URI[x86_64_v2_kruler.sha256sum] = "bce023577ea3e58b8f8aa3dd5ba744b92e0b17d713434e23c9a7f13bcb3f95f9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kruler-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kruler;unpack=0"
SRC_URI[aarch64_kruler.sha256sum] = "8016613f0eafd3505415cf583953b4db53479fa3e4869a76b22500628cc1fb21"

RDEPENDS:kruler = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
