# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "koji-image-builder"
PV = "12"
PR = "1.el10_3"
PACKAGES = " \
 koji-image-builder \
 koji-image-builder-builder \
 koji-image-builder-cli \
 koji-image-builder-hub \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/koji-image-builder-12-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2d705382017617ae70991a317cf6beaab2bd47907f6f86efaaa04ae478144df0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-image-builder-12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_koji-image-builder;unpack=0"
SRC_URI[x86_64_v2_koji-image-builder.sha256sum] = "7db543ebbdda81a98c3c6ffce281dcefba16cd5ce3b885caaeb885f48a234511"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-image-builder-builder-12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_koji-image-builder-builder;unpack=0"
SRC_URI[x86_64_v2_koji-image-builder-builder.sha256sum] = "37704c257b78f2c6b5ba85d3adbd045f59c1d453058d6e6b3e7ddf0d32cd5698"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-image-builder-cli-12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_koji-image-builder-cli;unpack=0"
SRC_URI[x86_64_v2_koji-image-builder-cli.sha256sum] = "47020a9d5edc558b5c12498c5b182ae0ec41bc9d3aec533dca7588472e5fb59c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-image-builder-hub-12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_koji-image-builder-hub;unpack=0"
SRC_URI[x86_64_v2_koji-image-builder-hub.sha256sum] = "afc5065a88653ed1f86789f0c577b0219731ea326ff7787df9f833c1dc1db3e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/koji-image-builder-12-1.el10_3.noarch.rpm;name=aarch64_koji-image-builder;unpack=0"
SRC_URI[aarch64_koji-image-builder.sha256sum] = "683718685b18701b8afcc35366090b4ca5948e29ab6da1110b52bd5097cfdad5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/koji-image-builder-builder-12-1.el10_3.noarch.rpm;name=aarch64_koji-image-builder-builder;unpack=0"
SRC_URI[aarch64_koji-image-builder-builder.sha256sum] = "1d6978f3074ad0486fe6d9d5231d98446d7d363c93e883efde0158bfa317c3a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/koji-image-builder-cli-12-1.el10_3.noarch.rpm;name=aarch64_koji-image-builder-cli;unpack=0"
SRC_URI[aarch64_koji-image-builder-cli.sha256sum] = "339ef208ddfc70da7f262e9af388b10a37347425117e7b6316227ac72f9c6380"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/koji-image-builder-hub-12-1.el10_3.noarch.rpm;name=aarch64_koji-image-builder-hub;unpack=0"
SRC_URI[aarch64_koji-image-builder-hub.sha256sum] = "baaa92770d0f806754b83b39df12db22f8290d6e518b8e4f4a64d1b67d4f2687"

RDEPENDS:koji-image-builder = " \
 "
RDEPENDS:koji-image-builder-builder = " \
 koji-builder \
 koji-builder-plugins \
 koji-image-builder \
 python3 \
 "
RDEPENDS:koji-image-builder-cli = " \
 koji \
 koji-image-builder \
 python3 \
 python3-koji-cli-plugins \
 "
RDEPENDS:koji-image-builder-hub = " \
 koji-hub \
 koji-hub-plugins \
 koji-image-builder \
 python3-jsonschema \
 "
