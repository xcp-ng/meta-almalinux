# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-portalocker"
PV = "3.1.1"
PR = "2.el10_1"
PACKAGES = " \
 python3-portalocker \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-portalocker-3.1.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a40f8b5bb51b059a91cd14c1f91a0767d67b69eed3c06d7c3a1b28da54dfe84c"

URI_x86_64_v2_python3-portalocker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-portalocker-3.1.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-portalocker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-portalocker}"
SRC_URI[x86_64_v2_python3-portalocker.sha256sum] = "6795c19ed02d92f8b3e47a07c6ad4e75d97ebc7f2551719ca3e9fe9d32d6455c"

URI_aarch64_python3-portalocker = "${EPEL_MIRROR}/aarch64/Packages/p/python3-portalocker-3.1.1-2.el10_1.noarch.rpm;name=aarch64_python3-portalocker;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-portalocker}"
SRC_URI[aarch64_python3-portalocker.sha256sum] = "05d833d97854a7728b245a8484e688279a246427a3d49a430c2d276d72f0ac65"

RDEPENDS:python3-portalocker = " \
 python3 \
 "
