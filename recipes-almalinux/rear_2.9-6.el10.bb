# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rear"
PV = "2.9"
PR = "6.el10"
PACKAGES = " \
 rear \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rear-2.9-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "308e347c0845a0888eaf50de6e815b3f11c573602c42a03d3628b456cbb9ea4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rear-2.9-6.el10.x86_64_v2.rpm;name=x86_64_v2_rear;unpack=0"
SRC_URI[x86_64_v2_rear.sha256sum] = "dbb88a9bc86d56385c2a44f6f8b4961500566b552f93f958efd304de196efe3e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rear-2.9-6.el10.aarch64.rpm;name=aarch64_rear;unpack=0"
SRC_URI[aarch64_rear.sha256sum] = "ba5958ef7466804903d6708fe81d41f73a149d88742bf73d2015304bee39b597"

RDEPENDS:rear:x86_64_v2 = " \
 attr \
 bash \
 bc \
 binutils \
 dhcpcd \
 dosfstools \
 ethtool \
 file \
 gawk \
 grub2-efi-x64-modules \
 grub2-tools-extra \
 gzip \
 iproute \
 iputils \
 lftp \
 openssl \
 parted \
 squashfs-tools \
 syslinux-extlinux \
 tar \
 util-linux \
 xorriso \
"
RDEPENDS:rear:aarch64 = " \
 attr \
 bash \
 bc \
 binutils \
 dhcpcd \
 dosfstools \
 ethtool \
 file \
 gawk \
 grub2-efi-aa64-modules \
 grub2-tools-extra \
 gzip \
 iproute \
 iputils \
 lftp \
 openssl \
 parted \
 squashfs-tools \
 tar \
 util-linux \
 xorriso \
"
