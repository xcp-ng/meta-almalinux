# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-text-unidecode"
PV = "1.3"
PR = "19.el10_1"
PACKAGES = " \
 python3-text-unidecode \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-text-unidecode-1.3-19.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b68024cf829ec5e2a618b986aeb18375bd70fb9aa0993eae6626bbe715ae5af3"

URI_x86_64_v2_python3-text-unidecode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-text-unidecode-1.3-19.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-text-unidecode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-text-unidecode}"
SRC_URI[x86_64_v2_python3-text-unidecode.sha256sum] = "3b7f4b17472e1f53ce3592f457b1ce57f3e7ac0e94553440c778734e06fb7d05"

URI_aarch64_python3-text-unidecode = "${EPEL_MIRROR}/aarch64/Packages/p/python3-text-unidecode-1.3-19.el10_1.noarch.rpm;name=aarch64_python3-text-unidecode;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-text-unidecode}"
SRC_URI[aarch64_python3-text-unidecode.sha256sum] = "0dde73636a9937a4ebe427314f29297eec905193f5372304744ef257759dde0e"

RDEPENDS:python3-text-unidecode = " \
 python3 \
 "
