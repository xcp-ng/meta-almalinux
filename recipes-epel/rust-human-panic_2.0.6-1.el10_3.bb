# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-human-panic"
PV = "2.0.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-human-panic+color-devel \
 rust-human-panic+default-devel \
 rust-human-panic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-human-panic-2.0.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25005cad3f78cd40b3988dff433e2af7efa0adf52f8a78c8e7e27350a9685994"

URI_x86_64_v2_rust-human-panic+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-panic+color-devel-2.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-panic+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-panic+color-devel}"
SRC_URI[x86_64_v2_rust-human-panic+color-devel.sha256sum] = "6cfd6cfc17bf986b49f8d05bffd8da8d075de1dcf6d3b41cca5acc22db0cda94"

URI_x86_64_v2_rust-human-panic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-panic+default-devel-2.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-panic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-panic+default-devel}"
SRC_URI[x86_64_v2_rust-human-panic+default-devel.sha256sum] = "fe9e19b461e2482f800935bc6590649cbf55150d7ebb8e0c6c98e583ec255e99"

URI_x86_64_v2_rust-human-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-panic-devel-2.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-panic-devel}"
SRC_URI[x86_64_v2_rust-human-panic-devel.sha256sum] = "9e3618ba7f63ce225cccc40b31a6feee42008440ba909d1e47ad455731809e29"

URI_aarch64_rust-human-panic+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-panic+color-devel-2.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-human-panic+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-panic+color-devel}"
SRC_URI[aarch64_rust-human-panic+color-devel.sha256sum] = "7d658478aed83814a84b9209c70b3e404d696922eaf437361e8bdcf23f8ecad1"

URI_aarch64_rust-human-panic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-panic+default-devel-2.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-human-panic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-panic+default-devel}"
SRC_URI[aarch64_rust-human-panic+default-devel.sha256sum] = "32b44e2d45a0efb398b74ef202036e46298f9c8e0ce9a96fd590ca2228e7cbac"

URI_aarch64_rust-human-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-panic-devel-2.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-human-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-panic-devel}"
SRC_URI[aarch64_rust-human-panic-devel.sha256sum] = "bfc3da912977252e777c25e354ac76db43d06778759a40cc7c262d1f2d037b2d"

RDEPENDS:rust-human-panic+color-devel = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-anstyle+default-devel \
 rust-human-panic-devel \
 "
RDEPENDS:rust-human-panic+default-devel = " \
 cargo \
 rust-human-panic+color-devel \
 rust-human-panic-devel \
 "
RDEPENDS:rust-human-panic-devel = " \
 cargo \
 rust \
 rust-backtrace+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-sysinfo+system-devel \
 rust-sysinfo-devel \
 rust-toml0.9+display-devel \
 rust-toml0.9+serde-devel \
 rust-toml0.9-devel \
 rust-uuid+v4-devel \
 rust-uuid-devel \
 "
