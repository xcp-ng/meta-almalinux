# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluechi"
PV = "1.3.0"
PR = "1.el10_3"
PACKAGES = " \
 bluechi-agent \
 bluechi-controller \
 bluechi-ctl \
 bluechi-is-online \
 bluechi-selinux \
 python3-bluechi \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/bluechi-1.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "43f9afa0e171f7358c3f64711f45d6b83e3edc1a0985b67442cfe5cebc798fe6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-agent-1.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-agent;unpack=0"
SRC_URI[x86_64_v2_bluechi-agent.sha256sum] = "d796336647f4f95f90580e1ca32f95d78cf0a9a3527c9e26e0744bd8e7db2e6c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-controller-1.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-controller;unpack=0"
SRC_URI[x86_64_v2_bluechi-controller.sha256sum] = "5006b9fa9d3b5560d2db1bfd9c34e1305edfc0950363bc64ab4b2758e644cc24"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-ctl-1.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-ctl;unpack=0"
SRC_URI[x86_64_v2_bluechi-ctl.sha256sum] = "a6c4a1f4380b04ca0b3fb1fe80c818339056f598a5c0ae946a22a9f4554a44c8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-is-online-1.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-is-online;unpack=0"
SRC_URI[x86_64_v2_bluechi-is-online.sha256sum] = "e4089795ad7e5e7b76a786ffdcc92dd8f7839beadcc912e71a0976ee5bf7d864"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-selinux-1.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_bluechi-selinux;unpack=0"
SRC_URI[x86_64_v2_bluechi-selinux.sha256sum] = "dd5d90778a3ef2db4c53a73f2e6a3cb8403f8c7be62c9cde39a7795ed2ed2f29"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bluechi-1.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-bluechi;unpack=0"
SRC_URI[x86_64_v2_python3-bluechi.sha256sum] = "d990a12c750b07daa770d9eae252242fea5bd79d46e7a3b398168be41c68ae1c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bluechi-agent-1.3.0-1.el10_3.aarch64.rpm;name=aarch64_bluechi-agent;unpack=0"
SRC_URI[aarch64_bluechi-agent.sha256sum] = "38761d633b3acdf79738949ea6257eb7276bd4c983e9c96ea60425e77f3678ea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bluechi-controller-1.3.0-1.el10_3.aarch64.rpm;name=aarch64_bluechi-controller;unpack=0"
SRC_URI[aarch64_bluechi-controller.sha256sum] = "e95c49fc6b85b8e730d78789978c027c6b8c7edb50c925382c72579688d6dbb9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bluechi-ctl-1.3.0-1.el10_3.aarch64.rpm;name=aarch64_bluechi-ctl;unpack=0"
SRC_URI[aarch64_bluechi-ctl.sha256sum] = "b0a51aaab76b9985463fdf35a12c3cf821a6b19d56b617b4c52ef183035733ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bluechi-is-online-1.3.0-1.el10_3.aarch64.rpm;name=aarch64_bluechi-is-online;unpack=0"
SRC_URI[aarch64_bluechi-is-online.sha256sum] = "382660fac8fbde3d2dab8b95420533e36746a77b0582c2b73eec90b15ee3850c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bluechi-selinux-1.3.0-1.el10_3.noarch.rpm;name=aarch64_bluechi-selinux;unpack=0"
SRC_URI[aarch64_bluechi-selinux.sha256sum] = "34cd28ec0975aa652c3bd9fd710143981d3a737b20dbea479dfbe973db1c7938"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-bluechi-1.3.0-1.el10_3.noarch.rpm;name=aarch64_python3-bluechi;unpack=0"
SRC_URI[aarch64_python3-bluechi.sha256sum] = "9139af1fe4b48ea875891351ed88d7ad7fb9aa656b0411b530e859f3dd432992"

RDEPENDS:bluechi-agent = " \
 bash \
 glibc \
 libgcc \
 systemd \
 systemd-libs \
 "
RDEPENDS:bluechi-controller = " \
 bash \
 glibc \
 libgcc \
 libselinux \
 systemd \
 systemd-libs \
 "
RDEPENDS:bluechi-ctl = " \
 bluechi-controller \
 glibc \
 libgcc \
 systemd-libs \
 "
RDEPENDS:bluechi-is-online = " \
 glibc \
 libgcc \
 systemd-libs \
 "
RDEPENDS:bluechi-selinux:x86_64_v2 = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/selinux-policy-any_ge_42.1.27 \
"
RDEPENDS:bluechi-selinux:aarch64 = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/selinux-policy-any_ge_42.1.26 \
"
RDEPENDS:python3-bluechi = " \
 python3 \
 python3-dasbus \
 "
