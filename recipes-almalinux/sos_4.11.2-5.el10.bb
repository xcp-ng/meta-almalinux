# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sos"
PV = "4.11.2"
PR = "5.el10"
PACKAGES = " \
 sos \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sos-4.11.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "765d361e5e6037cf12d0c97eff6ae47d429f11c61b9afe5c4dace44957463e29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sos-4.11.2-5.el10.noarch.rpm;name=x86_64_v2_sos;unpack=0"
SRC_URI[x86_64_v2_sos.sha256sum] = "41d6354ebfc23c96efae03d07ff394cf25f55287371c24517f030596b4359787"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sos-4.11.2-5.el10.noarch.rpm;name=aarch64_sos;unpack=0"
SRC_URI[aarch64_sos.sha256sum] = "41d6354ebfc23c96efae03d07ff394cf25f55287371c24517f030596b4359787"

RDEPENDS:sos = " \
 python3 \
 python3-packaging \
 python3-pexpect \
 python3-pyyaml \
 python3-requests \
 python3-setuptools \
 "
