# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "canl-java"
PV = "2.9.0"
PR = "1.el10_3"
PACKAGES = " \
 canl-java \
 canl-java-javadoc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/canl-java-2.9.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d598c762a1703e3328e9913e46822d50a4fed7322235f5560a6bb6b895ecdf5c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/canl-java-2.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_canl-java;unpack=0"
SRC_URI[x86_64_v2_canl-java.sha256sum] = "0c414ea5adc29a36c4a58cdbe1d76c434300ea8f719a2551ff39666359260057"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/canl-java-javadoc-2.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_canl-java-javadoc;unpack=0"
SRC_URI[x86_64_v2_canl-java-javadoc.sha256sum] = "12a4dc4d2a94a61eeebc9aa7f504d981b9236f102806e5261284aac4d03da450"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/canl-java-2.9.0-1.el10_3.noarch.rpm;name=aarch64_canl-java;unpack=0"
SRC_URI[aarch64_canl-java.sha256sum] = "425d5edbced621edbaf6644907ef216766f5bc722fc0755f86e378d2d09f7b0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/canl-java-javadoc-2.9.0-1.el10_3.noarch.rpm;name=aarch64_canl-java-javadoc;unpack=0"
SRC_URI[aarch64_canl-java-javadoc.sha256sum] = "98f404a3a5bc75fbdbe961678dfd5eda4141d6af073b90f2c384c08eb43c5c0c"

RDEPENDS:canl-java = " \
 apache-commons-io \
 bouncycastle \
 bouncycastle-pkix \
 javapackages-filesystem \
 "
RDEPENDS:canl-java-javadoc = " \
 javapackages-filesystem \
 "
