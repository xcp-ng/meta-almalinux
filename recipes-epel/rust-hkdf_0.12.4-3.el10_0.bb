# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hkdf"
PV = "0.12.4"
PR = "3.el10_0"
PACKAGES = " \
 rust-hkdf+default-devel \
 rust-hkdf+std-devel \
 rust-hkdf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hkdf-0.12.4-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d4c94699b00ddb0b679f818fee94eea745057e7f86b4a9069e3d843cb5f1822"

URI_x86_64_v2_rust-hkdf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hkdf+default-devel-0.12.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hkdf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hkdf+default-devel}"
SRC_URI[x86_64_v2_rust-hkdf+default-devel.sha256sum] = "970c1be652a2f08c49b92ae188352104712406ca7d2596fa09fda9abdeece174"

URI_x86_64_v2_rust-hkdf+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hkdf+std-devel-0.12.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hkdf+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hkdf+std-devel}"
SRC_URI[x86_64_v2_rust-hkdf+std-devel.sha256sum] = "9f937516cfbed8dcfbbd3baffa04324084c11086f513f096360d6406b03ad44b"

URI_x86_64_v2_rust-hkdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hkdf-devel-0.12.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hkdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hkdf-devel}"
SRC_URI[x86_64_v2_rust-hkdf-devel.sha256sum] = "11eba0d324d5db70d871461967dffe87695b8d4c5a1bcc6c0e844c1a76662aac"

URI_aarch64_rust-hkdf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hkdf+default-devel-0.12.4-3.el10_0.noarch.rpm;name=aarch64_rust-hkdf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hkdf+default-devel}"
SRC_URI[aarch64_rust-hkdf+default-devel.sha256sum] = "4784c23d2b0578c98eb6855880c464a5972e687d12570c29c7c3fdeb55eab942"

URI_aarch64_rust-hkdf+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hkdf+std-devel-0.12.4-3.el10_0.noarch.rpm;name=aarch64_rust-hkdf+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hkdf+std-devel}"
SRC_URI[aarch64_rust-hkdf+std-devel.sha256sum] = "8444154e55cf991e9556cc5881170d600817299f7d944f2329799a6662ae88a3"

URI_aarch64_rust-hkdf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hkdf-devel-0.12.4-3.el10_0.noarch.rpm;name=aarch64_rust-hkdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hkdf-devel}"
SRC_URI[aarch64_rust-hkdf-devel.sha256sum] = "389f72f6fc1cd202a00ba697d1c2a57b923dd5ba795f793d1916c4bbea541fef"

RDEPENDS:rust-hkdf+default-devel = " \
 cargo \
 rust-hkdf-devel \
 "
RDEPENDS:rust-hkdf+std-devel = " \
 cargo \
 rust-hkdf-devel \
 rust-hmac+std-devel \
 "
RDEPENDS:rust-hkdf-devel = " \
 cargo \
 rust-hmac+default-devel \
 "
