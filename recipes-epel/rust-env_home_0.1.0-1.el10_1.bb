# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_home"
PV = "0.1.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-env_home+default-devel \
 rust-env_home-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_home-0.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01f0748d7681042cb9a150ae441a1d0d64d38632a1fa6492278f12bdc61f38a1"

URI_x86_64_v2_rust-env_home+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_home+default-devel-0.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_home+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_home+default-devel}"
SRC_URI[x86_64_v2_rust-env_home+default-devel.sha256sum] = "7959f28663a2cb171e6c1d83adee88ee45b6d6ade2d043a21dd054fc64d2cf9e"

URI_x86_64_v2_rust-env_home-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_home-devel-0.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_home-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_home-devel}"
SRC_URI[x86_64_v2_rust-env_home-devel.sha256sum] = "a5853f90582064b659d4c5dd0dfa504d1ef66b858852c97af4fdef179d4e7df5"

URI_aarch64_rust-env_home+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_home+default-devel-0.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-env_home+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_home+default-devel}"
SRC_URI[aarch64_rust-env_home+default-devel.sha256sum] = "d9e0d4d8b7c761d98be3c6fee4396d9ce8358ba2f14ab327d64954dc2a16e9e4"

URI_aarch64_rust-env_home-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_home-devel-0.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-env_home-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_home-devel}"
SRC_URI[aarch64_rust-env_home-devel.sha256sum] = "4ef045d203597db58b992658fbedf44d8cdf72fc50871ddc288ceb9be40492f6"

RDEPENDS:rust-env_home+default-devel = " \
 cargo \
 rust-env_home-devel \
 "
RDEPENDS:rust-env_home-devel = " \
 cargo \
 "
