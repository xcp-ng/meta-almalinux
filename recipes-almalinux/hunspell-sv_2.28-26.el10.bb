# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-sv"
PV = "2.28"
PR = "26.el10"
PACKAGES = " \
 hunspell-sv \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-sv-2.28-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83d476ae926ed9a59b6f5a530dfe49031d849ee2240a0d4948d5e1b7b7be7020"

URI_x86_64_v2_hunspell-sv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-sv-2.28-26.el10.noarch.rpm;name=x86_64_v2_hunspell-sv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-sv}"
SRC_URI[x86_64_v2_hunspell-sv.sha256sum] = "f2ac738bb9381550efa07f4008e45bfe298c152ffd5383a21103e0ac5c112398"

URI_aarch64_hunspell-sv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-sv-2.28-26.el10.noarch.rpm;name=aarch64_hunspell-sv;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-sv}"
SRC_URI[aarch64_hunspell-sv.sha256sum] = "f2ac738bb9381550efa07f4008e45bfe298c152ffd5383a21103e0ac5c112398"

RDEPENDS:hunspell-sv = " \
 hunspell \
 "
