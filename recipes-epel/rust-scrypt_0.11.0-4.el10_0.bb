# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scrypt"
PV = "0.11.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-scrypt+default-devel \
 rust-scrypt+password-hash-devel \
 rust-scrypt+simple-devel \
 rust-scrypt+std-devel \
 rust-scrypt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scrypt-0.11.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3944ca7c446278218c22ef7ab3cfba3c48f90e5b803ca5fd13690aeb8e5d8546"

URI_x86_64_v2_rust-scrypt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt+default-devel-0.11.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt+default-devel}"
SRC_URI[x86_64_v2_rust-scrypt+default-devel.sha256sum] = "d0eb3d9a266cfaa2ae756be69d2eb57028a862419c3e80731040d81cb3dd4a7f"

URI_x86_64_v2_rust-scrypt+password-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt+password-hash-devel-0.11.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt+password-hash-devel}"
SRC_URI[x86_64_v2_rust-scrypt+password-hash-devel.sha256sum] = "dddfc669cae38dffc892056c350c1f6a951b68f0f370dd285bd13c22ee376860"

URI_x86_64_v2_rust-scrypt+simple-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt+simple-devel-0.11.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt+simple-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt+simple-devel}"
SRC_URI[x86_64_v2_rust-scrypt+simple-devel.sha256sum] = "938b576672336589aef4e09239c1f34533b3398d67ad5572c3f020135914ee09"

URI_x86_64_v2_rust-scrypt+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt+std-devel-0.11.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt+std-devel}"
SRC_URI[x86_64_v2_rust-scrypt+std-devel.sha256sum] = "8fb35d82b84420150b075ab2af05c96ff9494d0ef49ccf94199054165f41cbe1"

URI_x86_64_v2_rust-scrypt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt-devel-0.11.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt-devel}"
SRC_URI[x86_64_v2_rust-scrypt-devel.sha256sum] = "4e6807044e14fe5154e8f88d67cf73764738172a6eafb917d08384afea8c2bbd"

URI_aarch64_rust-scrypt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt+default-devel-0.11.0-4.el10_0.noarch.rpm;name=aarch64_rust-scrypt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt+default-devel}"
SRC_URI[aarch64_rust-scrypt+default-devel.sha256sum] = "29a73aa17d0103ca0e727d347826999713418ae922c6955fcd735e40523db421"

URI_aarch64_rust-scrypt+password-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt+password-hash-devel-0.11.0-4.el10_0.noarch.rpm;name=aarch64_rust-scrypt+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt+password-hash-devel}"
SRC_URI[aarch64_rust-scrypt+password-hash-devel.sha256sum] = "c2c98ac466fc6aeee94df81b98aaf31b3fa90423d2a9ebc852806bacd2173a8a"

URI_aarch64_rust-scrypt+simple-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt+simple-devel-0.11.0-4.el10_0.noarch.rpm;name=aarch64_rust-scrypt+simple-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt+simple-devel}"
SRC_URI[aarch64_rust-scrypt+simple-devel.sha256sum] = "dc697bc236d4f7e2f3c64c33f6c7fc6a45380412b47e9f8c992210db409a3b6d"

URI_aarch64_rust-scrypt+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt+std-devel-0.11.0-4.el10_0.noarch.rpm;name=aarch64_rust-scrypt+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt+std-devel}"
SRC_URI[aarch64_rust-scrypt+std-devel.sha256sum] = "7323799bc6d7e52fe36f7017e9e421e71faddd286bfbc611146e2ef729201a3f"

URI_aarch64_rust-scrypt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt-devel-0.11.0-4.el10_0.noarch.rpm;name=aarch64_rust-scrypt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt-devel}"
SRC_URI[aarch64_rust-scrypt-devel.sha256sum] = "2394ad287326552dcfb081763e857687ab883c460cd31577c210f5dea49d6eed"

RDEPENDS:rust-scrypt+default-devel = " \
 cargo \
 rust-scrypt+simple-devel \
 rust-scrypt+std-devel \
 rust-scrypt-devel \
 "
RDEPENDS:rust-scrypt+password-hash-devel = " \
 cargo \
 rust-password-hash+rand_core-devel \
 rust-password-hash-devel \
 rust-scrypt-devel \
 "
RDEPENDS:rust-scrypt+simple-devel = " \
 cargo \
 rust-scrypt+password-hash-devel \
 rust-scrypt-devel \
 "
RDEPENDS:rust-scrypt+std-devel = " \
 cargo \
 rust-password-hash+rand_core-devel \
 rust-password-hash+std-devel \
 rust-password-hash-devel \
 rust-scrypt-devel \
 "
RDEPENDS:rust-scrypt-devel = " \
 cargo \
 rust \
 rust-pbkdf2+default-devel \
 rust-salsa20-devel \
 rust-sha2-devel \
 "
