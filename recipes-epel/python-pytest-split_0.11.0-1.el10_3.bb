# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-split"
PV = "0.11.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-pytest-split \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-split-0.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "deab4486dba5816df5050685178f399ecfde4d4d2636b28f0adfc18644c9f07b"

URI_x86_64_v2_python3-pytest-split = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-split-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-split;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-split}"
SRC_URI[x86_64_v2_python3-pytest-split.sha256sum] = "07f40a359dabe12f0f517040faa7b63d1cbd595abd16606def9223737f4a05a1"

URI_aarch64_python3-pytest-split = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-split-0.11.0-1.el10_3.noarch.rpm;name=aarch64_python3-pytest-split;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-split}"
SRC_URI[aarch64_python3-pytest-split.sha256sum] = "6e8027f9a7d06edf63879c88c2fc1d65e9bce0accfd094abfe3345c8f9902e1d"

RDEPENDS:python3-pytest-split = " \
 python3 \
 python3-pytest \
 "
