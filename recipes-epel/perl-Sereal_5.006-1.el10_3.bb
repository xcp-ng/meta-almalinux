# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sereal"
PV = "5.006"
PR = "1.el10_3"
PACKAGES = " \
 perl-Sereal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sereal-5.006-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc8dbebf49089d0b22e16d7d658420205d6e7503c0e4c834e2e4812f7edd649e"

URI_x86_64_v2_perl-Sereal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sereal-5.006-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sereal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sereal}"
SRC_URI[x86_64_v2_perl-Sereal.sha256sum] = "9e280f4cc8e606dc932958042619af2a5d140d0f47ab9043e51ba31860e69427"

URI_aarch64_perl-Sereal = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sereal-5.006-1.el10_3.noarch.rpm;name=aarch64_perl-Sereal;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sereal}"
SRC_URI[aarch64_perl-Sereal.sha256sum] = "05362912c5a0fee9652b558ea98a8648ceb042ab306ee05e22e9d30aea996683"

RDEPENDS:perl-Sereal = " \
 perl-Exporter \
 perl-Sereal-Decoder \
 perl-Sereal-Encoder \
 perl-libs \
 "
