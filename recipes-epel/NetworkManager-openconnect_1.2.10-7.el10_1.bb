# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager-openconnect"
PV = "1.2.10"
PR = "7.el10_1"
PACKAGES = " \
 NetworkManager-openconnect \
 NetworkManager-openconnect-gnome \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/NetworkManager-openconnect-1.2.10-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3350504911125c1a373baf7c20a84f79bbf52501e4e3f95e0b85188829b65ea9"

URI_x86_64_v2_NetworkManager-openconnect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-openconnect-1.2.10-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-openconnect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-openconnect}"
SRC_URI[x86_64_v2_NetworkManager-openconnect.sha256sum] = "beb80c3a4c94616fb295d0733e65c93d7167a8331a241d46173c3f10d8ceaeb9"

URI_x86_64_v2_NetworkManager-openconnect-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-openconnect-gnome-1.2.10-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-openconnect-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-openconnect-gnome}"
SRC_URI[x86_64_v2_NetworkManager-openconnect-gnome.sha256sum] = "d1bb9c785546fe335994bc2919375cf5fc00177a95c47de991d54785dd49fe4a"

URI_aarch64_NetworkManager-openconnect = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-openconnect-1.2.10-7.el10_1.aarch64.rpm;name=aarch64_NetworkManager-openconnect;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-openconnect}"
SRC_URI[aarch64_NetworkManager-openconnect.sha256sum] = "7d6144bd87a29eb259a10e1789f017198db01fb32f7f0d342ca978a08bbc9c60"

URI_aarch64_NetworkManager-openconnect-gnome = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-openconnect-gnome-1.2.10-7.el10_1.aarch64.rpm;name=aarch64_NetworkManager-openconnect-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-openconnect-gnome}"
SRC_URI[aarch64_NetworkManager-openconnect-gnome.sha256sum] = "ea3918f80a85e08a379583f983ca50006390e90e0c6d54aac5dca315a5258d0e"

RDEPENDS:NetworkManager-openconnect = " \
 NetworkManager \
 NetworkManager-libnm \
 bash \
 dbus-common \
 glib2 \
 glibc \
 libgcc \
 openconnect \
 shadow-utils \
 "
RDEPENDS:NetworkManager-openconnect-gnome = " \
 NetworkManager-libnm \
 NetworkManager-openconnect \
 atk \
 cairo \
 cairo-gobject \
 gcr3 \
 gcr3-base \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk3 \
 gtk4 \
 harfbuzz \
 libnma \
 libnma-gtk4 \
 libsecret \
 libsoup3 \
 libxml2 \
 openconnect \
 pango \
 vulkan-loader \
 webkit2gtk4.1 \
 "
