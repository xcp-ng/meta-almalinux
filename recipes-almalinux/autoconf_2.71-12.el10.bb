# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "autoconf"
PV = "2.71"
PR = "12.el10"
PACKAGES = " \
 autoconf \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/autoconf-2.71-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1729f4f5912142f135df82e9429613886e316656498d852a633e15f2558e1dc"

URI_x86_64_v2_autoconf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/autoconf-2.71-12.el10.noarch.rpm;name=x86_64_v2_autoconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_autoconf}"
SRC_URI[x86_64_v2_autoconf.sha256sum] = "e5c2aaa1797d84dbddbe548d1371722ec6b0071e9bff9900774c5179841f3879"

URI_aarch64_autoconf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/autoconf-2.71-12.el10.noarch.rpm;name=aarch64_autoconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_autoconf}"
SRC_URI[aarch64_autoconf.sha256sum] = "e5c2aaa1797d84dbddbe548d1371722ec6b0071e9bff9900774c5179841f3879"

RDEPENDS:autoconf = " \
 bash \
 emacs-filesystem \
 m4 \
 perl-Carp \
 perl-Class-Struct \
 perl-Data-Dumper \
 perl-Errno \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Temp \
 perl-File-stat \
 perl-Getopt-Long \
 perl-IO \
 perl-POSIX \
 perl-PathTools \
 perl-Text-ParseWords \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
