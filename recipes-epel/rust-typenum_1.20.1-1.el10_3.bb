# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typenum"
PV = "1.20.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-typenum+const-generics-devel \
 rust-typenum+default-devel \
 rust-typenum+i128-devel \
 rust-typenum+strict-devel \
 rust-typenum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typenum-1.20.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd551ae85ab7600b216e3e5a1b4dd37ba39932ef65e7481d3c3042203baf7976"

URI_x86_64_v2_rust-typenum+const-generics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+const-generics-devel-1.20.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+const-generics-devel}"
SRC_URI[x86_64_v2_rust-typenum+const-generics-devel.sha256sum] = "4474b8c0a727320312952b6c1032e9c0c1541741a703162038a1b6b2fe4ffc75"

URI_x86_64_v2_rust-typenum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+default-devel-1.20.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+default-devel}"
SRC_URI[x86_64_v2_rust-typenum+default-devel.sha256sum] = "6fdd2b0e099b2eded12baa42808a17e3f2a0148363069a395e3ae61053637203"

URI_x86_64_v2_rust-typenum+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+i128-devel-1.20.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+i128-devel}"
SRC_URI[x86_64_v2_rust-typenum+i128-devel.sha256sum] = "4b78b7e10bf04930d308e9d57a1f4ecac732a1a2120287bfca9c2eb57af855c8"

URI_x86_64_v2_rust-typenum+strict-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+strict-devel-1.20.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+strict-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+strict-devel}"
SRC_URI[x86_64_v2_rust-typenum+strict-devel.sha256sum] = "4df5b484177091970c8bcdd641858e45aeaa028812db2c1e3d6a628717ad8a9b"

URI_x86_64_v2_rust-typenum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum-devel-1.20.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum-devel}"
SRC_URI[x86_64_v2_rust-typenum-devel.sha256sum] = "33f48d8f4ba9c27111aab1e27c1c5baeaf91b53171b9e59969679d24ea99045c"

URI_aarch64_rust-typenum+const-generics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+const-generics-devel-1.20.1-1.el10_3.noarch.rpm;name=aarch64_rust-typenum+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+const-generics-devel}"
SRC_URI[aarch64_rust-typenum+const-generics-devel.sha256sum] = "5839ead44eb083af139f62e2193fcfd0141ebce80319b22cff183a4c57cbdc5b"

URI_aarch64_rust-typenum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+default-devel-1.20.1-1.el10_3.noarch.rpm;name=aarch64_rust-typenum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+default-devel}"
SRC_URI[aarch64_rust-typenum+default-devel.sha256sum] = "9dceef4ea3599f79292021a0f0193c38607c0798fe4a7da6a76758e99835fd15"

URI_aarch64_rust-typenum+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+i128-devel-1.20.1-1.el10_3.noarch.rpm;name=aarch64_rust-typenum+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+i128-devel}"
SRC_URI[aarch64_rust-typenum+i128-devel.sha256sum] = "f5a8cd8ccee677e31e37d264dd106722053b42eeb4861d4c62006013952aaf78"

URI_aarch64_rust-typenum+strict-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+strict-devel-1.20.1-1.el10_3.noarch.rpm;name=aarch64_rust-typenum+strict-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+strict-devel}"
SRC_URI[aarch64_rust-typenum+strict-devel.sha256sum] = "5e7c7591fd00398152e7e604f1a9fcb44ac138ab2ffbaf93e3f916fbf85e0f8e"

URI_aarch64_rust-typenum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum-devel-1.20.1-1.el10_3.noarch.rpm;name=aarch64_rust-typenum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum-devel}"
SRC_URI[aarch64_rust-typenum-devel.sha256sum] = "6ef85c70960edb0c5afd39cbf45963c0875651ecc165e26e96936e203d3301e2"

RDEPENDS:rust-typenum+const-generics-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+default-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+i128-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+strict-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum-devel = " \
 cargo \
 rust \
 "
