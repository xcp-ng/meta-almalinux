# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "messagelib"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 messagelib \
 messagelib-devel \
 messagelib-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/messagelib-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1e25c8213aca5bbacdd4d425c0d1e0421d5d1ea6dcc8660e8ca455260ce24ce"

URI_x86_64_v2_messagelib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/messagelib-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_messagelib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_messagelib}"
SRC_URI[x86_64_v2_messagelib.sha256sum] = "1648f0a0079ccf3cb90374033d4f29f7a385a0e575d428ecea2eae6b1640a166"

URI_x86_64_v2_messagelib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/messagelib-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_messagelib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_messagelib-devel}"
SRC_URI[x86_64_v2_messagelib-devel.sha256sum] = "08814e34fa896a919b67c1894877438d54353b3acd7708f9b12dff7bbddb9034"

URI_x86_64_v2_messagelib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/messagelib-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_messagelib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_messagelib-doc}"
SRC_URI[x86_64_v2_messagelib-doc.sha256sum] = "7d376fac4b21abc4bf9a38b0d8bb69a23db8c2944cafeb68a0feb85e385bae50"

URI_aarch64_messagelib = "${EPEL_MIRROR}/aarch64/Packages/m/messagelib-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_messagelib;unpack=0"
SRC_URI:append = " ${URI_aarch64_messagelib}"
SRC_URI[aarch64_messagelib.sha256sum] = "a0b10834ce01ef7d6dbe5539bfecc4e081b0dbdb49ad4f2c041d1c50186ebc8a"

URI_aarch64_messagelib-devel = "${EPEL_MIRROR}/aarch64/Packages/m/messagelib-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_messagelib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_messagelib-devel}"
SRC_URI[aarch64_messagelib-devel.sha256sum] = "07415eb704859ad57c73a2bfca832b84bac0b428f88cd390d61c07b1c9bee30e"

URI_aarch64_messagelib-doc = "${EPEL_MIRROR}/aarch64/Packages/m/messagelib-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_messagelib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_messagelib-doc}"
SRC_URI[aarch64_messagelib-doc.sha256sum] = "ff4c17836184193c4a2af65a37531f138a3a4ce15f041cf3b1977a470bb5d04b"

RDEPENDS:messagelib = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-search \
 akonadi-server \
 glibc \
 gpgmepp \
 grantleetheme \
 kf6-karchive \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-ktexttemplate \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kmailtransport \
 kmbox \
 kmime \
 kpimtextedit \
 ktextaddons-qt6 \
 libgcc \
 libgravatar \
 libkdepim \
 libkleo \
 libstdc++ \
 openssl-libs \
 pimcommon \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:messagelib-devel = " \
 akonadi-mime-devel \
 akonadi-server-devel \
 cmake-filesystem \
 kf6-kcontacts-devel \
 kidentitymanagement-devel \
 kmime-devel \
 libkleo-devel \
 messagelib \
 pimcommon-devel \
 qt6-qtwebengine-devel \
 "
RDEPENDS:messagelib-doc = " \
 "
