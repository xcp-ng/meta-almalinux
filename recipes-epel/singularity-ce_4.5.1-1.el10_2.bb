# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "singularity-ce"
PV = "4.5.1"
PR = "1.el10_2"
PACKAGES = " \
 singularity-ce \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/singularity-ce-4.5.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7e7db681bb4fd43d986ef473e749a07d7d8aea0fac775c8e43251a2551007481"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/singularity-ce-4.5.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_singularity-ce;unpack=0"
SRC_URI[x86_64_v2_singularity-ce.sha256sum] = "fab5293dcfbdf1b41b802f1faf6363bebda83d41add7841253093ca13243f3e7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/singularity-ce-4.5.1-1.el10_2.aarch64.rpm;name=aarch64_singularity-ce;unpack=0"
SRC_URI[aarch64_singularity-ce.sha256sum] = "5a4c080e4776030c6f4e6e297147fffda6c62c1ec43f74fcbc1986770d4246b2"

RDEPENDS:singularity-ce = " \
 bash \
 conmon \
 crun \
 cryptsetup \
 fuse \
 fuse3 \
 glibc \
 libseccomp \
 shadow-utils \
 shadow-utils-subid \
 squashfs-tools \
 squashfuse \
 "
