# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-rpm-macros"
PV = "1.3.7"
PR = "1.el10_2"
PACKAGES = " \
 R-rpm-macros \
 R-srpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-rpm-macros-1.3.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77c67726e39e850a1662ac61f9646462444e59edad03172254fde900cc64d022"

URI_x86_64_v2_R-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-rpm-macros-1.3.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_R-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-rpm-macros}"
SRC_URI[x86_64_v2_R-rpm-macros.sha256sum] = "4015c7b703d00d6a6387da65a7be8ce3501a8e77faa3944f82c62c09c8bda2c2"

URI_x86_64_v2_R-srpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-srpm-macros-1.3.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_R-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-srpm-macros}"
SRC_URI[x86_64_v2_R-srpm-macros.sha256sum] = "e0e6758583f6f4629da365e9c5ea03e4e33f58a0f9fcf939feb2fc378e697a4e"

URI_aarch64_R-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/r/R-rpm-macros-1.3.7-1.el10_2.noarch.rpm;name=aarch64_R-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-rpm-macros}"
SRC_URI[aarch64_R-rpm-macros.sha256sum] = "2748acff3368dee64914ae729e7ecde4d931e1416d8c38e8ce1df3a84765d3b9"

URI_aarch64_R-srpm-macros = "${EPEL_MIRROR}/aarch64/Packages/r/R-srpm-macros-1.3.7-1.el10_2.noarch.rpm;name=aarch64_R-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-srpm-macros}"
SRC_URI[aarch64_R-srpm-macros.sha256sum] = "18c054b2365e5a4bff76166b86dbf2d9e3bcc204522d9e1999b2aff7b5836625"

RDEPENDS:R-rpm-macros = " \
 R-core \
 R-srpm-macros \
 rpm \
 "
RDEPENDS:R-srpm-macros = " \
 redhat-rpm-config \
 "
