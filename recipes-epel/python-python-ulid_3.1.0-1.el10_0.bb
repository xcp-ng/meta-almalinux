# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-python-ulid"
PV = "3.1.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-python-ulid \
 python3-python-ulid+pydantic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-python-ulid-3.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc7dec3b4bfbd1c38bcccf018537708f3722ce4add9465ffe20796da6df05c83"

URI_x86_64_v2_python3-python-ulid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-python-ulid-3.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-python-ulid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-python-ulid}"
SRC_URI[x86_64_v2_python3-python-ulid.sha256sum] = "ef7fc2d7fe425e66922b0ee3fc6c9ea5d5d2564c6f6f0daa9be0a8232a32ef5b"

URI_x86_64_v2_python3-python-ulid+pydantic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-python-ulid+pydantic-3.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-python-ulid+pydantic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-python-ulid+pydantic}"
SRC_URI[x86_64_v2_python3-python-ulid+pydantic.sha256sum] = "487599158cb3e1591311c4f69d03a2850edb26f5c18e646207e71fa1560350bf"

URI_aarch64_python3-python-ulid = "${EPEL_MIRROR}/aarch64/Packages/p/python3-python-ulid-3.1.0-1.el10_0.noarch.rpm;name=aarch64_python3-python-ulid;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-python-ulid}"
SRC_URI[aarch64_python3-python-ulid.sha256sum] = "6f16c92a4c71afaf63ac8fcf62e393d2d6b267be9b4c2be311421e76d532a4fc"

URI_aarch64_python3-python-ulid+pydantic = "${EPEL_MIRROR}/aarch64/Packages/p/python3-python-ulid+pydantic-3.1.0-1.el10_0.noarch.rpm;name=aarch64_python3-python-ulid+pydantic;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-python-ulid+pydantic}"
SRC_URI[aarch64_python3-python-ulid+pydantic.sha256sum] = "4cc88e42e11e3f53603106de3b53d4452619968f7a9c6184d06a96ee8f9629be"

RDEPENDS:python3-python-ulid = " \
 python3 \
 "
RDEPENDS:python3-python-ulid+pydantic = " \
 python3 \
 python3-pydantic \
 python3-python-ulid \
 "
