# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-dependency"
PV = "0.6.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-pytest-dependency \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-dependency-0.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "822d85baf532deb7455aa9a24db90fbbf5802408d5f1bffc96e72fa6e01be4aa"

URI_x86_64_v2_python3-pytest-dependency = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-dependency-0.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-dependency;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-dependency}"
SRC_URI[x86_64_v2_python3-pytest-dependency.sha256sum] = "694dbd866cd4a25856027442fa16e5818eb21280bf3a29e6ab0e82978b9b72e7"

URI_aarch64_python3-pytest-dependency = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-dependency-0.6.0-1.el10_0.noarch.rpm;name=aarch64_python3-pytest-dependency;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-dependency}"
SRC_URI[aarch64_python3-pytest-dependency.sha256sum] = "817421c30f2ef16b48033ca9a2afc496b4397f3a892deabe82c74ebc579dee19"

RDEPENDS:python3-pytest-dependency = " \
 python3 \
 python3-pytest \
 python3-setuptools \
 "
