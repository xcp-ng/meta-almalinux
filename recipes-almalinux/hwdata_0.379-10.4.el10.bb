# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hwdata"
PV = "0.379"
PR = "10.4.el10"
PACKAGES = " \
 hwdata \
 hwdata-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/hwdata-0.379-10.4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1768c83cabb6a95eddf3247cf36a86c6725e023088b5e4211f62fc461cac6b93"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/hwdata-0.379-10.4.el10.noarch.rpm;name=x86_64_v2_hwdata;unpack=0"
SRC_URI[x86_64_v2_hwdata.sha256sum] = "8791f482deedf0489e583f12f5c0093596083901277f1d875f80bc333008150e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/hwdata-devel-0.379-10.4.el10.noarch.rpm;name=x86_64_v2_hwdata-devel;unpack=0"
SRC_URI[x86_64_v2_hwdata-devel.sha256sum] = "39960cb2c778971be67cffd9699f5c7d9661122c21d070e8a6c450a6c95b802d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/hwdata-0.379-10.4.el10.noarch.rpm;name=aarch64_hwdata;unpack=0"
SRC_URI[aarch64_hwdata.sha256sum] = "8791f482deedf0489e583f12f5c0093596083901277f1d875f80bc333008150e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/hwdata-devel-0.379-10.4.el10.noarch.rpm;name=aarch64_hwdata-devel;unpack=0"
SRC_URI[aarch64_hwdata-devel.sha256sum] = "39960cb2c778971be67cffd9699f5c7d9661122c21d070e8a6c450a6c95b802d"

RDEPENDS:hwdata = " \
 "
RDEPENDS:hwdata-devel = " \
 hwdata \
 pkgconf-pkg-config \
 "
