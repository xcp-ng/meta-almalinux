# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-validation-layers"
PV = "1.4.304.0"
PR = "1.el10"
PACKAGES = " \
 vulkan-validation-layers \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-validation-layers-1.4.304.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27ee11ca36b3cd216455f406874247e4ab77dc2f161b1caa35773ee86cbfe081"

URI_x86_64_v2_vulkan-validation-layers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-validation-layers-1.4.304.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-validation-layers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-validation-layers}"
SRC_URI[x86_64_v2_vulkan-validation-layers.sha256sum] = "c4b56fba765700007939e070b29d1e44cd7f8505686f8e6fa857bd5eeab5fff8"

URI_aarch64_vulkan-validation-layers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-validation-layers-1.4.304.0-1.el10.aarch64.rpm;name=aarch64_vulkan-validation-layers;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-validation-layers}"
SRC_URI[aarch64_vulkan-validation-layers.sha256sum] = "7b010dbd6f6b35201f7ba0bdcb5cfa14244ae49405a1e45563af658d9dd0bc1b"

RDEPENDS:vulkan-validation-layers = " \
 glibc \
 libgcc \
 libstdc++ \
 spirv-tools-libs \
 "
