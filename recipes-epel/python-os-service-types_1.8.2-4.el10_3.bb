# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-os-service-types"
PV = "1.8.2"
PR = "4.el10_3"
PACKAGES = " \
 python-os-service-types-doc \
 python3-os-service-types \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-os-service-types-1.8.2-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7c85b95ac36c578e1577fac88edc1b142b8e4f8d99ddb4db4f4382d0a937928"

URI_x86_64_v2_python-os-service-types-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-os-service-types-doc-1.8.2-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-os-service-types-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-os-service-types-doc}"
SRC_URI[x86_64_v2_python-os-service-types-doc.sha256sum] = "36a2ee0809a1d0e309c4e91706af95092fc371d3131e98fbf452f57fa56392d3"

URI_x86_64_v2_python3-os-service-types = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-os-service-types-1.8.2-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-os-service-types;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-os-service-types}"
SRC_URI[x86_64_v2_python3-os-service-types.sha256sum] = "431a1129226318ec020266a1cfe3985c5c4bfe0b8f1f164965368d6271876d30"

URI_aarch64_python-os-service-types-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-os-service-types-doc-1.8.2-4.el10_3.noarch.rpm;name=aarch64_python-os-service-types-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-os-service-types-doc}"
SRC_URI[aarch64_python-os-service-types-doc.sha256sum] = "b1462df4c71772d0b9c057fe306f0e7dd5cb354a5e7b13db23b3fc6ae7173acb"

URI_aarch64_python3-os-service-types = "${EPEL_MIRROR}/aarch64/Packages/p/python3-os-service-types-1.8.2-4.el10_3.noarch.rpm;name=aarch64_python3-os-service-types;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-os-service-types}"
SRC_URI[aarch64_python3-os-service-types.sha256sum] = "758997cd97b11c39a99b4b383f74d553588a3056e965b9e7bc2c063fd262c755"

RDEPENDS:python-os-service-types-doc = " \
 python3-os-service-types \
 "
RDEPENDS:python3-os-service-types = " \
 python3 \
 python3-pbr \
 python3-typing-extensions \
 "
