# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpipewire"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kpipewire \
 kpipewire-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpipewire-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d0ea97d8e797cec0a4a1d136925f71ca50c2934f81d60061b42baf8a344ee5f"

URI_x86_64_v2_kpipewire = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpipewire-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpipewire;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpipewire}"
SRC_URI[x86_64_v2_kpipewire.sha256sum] = "e81cadcc56b82e071745bb679f9c5949428b899e004ad447455a394f0d418a3f"

URI_x86_64_v2_kpipewire-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpipewire-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpipewire-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpipewire-devel}"
SRC_URI[x86_64_v2_kpipewire-devel.sha256sum] = "99044425a74537e8615a00c18623d999bdc989a3c4f268a30f0db4290520cd5f"

URI_aarch64_kpipewire = "${EPEL_MIRROR}/aarch64/Packages/k/kpipewire-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kpipewire;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpipewire}"
SRC_URI[aarch64_kpipewire.sha256sum] = "36264c33d49e35f531398bceb28da465f9ffc5b3547c1a7ff2f014d2f67e6190"

URI_aarch64_kpipewire-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpipewire-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kpipewire-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpipewire-devel}"
SRC_URI[aarch64_kpipewire-devel.sha256sum] = "79d154bc3da1d6c04dd847cbc438e7c74f15921377d12414699ff6f76b764730"

RDEPENDS:kpipewire = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libdrm \
 libepoxy \
 libgcc \
 libstdc++ \
 libva \
 mesa-libgbm \
 pipewire-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kpipewire-devel = " \
 cmake-filesystem \
 kpipewire \
 pipewire-devel \
 "
