# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdk-pixbuf2"
PV = "2.42.12"
PR = "5.el10"
PACKAGES = " \
 gdk-pixbuf2 \
 gdk-pixbuf2-devel \
 gdk-pixbuf2-modules \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdk-pixbuf2-2.42.12-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e36ebcde2cb3450365c387226f9793479cb0451ea4af7c8e6dceb43b66ffc978"

URI_x86_64_v2_gdk-pixbuf2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdk-pixbuf2-2.42.12-5.el10.x86_64_v2.rpm;name=x86_64_v2_gdk-pixbuf2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdk-pixbuf2}"
SRC_URI[x86_64_v2_gdk-pixbuf2.sha256sum] = "560f09cb4fa7fed6847df0c1697f647ab4348be47517faa03db317b0a63a9489"

URI_x86_64_v2_gdk-pixbuf2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdk-pixbuf2-devel-2.42.12-5.el10.x86_64_v2.rpm;name=x86_64_v2_gdk-pixbuf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdk-pixbuf2-devel}"
SRC_URI[x86_64_v2_gdk-pixbuf2-devel.sha256sum] = "035aecabb3131ccc39b237a77f206c9a649260f857aa13ba4a13ed0393439a6b"

URI_x86_64_v2_gdk-pixbuf2-modules = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdk-pixbuf2-modules-2.42.12-5.el10.x86_64_v2.rpm;name=x86_64_v2_gdk-pixbuf2-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdk-pixbuf2-modules}"
SRC_URI[x86_64_v2_gdk-pixbuf2-modules.sha256sum] = "e58dacafbe40c109b11469ddfe9e466b487aac80fc56735f30a41089ee510eb6"

URI_aarch64_gdk-pixbuf2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdk-pixbuf2-2.42.12-5.el10.aarch64.rpm;name=aarch64_gdk-pixbuf2;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdk-pixbuf2}"
SRC_URI[aarch64_gdk-pixbuf2.sha256sum] = "b708e5ea4ffa8492284e82262ea7b35d211ffd4113a4b52195c3c3e19f49ea8e"

URI_aarch64_gdk-pixbuf2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdk-pixbuf2-devel-2.42.12-5.el10.aarch64.rpm;name=aarch64_gdk-pixbuf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdk-pixbuf2-devel}"
SRC_URI[aarch64_gdk-pixbuf2-devel.sha256sum] = "2c3d1511da8b5a9024f4634b52184ad2432100320d857f2aa96df4f7d6812ac9"

URI_aarch64_gdk-pixbuf2-modules = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdk-pixbuf2-modules-2.42.12-5.el10.aarch64.rpm;name=aarch64_gdk-pixbuf2-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdk-pixbuf2-modules}"
SRC_URI[aarch64_gdk-pixbuf2-modules.sha256sum] = "ad27db26f7b52ce22e95d4024e8a07572f28729b1d015fbc1c3c5d0dd2a3bea0"

RDEPENDS:gdk-pixbuf2 = " \
 bash \
 glib2 \
 glibc \
 libjpeg-turbo \
 libpng \
 shared-mime-info \
 "
RDEPENDS:gdk-pixbuf2-devel = " \
 gdk-pixbuf2 \
 glib2 \
 glib2-devel \
 glibc \
 libjpeg-turbo-devel \
 libpng-devel \
 libtiff-devel \
 pkgconf-pkg-config \
 shared-mime-info \
 "
RDEPENDS:gdk-pixbuf2-modules = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libtiff \
 "
