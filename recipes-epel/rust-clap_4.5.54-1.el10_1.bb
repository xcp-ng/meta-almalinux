# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap"
PV = "4.5.54"
PR = "1.el10_1"
PACKAGES = " \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+debug-devel \
 rust-clap+default-devel \
 rust-clap+deprecated-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+error-context-devel \
 rust-clap+help-devel \
 rust-clap+std-devel \
 rust-clap+string-devel \
 rust-clap+suggestions-devel \
 rust-clap+unicode-devel \
 rust-clap+unstable-doc-devel \
 rust-clap+unstable-ext-devel \
 rust-clap+unstable-markdown-devel \
 rust-clap+unstable-styles-devel \
 rust-clap+unstable-v5-devel \
 rust-clap+usage-devel \
 rust-clap+wrap_help-devel \
 rust-clap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap-4.5.54-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf1264bc037de64babcc3c24b6b923e5dda2a214ae7c4f39b203b3a1f656c795"

URI_x86_64_v2_rust-clap+cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+cargo-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+cargo-devel}"
SRC_URI[x86_64_v2_rust-clap+cargo-devel.sha256sum] = "6e776a179b3c9ad5ddac9b9ea8b0784aa0b58f1788d35ac27850086ef0e19053"

URI_x86_64_v2_rust-clap+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+color-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+color-devel}"
SRC_URI[x86_64_v2_rust-clap+color-devel.sha256sum] = "ee7c239b06ad6c48554ade0822d7a379ef5ad7522c363b41e1f6ed9a36b0f3bb"

URI_x86_64_v2_rust-clap+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+debug-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+debug-devel}"
SRC_URI[x86_64_v2_rust-clap+debug-devel.sha256sum] = "c85f873ee5b5e1bac423ced50fb96e4c5a08ba271bab990bdfb81b7a82854e66"

URI_x86_64_v2_rust-clap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+default-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+default-devel}"
SRC_URI[x86_64_v2_rust-clap+default-devel.sha256sum] = "736126f3e3ff7561affadff12572130d66500873886f1de358166571d33a014a"

URI_x86_64_v2_rust-clap+deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+deprecated-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap+deprecated-devel.sha256sum] = "a6eaf2fd5d4eefedd3a6b2b7ce002dac0f01ea1b2d73788c7f2f29ac1a1e1838"

URI_x86_64_v2_rust-clap+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+derive-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+derive-devel}"
SRC_URI[x86_64_v2_rust-clap+derive-devel.sha256sum] = "d2d3c1f6748b22cb4f456ff6c50a2f806aca4a7b2b37945c15e979e7bb618d19"

URI_x86_64_v2_rust-clap+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+env-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+env-devel}"
SRC_URI[x86_64_v2_rust-clap+env-devel.sha256sum] = "c229e4acb17fdcd30b13a8698329f5a1dbc1f0b14879b6558cacfd1c38517103"

URI_x86_64_v2_rust-clap+error-context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+error-context-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+error-context-devel}"
SRC_URI[x86_64_v2_rust-clap+error-context-devel.sha256sum] = "4163f013e7a68a6b5244f102f24040ab9b4713430c7d62f5fe1db006546e7af3"

URI_x86_64_v2_rust-clap+help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+help-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+help-devel}"
SRC_URI[x86_64_v2_rust-clap+help-devel.sha256sum] = "c24b14161948ab8f8fb240cc6c7e39d84641866d9081adbdcbb6ac3cb1b01707"

URI_x86_64_v2_rust-clap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+std-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+std-devel}"
SRC_URI[x86_64_v2_rust-clap+std-devel.sha256sum] = "3d13705e7f7dcdb0c6b5e1a73607ed6b8231bf1d37f0000409c4b2135239f17a"

URI_x86_64_v2_rust-clap+string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+string-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+string-devel}"
SRC_URI[x86_64_v2_rust-clap+string-devel.sha256sum] = "22082cfaa2ae67039899a8464ac2b1d9876308d53d2d2e4b904f917f94848089"

URI_x86_64_v2_rust-clap+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+suggestions-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+suggestions-devel}"
SRC_URI[x86_64_v2_rust-clap+suggestions-devel.sha256sum] = "8d7db496d610f757c0ece75794b3dd8b6733cec8265385c219bcef03a0e8b23d"

URI_x86_64_v2_rust-clap+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unicode-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unicode-devel}"
SRC_URI[x86_64_v2_rust-clap+unicode-devel.sha256sum] = "22ab0d2ac12c9890b03a75b014ff7d31075d8799aafbe6b43f64181b29a5740f"

URI_x86_64_v2_rust-clap+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-doc-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-doc-devel.sha256sum] = "76e1cb70889511f0834a8d23a3510c1fb61cf5c47f42a3e0a0cb111fe01a8d59"

URI_x86_64_v2_rust-clap+unstable-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-ext-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-ext-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-ext-devel.sha256sum] = "1efab1d3a5bbae3978598dc0bbd74253e3e74abf15baa5ae729a00293728da52"

URI_x86_64_v2_rust-clap+unstable-markdown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-markdown-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-markdown-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-markdown-devel.sha256sum] = "db02d0e7154ccbeb2d37c87ad7f66a8dc0cfd5d1ad034cd3b695a6ec803ee61c"

URI_x86_64_v2_rust-clap+unstable-styles-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-styles-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-styles-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-styles-devel.sha256sum] = "71e79afbf24befe2b9509de8787c0bf7b1edd88972d42ee7eae4fa4308b25c22"

URI_x86_64_v2_rust-clap+unstable-v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-v5-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-v5-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-v5-devel.sha256sum] = "1ba664d0fff25e13b79829bc28f4ff669c797d1a7051122dc61414180cf7d139"

URI_x86_64_v2_rust-clap+usage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+usage-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+usage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+usage-devel}"
SRC_URI[x86_64_v2_rust-clap+usage-devel.sha256sum] = "67d380077949c999930989b94dd1ee381d31332c7c0b32a1b23977315be99f0d"

URI_x86_64_v2_rust-clap+wrap_help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+wrap_help-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+wrap_help-devel}"
SRC_URI[x86_64_v2_rust-clap+wrap_help-devel.sha256sum] = "ec6e7756c40e7880a0bda95a2a218fa3f0e139683820ad4eda5c81511f66a76b"

URI_x86_64_v2_rust-clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-devel}"
SRC_URI[x86_64_v2_rust-clap-devel.sha256sum] = "879b173d9b8b6fe1db8cb45c220f6e7ccbc900349611f71a21f1a0b18d11337f"

URI_aarch64_rust-clap+cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+cargo-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+cargo-devel}"
SRC_URI[aarch64_rust-clap+cargo-devel.sha256sum] = "8aff5943266d06e257206d06d3ba204163c55fd7b8ce2f9d2a1ba85a3aedd53e"

URI_aarch64_rust-clap+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+color-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+color-devel}"
SRC_URI[aarch64_rust-clap+color-devel.sha256sum] = "d2256a59235c4fc8193cb9d577a2f6ebb6000fdca1246614eddfcc7451b55934"

URI_aarch64_rust-clap+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+debug-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+debug-devel}"
SRC_URI[aarch64_rust-clap+debug-devel.sha256sum] = "dea1e3d1f0a9d9ad6f223b1697d59d23a09970c0a6ced26272b5a4342208b30b"

URI_aarch64_rust-clap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+default-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+default-devel}"
SRC_URI[aarch64_rust-clap+default-devel.sha256sum] = "58a49ec0ebe10a68dd773381aec15d435118a3a79ceaa5638b17ffe73fde2fec"

URI_aarch64_rust-clap+deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+deprecated-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+deprecated-devel}"
SRC_URI[aarch64_rust-clap+deprecated-devel.sha256sum] = "df863a2d1b4aaae2d4d5d5f325638888c6e1b6c988ed95213a2fa23b06338656"

URI_aarch64_rust-clap+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+derive-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+derive-devel}"
SRC_URI[aarch64_rust-clap+derive-devel.sha256sum] = "e6a1c3b708e327a091f537997f71b7ee6a418d25c548dc51cecedeb7f9439265"

URI_aarch64_rust-clap+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+env-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+env-devel}"
SRC_URI[aarch64_rust-clap+env-devel.sha256sum] = "c96178f3f094ce0a61e5682506d913964ce4360ceee1a3b1bb3ef15c6c68e8a5"

URI_aarch64_rust-clap+error-context-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+error-context-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+error-context-devel}"
SRC_URI[aarch64_rust-clap+error-context-devel.sha256sum] = "81a96a91e94b17c67d8e9f7d0c0a2faff73536457dfed224a825896dff3a528e"

URI_aarch64_rust-clap+help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+help-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+help-devel}"
SRC_URI[aarch64_rust-clap+help-devel.sha256sum] = "dc0e0dd708ad4823ac6f89327446263b159b156aee6d3cc6488c917670822488"

URI_aarch64_rust-clap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+std-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+std-devel}"
SRC_URI[aarch64_rust-clap+std-devel.sha256sum] = "3383c481545b8b291c4dd5a53e3bb248fae6afa0fba6400512e84d4fca4f1c5a"

URI_aarch64_rust-clap+string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+string-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+string-devel}"
SRC_URI[aarch64_rust-clap+string-devel.sha256sum] = "a339c06642d9b4fb52e421fc61f4bf210f8a9d4692ebabbb5bcacf249ed1f061"

URI_aarch64_rust-clap+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+suggestions-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+suggestions-devel}"
SRC_URI[aarch64_rust-clap+suggestions-devel.sha256sum] = "846efa015af896a3d3e111bbf13d3edbe9d265f986ecc9298ff4d19a399efb90"

URI_aarch64_rust-clap+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unicode-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unicode-devel}"
SRC_URI[aarch64_rust-clap+unicode-devel.sha256sum] = "6b4d9f7a103f7d937006e5429e4529a8daf591dacc60358113f4e734d8f43968"

URI_aarch64_rust-clap+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-doc-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-doc-devel}"
SRC_URI[aarch64_rust-clap+unstable-doc-devel.sha256sum] = "1615164a15e2e529fecd530dcb99fc496e49084ea5716ca47e21bcb2c5210476"

URI_aarch64_rust-clap+unstable-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-ext-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-ext-devel}"
SRC_URI[aarch64_rust-clap+unstable-ext-devel.sha256sum] = "d7354d1791ffe0ba0f288f6dfae37faf3f19ee3cb5e3d9ac37f363882b5ec19d"

URI_aarch64_rust-clap+unstable-markdown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-markdown-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-markdown-devel}"
SRC_URI[aarch64_rust-clap+unstable-markdown-devel.sha256sum] = "9cb3382fa3ad7a0e99974537b4ab885ee4efa9895384852bb37cd4ba4d35c585"

URI_aarch64_rust-clap+unstable-styles-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-styles-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-styles-devel}"
SRC_URI[aarch64_rust-clap+unstable-styles-devel.sha256sum] = "15bd36425f54258f1d5621af470414153af405ae57727daa1ba746eb51ac5122"

URI_aarch64_rust-clap+unstable-v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-v5-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-v5-devel}"
SRC_URI[aarch64_rust-clap+unstable-v5-devel.sha256sum] = "a51385afb92ab1c353c09d13875dbf21350045d481bb2e2eb4066006cc339e07"

URI_aarch64_rust-clap+usage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+usage-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+usage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+usage-devel}"
SRC_URI[aarch64_rust-clap+usage-devel.sha256sum] = "69b37d887f6add3980213d3cfbdddf1a2bc3f9cc130842b1bd37409e3ca2821d"

URI_aarch64_rust-clap+wrap_help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+wrap_help-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+wrap_help-devel}"
SRC_URI[aarch64_rust-clap+wrap_help-devel.sha256sum] = "ae6d5557ce42a7d4a2622a88b6e24de420d4d7f2ecbddfd26afcec313d75b5dc"

URI_aarch64_rust-clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-devel}"
SRC_URI[aarch64_rust-clap-devel.sha256sum] = "8a9017aa5251450f324393193bf7f3ab605b54fa6471c6984731bf49dacac75f"

RDEPENDS:rust-clap+cargo-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+cargo-devel \
 "
RDEPENDS:rust-clap+color-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+color-devel \
 "
RDEPENDS:rust-clap+debug-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+debug-devel \
 rust-clap_derive+debug-devel \
 rust-clap_derive+default-devel \
 "
RDEPENDS:rust-clap+default-devel = " \
 cargo \
 rust-clap+color-devel \
 rust-clap+error-context-devel \
 rust-clap+help-devel \
 rust-clap+std-devel \
 rust-clap+suggestions-devel \
 rust-clap+usage-devel \
 rust-clap-devel \
 "
RDEPENDS:rust-clap+deprecated-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+deprecated-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+deprecated-devel \
 "
RDEPENDS:rust-clap+derive-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_derive+default-devel \
 "
RDEPENDS:rust-clap+env-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+env-devel \
 "
RDEPENDS:rust-clap+error-context-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+error-context-devel \
 "
RDEPENDS:rust-clap+help-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+help-devel \
 "
RDEPENDS:rust-clap+std-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+std-devel \
 "
RDEPENDS:rust-clap+string-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+string-devel \
 "
RDEPENDS:rust-clap+suggestions-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+suggestions-devel \
 "
RDEPENDS:rust-clap+unicode-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+unicode-devel \
 "
RDEPENDS:rust-clap+unstable-doc-devel = " \
 cargo \
 rust-clap+derive-devel \
 rust-clap-devel \
 rust-clap_builder+unstable-doc-devel \
 "
RDEPENDS:rust-clap+unstable-ext-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+unstable-ext-devel \
 "
RDEPENDS:rust-clap+unstable-markdown-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+unstable-markdown-devel \
 "
RDEPENDS:rust-clap+unstable-styles-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+unstable-styles-devel \
 "
RDEPENDS:rust-clap+unstable-v5-devel = " \
 cargo \
 rust-clap+deprecated-devel \
 rust-clap-devel \
 rust-clap_builder+unstable-v5-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+unstable-v5-devel \
 "
RDEPENDS:rust-clap+usage-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+usage-devel \
 "
RDEPENDS:rust-clap+wrap_help-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+wrap_help-devel \
 "
RDEPENDS:rust-clap-devel = " \
 cargo \
 rust \
 rust-clap_builder-devel \
 "
