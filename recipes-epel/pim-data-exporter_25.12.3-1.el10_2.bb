# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pim-data-exporter"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 pim-data-exporter \
 pim-data-exporter-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pim-data-exporter-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be7d487531bf981035fd6db069f8b93d638c6228e4ecd42935059d742c1405f9"

URI_x86_64_v2_pim-data-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pim-data-exporter-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pim-data-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pim-data-exporter}"
SRC_URI[x86_64_v2_pim-data-exporter.sha256sum] = "32b1d0d4039ac6712a9137f77904c1610959004a79660cea395cd30e78af39a8"

URI_x86_64_v2_pim-data-exporter-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pim-data-exporter-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pim-data-exporter-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pim-data-exporter-libs}"
SRC_URI[x86_64_v2_pim-data-exporter-libs.sha256sum] = "e4345e1a3e9d14940a5c6fc3d4d24e653ce6908bb6f698e659f95f4b22ea5b40"

URI_aarch64_pim-data-exporter = "${EPEL_MIRROR}/aarch64/Packages/p/pim-data-exporter-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_pim-data-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_pim-data-exporter}"
SRC_URI[aarch64_pim-data-exporter.sha256sum] = "6d8594c74a8999d6bd7306e82b7b284145b150edcc5931fd833d3f0d28166c96"

URI_aarch64_pim-data-exporter-libs = "${EPEL_MIRROR}/aarch64/Packages/p/pim-data-exporter-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_pim-data-exporter-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pim-data-exporter-libs}"
SRC_URI[aarch64_pim-data-exporter-libs.sha256sum] = "ddf7aab2ff5e64c57f68771a287aaabb30b9cf7c998e19959cb8c3b4fa9e7037"

RDEPENDS:pim-data-exporter = " \
 akonadi-server \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kitemviews \
 kf6-kstatusnotifieritem \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 mailcommon \
 pim-data-exporter-libs \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pim-data-exporter-libs = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kf6-karchive \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kidentitymanagement \
 kmailtransport \
 kmime \
 libgcc \
 libstdc++ \
 mailcommon \
 pim-data-exporter \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
