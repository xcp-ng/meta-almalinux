# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdwarf"
PE = "1"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 libdwarf \
 libdwarf-devel \
 libdwarf-static \
 libdwarf-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdwarf-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bed732f17b70de393ec37dbcb8b5079cb1ce200ff9acfa67be463b544d028c0"

URI_x86_64_v2_libdwarf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdwarf-2.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdwarf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdwarf}"
SRC_URI[x86_64_v2_libdwarf.sha256sum] = "811b8c89d25d6cf359d5afbefb742505872ebf8c0596e0fcb7f91a2d36d6a57c"

URI_x86_64_v2_libdwarf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdwarf-devel-2.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdwarf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdwarf-devel}"
SRC_URI[x86_64_v2_libdwarf-devel.sha256sum] = "2b99eed4acd6d28b23eefa20ff018d5b2babb590a646663327d610db31f008da"

URI_x86_64_v2_libdwarf-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdwarf-static-2.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdwarf-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdwarf-static}"
SRC_URI[x86_64_v2_libdwarf-static.sha256sum] = "5eb1ddd1d28ecd9a0f74aeaea673a012fd27dd804b5a3bae48a1e9238ddb965f"

URI_x86_64_v2_libdwarf-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdwarf-tools-2.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdwarf-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdwarf-tools}"
SRC_URI[x86_64_v2_libdwarf-tools.sha256sum] = "00eeed99aa1d0fa9bf1166d16d48259f0701af97350762106923e0587e367ae5"

URI_aarch64_libdwarf = "${EPEL_MIRROR}/aarch64/Packages/l/libdwarf-2.2.0-1.el10_2.aarch64.rpm;name=aarch64_libdwarf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdwarf}"
SRC_URI[aarch64_libdwarf.sha256sum] = "95aa2effdc205a6f802c74bb0a802a2b5415a49d24067c95738556107754b21f"

URI_aarch64_libdwarf-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdwarf-devel-2.2.0-1.el10_2.aarch64.rpm;name=aarch64_libdwarf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdwarf-devel}"
SRC_URI[aarch64_libdwarf-devel.sha256sum] = "e8e0fb85219b8cbf97aa57a93d97eba256434ad0438c626c53139f9d6fb39708"

URI_aarch64_libdwarf-static = "${EPEL_MIRROR}/aarch64/Packages/l/libdwarf-static-2.2.0-1.el10_2.aarch64.rpm;name=aarch64_libdwarf-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdwarf-static}"
SRC_URI[aarch64_libdwarf-static.sha256sum] = "3bfc0d25523664c494f2d3c4368d7665849dad758dbaeddaa9bd92800c3ae84e"

URI_aarch64_libdwarf-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libdwarf-tools-2.2.0-1.el10_2.aarch64.rpm;name=aarch64_libdwarf-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdwarf-tools}"
SRC_URI[aarch64_libdwarf-tools.sha256sum] = "539de2e89276c733136c82e9eeeda85c1ed15b3b463055e195ce613cd13f9101"

RDEPENDS:libdwarf = " \
 glibc \
 "
RDEPENDS:libdwarf-devel = " \
 libdwarf \
 libzstd-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libdwarf-static = " \
 libdwarf-devel \
 "
RDEPENDS:libdwarf-tools = " \
 glibc \
 libdwarf \
 libgcc \
 libstdc++ \
 "
