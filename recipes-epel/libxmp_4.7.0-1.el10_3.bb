# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxmp"
PV = "4.7.0"
PR = "1.el10_3"
PACKAGES = " \
 libxmp \
 libxmp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libxmp-4.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d109521ea634d3bf03e4710e127d59eadcce110a23a5621928c3b5426d0182d"

URI_x86_64_v2_libxmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxmp-4.7.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxmp}"
SRC_URI[x86_64_v2_libxmp.sha256sum] = "2e8e4b01badb5e512f52a5e039d1f02d87a0746d1c9aa488f2c60dd61e7906dd"

URI_x86_64_v2_libxmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxmp-devel-4.7.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxmp-devel}"
SRC_URI[x86_64_v2_libxmp-devel.sha256sum] = "4e6aff81c01d73d1ff4352d804e6c3c0224ce3eeb8cbfc1d26002e6ac71bc174"

URI_aarch64_libxmp = "${EPEL_MIRROR}/aarch64/Packages/l/libxmp-4.7.0-1.el10_3.aarch64.rpm;name=aarch64_libxmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxmp}"
SRC_URI[aarch64_libxmp.sha256sum] = "f46d5ba9b591dbda626526d3c2c25a32aaf09735ec7c7bb09c84681e14293df6"

URI_aarch64_libxmp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libxmp-devel-4.7.0-1.el10_3.aarch64.rpm;name=aarch64_libxmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxmp-devel}"
SRC_URI[aarch64_libxmp-devel.sha256sum] = "1c8831f09665929783b58e85a1e149f91457650e1845e2e835ef2bd9f7dd55f8"

RDEPENDS:libxmp = " \
 glibc \
 "
RDEPENDS:libxmp-devel = " \
 cmake-filesystem \
 libxmp \
 pkgconf-pkg-config \
 "
