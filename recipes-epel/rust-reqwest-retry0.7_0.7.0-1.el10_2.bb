# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest-retry0.7"
PV = "0.7.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqwest-retry0.7+default-devel \
 rust-reqwest-retry0.7+tracing-devel \
 rust-reqwest-retry0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest-retry0.7-0.7.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af69aa57e7f985abd3f870e9072fd19c6ec524a452cb0ac474790d5575b88680"

URI_x86_64_v2_rust-reqwest-retry0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-retry0.7+default-devel-0.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-retry0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-retry0.7+default-devel}"
SRC_URI[x86_64_v2_rust-reqwest-retry0.7+default-devel.sha256sum] = "62cac7ab48f21612ad3a0509e4241fc35b2e2578eb30a3b45990102e127a289c"

URI_x86_64_v2_rust-reqwest-retry0.7+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-retry0.7+tracing-devel-0.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-retry0.7+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-retry0.7+tracing-devel}"
SRC_URI[x86_64_v2_rust-reqwest-retry0.7+tracing-devel.sha256sum] = "39d51cc51125f3b6aa263d2160703a569d4385546129b19dea9ecb229fe2b9ad"

URI_x86_64_v2_rust-reqwest-retry0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-retry0.7-devel-0.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-retry0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-retry0.7-devel}"
SRC_URI[x86_64_v2_rust-reqwest-retry0.7-devel.sha256sum] = "57cfc2d776d8c10ad965be084df5a9b52944ca38433b10a3753fcfb67adc881b"

URI_aarch64_rust-reqwest-retry0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-retry0.7+default-devel-0.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-retry0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-retry0.7+default-devel}"
SRC_URI[aarch64_rust-reqwest-retry0.7+default-devel.sha256sum] = "f4ff8de236fcc4c99e9dc1e2c5b6708d672d96c347f56ac9c8e3883d1f118022"

URI_aarch64_rust-reqwest-retry0.7+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-retry0.7+tracing-devel-0.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-retry0.7+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-retry0.7+tracing-devel}"
SRC_URI[aarch64_rust-reqwest-retry0.7+tracing-devel.sha256sum] = "cabaddd1aecc58e49e7aa1af5bdfc8b55564225ced43bb9eb4240e211eb9db4f"

URI_aarch64_rust-reqwest-retry0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-retry0.7-devel-0.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-retry0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-retry0.7-devel}"
SRC_URI[aarch64_rust-reqwest-retry0.7-devel.sha256sum] = "401e2c2f12d6bda3a7794f13ba955779e7f5f4f610ccaf05436c5de6b1931b7c"

RDEPENDS:rust-reqwest-retry0.7+default-devel = " \
 cargo \
 rust-reqwest-retry0.7+tracing-devel \
 rust-reqwest-retry0.7-devel \
 "
RDEPENDS:rust-reqwest-retry0.7+tracing-devel = " \
 cargo \
 rust-reqwest-retry0.7-devel \
 rust-tracing+default-devel \
 "
RDEPENDS:rust-reqwest-retry0.7-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-futures+default-devel \
 rust-http+default-devel \
 rust-hyper+default-devel \
 rust-reqwest-middleware0.4+default-devel \
 rust-reqwest0.12-devel \
 rust-retry-policies0.4+default-devel \
 rust-thiserror1+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
