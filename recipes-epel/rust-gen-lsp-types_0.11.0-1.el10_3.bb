# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gen-lsp-types"
PV = "0.11.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gen-lsp-types+default-devel \
 rust-gen-lsp-types+fluent-uri-devel \
 rust-gen-lsp-types+url-devel \
 rust-gen-lsp-types-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-gen-lsp-types-0.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "999ea28f502ce0687b97e7d50e64a9f0bca5789777808a9363cd2b38899cb43b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gen-lsp-types+default-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gen-lsp-types+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gen-lsp-types+default-devel.sha256sum] = "80934f3bac70ef5c1be1ffa3c3f4b1de74e3bdb32a67082af71093ab6094a4fe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gen-lsp-types+fluent-uri-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gen-lsp-types+fluent-uri-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gen-lsp-types+fluent-uri-devel.sha256sum] = "eac5f8bea64ba556e59a3e966ad80e70d8b14c03356882059df7e788e90606ec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gen-lsp-types+url-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gen-lsp-types+url-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gen-lsp-types+url-devel.sha256sum] = "c700d9f07e0bdf8269318ddab74c6642bd1300bf37d7e5a174eeb541f13e332e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gen-lsp-types-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gen-lsp-types-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gen-lsp-types-devel.sha256sum] = "0bc80ac5a1b45fb6df482c89ca9073c8be309e56ed2d4ed184ac12f93248a51c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gen-lsp-types+default-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-gen-lsp-types+default-devel;unpack=0"
SRC_URI[aarch64_rust-gen-lsp-types+default-devel.sha256sum] = "f17d49d9b46fce52ddf475200d7fb8d04863b072cecf3bab38513726f2139c32"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gen-lsp-types+fluent-uri-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-gen-lsp-types+fluent-uri-devel;unpack=0"
SRC_URI[aarch64_rust-gen-lsp-types+fluent-uri-devel.sha256sum] = "74d942a59ebaa9627a17546720a6b23b6af2f120464cf19f20ebd2eaba702b11"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gen-lsp-types+url-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-gen-lsp-types+url-devel;unpack=0"
SRC_URI[aarch64_rust-gen-lsp-types+url-devel.sha256sum] = "54ff908d0742d7b3b311e86501fb3da6bf1ac1531e528fcd708acf0cd520ebfc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gen-lsp-types-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-gen-lsp-types-devel;unpack=0"
SRC_URI[aarch64_rust-gen-lsp-types-devel.sha256sum] = "4bd49c81a54dc1c857cbfbe9d51f729b1128fd6d50c87f13cd35f7f19a58e704"

RDEPENDS:rust-gen-lsp-types+default-devel = " \
 cargo \
 rust-gen-lsp-types-devel \
 "
RDEPENDS:rust-gen-lsp-types+fluent-uri-devel = " \
 cargo \
 rust-fluent-uri+default-devel \
 rust-fluent-uri+serde-devel \
 rust-gen-lsp-types-devel \
 "
RDEPENDS:rust-gen-lsp-types+url-devel = " \
 cargo \
 rust-gen-lsp-types-devel \
 rust-url+default-devel \
 rust-url+serde-devel \
 "
RDEPENDS:rust-gen-lsp-types-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
