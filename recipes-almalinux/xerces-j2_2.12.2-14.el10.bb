# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xerces-j2"
PV = "2.12.2"
PR = "14.el10"
PACKAGES = " \
 xerces-j2 \
 xerces-j2-demo \
 xerces-j2-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xerces-j2-2.12.2-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e9d0f9d376dc2b7d1194e20aeee2ee1d8687c52442a2099c60fcf7fa176aa44"

URI_x86_64_v2_xerces-j2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xerces-j2-2.12.2-14.el10.noarch.rpm;name=x86_64_v2_xerces-j2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xerces-j2}"
SRC_URI[x86_64_v2_xerces-j2.sha256sum] = "95b7de39b8745871a771bf4124b60492bc98d2ae92f1fdc078f86048555143ce"

URI_x86_64_v2_xerces-j2-demo = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xerces-j2-demo-2.12.2-14.el10.noarch.rpm;name=x86_64_v2_xerces-j2-demo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xerces-j2-demo}"
SRC_URI[x86_64_v2_xerces-j2-demo.sha256sum] = "392eca8d1637b9b150f450f2ef8c7609bd1a87f66ae83aaeb97c6498f8985d1c"

URI_x86_64_v2_xerces-j2-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xerces-j2-javadoc-2.12.2-14.el10.noarch.rpm;name=x86_64_v2_xerces-j2-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xerces-j2-javadoc}"
SRC_URI[x86_64_v2_xerces-j2-javadoc.sha256sum] = "cee52e5dde509de00eecf82af1d5ec5d98bf289fe592c9d589a7a671181727ef"

URI_aarch64_xerces-j2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xerces-j2-2.12.2-14.el10.noarch.rpm;name=aarch64_xerces-j2;unpack=0"
SRC_URI:append = " ${URI_aarch64_xerces-j2}"
SRC_URI[aarch64_xerces-j2.sha256sum] = "95b7de39b8745871a771bf4124b60492bc98d2ae92f1fdc078f86048555143ce"

URI_aarch64_xerces-j2-demo = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xerces-j2-demo-2.12.2-14.el10.noarch.rpm;name=aarch64_xerces-j2-demo;unpack=0"
SRC_URI:append = " ${URI_aarch64_xerces-j2-demo}"
SRC_URI[aarch64_xerces-j2-demo.sha256sum] = "392eca8d1637b9b150f450f2ef8c7609bd1a87f66ae83aaeb97c6498f8985d1c"

URI_aarch64_xerces-j2-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xerces-j2-javadoc-2.12.2-14.el10.noarch.rpm;name=aarch64_xerces-j2-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_xerces-j2-javadoc}"
SRC_URI[aarch64_xerces-j2-javadoc.sha256sum] = "cee52e5dde509de00eecf82af1d5ec5d98bf289fe592c9d589a7a671181727ef"

RDEPENDS:xerces-j2 = " \
 bash \
 javapackages-filesystem \
 javapackages-tools \
 xml-commons-apis \
 xml-commons-resolver \
 "
RDEPENDS:xerces-j2-demo = " \
 xerces-j2 \
 "
RDEPENDS:xerces-j2-javadoc = " \
 javapackages-filesystem \
 "
