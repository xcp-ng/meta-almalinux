# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-path-pieces"
PV = "0.2.1"
PR = "39.el10_0"
PACKAGES = " \
 ghc-path-pieces \
 ghc-path-pieces-devel \
 ghc-path-pieces-doc \
 ghc-path-pieces-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-path-pieces-0.2.1-39.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ae6c5ee327ef5c8f67c40447c6ebe35a20a8c83b70e0128a6dbae98a668810b"

URI_x86_64_v2_ghc-path-pieces = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-path-pieces-0.2.1-39.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-path-pieces;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-path-pieces}"
SRC_URI[x86_64_v2_ghc-path-pieces.sha256sum] = "e43ec5797322cba596972c543246285fb39e8862a728bec3b09396a3d99331e4"

URI_x86_64_v2_ghc-path-pieces-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-path-pieces-devel-0.2.1-39.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-path-pieces-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-path-pieces-devel}"
SRC_URI[x86_64_v2_ghc-path-pieces-devel.sha256sum] = "ef046ef5b52a30de199119e885af2e769701d593cfbb3c41c9c4195b4dafc2a6"

URI_x86_64_v2_ghc-path-pieces-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-path-pieces-doc-0.2.1-39.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-path-pieces-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-path-pieces-doc}"
SRC_URI[x86_64_v2_ghc-path-pieces-doc.sha256sum] = "d4e6851b3f2c4f7c0d118e386f9471c9d02ee266272bd95a7e6483c267b37ec3"

URI_x86_64_v2_ghc-path-pieces-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-path-pieces-prof-0.2.1-39.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-path-pieces-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-path-pieces-prof}"
SRC_URI[x86_64_v2_ghc-path-pieces-prof.sha256sum] = "8a1f5a2684a107c35220f59067d37e3acda4bfb4d7e906ebcd3fad61bc443265"

URI_aarch64_ghc-path-pieces = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-path-pieces-0.2.1-39.el10_0.aarch64.rpm;name=aarch64_ghc-path-pieces;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-path-pieces}"
SRC_URI[aarch64_ghc-path-pieces.sha256sum] = "18baf38b4316aebc2b20e6e9b7f4fe59f65da0d56d3c1db8bf29f896c00979df"

URI_aarch64_ghc-path-pieces-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-path-pieces-devel-0.2.1-39.el10_0.aarch64.rpm;name=aarch64_ghc-path-pieces-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-path-pieces-devel}"
SRC_URI[aarch64_ghc-path-pieces-devel.sha256sum] = "90b9e215a775eb406e7c33ad40339ea4028ef456a8f873b1507b56937494e0c2"

URI_aarch64_ghc-path-pieces-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-path-pieces-doc-0.2.1-39.el10_0.noarch.rpm;name=aarch64_ghc-path-pieces-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-path-pieces-doc}"
SRC_URI[aarch64_ghc-path-pieces-doc.sha256sum] = "54d757dea530ac54b8b29dd972a627e7031a9bf26ceee13f3be2d22cff74201c"

URI_aarch64_ghc-path-pieces-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-path-pieces-prof-0.2.1-39.el10_0.aarch64.rpm;name=aarch64_ghc-path-pieces-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-path-pieces-prof}"
SRC_URI[aarch64_ghc-path-pieces-prof.sha256sum] = "2c6833fe79d3fe73ed3974f4bd7493da7053a62b0876f4c3e66f32828fcd6cde"

RDEPENDS:ghc-path-pieces = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 glibc \
 gmp \
 "
RDEPENDS:ghc-path-pieces-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-path-pieces \
 ghc-text-devel \
 ghc-time-devel \
 "
RDEPENDS:ghc-path-pieces-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-path-pieces-prof = " \
 ghc-base-prof \
 ghc-path-pieces-devel \
 ghc-text-prof \
 ghc-time-prof \
 "
