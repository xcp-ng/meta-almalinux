# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtremoteobjects"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtremoteobjects \
 qt5-qtremoteobjects-devel \
 qt5-qtremoteobjects-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtremoteobjects-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c50ebb28d94ed6c608386f2ec138158e5339bd27e248d899a53322629d6b2f2"

URI_x86_64_v2_qt5-qtremoteobjects = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtremoteobjects-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtremoteobjects;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtremoteobjects}"
SRC_URI[x86_64_v2_qt5-qtremoteobjects.sha256sum] = "2899c3d1af6d2afe6a8be079653cfc3a95e6f3ce17457609bb73373f04208f4a"

URI_x86_64_v2_qt5-qtremoteobjects-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtremoteobjects-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtremoteobjects-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtremoteobjects-devel}"
SRC_URI[x86_64_v2_qt5-qtremoteobjects-devel.sha256sum] = "3b5c936f178db1c13fc38a2917622fff533d6720a296f973ee1a943669fe36ea"

URI_x86_64_v2_qt5-qtremoteobjects-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtremoteobjects-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtremoteobjects-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtremoteobjects-examples}"
SRC_URI[x86_64_v2_qt5-qtremoteobjects-examples.sha256sum] = "9e5d23d68beeba1dcf4866d237604d27bff39e42a88de6a081d2aee68dd6edb0"

URI_aarch64_qt5-qtremoteobjects = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtremoteobjects-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtremoteobjects;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtremoteobjects}"
SRC_URI[aarch64_qt5-qtremoteobjects.sha256sum] = "14c615092fbf26ba376cced182117c14af5656e83df5e1f90c1fd5d1a05b8c85"

URI_aarch64_qt5-qtremoteobjects-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtremoteobjects-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtremoteobjects-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtremoteobjects-devel}"
SRC_URI[aarch64_qt5-qtremoteobjects-devel.sha256sum] = "2bca5014f807168c6835f4e48324aff186ba2a1468ea87d9d0845920f0845967"

URI_aarch64_qt5-qtremoteobjects-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtremoteobjects-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtremoteobjects-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtremoteobjects-examples}"
SRC_URI[aarch64_qt5-qtremoteobjects-examples.sha256sum] = "a5dd1bcba0a04da06f2d8ac3cb51d460cc5adc8d66cf18820009bed1e82e015d"

RDEPENDS:qt5-qtremoteobjects = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtremoteobjects-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtremoteobjects \
 "
RDEPENDS:qt5-qtremoteobjects-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtremoteobjects \
 "
