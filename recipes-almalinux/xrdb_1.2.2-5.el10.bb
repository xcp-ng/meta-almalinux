# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xrdb"
PV = "1.2.2"
PR = "5.el10"
PACKAGES = " \
 xrdb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xrdb-1.2.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0defafaf0c50ff28e8533157d317a48b49e33116476e9b6b3491fed6edc54540"

URI_x86_64_v2_xrdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xrdb-1.2.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_xrdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrdb}"
SRC_URI[x86_64_v2_xrdb.sha256sum] = "2d17dc87b7f4c6a4befbb3986a01b8ee554bf721728dd75ed8c227ccfed1e951"

URI_aarch64_xrdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xrdb-1.2.2-5.el10.aarch64.rpm;name=aarch64_xrdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrdb}"
SRC_URI[aarch64_xrdb.sha256sum] = "e958ba071e802ff3e28728f8ddaa9d2245e97185c52e54ae2fcf5699c9fbb847"

RDEPENDS:xrdb = " \
 glibc \
 libX11 \
 libXmu \
 "
