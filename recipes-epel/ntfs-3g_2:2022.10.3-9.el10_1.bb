# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ntfs-3g"
PE = "2"
PV = "2022.10.3"
PR = "9.el10_1"
PACKAGES = " \
 ntfs-3g \
 ntfs-3g-devel \
 ntfs-3g-libs \
 ntfsprogs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ntfs-3g-2022.10.3-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b71773cd483837e2e9af02df886292c1e02ea8428d09b5821e8b6e832862ad81"

URI_x86_64_v2_ntfs-3g = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfs-3g-2022.10.3-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfs-3g;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfs-3g}"
SRC_URI[x86_64_v2_ntfs-3g.sha256sum] = "febcb82d9c1626fe866146602a6dd681b6e7ed592011ce228933e9e1983c353b"

URI_x86_64_v2_ntfs-3g-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfs-3g-devel-2022.10.3-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfs-3g-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfs-3g-devel}"
SRC_URI[x86_64_v2_ntfs-3g-devel.sha256sum] = "49d53c1ce47261d41a8c471252213b4a30b9ab70de6035e29d736a98dac49683"

URI_x86_64_v2_ntfs-3g-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfs-3g-libs-2022.10.3-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfs-3g-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfs-3g-libs}"
SRC_URI[x86_64_v2_ntfs-3g-libs.sha256sum] = "dc42c0655f29f0ea32949cad8c0b2ca44fa62af4f7212c56b73662e3db6fede0"

URI_x86_64_v2_ntfsprogs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfsprogs-2022.10.3-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfsprogs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfsprogs}"
SRC_URI[x86_64_v2_ntfsprogs.sha256sum] = "4b8ade42fb8f2bc6448ecdd572305851f5553fa62aaa12082de7289e703cedb4"

URI_aarch64_ntfs-3g = "${EPEL_MIRROR}/aarch64/Packages/n/ntfs-3g-2022.10.3-9.el10_1.aarch64.rpm;name=aarch64_ntfs-3g;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfs-3g}"
SRC_URI[aarch64_ntfs-3g.sha256sum] = "3f9d9734064b791562879a9cd725c21e8e7ec7c00a4dc5e7cb608bd26cafb082"

URI_aarch64_ntfs-3g-devel = "${EPEL_MIRROR}/aarch64/Packages/n/ntfs-3g-devel-2022.10.3-9.el10_1.aarch64.rpm;name=aarch64_ntfs-3g-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfs-3g-devel}"
SRC_URI[aarch64_ntfs-3g-devel.sha256sum] = "3b1f636aa554dda4c9511d846135b4c007357ea29d09e02ec8a2441af8c6f4be"

URI_aarch64_ntfs-3g-libs = "${EPEL_MIRROR}/aarch64/Packages/n/ntfs-3g-libs-2022.10.3-9.el10_1.aarch64.rpm;name=aarch64_ntfs-3g-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfs-3g-libs}"
SRC_URI[aarch64_ntfs-3g-libs.sha256sum] = "94e0a7430d9435aabc300d35e679f96cfce921d633fdf3480823b9ff8688961c"

URI_aarch64_ntfsprogs = "${EPEL_MIRROR}/aarch64/Packages/n/ntfsprogs-2022.10.3-9.el10_1.aarch64.rpm;name=aarch64_ntfsprogs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfsprogs}"
SRC_URI[aarch64_ntfsprogs.sha256sum] = "1631b20e7ae5d83e004e3fdbc3a9c44a4a9bc9ad92df11da4b9315f340f21714"

RDEPENDS:ntfs-3g = " \
 glibc \
 ntfs-3g-libs \
 "
RDEPENDS:ntfs-3g-devel = " \
 ntfs-3g-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:ntfs-3g-libs = " \
 glibc \
 "
RDEPENDS:ntfsprogs = " \
 glibc \
 gnutls \
 libgcrypt \
 libuuid \
 ntfs-3g-libs \
 "
