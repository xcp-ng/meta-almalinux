# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shadow-utils"
PE = "2"
PV = "4.15.0"
PR = "11.el10"
PACKAGES = " \
 shadow-utils \
 shadow-utils-subid \
 shadow-utils-subid-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/shadow-utils-4.15.0-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6d5b1583ec4ac955a742ff7be419c6ca562d754f1e2acca84441351b9a6ec5a"

URI_x86_64_v2_shadow-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/shadow-utils-4.15.0-11.el10.x86_64_v2.rpm;name=x86_64_v2_shadow-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shadow-utils}"
SRC_URI[x86_64_v2_shadow-utils.sha256sum] = "48f4704783e8757da0be9a6356ee89000913a79ba9aea2e4457bc7f648c7b655"

URI_x86_64_v2_shadow-utils-subid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/shadow-utils-subid-4.15.0-11.el10.x86_64_v2.rpm;name=x86_64_v2_shadow-utils-subid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shadow-utils-subid}"
SRC_URI[x86_64_v2_shadow-utils-subid.sha256sum] = "89518cd8a0d6feaa225b7282aa41cb34b45592318eecc5cd1d850057692f41b3"

URI_x86_64_v2_shadow-utils-subid-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/shadow-utils-subid-devel-4.15.0-11.el10.x86_64_v2.rpm;name=x86_64_v2_shadow-utils-subid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shadow-utils-subid-devel}"
SRC_URI[x86_64_v2_shadow-utils-subid-devel.sha256sum] = "751c408d8942954ba432bd78df4dde6519cc60b1af4527d20886e6dba6e38a44"

URI_aarch64_shadow-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/shadow-utils-4.15.0-11.el10.aarch64.rpm;name=aarch64_shadow-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_shadow-utils}"
SRC_URI[aarch64_shadow-utils.sha256sum] = "76d5cacf55c7728ef2357ad6f0b12f023c76ab00d16fc13ca2a3e7099b0e4c4d"

URI_aarch64_shadow-utils-subid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/shadow-utils-subid-4.15.0-11.el10.aarch64.rpm;name=aarch64_shadow-utils-subid;unpack=0"
SRC_URI:append = " ${URI_aarch64_shadow-utils-subid}"
SRC_URI[aarch64_shadow-utils-subid.sha256sum] = "6c801ed785943b5a9690a9721168353cd06bea0e2494bcf72f908ed100512c63"

URI_aarch64_shadow-utils-subid-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/shadow-utils-subid-devel-4.15.0-11.el10.aarch64.rpm;name=aarch64_shadow-utils-subid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_shadow-utils-subid-devel}"
SRC_URI[aarch64_shadow-utils-subid-devel.sha256sum] = "aefa075858ebbc46e98555c192a2c1a5966538d2aaded3f6df87c2ab16a9e9cc"

RDEPENDS:shadow-utils = " \
 audit-libs \
 glibc \
 libacl \
 libattr \
 libeconf \
 libselinux \
 libsemanage \
 libxcrypt \
 pam-libs \
 setup \
 "
RDEPENDS:shadow-utils-subid = " \
 audit-libs \
 glibc \
 libacl \
 libattr \
 libeconf \
 libselinux \
 libsemanage \
 libxcrypt \
 pam-libs \
 "
RDEPENDS:shadow-utils-subid-devel = " \
 shadow-utils-subid \
 "
