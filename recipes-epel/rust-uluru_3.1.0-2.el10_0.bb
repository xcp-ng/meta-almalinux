# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uluru"
PV = "3.1.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-uluru+default-devel \
 rust-uluru-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uluru-3.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7233e8d85b2974382b57ef18f88487d5998a3808928797f633087d2cb62f937"

URI_x86_64_v2_rust-uluru+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uluru+default-devel-3.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uluru+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uluru+default-devel}"
SRC_URI[x86_64_v2_rust-uluru+default-devel.sha256sum] = "063ccdd1f7931da73b2ed21e8915e0339e4a38390a0ed510acbe1692d1b6212f"

URI_x86_64_v2_rust-uluru-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uluru-devel-3.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uluru-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uluru-devel}"
SRC_URI[x86_64_v2_rust-uluru-devel.sha256sum] = "11c95672a5a3c916bdb5a71b8599770f906bf0665a175dab1079a172f102f747"

URI_aarch64_rust-uluru+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uluru+default-devel-3.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-uluru+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uluru+default-devel}"
SRC_URI[aarch64_rust-uluru+default-devel.sha256sum] = "8ccd3f5ef1f49dbdbdbe28976a2339d8ddfec562785b715083ee91ca196d8d73"

URI_aarch64_rust-uluru-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uluru-devel-3.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-uluru-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uluru-devel}"
SRC_URI[aarch64_rust-uluru-devel.sha256sum] = "a10b58000ae8fbfb0319d1d3be0ec9f7348b07d3c61e55a7efc4b6f2e6a5c482"

RDEPENDS:rust-uluru+default-devel = " \
 cargo \
 rust-uluru-devel \
 "
RDEPENDS:rust-uluru-devel = " \
 cargo \
 rust-arrayvec-devel \
 "
