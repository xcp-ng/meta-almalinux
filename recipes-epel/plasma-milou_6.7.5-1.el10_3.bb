# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-milou"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-milou \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-milou-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d5920181eb5a3bc52188ed2c78e5abfa8ee6a755e040813cab69fb7439b47cc9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-milou-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-milou;unpack=0"
SRC_URI[x86_64_v2_plasma-milou.sha256sum] = "68d1ece4304c7a9d291f7c44231f3d7e838945912209d12a64fa6e2c148f54be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-milou-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-milou;unpack=0"
SRC_URI[aarch64_plasma-milou.sha256sum] = "9b84691030eb14a0f558e11b647ccac6baf09713fa2bc0b5c70d560faa6770c9"

RDEPENDS:plasma-milou = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-krunner \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
