# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-LexAlias"
PV = "0.05"
PR = "32.el10_0"
PACKAGES = " \
 perl-Devel-LexAlias \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-LexAlias-0.05-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad1e6e8fdbd663179bf5ddf7bd4817c4a2077cf046ec5a84aab39008cd7376e3"

URI_x86_64_v2_perl-Devel-LexAlias = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-LexAlias-0.05-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Devel-LexAlias;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-LexAlias}"
SRC_URI[x86_64_v2_perl-Devel-LexAlias.sha256sum] = "b416879b654f25f7710ca0f10ed48465c482b2afb915153be19c75ea9a45b2ff"

URI_aarch64_perl-Devel-LexAlias = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-LexAlias-0.05-32.el10_0.aarch64.rpm;name=aarch64_perl-Devel-LexAlias;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-LexAlias}"
SRC_URI[aarch64_perl-Devel-LexAlias.sha256sum] = "495cca667ee57562d795f27664a29cc729932343f7d019db34a46a3f0369390e"

RDEPENDS:perl-Devel-LexAlias = " \
 glibc \
 perl-Devel-Caller \
 perl-DynaLoader \
 perl-libs \
 "
