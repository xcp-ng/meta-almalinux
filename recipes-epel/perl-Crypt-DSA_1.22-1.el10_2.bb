# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-DSA"
PV = "1.22"
PR = "1.el10_2"
PACKAGES = " \
 perl-Crypt-DSA \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-DSA-1.22-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "418416fc2f478597f949ab340b926bc843033eac3241e25f4adf121aac65d58b"

URI_x86_64_v2_perl-Crypt-DSA = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-DSA-1.22-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-DSA;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-DSA}"
SRC_URI[x86_64_v2_perl-Crypt-DSA.sha256sum] = "60788f73d38025331ec88a9b225599903fe841d48557935d1e0f45e77411857f"

URI_aarch64_perl-Crypt-DSA = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-DSA-1.22-1.el10_2.noarch.rpm;name=aarch64_perl-Crypt-DSA;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-DSA}"
SRC_URI[aarch64_perl-Crypt-DSA.sha256sum] = "7d67db9191883cabc8c8c8238f0fabafcb053685e23edd523e73caaef8d2441a"

RDEPENDS:perl-Crypt-DSA = " \
 openssl \
 perl-Carp \
 perl-Convert-ASN1 \
 perl-Convert-PEM \
 perl-Crypt-DSA \
 perl-Crypt-URandom \
 perl-Data-Buffer \
 perl-Digest-SHA \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Which \
 perl-IPC-Open3 \
 perl-MIME-Base64 \
 perl-Math-BigInt \
 perl-Math-BigInt-GMP \
 perl-PathTools \
 perl-Symbol \
 perl-base \
 perl-constant \
 perl-libs \
 perl-vars \
 "
