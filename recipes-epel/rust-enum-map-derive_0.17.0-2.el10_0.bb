# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enum-map-derive"
PV = "0.17.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-enum-map-derive+default-devel \
 rust-enum-map-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enum-map-derive-0.17.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ccae75215f0bf779369b683e1e096a9b1fd4affb434a1a3a9d1f732e9d3b0fc"

URI_x86_64_v2_rust-enum-map-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-map-derive+default-devel-0.17.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-map-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-map-derive+default-devel}"
SRC_URI[x86_64_v2_rust-enum-map-derive+default-devel.sha256sum] = "6de43b60638a39426cb32e525e27d5284db0e3799f5a88d9cb5328419e2017b4"

URI_x86_64_v2_rust-enum-map-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-map-derive-devel-0.17.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-map-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-map-derive-devel}"
SRC_URI[x86_64_v2_rust-enum-map-derive-devel.sha256sum] = "e36fd4371d0a951bf465b4ee20259e30d763a606c3e7c0e63564f44e0f9cc44f"

URI_aarch64_rust-enum-map-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-map-derive+default-devel-0.17.0-2.el10_0.noarch.rpm;name=aarch64_rust-enum-map-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-map-derive+default-devel}"
SRC_URI[aarch64_rust-enum-map-derive+default-devel.sha256sum] = "e42381eb47efa2ab9567d1bb4e98c6f6a03cb9a74963dbf424bd8db73a2eea3b"

URI_aarch64_rust-enum-map-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-map-derive-devel-0.17.0-2.el10_0.noarch.rpm;name=aarch64_rust-enum-map-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-map-derive-devel}"
SRC_URI[aarch64_rust-enum-map-derive-devel.sha256sum] = "f1b855d6bed6f3c09befb7d30b3b87d147a2efaee56b693047da5125220778fd"

RDEPENDS:rust-enum-map-derive+default-devel = " \
 cargo \
 rust-enum-map-derive-devel \
 "
RDEPENDS:rust-enum-map-derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
