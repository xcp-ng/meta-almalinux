# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nagiosplugin"
PV = "1.3.3"
PR = "14.el10_1"
PACKAGES = " \
 python3-nagiosplugin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-nagiosplugin-1.3.3-14.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3267ab99e570218752283dcdb49f65de58e0fc18ada9ab47080a646c4051946e"

URI_x86_64_v2_python3-nagiosplugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nagiosplugin-1.3.3-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-nagiosplugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nagiosplugin}"
SRC_URI[x86_64_v2_python3-nagiosplugin.sha256sum] = "3a4226cdc4fa544eb04dcf4e5ced737ddb3558182ac1b1906c03a32519d6cfb3"

URI_aarch64_python3-nagiosplugin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nagiosplugin-1.3.3-14.el10_1.noarch.rpm;name=aarch64_python3-nagiosplugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nagiosplugin}"
SRC_URI[aarch64_python3-nagiosplugin.sha256sum] = "6e1933c3a403b3f87cbbe545e36898257adb749ec5949d1720f686644d3eb59d"

RDEPENDS:python3-nagiosplugin = " \
 python3 \
 "
