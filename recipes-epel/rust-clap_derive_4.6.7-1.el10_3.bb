# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_derive"
PV = "4.6.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-clap_derive+debug-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+deprecated-devel \
 rust-clap_derive+raw-deprecated-devel \
 rust-clap_derive+unstable-markdown-devel \
 rust-clap_derive+unstable-v5-devel \
 rust-clap_derive-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-clap_derive-4.6.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0b2699163709c474a0dfe600f9bf930ba4b0425a2a27f3730451d9d80002a94d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+debug-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_derive+debug-devel.sha256sum] = "71570b6e032f9e8b2e2cd9b76182fdbc98052acc25739d1187f42c0b45219416"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+default-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_derive+default-devel.sha256sum] = "3fcaf3d17dd7a7bb767824316e4465f742e2e5f35932941ea42bb67be3cf9b5c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+deprecated-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+deprecated-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_derive+deprecated-devel.sha256sum] = "a812b0c41089df1196f6379a01eb72bd4a378f0dcc2b6f0a9d856a7825f59b8c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+raw-deprecated-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+raw-deprecated-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_derive+raw-deprecated-devel.sha256sum] = "ad2bc7d31e1a5a3dbf8d6a96b1aef16ca858827a371541b46ef03c6342f7fd0d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+unstable-markdown-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+unstable-markdown-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_derive+unstable-markdown-devel.sha256sum] = "a81b3d448d46580b231f7ebb216a62cecb0311d4572f49359c63bc2e429ecdcc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+unstable-v5-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+unstable-v5-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_derive+unstable-v5-devel.sha256sum] = "75f3605db107d09b61abd98c600d5497d13c91b613bdffa188156ceabdf1aa07"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_derive-devel.sha256sum] = "7af964549eac87ab3f207cc66e65dc05317f487f0a8ff311c4f7674bc2b88a41"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+debug-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_derive+debug-devel;unpack=0"
SRC_URI[aarch64_rust-clap_derive+debug-devel.sha256sum] = "1b1efe86b73e36b9588f17b9fd9073fb1ccd3d4a94434e083c7534cabb38a926"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+default-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_derive+default-devel;unpack=0"
SRC_URI[aarch64_rust-clap_derive+default-devel.sha256sum] = "948b74b67e241ebbcdc29e09739442dfc4140636d4e83dff30c51b37a68997ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+deprecated-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_derive+deprecated-devel;unpack=0"
SRC_URI[aarch64_rust-clap_derive+deprecated-devel.sha256sum] = "5e4562522e3dbbbd4a1e99790b11176f0835eda94c960216a0a643efa81b19bd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+raw-deprecated-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_derive+raw-deprecated-devel;unpack=0"
SRC_URI[aarch64_rust-clap_derive+raw-deprecated-devel.sha256sum] = "cb911a0190d968c3dacc7d12e0105b366e3d1253e989156704b5a9c2eab7b2dd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+unstable-markdown-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_derive+unstable-markdown-devel;unpack=0"
SRC_URI[aarch64_rust-clap_derive+unstable-markdown-devel.sha256sum] = "3a228b0052d5a345335a36c57231a2cf3cb4d6b919c3f4521574578850522119"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+unstable-v5-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_derive+unstable-v5-devel;unpack=0"
SRC_URI[aarch64_rust-clap_derive+unstable-v5-devel.sha256sum] = "d027e6268bd90c45a37ca46d2fd9e6623abc396acecb26a5ce8230f823ad1da1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_derive-devel;unpack=0"
SRC_URI[aarch64_rust-clap_derive-devel.sha256sum] = "1ff6e6454ee95310fefd5e7bc006ef5703c7fe1d5636685aba549c7fec21c80a"

RDEPENDS:rust-clap_derive+debug-devel = " \
 cargo \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+default-devel = " \
 cargo \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+deprecated-devel = " \
 cargo \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+raw-deprecated-devel = " \
 cargo \
 rust-clap_derive+deprecated-devel \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+unstable-markdown-devel = " \
 cargo \
 rust-anstyle+default-devel \
 rust-clap_derive-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-clap_derive+unstable-v5-devel = " \
 cargo \
 rust-clap_derive+deprecated-devel \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
