# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sympa"
PV = "6.2.76"
PR = "1.el10_0"
PACKAGES = " \
 sympa \
 sympa-devel-doc \
 sympa-httpd \
 sympa-lighttpd \
 sympa-nginx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sympa-6.2.76-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec9557a307fb1b39c5b6450b0ddffc6ae24fcffdcf3d01f9dcd8c931e511c5b4"

URI_x86_64_v2_sympa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-6.2.76-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sympa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa}"
SRC_URI[x86_64_v2_sympa.sha256sum] = "9bdb144b853691c61534b8e0be1fb59593fdfeacadb8f712b707d0a603902b4b"

URI_x86_64_v2_sympa-devel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-devel-doc-6.2.76-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sympa-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-devel-doc}"
SRC_URI[x86_64_v2_sympa-devel-doc.sha256sum] = "53b0e86e35e2bcb825e567fbf0b3e53107114a36ecc59042f37a53a438a25b2d"

URI_x86_64_v2_sympa-httpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-httpd-6.2.76-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sympa-httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-httpd}"
SRC_URI[x86_64_v2_sympa-httpd.sha256sum] = "43623a140bf69ed922d4bce3c15ecbcfd842cee67111ad331a48536c7d9cc155"

URI_x86_64_v2_sympa-lighttpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-lighttpd-6.2.76-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sympa-lighttpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-lighttpd}"
SRC_URI[x86_64_v2_sympa-lighttpd.sha256sum] = "96ee0e770e55eeec8a2c1eee399818c391bb4dbdcb097d199d31f7db44d0e8ab"

URI_x86_64_v2_sympa-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-nginx-6.2.76-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sympa-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-nginx}"
SRC_URI[x86_64_v2_sympa-nginx.sha256sum] = "35235390810dd6670e1b4ba8ec10168a66a2a332e28f16c7c164e313c75f8288"

URI_aarch64_sympa = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-6.2.76-1.el10_0.aarch64.rpm;name=aarch64_sympa;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa}"
SRC_URI[aarch64_sympa.sha256sum] = "3f5bbcf75c99f58f56ef8322c863cba6fbc04a6bedbfd0616579153b23bb1e20"

URI_aarch64_sympa-devel-doc = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-devel-doc-6.2.76-1.el10_0.aarch64.rpm;name=aarch64_sympa-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-devel-doc}"
SRC_URI[aarch64_sympa-devel-doc.sha256sum] = "53dc1675cfe223b66042d41d8004369285e8b93c6502cb621a8bb96c064de6ea"

URI_aarch64_sympa-httpd = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-httpd-6.2.76-1.el10_0.aarch64.rpm;name=aarch64_sympa-httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-httpd}"
SRC_URI[aarch64_sympa-httpd.sha256sum] = "f673deebe43d0c6153a6e3658bfa446da2eecb0d636f77f477acf583bcaa8a49"

URI_aarch64_sympa-lighttpd = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-lighttpd-6.2.76-1.el10_0.aarch64.rpm;name=aarch64_sympa-lighttpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-lighttpd}"
SRC_URI[aarch64_sympa-lighttpd.sha256sum] = "9ba29712d4779fc28f0ea37902dfac31215f3af64513df3b610ded763c6cf14c"

URI_aarch64_sympa-nginx = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-nginx-6.2.76-1.el10_0.aarch64.rpm;name=aarch64_sympa-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-nginx}"
SRC_URI[aarch64_sympa-nginx.sha256sum] = "ae48ef3878e5fa86b34bdec146e66b03714d7b900f9f699ac1d2e8a8d2b523c7"

RDEPENDS:sympa = " \
 bash \
 glibc \
 js-jquery \
 js-jquery-ui \
 logrotate \
 mhonarc \
 perl-Archive-Zip-SimpleZip \
 perl-AuthCAS \
 perl-CGI \
 perl-CGI-Fast \
 perl-Carp \
 perl-Class-Singleton \
 perl-Clone \
 perl-Crypt-CipherSaber \
 perl-Crypt-Eksblowfish \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-SMIME \
 perl-DBD-CSV \
 perl-DBD-MySQL \
 perl-DBI \
 perl-Data-Dumper \
 perl-Data-Password \
 perl-DateTime \
 perl-DateTime-Format-Mail \
 perl-DateTime-TimeZone \
 perl-Digest-MD5 \
 perl-Encode \
 perl-Encode-EUCJPASCII \
 perl-Encode-HanExtra \
 perl-Encode-Locale \
 perl-English \
 perl-FCGI \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Copy-Recursive \
 perl-File-Find \
 perl-File-NFSLock \
 perl-File-Path \
 perl-Getopt-Long \
 perl-HTML-Formatter \
 perl-HTML-Parser \
 perl-HTML-StripScripts-Parser \
 perl-HTML-Tree \
 perl-HTTP-Cookies \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Socket-IP \
 perl-IO-Socket-SSL \
 perl-IO-stringy \
 perl-LDAP \
 perl-LWP-Protocol-https \
 perl-MIME-Base64 \
 perl-MIME-Charset \
 perl-MIME-EncWords \
 perl-MIME-Lite-HTML \
 perl-MIME-tools \
 perl-Mail-DKIM \
 perl-MailTools \
 perl-Net-CIDR \
 perl-Net-DNS \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Usage \
 perl-SOAP-Lite \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Template-Toolkit \
 perl-Term-ProgressBar \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-URI \
 perl-Unicode-LineBreak \
 perl-Unicode-Normalize \
 perl-Unicode-UTF8 \
 perl-XML-LibXML \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libintl-perl \
 perl-libnet \
 perl-libs \
 perl-libwww-perl \
 perl-parent \
 shadow-utils \
 sympa \
 systemd \
 virtual/smtpdaemon \
 "
RDEPENDS:sympa-devel-doc = " \
 sympa \
 "
RDEPENDS:sympa-httpd = " \
 bash \
 httpd \
 multiwatch \
 sympa \
 "
RDEPENDS:sympa-lighttpd = " \
 lighttpd \
 lighttpd-fastcgi \
 sympa \
 "
RDEPENDS:sympa-nginx = " \
 bash \
 multiwatch \
 nginx \
 sympa \
 "
