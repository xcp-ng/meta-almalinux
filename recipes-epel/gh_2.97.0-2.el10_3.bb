# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gh"
PV = "2.97.0"
PR = "2.el10_3"
PACKAGES = " \
 gh \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gh-2.97.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08f32b77d1c4d115ed87c91e52ff6bc28414d48538deb324538ca53e289b8314"

URI_x86_64_v2_gh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gh-2.97.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gh}"
SRC_URI[x86_64_v2_gh.sha256sum] = "f2ba29f783d43bb595462c628d6ccf129f7d66e42b9b78745e6df4cc7b16fdbe"

URI_aarch64_gh = "${EPEL_MIRROR}/aarch64/Packages/g/gh-2.97.0-2.el10_3.aarch64.rpm;name=aarch64_gh;unpack=0"
SRC_URI:append = " ${URI_aarch64_gh}"
SRC_URI[aarch64_gh.sha256sum] = "31040e8a1e01f6633128d725090bec493e0e25579c2f1e853e998dd7466560bc"

RDEPENDS:gh = " \
 git-core \
 glibc \
 "
