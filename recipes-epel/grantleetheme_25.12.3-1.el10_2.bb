# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grantleetheme"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 grantleetheme \
 grantleetheme-devel \
 grantleetheme-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/grantleetheme-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b8e2a5d107d2d3c057646ff8e65f32ddc600c743369184b1176f7d10ff52bf0"

URI_x86_64_v2_grantleetheme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantleetheme-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantleetheme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantleetheme}"
SRC_URI[x86_64_v2_grantleetheme.sha256sum] = "7e1b673f775a43f6ce6af8a196f7a021981834d03109f502890216a495c47911"

URI_x86_64_v2_grantleetheme-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantleetheme-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantleetheme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantleetheme-devel}"
SRC_URI[x86_64_v2_grantleetheme-devel.sha256sum] = "a31a1a71ad9e4eeebed2624d46e13d2452f1a2384588bb1cb4db8cde0a7a1b3d"

URI_x86_64_v2_grantleetheme-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantleetheme-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_grantleetheme-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantleetheme-doc}"
SRC_URI[x86_64_v2_grantleetheme-doc.sha256sum] = "77f8873352766bb2f0fdbbbe696afcd8676793da9b448eae57d6280d0c330e4e"

URI_aarch64_grantleetheme = "${EPEL_MIRROR}/aarch64/Packages/g/grantleetheme-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_grantleetheme;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantleetheme}"
SRC_URI[aarch64_grantleetheme.sha256sum] = "f08c8252d6ce92c7d9d2e83f6d24f89a6e0afe3653435cc54a4bdd60788c472e"

URI_aarch64_grantleetheme-devel = "${EPEL_MIRROR}/aarch64/Packages/g/grantleetheme-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_grantleetheme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantleetheme-devel}"
SRC_URI[aarch64_grantleetheme-devel.sha256sum] = "88a80d12d7d5797939aa1561e971839b82f9c27d0db91ae52cc8a04d2a2f0bbf"

URI_aarch64_grantleetheme-doc = "${EPEL_MIRROR}/aarch64/Packages/g/grantleetheme-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_grantleetheme-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantleetheme-doc}"
SRC_URI[aarch64_grantleetheme-doc.sha256sum] = "4468dcf9bab756b4c72fb5b762127764996d4da239e95e2d153213ede7df0c61"

RDEPENDS:grantleetheme = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knewstuff \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:grantleetheme-devel = " \
 cmake-filesystem \
 grantleetheme \
 kf6-ktexttemplate-devel \
 "
RDEPENDS:grantleetheme-doc = " \
 "
