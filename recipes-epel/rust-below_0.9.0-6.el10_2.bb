# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below"
PV = "0.9.0"
PR = "6.el10_2"
PACKAGES = " \
 below \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-0.9.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61e8b98e27c37a80fae5e5aa255a835308c87ed0d7511ee2a42bc38d610acb90"

URI_x86_64_v2_below = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/below-0.9.0-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_below;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_below}"
SRC_URI[x86_64_v2_below.sha256sum] = "2ab4337dcd9ed937f3493f1fa73cc174a9626509a0fd7b661562843dd99c5823"

URI_aarch64_below = "${EPEL_MIRROR}/aarch64/Packages/b/below-0.9.0-6.el10_2.aarch64.rpm;name=aarch64_below;unpack=0"
SRC_URI:append = " ${URI_aarch64_below}"
SRC_URI[aarch64_below.sha256sum] = "0eed45268d59e96b6c68e4e908b0f2485a99f406f77f8938bf2214bb52ccba32"

RDEPENDS:below = " \
 bash \
 elfutils-libelf \
 glibc \
 libgcc \
 libzstd \
 zlib-ng-compat \
 "
