# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnulib"
PV = "0"
PR = "57.20260302git4a3650d.el10_1"
PACKAGES = " \
 gnulib-devel \
 gnulib-docs \
 gnulib-javaversion \
 python3-gnulib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnulib-0-57.20260302git4a3650d.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d69bd46f8f4bf4c32bdad160547d353e88f3780636ce27f95d11bea5e8da4d5"

URI_x86_64_v2_gnulib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnulib-devel-0-57.20260302git4a3650d.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gnulib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnulib-devel}"
SRC_URI[x86_64_v2_gnulib-devel.sha256sum] = "9a12d4054a1f5323cd482db02cd9069f342cd442e9e3cbcaeb9f34a5a57d846c"

URI_x86_64_v2_gnulib-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnulib-docs-0-57.20260302git4a3650d.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gnulib-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnulib-docs}"
SRC_URI[x86_64_v2_gnulib-docs.sha256sum] = "c6feadd48cce9d8b60a61c23aa1e1701da1cd0b268f01f4ff40a090d2265da02"

URI_x86_64_v2_gnulib-javaversion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnulib-javaversion-0-57.20260302git4a3650d.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnulib-javaversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnulib-javaversion}"
SRC_URI[x86_64_v2_gnulib-javaversion.sha256sum] = "d427cfc5841f1794c57295af4f7f94ed631966a3ec343e30532684e8d4ef0ef3"

URI_x86_64_v2_python3-gnulib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gnulib-0-57.20260302git4a3650d.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gnulib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gnulib}"
SRC_URI[x86_64_v2_python3-gnulib.sha256sum] = "d14a47ad20bb97ec2420bfed9f0e54ba9addad046d9061273410fd8b6a7f7373"

URI_aarch64_gnulib-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gnulib-devel-0-57.20260302git4a3650d.el10_1.noarch.rpm;name=aarch64_gnulib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnulib-devel}"
SRC_URI[aarch64_gnulib-devel.sha256sum] = "45fb555d20af1a0734cbbfed882b4f38bb30b9d2b5e8c2c0184f22df07044483"

URI_aarch64_gnulib-docs = "${EPEL_MIRROR}/aarch64/Packages/g/gnulib-docs-0-57.20260302git4a3650d.el10_1.noarch.rpm;name=aarch64_gnulib-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnulib-docs}"
SRC_URI[aarch64_gnulib-docs.sha256sum] = "8062bd2fe7d9a212f3f53d94661048554b5d4ae4642bd3e322029924e8cd6cf4"

URI_aarch64_gnulib-javaversion = "${EPEL_MIRROR}/aarch64/Packages/g/gnulib-javaversion-0-57.20260302git4a3650d.el10_1.aarch64.rpm;name=aarch64_gnulib-javaversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnulib-javaversion}"
SRC_URI[aarch64_gnulib-javaversion.sha256sum] = "86ec25b625a0f1ebcb7634b2f588f180b7184986a96b8abdce6dea60c9ac847a"

URI_aarch64_python3-gnulib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gnulib-0-57.20260302git4a3650d.el10_1.noarch.rpm;name=aarch64_python3-gnulib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gnulib}"
SRC_URI[aarch64_python3-gnulib.sha256sum] = "9b11d533be86c7c1751f3d96ad21aac5f415c71fb7fa4ebd1d51d29e59943e96"

RDEPENDS:gnulib-devel = " \
 autoconf \
 automake \
 bash \
 bison \
 diffutils \
 gawk \
 gcc \
 gettext-devel \
 gperf \
 grep \
 libtool \
 m4 \
 make \
 patch \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-constant \
 perl-interpreter \
 perl-libs \
 python3 \
 python3-gnulib \
 texinfo \
 virtual/coreutils \
 "
RDEPENDS:gnulib-docs = " \
 gnulib-devel \
 "
RDEPENDS:gnulib-javaversion = " \
 gnulib-devel \
 "
RDEPENDS:python3-gnulib = " \
 gnulib-devel \
 python3 \
 "
