# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-netlink-sys"
PV = "0.8.7"
PR = "2.el10_1"
PACKAGES = " \
 rust-netlink-sys+async-io-devel \
 rust-netlink-sys+default-devel \
 rust-netlink-sys+futures-devel \
 rust-netlink-sys+mio-devel \
 rust-netlink-sys+mio_socket-devel \
 rust-netlink-sys+smol_socket-devel \
 rust-netlink-sys+tokio-devel \
 rust-netlink-sys+tokio_socket-devel \
 rust-netlink-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-netlink-sys-0.8.7-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33674cbb663cd601b1dbf1284978278d6d6bb37c7078f360f35054c8023b8c38"

URI_x86_64_v2_rust-netlink-sys+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+async-io-devel-0.8.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+async-io-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+async-io-devel.sha256sum] = "f05c2357c5217b37025a0148cf9992361546142a62751e9571df368a279a0140"

URI_x86_64_v2_rust-netlink-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+default-devel-0.8.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+default-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+default-devel.sha256sum] = "1234f18901acfa35604d576385773d27be3b5ebc9f5aff98d1bfd767a5604de3"

URI_x86_64_v2_rust-netlink-sys+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+futures-devel-0.8.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+futures-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+futures-devel.sha256sum] = "9c871bb9661655aa3b594b1e1b2faf79238cd3dc7d3582f3edbc37ffe33b4256"

URI_x86_64_v2_rust-netlink-sys+mio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+mio-devel-0.8.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+mio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+mio-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+mio-devel.sha256sum] = "5ad27ee838811cc5f51a2a4aa7133e931bd435b18c81d0c94db18c1d57ca52e8"

URI_x86_64_v2_rust-netlink-sys+mio_socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+mio_socket-devel-0.8.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+mio_socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+mio_socket-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+mio_socket-devel.sha256sum] = "d773961fe549577da78f440ff74e921ef64a9ac2dc8d7e2031ffed3e9211f9e1"

URI_x86_64_v2_rust-netlink-sys+smol_socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+smol_socket-devel-0.8.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+smol_socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+smol_socket-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+smol_socket-devel.sha256sum] = "65fae31b850e24dc53bde4baba2e7213fb3686d7b5450bc4078e914dc351812e"

URI_x86_64_v2_rust-netlink-sys+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+tokio-devel-0.8.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+tokio-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+tokio-devel.sha256sum] = "1a4b486df2988ea1d15d6baf982c4726e32ea9095c027ba207bd369c3f3cbf4f"

URI_x86_64_v2_rust-netlink-sys+tokio_socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+tokio_socket-devel-0.8.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+tokio_socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+tokio_socket-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+tokio_socket-devel.sha256sum] = "ceaedfe60541af3d16402e94db0b84e1affeeffffdd8499b01ab4d22d2f4c9ee"

URI_x86_64_v2_rust-netlink-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys-devel-0.8.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys-devel.sha256sum] = "acfbb497854998fd0482d56b368d7b72848f88e056d9b947e6f314ff9b9e66ee"

URI_aarch64_rust-netlink-sys+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+async-io-devel-0.8.7-2.el10_1.noarch.rpm;name=aarch64_rust-netlink-sys+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+async-io-devel}"
SRC_URI[aarch64_rust-netlink-sys+async-io-devel.sha256sum] = "e39ad1344e3b18c09bc515117896959d26edabfac7ba99948ecc4cf62eccd838"

URI_aarch64_rust-netlink-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+default-devel-0.8.7-2.el10_1.noarch.rpm;name=aarch64_rust-netlink-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+default-devel}"
SRC_URI[aarch64_rust-netlink-sys+default-devel.sha256sum] = "3821df43770cbebcf5c6dd6886fc6e14bc979c2f4c20dc8fe27ad6b8bb268edb"

URI_aarch64_rust-netlink-sys+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+futures-devel-0.8.7-2.el10_1.noarch.rpm;name=aarch64_rust-netlink-sys+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+futures-devel}"
SRC_URI[aarch64_rust-netlink-sys+futures-devel.sha256sum] = "f8e1293bd044f9c34ae01939ee2b39076bd6b908e5becdc43a1225e9332ff34a"

URI_aarch64_rust-netlink-sys+mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+mio-devel-0.8.7-2.el10_1.noarch.rpm;name=aarch64_rust-netlink-sys+mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+mio-devel}"
SRC_URI[aarch64_rust-netlink-sys+mio-devel.sha256sum] = "28cc5af9e319f569c6fc80e7bb18e9081b7ec6d3755c8bf870fa875ef206c4ec"

URI_aarch64_rust-netlink-sys+mio_socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+mio_socket-devel-0.8.7-2.el10_1.noarch.rpm;name=aarch64_rust-netlink-sys+mio_socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+mio_socket-devel}"
SRC_URI[aarch64_rust-netlink-sys+mio_socket-devel.sha256sum] = "803e089a81f0e9052d404d852a7c75863699685fa6a50f69dad5987abd965c17"

URI_aarch64_rust-netlink-sys+smol_socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+smol_socket-devel-0.8.7-2.el10_1.noarch.rpm;name=aarch64_rust-netlink-sys+smol_socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+smol_socket-devel}"
SRC_URI[aarch64_rust-netlink-sys+smol_socket-devel.sha256sum] = "d87b8af4a5b85d60e077a99541187006149e07e63339a4f81213566efe670dc2"

URI_aarch64_rust-netlink-sys+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+tokio-devel-0.8.7-2.el10_1.noarch.rpm;name=aarch64_rust-netlink-sys+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+tokio-devel}"
SRC_URI[aarch64_rust-netlink-sys+tokio-devel.sha256sum] = "30039dd13263393fd37a1c3eade87c046ac1c938a2298246ba3e7a8ab5a8c500"

URI_aarch64_rust-netlink-sys+tokio_socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+tokio_socket-devel-0.8.7-2.el10_1.noarch.rpm;name=aarch64_rust-netlink-sys+tokio_socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+tokio_socket-devel}"
SRC_URI[aarch64_rust-netlink-sys+tokio_socket-devel.sha256sum] = "5d02ec92ed29d07d77be7ca4b7270e6d567136945d5d3ba71109203d9940c098"

URI_aarch64_rust-netlink-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys-devel-0.8.7-2.el10_1.noarch.rpm;name=aarch64_rust-netlink-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys-devel}"
SRC_URI[aarch64_rust-netlink-sys-devel.sha256sum] = "83b43d629c4c1ac4c8baa880567459679202a5d4f13a8ec6b76959412a2e35b6"

RDEPENDS:rust-netlink-sys+async-io-devel = " \
 cargo \
 rust-async-io+default-devel \
 rust-netlink-sys-devel \
 "
RDEPENDS:rust-netlink-sys+default-devel = " \
 cargo \
 rust-netlink-sys-devel \
 "
RDEPENDS:rust-netlink-sys+futures-devel = " \
 cargo \
 rust-futures+default-devel \
 rust-netlink-sys-devel \
 "
RDEPENDS:rust-netlink-sys+mio-devel = " \
 cargo \
 rust-mio+default-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-netlink-sys-devel \
 "
RDEPENDS:rust-netlink-sys+mio_socket-devel = " \
 cargo \
 rust-netlink-sys+mio-devel \
 rust-netlink-sys-devel \
 "
RDEPENDS:rust-netlink-sys+smol_socket-devel = " \
 cargo \
 rust-netlink-sys+async-io-devel \
 rust-netlink-sys+futures-devel \
 rust-netlink-sys-devel \
 "
RDEPENDS:rust-netlink-sys+tokio-devel = " \
 cargo \
 rust-netlink-sys-devel \
 rust-tokio+net-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-netlink-sys+tokio_socket-devel = " \
 cargo \
 rust-netlink-sys+futures-devel \
 rust-netlink-sys+tokio-devel \
 rust-netlink-sys-devel \
 "
RDEPENDS:rust-netlink-sys-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 "
