# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocrand"
PV = "6.4.2"
PR = "5.el10_1"
PACKAGES:x86_64_v2 = " \
 rocrand \
 rocrand-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocrand-6.4.2-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "018a418824fb2cc46a58c298b6e33e4134cf8b8493ae5fc2f06361547cddabc0"

URI_x86_64_v2_rocrand = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocrand-6.4.2-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocrand;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocrand}"
SRC_URI[x86_64_v2_rocrand.sha256sum] = "05e5c6380cd76e867a0ac21683d2f6ec321ef535adbd86401c0104032bcd5ac0"

URI_x86_64_v2_rocrand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocrand-devel-6.4.2-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocrand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocrand-devel}"
SRC_URI[x86_64_v2_rocrand-devel.sha256sum] = "586a5a80126d3640c1627a8a050713412f1f0410d4642d6127cc96faa9b57ceb"

RDEPENDS:rocrand = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 "
RDEPENDS:rocrand-devel = " \
 cmake-filesystem \
 rocrand \
 "
