# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snapbox"
PV = "1.2.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-snapbox+cmd-devel \
 rust-snapbox+color-auto-devel \
 rust-snapbox+color-devel \
 rust-snapbox+debug-devel \
 rust-snapbox+default-devel \
 rust-snapbox+detect-encoding-devel \
 rust-snapbox+diff-devel \
 rust-snapbox+dir-devel \
 rust-snapbox+document-features-devel \
 rust-snapbox+examples-devel \
 rust-snapbox+json-devel \
 rust-snapbox+path-devel \
 rust-snapbox+regex-devel \
 rust-snapbox+structured-data-devel \
 rust-snapbox+term-svg-devel \
 rust-snapbox-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snapbox-1.2.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "479869af1ed8d6cc05399772fa33f9f4cd853e5396153468d1b831787a7ad44b"

URI_x86_64_v2_rust-snapbox+cmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+cmd-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+cmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+cmd-devel}"
SRC_URI[x86_64_v2_rust-snapbox+cmd-devel.sha256sum] = "1fceedeecff33c278f78a118b00ac09c0cc46e9b28fa02d2b02898dc434cf455"

URI_x86_64_v2_rust-snapbox+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+color-auto-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+color-auto-devel}"
SRC_URI[x86_64_v2_rust-snapbox+color-auto-devel.sha256sum] = "335f28760b0adf0a000dccc8b6a06c07127d6f85b784faf0795b5c278351f41d"

URI_x86_64_v2_rust-snapbox+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+color-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+color-devel}"
SRC_URI[x86_64_v2_rust-snapbox+color-devel.sha256sum] = "72df55caad1eaee99e85e1a5db43428fb49765d03c033c0fb61d34f2e16a91c7"

URI_x86_64_v2_rust-snapbox+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+debug-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+debug-devel}"
SRC_URI[x86_64_v2_rust-snapbox+debug-devel.sha256sum] = "6bd633a221935a8c5d8b79f242417049f26715fe83a59ef093e707098bebc4d4"

URI_x86_64_v2_rust-snapbox+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+default-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+default-devel}"
SRC_URI[x86_64_v2_rust-snapbox+default-devel.sha256sum] = "97f70fd2674c13fa80fb0cd973b147fb79ad8734a11156e5afef1904cd631693"

URI_x86_64_v2_rust-snapbox+detect-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+detect-encoding-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+detect-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+detect-encoding-devel}"
SRC_URI[x86_64_v2_rust-snapbox+detect-encoding-devel.sha256sum] = "efc47a63266d45fb8af7b736b6720a662d7b0eb83d9e9929c2df6149f160c1c2"

URI_x86_64_v2_rust-snapbox+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+diff-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+diff-devel}"
SRC_URI[x86_64_v2_rust-snapbox+diff-devel.sha256sum] = "7f55fc6032ca25f938525224782663f78b0a4d7b13867ecce0f0d0ac2cdd1598"

URI_x86_64_v2_rust-snapbox+dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+dir-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+dir-devel}"
SRC_URI[x86_64_v2_rust-snapbox+dir-devel.sha256sum] = "f4ef6ae239f5711832c7ddd62eca3e5e5f114fa7c5a4d204e307a82763a498bb"

URI_x86_64_v2_rust-snapbox+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+document-features-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+document-features-devel}"
SRC_URI[x86_64_v2_rust-snapbox+document-features-devel.sha256sum] = "5818e37fc03dc7b7edd3a4cea48747df61b7590485eb3313fabd39b22514c986"

URI_x86_64_v2_rust-snapbox+examples-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+examples-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+examples-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+examples-devel}"
SRC_URI[x86_64_v2_rust-snapbox+examples-devel.sha256sum] = "200dbb4d3a820cf63e53cfc811ef776a0593425ec60a5aa64194e3a31cbd8474"

URI_x86_64_v2_rust-snapbox+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+json-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+json-devel}"
SRC_URI[x86_64_v2_rust-snapbox+json-devel.sha256sum] = "6b856bd057eaef7e62c7332319647a57ea73be8552f7476a7ce05226fdc71058"

URI_x86_64_v2_rust-snapbox+path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+path-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+path-devel}"
SRC_URI[x86_64_v2_rust-snapbox+path-devel.sha256sum] = "60a18614ea24dcc94e9b0f833547bf660db787b9152a567854c71bfbcea4a1a4"

URI_x86_64_v2_rust-snapbox+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+regex-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+regex-devel}"
SRC_URI[x86_64_v2_rust-snapbox+regex-devel.sha256sum] = "6c155edb536d82a25a096c823570ef102fc94bd7a98ac4b822206762efdece27"

URI_x86_64_v2_rust-snapbox+structured-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+structured-data-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+structured-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+structured-data-devel}"
SRC_URI[x86_64_v2_rust-snapbox+structured-data-devel.sha256sum] = "e232b91ae1314e293cdbae18a3d3b3294b85159d177c282bb9cc5ff7d74ca5cd"

URI_x86_64_v2_rust-snapbox+term-svg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+term-svg-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+term-svg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+term-svg-devel}"
SRC_URI[x86_64_v2_rust-snapbox+term-svg-devel.sha256sum] = "e4a888b3491bd3f3654d3a92615c74093afe72fcfc1ebd93512d1cbfe2e7b96a"

URI_x86_64_v2_rust-snapbox-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-devel}"
SRC_URI[x86_64_v2_rust-snapbox-devel.sha256sum] = "a6fc4b76141f068f1e05cf687594501a5dba05779680c199be90b38a6f524095"

URI_aarch64_rust-snapbox+cmd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+cmd-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox+cmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+cmd-devel}"
SRC_URI[aarch64_rust-snapbox+cmd-devel.sha256sum] = "e58cf98da315c4d16179b144b0b31d5431c3204fd61891ab7c02c474f7dedb09"

URI_aarch64_rust-snapbox+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+color-auto-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+color-auto-devel}"
SRC_URI[aarch64_rust-snapbox+color-auto-devel.sha256sum] = "7553e9b811fb970cd3eb9eec64fe9c56440ab90bc7743707b7820d40e11cc32a"

URI_aarch64_rust-snapbox+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+color-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+color-devel}"
SRC_URI[aarch64_rust-snapbox+color-devel.sha256sum] = "d83b185932ffdf6b70eafd2af05a3fd3e9a7b07b5cc2561976f59a5232d8e2ae"

URI_aarch64_rust-snapbox+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+debug-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+debug-devel}"
SRC_URI[aarch64_rust-snapbox+debug-devel.sha256sum] = "32a7a920180db0caef4afa9feddf599829abd9c7f200eb52afd83bf60c8c1325"

URI_aarch64_rust-snapbox+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+default-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+default-devel}"
SRC_URI[aarch64_rust-snapbox+default-devel.sha256sum] = "ae16c0f25c6292e52f4ccd19152e36e1ebf1f1d9b8ed4fbec3dc6bf12c701cbb"

URI_aarch64_rust-snapbox+detect-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+detect-encoding-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox+detect-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+detect-encoding-devel}"
SRC_URI[aarch64_rust-snapbox+detect-encoding-devel.sha256sum] = "42c99c40668a4a3f113651642615ae4f23ea0c03e8e31c1b2f506533dfd63962"

URI_aarch64_rust-snapbox+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+diff-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+diff-devel}"
SRC_URI[aarch64_rust-snapbox+diff-devel.sha256sum] = "b755a27a1685b6ed9d8f5e794c341011d8f2f7c016711ffcd429d345823ae7a3"

URI_aarch64_rust-snapbox+dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+dir-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox+dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+dir-devel}"
SRC_URI[aarch64_rust-snapbox+dir-devel.sha256sum] = "86714fb22b4483c516113dd0d24ccf1262d122fa086195f439e7e4f209eff49e"

URI_aarch64_rust-snapbox+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+document-features-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+document-features-devel}"
SRC_URI[aarch64_rust-snapbox+document-features-devel.sha256sum] = "156db8b709d1cbd66a85145b686e2aaf4d083baa95f004517824ae1065f8cd5b"

URI_aarch64_rust-snapbox+examples-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+examples-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox+examples-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+examples-devel}"
SRC_URI[aarch64_rust-snapbox+examples-devel.sha256sum] = "ff6318e01685bbf8833fd3b92e4c752a362262fbd2215a99d705fcd9e781e63b"

URI_aarch64_rust-snapbox+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+json-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+json-devel}"
SRC_URI[aarch64_rust-snapbox+json-devel.sha256sum] = "690896d1ee31c611406ed0e352b17336bc78fcd6ec9d79caf6eb11b62244b2f9"

URI_aarch64_rust-snapbox+path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+path-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox+path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+path-devel}"
SRC_URI[aarch64_rust-snapbox+path-devel.sha256sum] = "02fc1e726d06360c86b9deb21a491f0a9d070a07dd43622ac5e9447aceb068e4"

URI_aarch64_rust-snapbox+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+regex-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+regex-devel}"
SRC_URI[aarch64_rust-snapbox+regex-devel.sha256sum] = "2f7a94d69ade04c85edef2d9c02d4da4546c44fb088d367d2488b52349d2c22a"

URI_aarch64_rust-snapbox+structured-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+structured-data-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox+structured-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+structured-data-devel}"
SRC_URI[aarch64_rust-snapbox+structured-data-devel.sha256sum] = "dd3ed69844135ae597290b8a8848e16ff9c75a77c8c4f8630f8b234fdb7534b8"

URI_aarch64_rust-snapbox+term-svg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+term-svg-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox+term-svg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+term-svg-devel}"
SRC_URI[aarch64_rust-snapbox+term-svg-devel.sha256sum] = "0ef882ce136c04da567767fae23d02e5d2bfdb4735bfa65b6a6e0c44d17a50a2"

URI_aarch64_rust-snapbox-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-devel}"
SRC_URI[aarch64_rust-snapbox-devel.sha256sum] = "d71c05adcae1b85b8f6cdd2d99aa890f32d1d943adb1c19e3d6900f0f07c1bfb"

RDEPENDS:rust-snapbox+cmd-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-os_pipe+default-devel \
 rust-snapbox-devel \
 rust-wait-timeout+default-devel \
 "
RDEPENDS:rust-snapbox+color-auto-devel = " \
 cargo \
 rust-snapbox+color-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-snapbox-devel \
 rust-snapbox-macros+color-devel \
 "
RDEPENDS:rust-snapbox+debug-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-snapbox-devel \
 rust-snapbox-macros+debug-devel \
 "
RDEPENDS:rust-snapbox+default-devel = " \
 cargo \
 rust-snapbox+color-auto-devel \
 rust-snapbox+diff-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+detect-encoding-devel = " \
 cargo \
 rust-content_inspector+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+diff-devel = " \
 cargo \
 rust-similar+default-devel \
 rust-similar+inline-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+dir-devel = " \
 cargo \
 rust-dunce+default-devel \
 rust-filetime+default-devel \
 rust-snapbox+detect-encoding-devel \
 rust-snapbox-devel \
 rust-tempfile-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-snapbox+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+examples-devel = " \
 cargo \
 rust-escargot+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+json-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 rust-snapbox+structured-data-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+path-devel = " \
 cargo \
 rust-snapbox+dir-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+regex-devel = " \
 cargo \
 rust-regex+std-devel \
 rust-regex-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+structured-data-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+term-svg-devel = " \
 cargo \
 rust-anstyle-svg+default-devel \
 rust-snapbox+structured-data-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-normalize-line-endings+default-devel \
 rust-snapbox-macros+default-devel \
 "
