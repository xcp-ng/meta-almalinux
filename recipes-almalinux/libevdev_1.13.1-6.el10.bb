# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libevdev"
PV = "1.13.1"
PR = "6.el10"
PACKAGES = " \
 libevdev \
 libevdev-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libevdev-1.13.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd2aaa0bb0091bb96d1f205ddc795321fc0bf4d6a03da5567f9642ecdb07d14f"

URI_x86_64_v2_libevdev = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libevdev-1.13.1-6.el10.x86_64_v2.rpm;name=x86_64_v2_libevdev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libevdev}"
SRC_URI[x86_64_v2_libevdev.sha256sum] = "4c959c03b17c89f1ec1700d5fe2b102043f595ae170adbb8f6b67ea28527e9fb"

URI_x86_64_v2_libevdev-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libevdev-devel-1.13.1-6.el10.x86_64_v2.rpm;name=x86_64_v2_libevdev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libevdev-devel}"
SRC_URI[x86_64_v2_libevdev-devel.sha256sum] = "697bd669eb423c1cd5660db6ffcf20ef3d1785388255ce618ac1ea9bdb24a40c"

URI_aarch64_libevdev = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libevdev-1.13.1-6.el10.aarch64.rpm;name=aarch64_libevdev;unpack=0"
SRC_URI:append = " ${URI_aarch64_libevdev}"
SRC_URI[aarch64_libevdev.sha256sum] = "a43178f1459082c86ab0911c8c709217445f214bc391dcb2dee5756c1ee46fe8"

URI_aarch64_libevdev-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libevdev-devel-1.13.1-6.el10.aarch64.rpm;name=aarch64_libevdev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libevdev-devel}"
SRC_URI[aarch64_libevdev-devel.sha256sum] = "c0d83cf9b83b97e8188aa3c46f2adde45dd2c443c88b566561449c5caf63cee2"

RDEPENDS:libevdev = " \
 glibc \
 "
RDEPENDS:libevdev-devel = " \
 libevdev \
 pkgconf-pkg-config \
 "
