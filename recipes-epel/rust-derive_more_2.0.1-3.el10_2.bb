# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derive_more"
PV = "2.0.1"
PR = "3.el10_2"
PACKAGES = " \
 rust-derive_more+add-devel \
 rust-derive_more+add_assign-devel \
 rust-derive_more+as_ref-devel \
 rust-derive_more+constructor-devel \
 rust-derive_more+debug-devel \
 rust-derive_more+default-devel \
 rust-derive_more+deref-devel \
 rust-derive_more+deref_mut-devel \
 rust-derive_more+display-devel \
 rust-derive_more+error-devel \
 rust-derive_more+from-devel \
 rust-derive_more+from_str-devel \
 rust-derive_more+full-devel \
 rust-derive_more+index-devel \
 rust-derive_more+index_mut-devel \
 rust-derive_more+into-devel \
 rust-derive_more+into_iterator-devel \
 rust-derive_more+is_variant-devel \
 rust-derive_more+mul-devel \
 rust-derive_more+mul_assign-devel \
 rust-derive_more+not-devel \
 rust-derive_more+std-devel \
 rust-derive_more+sum-devel \
 rust-derive_more+testing-helpers-devel \
 rust-derive_more+try_from-devel \
 rust-derive_more+try_into-devel \
 rust-derive_more+try_unwrap-devel \
 rust-derive_more+unwrap-devel \
 rust-derive_more-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-derive_more-2.0.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b34b0915dfe9bd630a268caaa29a8bb85f5fa0045284e46393a2b1eae9bd699"

URI_x86_64_v2_rust-derive_more+add-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+add-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+add-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+add-devel}"
SRC_URI[x86_64_v2_rust-derive_more+add-devel.sha256sum] = "406891b7f6c09a6c234f176d95d0126a237ee9cd37ef54f933a7b707827af475"

URI_x86_64_v2_rust-derive_more+add_assign-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+add_assign-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+add_assign-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+add_assign-devel}"
SRC_URI[x86_64_v2_rust-derive_more+add_assign-devel.sha256sum] = "4d1e36ed8029d0bfd0843a5828f9c27b51222dec815375cb0c69187f28943a41"

URI_x86_64_v2_rust-derive_more+as_ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+as_ref-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+as_ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+as_ref-devel}"
SRC_URI[x86_64_v2_rust-derive_more+as_ref-devel.sha256sum] = "e7ca2dbe868d48e84c5971033a429621f56b2e803835bbd61ee648ed2bcdf77e"

URI_x86_64_v2_rust-derive_more+constructor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+constructor-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+constructor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+constructor-devel}"
SRC_URI[x86_64_v2_rust-derive_more+constructor-devel.sha256sum] = "2a4019c7390795674fd56fb920f04759959ccb4b99bea7ca61e5754ad73982a4"

URI_x86_64_v2_rust-derive_more+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+debug-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+debug-devel}"
SRC_URI[x86_64_v2_rust-derive_more+debug-devel.sha256sum] = "825b95ee055f8c9703a157d7726b9bac597dfcde5e32af4064c68b45271b7515"

URI_x86_64_v2_rust-derive_more+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+default-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+default-devel}"
SRC_URI[x86_64_v2_rust-derive_more+default-devel.sha256sum] = "8e6720e577e6cb467ec8275746bd74fcf412da8bcaeaa86d2965dfc046dd0ec3"

URI_x86_64_v2_rust-derive_more+deref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+deref-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+deref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+deref-devel}"
SRC_URI[x86_64_v2_rust-derive_more+deref-devel.sha256sum] = "a9942042a55ae15b59b5ef2e82611cf91502157c8b9f607843facc671e39044b"

URI_x86_64_v2_rust-derive_more+deref_mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+deref_mut-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+deref_mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+deref_mut-devel}"
SRC_URI[x86_64_v2_rust-derive_more+deref_mut-devel.sha256sum] = "6a1f0034158e881b49791c183bfba5ca9ec5b3f0a6c3befbae61296449e5caff"

URI_x86_64_v2_rust-derive_more+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+display-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+display-devel}"
SRC_URI[x86_64_v2_rust-derive_more+display-devel.sha256sum] = "39e33bc74b11374ea9dd307bb4e884261e27217ade39309b188c1142a25163aa"

URI_x86_64_v2_rust-derive_more+error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+error-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+error-devel}"
SRC_URI[x86_64_v2_rust-derive_more+error-devel.sha256sum] = "14f6d6b98c4195de45987b369afd37ecd5d62fcbdfb9314ab5f6a635a0268e1a"

URI_x86_64_v2_rust-derive_more+from-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+from-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+from-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+from-devel}"
SRC_URI[x86_64_v2_rust-derive_more+from-devel.sha256sum] = "2678364ef60c14cd8573408ee2a6ced0d69f1bd2c4c525a449a34756efae4307"

URI_x86_64_v2_rust-derive_more+from_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+from_str-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+from_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+from_str-devel}"
SRC_URI[x86_64_v2_rust-derive_more+from_str-devel.sha256sum] = "89a1e8512b413dd39c3ef742d6acf8ffa3e98f099256d9a4cc78cfa6f679e4c2"

URI_x86_64_v2_rust-derive_more+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+full-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+full-devel}"
SRC_URI[x86_64_v2_rust-derive_more+full-devel.sha256sum] = "c5ff0b15151f22ea01fd09adb3619c91afb333688be77ab72e6f03b6b3b6c46f"

URI_x86_64_v2_rust-derive_more+index-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+index-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+index-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+index-devel}"
SRC_URI[x86_64_v2_rust-derive_more+index-devel.sha256sum] = "b698a60ceb3cd35830eb43036ca6e1d35bb720297d2463f6543999b6e58a8cff"

URI_x86_64_v2_rust-derive_more+index_mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+index_mut-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+index_mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+index_mut-devel}"
SRC_URI[x86_64_v2_rust-derive_more+index_mut-devel.sha256sum] = "162a1266054eef7a3a744e086e7eaf0a62e1898b87e9b4fbd4bb5e995a9ef700"

URI_x86_64_v2_rust-derive_more+into-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+into-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+into-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+into-devel}"
SRC_URI[x86_64_v2_rust-derive_more+into-devel.sha256sum] = "8c788aaccca42abe0d02bc8256324a92ce75b5f58e462deba620acb594012c9a"

URI_x86_64_v2_rust-derive_more+into_iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+into_iterator-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+into_iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+into_iterator-devel}"
SRC_URI[x86_64_v2_rust-derive_more+into_iterator-devel.sha256sum] = "cb9ea33264d093e42751b9649ce3a679e528e185cea343e8a9641508cc461f92"

URI_x86_64_v2_rust-derive_more+is_variant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+is_variant-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+is_variant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+is_variant-devel}"
SRC_URI[x86_64_v2_rust-derive_more+is_variant-devel.sha256sum] = "53fae50278e0f4b854272ce92af834880198fbf6bbf02172d7d8ed85a65fe54b"

URI_x86_64_v2_rust-derive_more+mul-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+mul-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+mul-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+mul-devel}"
SRC_URI[x86_64_v2_rust-derive_more+mul-devel.sha256sum] = "5523ad2415db8245166c79a6c7d7ca4a07853eb7c63fca34b8252358bd97fccf"

URI_x86_64_v2_rust-derive_more+mul_assign-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+mul_assign-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+mul_assign-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+mul_assign-devel}"
SRC_URI[x86_64_v2_rust-derive_more+mul_assign-devel.sha256sum] = "058fab24b9187d3124122429c52c7b09e93c1e66e659225a9685d306101b3cae"

URI_x86_64_v2_rust-derive_more+not-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+not-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+not-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+not-devel}"
SRC_URI[x86_64_v2_rust-derive_more+not-devel.sha256sum] = "fff1bec0384d23dbfa9fd5a820dbf7d59b68f7f61516507489f9f31e33040d23"

URI_x86_64_v2_rust-derive_more+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+std-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+std-devel}"
SRC_URI[x86_64_v2_rust-derive_more+std-devel.sha256sum] = "e81288a9b8fe5241399e0bf6d67119f2a8608b4cdd3547e8f6746ac980477222"

URI_x86_64_v2_rust-derive_more+sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+sum-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+sum-devel}"
SRC_URI[x86_64_v2_rust-derive_more+sum-devel.sha256sum] = "379b098de3c023a5e747c068e15fc733355929dae3f2d1d45b65285ff5e07067"

URI_x86_64_v2_rust-derive_more+testing-helpers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+testing-helpers-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+testing-helpers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+testing-helpers-devel}"
SRC_URI[x86_64_v2_rust-derive_more+testing-helpers-devel.sha256sum] = "b4238b0e2479465dae8326fb8767251c9e0c3abd51ef506e8c934e1a697465e5"

URI_x86_64_v2_rust-derive_more+try_from-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+try_from-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+try_from-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+try_from-devel}"
SRC_URI[x86_64_v2_rust-derive_more+try_from-devel.sha256sum] = "c5a6df35fb689165c54c79c8f86e0bc77264b25e2ac1fdcd6fb124e252a5ea5b"

URI_x86_64_v2_rust-derive_more+try_into-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+try_into-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+try_into-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+try_into-devel}"
SRC_URI[x86_64_v2_rust-derive_more+try_into-devel.sha256sum] = "c6a11370e2c41fe6f2cb85aacdfa3208e01b96cb2e33a3779c1bf6fb80531986"

URI_x86_64_v2_rust-derive_more+try_unwrap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+try_unwrap-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+try_unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+try_unwrap-devel}"
SRC_URI[x86_64_v2_rust-derive_more+try_unwrap-devel.sha256sum] = "d9cf59c8e1979aabbab2846d728760601a404041e6e301afd1785f2eda4415ac"

URI_x86_64_v2_rust-derive_more+unwrap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+unwrap-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+unwrap-devel}"
SRC_URI[x86_64_v2_rust-derive_more+unwrap-devel.sha256sum] = "d2dd7e022e55ab5c0ab4ee32e08ff1bfbe827c639f4b4aeb61d5a23231e5071b"

URI_x86_64_v2_rust-derive_more-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-devel-2.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-devel}"
SRC_URI[x86_64_v2_rust-derive_more-devel.sha256sum] = "648762ef6eeef16a53a2f716523e677e8113ae420e9a1be0b9bb6233693449d5"

URI_aarch64_rust-derive_more+add-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+add-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+add-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+add-devel}"
SRC_URI[aarch64_rust-derive_more+add-devel.sha256sum] = "987b94566043e05aebd1785ab2fc870ec3ab8631b0a2a60aaae742bf08bd9325"

URI_aarch64_rust-derive_more+add_assign-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+add_assign-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+add_assign-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+add_assign-devel}"
SRC_URI[aarch64_rust-derive_more+add_assign-devel.sha256sum] = "610e0248680da5488cb8d324829980e47a058dd3866c4bc1318b07e8e2cb1910"

URI_aarch64_rust-derive_more+as_ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+as_ref-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+as_ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+as_ref-devel}"
SRC_URI[aarch64_rust-derive_more+as_ref-devel.sha256sum] = "6d74fe29e228a5a1d195cac1c95ce055eb91fe5dd0f919aa388c54e4b99e7eb7"

URI_aarch64_rust-derive_more+constructor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+constructor-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+constructor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+constructor-devel}"
SRC_URI[aarch64_rust-derive_more+constructor-devel.sha256sum] = "eda0cb58aad2a05330dfcb87b287213d96e96fcae43db1049559df4925a542fc"

URI_aarch64_rust-derive_more+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+debug-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+debug-devel}"
SRC_URI[aarch64_rust-derive_more+debug-devel.sha256sum] = "e9f3424ac7c3b10a06f1ca8c930d8585e651f1c95b7b0a35e70d132cedbfb266"

URI_aarch64_rust-derive_more+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+default-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+default-devel}"
SRC_URI[aarch64_rust-derive_more+default-devel.sha256sum] = "17f42146236665e8ed66b906450d95855f8d894919c46b54e090b9f5cbbf5f3e"

URI_aarch64_rust-derive_more+deref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+deref-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+deref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+deref-devel}"
SRC_URI[aarch64_rust-derive_more+deref-devel.sha256sum] = "3873eedc135ce68d68ac8bf6d429e1a92f90e7d4b852684dac6dc5f88dc2c25b"

URI_aarch64_rust-derive_more+deref_mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+deref_mut-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+deref_mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+deref_mut-devel}"
SRC_URI[aarch64_rust-derive_more+deref_mut-devel.sha256sum] = "15cdaa37def2143adcc090910b1181e7a0f03c0fe2e67d244f88ff5246faad55"

URI_aarch64_rust-derive_more+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+display-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+display-devel}"
SRC_URI[aarch64_rust-derive_more+display-devel.sha256sum] = "77913f49c9e4fcc700d5362d64efb647c969240f58b0d153ca1f542cc8f78538"

URI_aarch64_rust-derive_more+error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+error-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+error-devel}"
SRC_URI[aarch64_rust-derive_more+error-devel.sha256sum] = "428eaad738bec63714007eb2d9dc0f720f664f774f5f1cba63fcfb92eae0f061"

URI_aarch64_rust-derive_more+from-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+from-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+from-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+from-devel}"
SRC_URI[aarch64_rust-derive_more+from-devel.sha256sum] = "a1c9c36fdcd3549d345f6146370ae6904681324256e0825233ef7c8e7e5efe63"

URI_aarch64_rust-derive_more+from_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+from_str-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+from_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+from_str-devel}"
SRC_URI[aarch64_rust-derive_more+from_str-devel.sha256sum] = "2f881920fcb4db3559338c89858d487c06f1047892052d070614b2145cb45dd0"

URI_aarch64_rust-derive_more+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+full-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+full-devel}"
SRC_URI[aarch64_rust-derive_more+full-devel.sha256sum] = "458a28a69888056228db60757d009d2712af09e304db1abdb378a7cfbc352abc"

URI_aarch64_rust-derive_more+index-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+index-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+index-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+index-devel}"
SRC_URI[aarch64_rust-derive_more+index-devel.sha256sum] = "4319bd0cfc3494f241a983824c41d3d9370878b9e7118f5e4c86d548574ad1cf"

URI_aarch64_rust-derive_more+index_mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+index_mut-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+index_mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+index_mut-devel}"
SRC_URI[aarch64_rust-derive_more+index_mut-devel.sha256sum] = "07f2489472478eae6aaa82321896f356c212700c976b1be2a4c85c498696a495"

URI_aarch64_rust-derive_more+into-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+into-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+into-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+into-devel}"
SRC_URI[aarch64_rust-derive_more+into-devel.sha256sum] = "ac1feba31b5b2e492929214f69196ca475d10499a621761ac202f98b1da25564"

URI_aarch64_rust-derive_more+into_iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+into_iterator-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+into_iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+into_iterator-devel}"
SRC_URI[aarch64_rust-derive_more+into_iterator-devel.sha256sum] = "42ef30ba90e84065f4e102b1140441c9e210376d4566999bb60a951eefd67b2f"

URI_aarch64_rust-derive_more+is_variant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+is_variant-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+is_variant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+is_variant-devel}"
SRC_URI[aarch64_rust-derive_more+is_variant-devel.sha256sum] = "aab3a0222fa3766c4b184a2122e6757166312178950fe3201d48f7de43432f10"

URI_aarch64_rust-derive_more+mul-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+mul-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+mul-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+mul-devel}"
SRC_URI[aarch64_rust-derive_more+mul-devel.sha256sum] = "d7f6ecf7b7699c00174148a9c581001fb52bbb389d485a06820ab7fea74930bb"

URI_aarch64_rust-derive_more+mul_assign-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+mul_assign-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+mul_assign-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+mul_assign-devel}"
SRC_URI[aarch64_rust-derive_more+mul_assign-devel.sha256sum] = "4aa9df431413dc47e5ecc042e255e2803836ae1db367cb8037f0a7973a3facc8"

URI_aarch64_rust-derive_more+not-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+not-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+not-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+not-devel}"
SRC_URI[aarch64_rust-derive_more+not-devel.sha256sum] = "e00f8b90f5ec2e07349743e050c1c047cc12b6ead9377348517f58ee9d0a401d"

URI_aarch64_rust-derive_more+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+std-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+std-devel}"
SRC_URI[aarch64_rust-derive_more+std-devel.sha256sum] = "6e2ff7b81033097bdc07200aa87e755a815e39df95862a737b04f734b167d576"

URI_aarch64_rust-derive_more+sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+sum-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+sum-devel}"
SRC_URI[aarch64_rust-derive_more+sum-devel.sha256sum] = "834b0bcfa2465c5a5290ea7f1b401888b88dc14aced9da0880da44755b3c43e6"

URI_aarch64_rust-derive_more+testing-helpers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+testing-helpers-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+testing-helpers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+testing-helpers-devel}"
SRC_URI[aarch64_rust-derive_more+testing-helpers-devel.sha256sum] = "b49148774417486d0f2c54d5611f4828069e5545d25d09bd68a2b9a174d28430"

URI_aarch64_rust-derive_more+try_from-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+try_from-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+try_from-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+try_from-devel}"
SRC_URI[aarch64_rust-derive_more+try_from-devel.sha256sum] = "fab64841fcef586d5e3083731232ed8e218a1a193e4afeedd2f95f346c51906d"

URI_aarch64_rust-derive_more+try_into-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+try_into-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+try_into-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+try_into-devel}"
SRC_URI[aarch64_rust-derive_more+try_into-devel.sha256sum] = "9167c3a8f1d32d31df7439f3afde142bdeaa7cd7d707532b678c407b95b52e54"

URI_aarch64_rust-derive_more+try_unwrap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+try_unwrap-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+try_unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+try_unwrap-devel}"
SRC_URI[aarch64_rust-derive_more+try_unwrap-devel.sha256sum] = "0fb64b1ccff37504250f56f0b2058c5959c012a9bb02bff1aa408ccd24dfacc7"

URI_aarch64_rust-derive_more+unwrap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+unwrap-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more+unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+unwrap-devel}"
SRC_URI[aarch64_rust-derive_more+unwrap-devel.sha256sum] = "00458d8239482263d44b211e9a1ea2b628fc06f852e278ada590d4d232e80650"

URI_aarch64_rust-derive_more-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-devel-2.0.1-3.el10_2.noarch.rpm;name=aarch64_rust-derive_more-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-devel}"
SRC_URI[aarch64_rust-derive_more-devel.sha256sum] = "9d9e4e68833c2258c33edf067cad009304667db1aa80d298f0e177be081b855d"

RDEPENDS:rust-derive_more+add-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+add-devel \
 "
RDEPENDS:rust-derive_more+add_assign-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+add_assign-devel \
 "
RDEPENDS:rust-derive_more+as_ref-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+as_ref-devel \
 "
RDEPENDS:rust-derive_more+constructor-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+constructor-devel \
 "
RDEPENDS:rust-derive_more+debug-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+debug-devel \
 "
RDEPENDS:rust-derive_more+default-devel = " \
 cargo \
 rust-derive_more+std-devel \
 rust-derive_more-devel \
 "
RDEPENDS:rust-derive_more+deref-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+deref-devel \
 "
RDEPENDS:rust-derive_more+deref_mut-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+deref_mut-devel \
 "
RDEPENDS:rust-derive_more+display-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+display-devel \
 "
RDEPENDS:rust-derive_more+error-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+error-devel \
 "
RDEPENDS:rust-derive_more+from-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+from-devel \
 "
RDEPENDS:rust-derive_more+from_str-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+from_str-devel \
 "
RDEPENDS:rust-derive_more+full-devel = " \
 cargo \
 rust-derive_more+add-devel \
 rust-derive_more+add_assign-devel \
 rust-derive_more+as_ref-devel \
 rust-derive_more+constructor-devel \
 rust-derive_more+debug-devel \
 rust-derive_more+deref-devel \
 rust-derive_more+deref_mut-devel \
 rust-derive_more+display-devel \
 rust-derive_more+error-devel \
 rust-derive_more+from-devel \
 rust-derive_more+from_str-devel \
 rust-derive_more+index-devel \
 rust-derive_more+index_mut-devel \
 rust-derive_more+into-devel \
 rust-derive_more+into_iterator-devel \
 rust-derive_more+is_variant-devel \
 rust-derive_more+mul-devel \
 rust-derive_more+mul_assign-devel \
 rust-derive_more+not-devel \
 rust-derive_more+sum-devel \
 rust-derive_more+try_from-devel \
 rust-derive_more+try_into-devel \
 rust-derive_more+try_unwrap-devel \
 rust-derive_more+unwrap-devel \
 rust-derive_more-devel \
 "
RDEPENDS:rust-derive_more+index-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+index-devel \
 "
RDEPENDS:rust-derive_more+index_mut-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+index_mut-devel \
 "
RDEPENDS:rust-derive_more+into-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+into-devel \
 "
RDEPENDS:rust-derive_more+into_iterator-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+into_iterator-devel \
 "
RDEPENDS:rust-derive_more+is_variant-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+is_variant-devel \
 "
RDEPENDS:rust-derive_more+mul-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+mul-devel \
 "
RDEPENDS:rust-derive_more+mul_assign-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+mul_assign-devel \
 "
RDEPENDS:rust-derive_more+not-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+not-devel \
 "
RDEPENDS:rust-derive_more+std-devel = " \
 cargo \
 rust-derive_more-devel \
 "
RDEPENDS:rust-derive_more+sum-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+sum-devel \
 "
RDEPENDS:rust-derive_more+testing-helpers-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+testing-helpers-devel \
 rust-rustc_version+default-devel \
 "
RDEPENDS:rust-derive_more+try_from-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+try_from-devel \
 "
RDEPENDS:rust-derive_more+try_into-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+try_into-devel \
 "
RDEPENDS:rust-derive_more+try_unwrap-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+try_unwrap-devel \
 "
RDEPENDS:rust-derive_more+unwrap-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+unwrap-devel \
 "
RDEPENDS:rust-derive_more-devel = " \
 cargo \
 rust \
 rust-derive_more-impl+default-devel \
 "
