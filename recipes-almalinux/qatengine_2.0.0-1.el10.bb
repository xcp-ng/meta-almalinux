# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qatengine"
PV = "2.0.0"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 qatengine \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qatengine-2.0.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a9bd267dda111040d1597e494418900ff02557781bab62adaba156b4d0b294b5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatengine-2.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatengine;unpack=0"
SRC_URI[x86_64_v2_qatengine.sha256sum] = "b34310dc08c75c391178ab68c08b13ef9e573732685cb9bd30d2601839fb7b83"

RDEPENDS:qatengine = " \
 glibc \
 qatlib \
 "
