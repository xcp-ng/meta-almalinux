# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc9.8"
PV = "9.8.4"
PR = "14.el10_0"
PACKAGES = " \
 ghc9.8 \
 ghc9.8-Cabal \
 ghc9.8-Cabal-devel \
 ghc9.8-Cabal-doc \
 ghc9.8-Cabal-prof \
 ghc9.8-Cabal-syntax \
 ghc9.8-Cabal-syntax-devel \
 ghc9.8-Cabal-syntax-doc \
 ghc9.8-Cabal-syntax-prof \
 ghc9.8-array \
 ghc9.8-array-devel \
 ghc9.8-array-doc \
 ghc9.8-array-prof \
 ghc9.8-base \
 ghc9.8-base-devel \
 ghc9.8-base-doc \
 ghc9.8-base-prof \
 ghc9.8-binary \
 ghc9.8-binary-devel \
 ghc9.8-binary-doc \
 ghc9.8-binary-prof \
 ghc9.8-bytestring \
 ghc9.8-bytestring-devel \
 ghc9.8-bytestring-doc \
 ghc9.8-bytestring-prof \
 ghc9.8-compiler \
 ghc9.8-compiler-default \
 ghc9.8-containers \
 ghc9.8-containers-devel \
 ghc9.8-containers-doc \
 ghc9.8-containers-prof \
 ghc9.8-deepseq \
 ghc9.8-deepseq-devel \
 ghc9.8-deepseq-doc \
 ghc9.8-deepseq-prof \
 ghc9.8-devel \
 ghc9.8-directory \
 ghc9.8-directory-devel \
 ghc9.8-directory-doc \
 ghc9.8-directory-prof \
 ghc9.8-doc \
 ghc9.8-doc-index \
 ghc9.8-exceptions \
 ghc9.8-exceptions-devel \
 ghc9.8-exceptions-doc \
 ghc9.8-exceptions-prof \
 ghc9.8-filepath \
 ghc9.8-filepath-devel \
 ghc9.8-filepath-doc \
 ghc9.8-filepath-prof \
 ghc9.8-filesystem \
 ghc9.8-ghc \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-bignum-devel \
 ghc9.8-ghc-bignum-doc \
 ghc9.8-ghc-bignum-prof \
 ghc9.8-ghc-boot \
 ghc9.8-ghc-boot-devel \
 ghc9.8-ghc-boot-doc \
 ghc9.8-ghc-boot-prof \
 ghc9.8-ghc-boot-th \
 ghc9.8-ghc-boot-th-devel \
 ghc9.8-ghc-boot-th-doc \
 ghc9.8-ghc-boot-th-prof \
 ghc9.8-ghc-compact \
 ghc9.8-ghc-compact-devel \
 ghc9.8-ghc-compact-doc \
 ghc9.8-ghc-compact-prof \
 ghc9.8-ghc-devel \
 ghc9.8-ghc-doc \
 ghc9.8-ghc-heap \
 ghc9.8-ghc-heap-devel \
 ghc9.8-ghc-heap-doc \
 ghc9.8-ghc-heap-prof \
 ghc9.8-ghc-prof \
 ghc9.8-ghci \
 ghc9.8-ghci-devel \
 ghc9.8-ghci-doc \
 ghc9.8-ghci-prof \
 ghc9.8-hadrian \
 ghc9.8-haskeline \
 ghc9.8-haskeline-devel \
 ghc9.8-haskeline-doc \
 ghc9.8-haskeline-prof \
 ghc9.8-hpc \
 ghc9.8-hpc-devel \
 ghc9.8-hpc-doc \
 ghc9.8-hpc-prof \
 ghc9.8-manual \
 ghc9.8-mtl \
 ghc9.8-mtl-devel \
 ghc9.8-mtl-doc \
 ghc9.8-mtl-prof \
 ghc9.8-parsec \
 ghc9.8-parsec-devel \
 ghc9.8-parsec-doc \
 ghc9.8-parsec-prof \
 ghc9.8-pretty \
 ghc9.8-pretty-devel \
 ghc9.8-pretty-doc \
 ghc9.8-pretty-prof \
 ghc9.8-process \
 ghc9.8-process-devel \
 ghc9.8-process-doc \
 ghc9.8-process-prof \
 ghc9.8-prof \
 ghc9.8-semaphore-compat \
 ghc9.8-semaphore-compat-devel \
 ghc9.8-semaphore-compat-doc \
 ghc9.8-semaphore-compat-prof \
 ghc9.8-stm \
 ghc9.8-stm-devel \
 ghc9.8-stm-doc \
 ghc9.8-stm-prof \
 ghc9.8-template-haskell \
 ghc9.8-template-haskell-devel \
 ghc9.8-template-haskell-doc \
 ghc9.8-template-haskell-prof \
 ghc9.8-terminfo \
 ghc9.8-terminfo-devel \
 ghc9.8-terminfo-doc \
 ghc9.8-terminfo-prof \
 ghc9.8-text \
 ghc9.8-text-devel \
 ghc9.8-text-doc \
 ghc9.8-text-prof \
 ghc9.8-time \
 ghc9.8-time-devel \
 ghc9.8-time-doc \
 ghc9.8-time-prof \
 ghc9.8-transformers \
 ghc9.8-transformers-devel \
 ghc9.8-transformers-doc \
 ghc9.8-transformers-prof \
 ghc9.8-unix \
 ghc9.8-unix-devel \
 ghc9.8-unix-doc \
 ghc9.8-unix-prof \
 ghc9.8-xhtml \
 ghc9.8-xhtml-devel \
 ghc9.8-xhtml-doc \
 ghc9.8-xhtml-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc9.8-9.8.4-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01631a3dd4ef16a02edd1f7118aafea066e4c7a9873eb6dbbf55b262646c2929"

URI_x86_64_v2_ghc9.8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8}"
SRC_URI[x86_64_v2_ghc9.8.sha256sum] = "f75600bdceee5fcaf2bdebad222c3bf2e727c33dbf2461759c449ccbcc19b4e0"

URI_x86_64_v2_ghc9.8-Cabal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-Cabal-3.10.3.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-Cabal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-Cabal}"
SRC_URI[x86_64_v2_ghc9.8-Cabal.sha256sum] = "513d6656e805bd061ca4a00cd98090d947541e4ea9d608bad5a06f117326f796"

URI_x86_64_v2_ghc9.8-Cabal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-Cabal-devel-3.10.3.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-Cabal-devel}"
SRC_URI[x86_64_v2_ghc9.8-Cabal-devel.sha256sum] = "53dce42d465399098cbc967139b12b825cd95fc5fab3b686d559c20b96f24e62"

URI_x86_64_v2_ghc9.8-Cabal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-Cabal-doc-3.10.3.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-Cabal-doc}"
SRC_URI[x86_64_v2_ghc9.8-Cabal-doc.sha256sum] = "e27c2c63b686ab179ced88675ab4d02ee03044c4db811f65c1e54f09eba75c0f"

URI_x86_64_v2_ghc9.8-Cabal-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-Cabal-prof-3.10.3.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-Cabal-prof}"
SRC_URI[x86_64_v2_ghc9.8-Cabal-prof.sha256sum] = "42b84d2a19c575065f2e20be87f0ff3bbac5ec2c3ee0eb2b0aa1b9ef7adadfaa"

URI_x86_64_v2_ghc9.8-Cabal-syntax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-Cabal-syntax-3.10.3.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-Cabal-syntax}"
SRC_URI[x86_64_v2_ghc9.8-Cabal-syntax.sha256sum] = "4c782a42666040baa5ddee8b261b304d377d7fa248b79ee67b22e0a6b9b54d6a"

URI_x86_64_v2_ghc9.8-Cabal-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-Cabal-syntax-devel-3.10.3.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-Cabal-syntax-devel}"
SRC_URI[x86_64_v2_ghc9.8-Cabal-syntax-devel.sha256sum] = "2cb09b02596119f428c2eeb2bf57df402386d2fc23c83b3ce0cfcf8d082b5b37"

URI_x86_64_v2_ghc9.8-Cabal-syntax-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-Cabal-syntax-doc-3.10.3.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-Cabal-syntax-doc}"
SRC_URI[x86_64_v2_ghc9.8-Cabal-syntax-doc.sha256sum] = "c6149a86c05f453d2559ca0f42bdc557807fe6c58dcaa2b3cf1f64581015db93"

URI_x86_64_v2_ghc9.8-Cabal-syntax-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-Cabal-syntax-prof-3.10.3.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-Cabal-syntax-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-Cabal-syntax-prof}"
SRC_URI[x86_64_v2_ghc9.8-Cabal-syntax-prof.sha256sum] = "1c064cefa5e3edd83f5a90014950bf8d041c850b22fc5d23c1f80c6a27c3dcd9"

URI_x86_64_v2_ghc9.8-array = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-array-0.5.8.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-array}"
SRC_URI[x86_64_v2_ghc9.8-array.sha256sum] = "dcc81eefa54b73daabc02a72a547a0396fd71b8bd166e7ce2d518ffee6d37500"

URI_x86_64_v2_ghc9.8-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-array-devel-0.5.8.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-array-devel}"
SRC_URI[x86_64_v2_ghc9.8-array-devel.sha256sum] = "a5377259612334c3f5e8117c2315aed8eac4553adea5112163736d10dab04ab5"

URI_x86_64_v2_ghc9.8-array-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-array-doc-0.5.8.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-array-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-array-doc}"
SRC_URI[x86_64_v2_ghc9.8-array-doc.sha256sum] = "59e45b0656e5d5f67614ab321e64f8db344ba0ce4b16734a87909be9920c5988"

URI_x86_64_v2_ghc9.8-array-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-array-prof-0.5.8.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-array-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-array-prof}"
SRC_URI[x86_64_v2_ghc9.8-array-prof.sha256sum] = "63b672fe64ae3b86a4418bfa822e04a69a3e4cce6c0e916c9b6ba779626faa9c"

URI_x86_64_v2_ghc9.8-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-base-4.19.2.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-base}"
SRC_URI[x86_64_v2_ghc9.8-base.sha256sum] = "1b73849cceebc579041e4d862a2a5e94765f77b25cefbd74d1381a053ef609d3"

URI_x86_64_v2_ghc9.8-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-base-devel-4.19.2.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-base-devel}"
SRC_URI[x86_64_v2_ghc9.8-base-devel.sha256sum] = "03b48da9fa540ab4dfbcbfcef517b0fe97a213e977f33e3c519a1d4ee542f6a9"

URI_x86_64_v2_ghc9.8-base-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-base-doc-4.19.2.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-base-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-base-doc}"
SRC_URI[x86_64_v2_ghc9.8-base-doc.sha256sum] = "7b003cf0269468fe3db1a2ed4e8294a134385c9b9ebdaaf3aa3dd126a782f2e7"

URI_x86_64_v2_ghc9.8-base-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-base-prof-4.19.2.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-base-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-base-prof}"
SRC_URI[x86_64_v2_ghc9.8-base-prof.sha256sum] = "a389320a2f097be5a59d8e875b7d3f6494c5a51d172d0c4c04d840f1f61cf80a"

URI_x86_64_v2_ghc9.8-binary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-binary-0.8.9.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-binary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-binary}"
SRC_URI[x86_64_v2_ghc9.8-binary.sha256sum] = "24bd4289e1d7370b1b8665dc0ae6620772ead1401df7b7cf8667d430c4571bee"

URI_x86_64_v2_ghc9.8-binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-binary-devel-0.8.9.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-binary-devel}"
SRC_URI[x86_64_v2_ghc9.8-binary-devel.sha256sum] = "d844f2c3ddd60f6a445fcc019080ff662a83da5a351434caea90b7b8ac79e138"

URI_x86_64_v2_ghc9.8-binary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-binary-doc-0.8.9.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-binary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-binary-doc}"
SRC_URI[x86_64_v2_ghc9.8-binary-doc.sha256sum] = "b1b1267d38f5d94f334bf04d8190a022569c1ea40dbee684feb464355e44d209"

URI_x86_64_v2_ghc9.8-binary-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-binary-prof-0.8.9.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-binary-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-binary-prof}"
SRC_URI[x86_64_v2_ghc9.8-binary-prof.sha256sum] = "f5721cdff4eff4505dbd199cba916e9e1bc29342210470b47ff46425260889c2"

URI_x86_64_v2_ghc9.8-bytestring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-bytestring-0.12.1.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-bytestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-bytestring}"
SRC_URI[x86_64_v2_ghc9.8-bytestring.sha256sum] = "e6c648a95fcf37d5159b7af8a942cd4425d5af81207eb947e8fafa8f3804bc29"

URI_x86_64_v2_ghc9.8-bytestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-bytestring-devel-0.12.1.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-bytestring-devel}"
SRC_URI[x86_64_v2_ghc9.8-bytestring-devel.sha256sum] = "06b7802c7ba0f44ef0531b1137c5d291145ea35428e11ba9a7bcab4173354192"

URI_x86_64_v2_ghc9.8-bytestring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-bytestring-doc-0.12.1.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-bytestring-doc}"
SRC_URI[x86_64_v2_ghc9.8-bytestring-doc.sha256sum] = "d0a5e8d6e2c025bd58e092833c618db3bc49d2c14c2971b0c40b09a758ed3400"

URI_x86_64_v2_ghc9.8-bytestring-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-bytestring-prof-0.12.1.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-bytestring-prof}"
SRC_URI[x86_64_v2_ghc9.8-bytestring-prof.sha256sum] = "9c3917778851a66f4808e5ded69423f92d3b2ca46ffa5a49a90b61c824ef01ba"

URI_x86_64_v2_ghc9.8-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-compiler-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-compiler}"
SRC_URI[x86_64_v2_ghc9.8-compiler.sha256sum] = "788c58681e38c03e5b3912fb272e1bd91afb0d8b94e24bee54bcc6a9706c8a60"

URI_x86_64_v2_ghc9.8-compiler-default = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-compiler-default-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-compiler-default;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-compiler-default}"
SRC_URI[x86_64_v2_ghc9.8-compiler-default.sha256sum] = "cbf5d63cb08bb6175fcfb54b1900b09d6150eeaaf2774ee96580c6687a35b414"

URI_x86_64_v2_ghc9.8-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-containers-0.6.8-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-containers}"
SRC_URI[x86_64_v2_ghc9.8-containers.sha256sum] = "9232a0b28e09177514a9d2179cecdd8c39e96e4a1f18dc3cbfd5af018a516976"

URI_x86_64_v2_ghc9.8-containers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-containers-devel-0.6.8-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-containers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-containers-devel}"
SRC_URI[x86_64_v2_ghc9.8-containers-devel.sha256sum] = "7e5f1ffeeccc0357055c7c6034054b355a4efeb235edc967d600af36af33fb96"

URI_x86_64_v2_ghc9.8-containers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-containers-doc-0.6.8-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-containers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-containers-doc}"
SRC_URI[x86_64_v2_ghc9.8-containers-doc.sha256sum] = "7d68689145669579f042f8c9c8b0dab9d77acd95f65998fa9b7c7851e08a37bb"

URI_x86_64_v2_ghc9.8-containers-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-containers-prof-0.6.8-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-containers-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-containers-prof}"
SRC_URI[x86_64_v2_ghc9.8-containers-prof.sha256sum] = "754f70994e77f7b4e46975196d325778f48945f6eb2a5587cc3138d0830e3fa1"

URI_x86_64_v2_ghc9.8-deepseq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-deepseq-1.5.1.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-deepseq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-deepseq}"
SRC_URI[x86_64_v2_ghc9.8-deepseq.sha256sum] = "44f456a1c11a21e04924b8c295bff136658a5ac77ea44f04003c26dcda8b2244"

URI_x86_64_v2_ghc9.8-deepseq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-deepseq-devel-1.5.1.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-deepseq-devel}"
SRC_URI[x86_64_v2_ghc9.8-deepseq-devel.sha256sum] = "c549766798a045a2efa21a1b70e9e23d90d11efd01a5d1e9b61b35d125137af0"

URI_x86_64_v2_ghc9.8-deepseq-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-deepseq-doc-1.5.1.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-deepseq-doc}"
SRC_URI[x86_64_v2_ghc9.8-deepseq-doc.sha256sum] = "2184f853d58eb4b2dfbee6efbf6e9b9647ee93f06602fbfc5e1745546556d4e8"

URI_x86_64_v2_ghc9.8-deepseq-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-deepseq-prof-1.5.1.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-deepseq-prof}"
SRC_URI[x86_64_v2_ghc9.8-deepseq-prof.sha256sum] = "10bfb92950444050a7806e3035d1c95422517502e61cd2a09b4ae6aecb6dc942"

URI_x86_64_v2_ghc9.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-devel-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-devel}"
SRC_URI[x86_64_v2_ghc9.8-devel.sha256sum] = "725531f44be7ae9217cff841a73e02185cc3e4efb8ded3f79d7bd8ac56c2659c"

URI_x86_64_v2_ghc9.8-directory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-directory-1.3.8.5-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-directory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-directory}"
SRC_URI[x86_64_v2_ghc9.8-directory.sha256sum] = "15116c9a1c98ed232a20e41b491bb22d7c5863bd5a10efe8bc3685fa0d828ee7"

URI_x86_64_v2_ghc9.8-directory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-directory-devel-1.3.8.5-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-directory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-directory-devel}"
SRC_URI[x86_64_v2_ghc9.8-directory-devel.sha256sum] = "a0e7ab4e80785629e12a056d0105743aa69a380da951c6120d9700c25e31c569"

URI_x86_64_v2_ghc9.8-directory-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-directory-doc-1.3.8.5-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-directory-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-directory-doc}"
SRC_URI[x86_64_v2_ghc9.8-directory-doc.sha256sum] = "375bcceda4835191b47a14fc06717dfe062bf8a2e273304acbba8a73648653c5"

URI_x86_64_v2_ghc9.8-directory-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-directory-prof-1.3.8.5-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-directory-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-directory-prof}"
SRC_URI[x86_64_v2_ghc9.8-directory-prof.sha256sum] = "c7050ca676c4afd71c049bd11d698114f4d6fd570980b7180dfa970c26d54c54"

URI_x86_64_v2_ghc9.8-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-doc-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-doc}"
SRC_URI[x86_64_v2_ghc9.8-doc.sha256sum] = "62e216126771a4c002ddc79a7b8ee9840eb3401c0be863ca8025ceb5137c3c51"

URI_x86_64_v2_ghc9.8-doc-index = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-doc-index-9.8.4-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-doc-index;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-doc-index}"
SRC_URI[x86_64_v2_ghc9.8-doc-index.sha256sum] = "583a42ae161efa854e52f1599d7a3864841373c241237333e9c0cc5f3a6d9803"

URI_x86_64_v2_ghc9.8-exceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-exceptions-0.10.7-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-exceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-exceptions}"
SRC_URI[x86_64_v2_ghc9.8-exceptions.sha256sum] = "ed8d19bb5cbaa9054157ac365660c1191aff4dfae530ad265b29a661a30d43ca"

URI_x86_64_v2_ghc9.8-exceptions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-exceptions-devel-0.10.7-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-exceptions-devel}"
SRC_URI[x86_64_v2_ghc9.8-exceptions-devel.sha256sum] = "fd9c1b7526856178ebfaa28a64ba234b1a280d86b9862f446688f2a0b6261df1"

URI_x86_64_v2_ghc9.8-exceptions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-exceptions-doc-0.10.7-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-exceptions-doc}"
SRC_URI[x86_64_v2_ghc9.8-exceptions-doc.sha256sum] = "316f2f382a98309a49d3dea256be6489a3da0ba39f964c929938a9732bbd8239"

URI_x86_64_v2_ghc9.8-exceptions-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-exceptions-prof-0.10.7-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-exceptions-prof}"
SRC_URI[x86_64_v2_ghc9.8-exceptions-prof.sha256sum] = "6c8109220d19a323cbf8d099cb29e87b64a48d39b8ff447ecb58ce04cd1bbbad"

URI_x86_64_v2_ghc9.8-filepath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-filepath-1.4.301.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-filepath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-filepath}"
SRC_URI[x86_64_v2_ghc9.8-filepath.sha256sum] = "6c5ce91e2d4b043527535c5552486c282e7d8fb4d3ed14b4963d40bb889b14e9"

URI_x86_64_v2_ghc9.8-filepath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-filepath-devel-1.4.301.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-filepath-devel}"
SRC_URI[x86_64_v2_ghc9.8-filepath-devel.sha256sum] = "e9fd029477e702bd33b2e61655bd9d81d6c2212e5fae56e92915f84ae4bc0879"

URI_x86_64_v2_ghc9.8-filepath-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-filepath-doc-1.4.301.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-filepath-doc}"
SRC_URI[x86_64_v2_ghc9.8-filepath-doc.sha256sum] = "1e2966d2d588a1b8c415b4db2530a190a6f2ce037940f7306afbf22a75c3f718"

URI_x86_64_v2_ghc9.8-filepath-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-filepath-prof-1.4.301.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-filepath-prof}"
SRC_URI[x86_64_v2_ghc9.8-filepath-prof.sha256sum] = "b8dff82cb4f569ddae95d5029dc580b1680921f52eae721b9e59fb6a2e2f9158"

URI_x86_64_v2_ghc9.8-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-filesystem-9.8.4-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-filesystem}"
SRC_URI[x86_64_v2_ghc9.8-filesystem.sha256sum] = "e825e5de44387fe0fe7808ddeae8cb7ba1a53b6b6b9eabd5a0e039eef19abb3a"

URI_x86_64_v2_ghc9.8-ghc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc}"
SRC_URI[x86_64_v2_ghc9.8-ghc.sha256sum] = "adf1a2bd56a1dc1f40be339c88d0bc33a759a9ecdbe856367d9ab8b90153aae2"

URI_x86_64_v2_ghc9.8-ghc-bignum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-bignum-1.3-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-bignum}"
SRC_URI[x86_64_v2_ghc9.8-ghc-bignum.sha256sum] = "4f38837da972291637b2a6a528a23189b4e567a8327c988965f5e9d5ed405116"

URI_x86_64_v2_ghc9.8-ghc-bignum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-bignum-devel-1.3-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-bignum-devel}"
SRC_URI[x86_64_v2_ghc9.8-ghc-bignum-devel.sha256sum] = "c62163866a0c65428f09c5cb70bf01ee8683ee6318847e3fe98e8d61a397e9f2"

URI_x86_64_v2_ghc9.8-ghc-bignum-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-bignum-doc-1.3-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-bignum-doc}"
SRC_URI[x86_64_v2_ghc9.8-ghc-bignum-doc.sha256sum] = "055bf8f3d9377820e580f252b40c3c2459e174e576468ac4783afcb5104184a8"

URI_x86_64_v2_ghc9.8-ghc-bignum-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-bignum-prof-1.3-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-bignum-prof}"
SRC_URI[x86_64_v2_ghc9.8-ghc-bignum-prof.sha256sum] = "f04a37704a74c2be6f825670a2ef0f3719c1028bf62a3184af38e25d593e7bea"

URI_x86_64_v2_ghc9.8-ghc-boot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-boot-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-boot}"
SRC_URI[x86_64_v2_ghc9.8-ghc-boot.sha256sum] = "8a9c00463ea264a225cd95e58eab492fd7fe3082c2692a23c24e7bf72e2c5ee7"

URI_x86_64_v2_ghc9.8-ghc-boot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-boot-devel-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-boot-devel}"
SRC_URI[x86_64_v2_ghc9.8-ghc-boot-devel.sha256sum] = "e02105e8358f220c72bd01438d57b82c455d729014bf68bb997eb9a6f85e416e"

URI_x86_64_v2_ghc9.8-ghc-boot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-boot-doc-9.8.4-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-boot-doc}"
SRC_URI[x86_64_v2_ghc9.8-ghc-boot-doc.sha256sum] = "b4c99707576a78c90f3b8c5f10d15fce2cb3b95071a6b734a459861cd085ab06"

URI_x86_64_v2_ghc9.8-ghc-boot-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-boot-prof-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-boot-prof}"
SRC_URI[x86_64_v2_ghc9.8-ghc-boot-prof.sha256sum] = "39be9a92769fee803433f6071144c2a9770771283f4dad0bef786f95a5afd4eb"

URI_x86_64_v2_ghc9.8-ghc-boot-th = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-boot-th-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-boot-th}"
SRC_URI[x86_64_v2_ghc9.8-ghc-boot-th.sha256sum] = "413d7a5f39008f5a9ce7ad9c852a685147f448184ee0d9fe13745bd65485794f"

URI_x86_64_v2_ghc9.8-ghc-boot-th-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-boot-th-devel-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-boot-th-devel}"
SRC_URI[x86_64_v2_ghc9.8-ghc-boot-th-devel.sha256sum] = "ed3d703b3ea392404c8ba9cb41289ac49864a8b210d20812a9999c3a70ffec08"

URI_x86_64_v2_ghc9.8-ghc-boot-th-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-boot-th-doc-9.8.4-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-boot-th-doc}"
SRC_URI[x86_64_v2_ghc9.8-ghc-boot-th-doc.sha256sum] = "87260520967f75d238780a64aa7f8b9b1626584198dea49442e296ecbcea0bbc"

URI_x86_64_v2_ghc9.8-ghc-boot-th-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-boot-th-prof-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-boot-th-prof}"
SRC_URI[x86_64_v2_ghc9.8-ghc-boot-th-prof.sha256sum] = "658c65d7cddd23e59f351150a184c930749e3686bb3dca84eb3243f51e0d2003"

URI_x86_64_v2_ghc9.8-ghc-compact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-compact-0.1.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-compact}"
SRC_URI[x86_64_v2_ghc9.8-ghc-compact.sha256sum] = "e36048d2ba654e4502f36b93045fb228f78f0b01d084c30eab798d5e41b5093b"

URI_x86_64_v2_ghc9.8-ghc-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-compact-devel-0.1.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-compact-devel}"
SRC_URI[x86_64_v2_ghc9.8-ghc-compact-devel.sha256sum] = "4b9fe735099074488a9e6ea05d813912f65aa182ba981879b7b76c18997f4e32"

URI_x86_64_v2_ghc9.8-ghc-compact-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-compact-doc-0.1.0.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-compact-doc}"
SRC_URI[x86_64_v2_ghc9.8-ghc-compact-doc.sha256sum] = "7a44a8a43f809dbd407d7fb9807dd79d21ade1ef8914f7dd3d6a984d51bab40e"

URI_x86_64_v2_ghc9.8-ghc-compact-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-compact-prof-0.1.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-compact-prof}"
SRC_URI[x86_64_v2_ghc9.8-ghc-compact-prof.sha256sum] = "fc0e19cd2d144e5f76b6599ee4c79205f67fe19edd43e69aed886152b19b0c0a"

URI_x86_64_v2_ghc9.8-ghc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-devel-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-devel}"
SRC_URI[x86_64_v2_ghc9.8-ghc-devel.sha256sum] = "30755248febb651b527bca6a1cf3264c1decd5f435a90088014c6a63d7e0b509"

URI_x86_64_v2_ghc9.8-ghc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-doc-9.8.4-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-doc}"
SRC_URI[x86_64_v2_ghc9.8-ghc-doc.sha256sum] = "9e891730989602f28ae8c8ba1eff79c2566df1fffe9d90482f9db3df28f6861a"

URI_x86_64_v2_ghc9.8-ghc-heap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-heap-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-heap}"
SRC_URI[x86_64_v2_ghc9.8-ghc-heap.sha256sum] = "72b0993c3e9c1ea4928452669d523edfd1e175e176b81e7e2bbebf2b92e1db24"

URI_x86_64_v2_ghc9.8-ghc-heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-heap-devel-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-heap-devel}"
SRC_URI[x86_64_v2_ghc9.8-ghc-heap-devel.sha256sum] = "ff76b12fe4ab3a6d809e238719b99ffa7aa2e4ad683e17bd970f0e452c7635aa"

URI_x86_64_v2_ghc9.8-ghc-heap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-heap-doc-9.8.4-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-heap-doc}"
SRC_URI[x86_64_v2_ghc9.8-ghc-heap-doc.sha256sum] = "6fd0d932c429cdd7f4c558b388c55ba0f04d089dfc93f6194bb26f772bad2c02"

URI_x86_64_v2_ghc9.8-ghc-heap-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-heap-prof-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-heap-prof}"
SRC_URI[x86_64_v2_ghc9.8-ghc-heap-prof.sha256sum] = "54a7f8c1512cb46b386d59f7bba0f1cbdae8c2f031e7e646644884eb7702e748"

URI_x86_64_v2_ghc9.8-ghc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghc-prof-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghc-prof}"
SRC_URI[x86_64_v2_ghc9.8-ghc-prof.sha256sum] = "571bc7ccfc234758847fd7d6cd20f28d988f3f2d362d46c60df1a66794903338"

URI_x86_64_v2_ghc9.8-ghci = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghci-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghci}"
SRC_URI[x86_64_v2_ghc9.8-ghci.sha256sum] = "b940c2c2f217c218894ded884845818dd4bb82525d6ce637432cb1cbad2993f4"

URI_x86_64_v2_ghc9.8-ghci-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghci-devel-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghci-devel}"
SRC_URI[x86_64_v2_ghc9.8-ghci-devel.sha256sum] = "ec52bcc82aa18213ad9ac753ea0928d7a9eb011eecdd529e8f823e6260e8921f"

URI_x86_64_v2_ghc9.8-ghci-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghci-doc-9.8.4-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghci-doc}"
SRC_URI[x86_64_v2_ghc9.8-ghci-doc.sha256sum] = "cbe9ffa5cc2ec11e1adf9932b4b57424083785159dd4960a632cc15af5d9e9ef"

URI_x86_64_v2_ghc9.8-ghci-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-ghci-prof-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-ghci-prof}"
SRC_URI[x86_64_v2_ghc9.8-ghci-prof.sha256sum] = "373a3f3d785fb2e45f74cec6a34ec0b61676fbd2e21a78be7b896a2bf7301f7d"

URI_x86_64_v2_ghc9.8-hadrian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-hadrian-0.1.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-hadrian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-hadrian}"
SRC_URI[x86_64_v2_ghc9.8-hadrian.sha256sum] = "6cdb18b5a705dcb95f18e14194b0e0d597e3d214419fe77155fcde7dd0955a66"

URI_x86_64_v2_ghc9.8-haskeline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-haskeline-0.8.2.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-haskeline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-haskeline}"
SRC_URI[x86_64_v2_ghc9.8-haskeline.sha256sum] = "fdc7109da5c2b5cb2a9c5be30d55bf44768309dcfd69de4f8a5511bec61ad1d2"

URI_x86_64_v2_ghc9.8-haskeline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-haskeline-devel-0.8.2.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-haskeline-devel}"
SRC_URI[x86_64_v2_ghc9.8-haskeline-devel.sha256sum] = "c478b081542df5b83f85fc4e1233c129f8938a8fb3b5c7e8cda0575fe746e65b"

URI_x86_64_v2_ghc9.8-haskeline-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-haskeline-doc-0.8.2.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-haskeline-doc}"
SRC_URI[x86_64_v2_ghc9.8-haskeline-doc.sha256sum] = "679f375fedfe5c39ab9b1627c664f10d96c199b7f888ae9a319c5575392a8129"

URI_x86_64_v2_ghc9.8-haskeline-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-haskeline-prof-0.8.2.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-haskeline-prof}"
SRC_URI[x86_64_v2_ghc9.8-haskeline-prof.sha256sum] = "2a53cb46ff99e3cbfb7fc4b48693d9c245ec9c2f4fadb90c8749db821f7abb16"

URI_x86_64_v2_ghc9.8-hpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-hpc-0.7.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-hpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-hpc}"
SRC_URI[x86_64_v2_ghc9.8-hpc.sha256sum] = "3d7bba07b7ec84362c9183a50194d667113c9546e362bd5aa417826824e94fd9"

URI_x86_64_v2_ghc9.8-hpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-hpc-devel-0.7.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-hpc-devel}"
SRC_URI[x86_64_v2_ghc9.8-hpc-devel.sha256sum] = "a652eb7ae826e8ebe0ba1ce6d3ec3bd7b0d893be70f46cdd9cfb2058cbf3ec39"

URI_x86_64_v2_ghc9.8-hpc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-hpc-doc-0.7.0.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-hpc-doc}"
SRC_URI[x86_64_v2_ghc9.8-hpc-doc.sha256sum] = "7eb888279c7c1944343c71cfa512b172637334cc360c009e620519812e17a52d"

URI_x86_64_v2_ghc9.8-hpc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-hpc-prof-0.7.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-hpc-prof}"
SRC_URI[x86_64_v2_ghc9.8-hpc-prof.sha256sum] = "b5ecba3d8f96d36585b1642636153e972bb295f98e16736310821ad185a2732e"

URI_x86_64_v2_ghc9.8-manual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-manual-9.8.4-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-manual}"
SRC_URI[x86_64_v2_ghc9.8-manual.sha256sum] = "21e8e0ba03ca9aacaabbf3448bbe2b7579d65eecba7d5c2d39302b58e433f700"

URI_x86_64_v2_ghc9.8-mtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-mtl-2.3.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-mtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-mtl}"
SRC_URI[x86_64_v2_ghc9.8-mtl.sha256sum] = "9b6cb36d921a2bc2b48c13feb7f31b9e722c75a331d65b82c0d0e31bc9ea467c"

URI_x86_64_v2_ghc9.8-mtl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-mtl-devel-2.3.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-mtl-devel}"
SRC_URI[x86_64_v2_ghc9.8-mtl-devel.sha256sum] = "a37882202d1fe4f08a772cc7158e1263004ef2a8d88ceae3e8a4d419d1e46013"

URI_x86_64_v2_ghc9.8-mtl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-mtl-doc-2.3.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-mtl-doc}"
SRC_URI[x86_64_v2_ghc9.8-mtl-doc.sha256sum] = "521b839a5b29d73f87f781c8feb3772b32467bbee65c1fbbc09af3339e85e48d"

URI_x86_64_v2_ghc9.8-mtl-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-mtl-prof-2.3.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-mtl-prof}"
SRC_URI[x86_64_v2_ghc9.8-mtl-prof.sha256sum] = "e88ccf811846e7572d5f9a222c664ad6b990c2510149ef2bd55e0d2a9bb71c89"

URI_x86_64_v2_ghc9.8-parsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-parsec-3.1.17.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-parsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-parsec}"
SRC_URI[x86_64_v2_ghc9.8-parsec.sha256sum] = "ea2777bb80583d276630c9945df6a08faacf845b68ce1eff3fb5ec808dd6e599"

URI_x86_64_v2_ghc9.8-parsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-parsec-devel-3.1.17.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-parsec-devel}"
SRC_URI[x86_64_v2_ghc9.8-parsec-devel.sha256sum] = "cc4ec1dcb164f8cc45644eeb6f0feef68f5364fb9ed7c5837ea62f666d64ff3d"

URI_x86_64_v2_ghc9.8-parsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-parsec-doc-3.1.17.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-parsec-doc}"
SRC_URI[x86_64_v2_ghc9.8-parsec-doc.sha256sum] = "a5e8b4d03a9ef9e9f97dcbf1ca4c00672ae3680da29d4a585c29e5c0e1475893"

URI_x86_64_v2_ghc9.8-parsec-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-parsec-prof-3.1.17.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-parsec-prof}"
SRC_URI[x86_64_v2_ghc9.8-parsec-prof.sha256sum] = "11edd183f4553292c15cc691bc471bf24f27f866141c1670e7c50615e8eed9d2"

URI_x86_64_v2_ghc9.8-pretty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-pretty-1.1.3.6-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-pretty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-pretty}"
SRC_URI[x86_64_v2_ghc9.8-pretty.sha256sum] = "622c8d4376900638c280fde9de06c3c2c8e6125b2623cbf6c090d2d09c635b4e"

URI_x86_64_v2_ghc9.8-pretty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-pretty-devel-1.1.3.6-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-pretty-devel}"
SRC_URI[x86_64_v2_ghc9.8-pretty-devel.sha256sum] = "b5cdbcf768948233a8f2f8bbe11eb853d14f4730ee38c7e3c3b2e32161e32f3a"

URI_x86_64_v2_ghc9.8-pretty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-pretty-doc-1.1.3.6-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-pretty-doc}"
SRC_URI[x86_64_v2_ghc9.8-pretty-doc.sha256sum] = "d4c71ebcc6f3aaa0b164a46c4fe4ee0bc6beee587fd77da5ad23208c0e99632c"

URI_x86_64_v2_ghc9.8-pretty-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-pretty-prof-1.1.3.6-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-pretty-prof}"
SRC_URI[x86_64_v2_ghc9.8-pretty-prof.sha256sum] = "f364251bfefc546e8c0203ed70b059663dcede4968af1c3dab7aaa4c7e643dc0"

URI_x86_64_v2_ghc9.8-process = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-process-1.6.25.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-process}"
SRC_URI[x86_64_v2_ghc9.8-process.sha256sum] = "2d6ee2ef148a5f0d4d8d4d9eb5c3100b52775ebc0a324a30a9ab78de8630bb30"

URI_x86_64_v2_ghc9.8-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-process-devel-1.6.25.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-process-devel}"
SRC_URI[x86_64_v2_ghc9.8-process-devel.sha256sum] = "f0e751b8b86346d0766eb2c1866f973a6563a98f947e64f5a93dd3b5b8583a05"

URI_x86_64_v2_ghc9.8-process-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-process-doc-1.6.25.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-process-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-process-doc}"
SRC_URI[x86_64_v2_ghc9.8-process-doc.sha256sum] = "054d1f579b090ffe32afaa577844f463f9d12e45fb3004da138935154de18ee5"

URI_x86_64_v2_ghc9.8-process-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-process-prof-1.6.25.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-process-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-process-prof}"
SRC_URI[x86_64_v2_ghc9.8-process-prof.sha256sum] = "14bcb56a9455de5c28419a2a9f981fa6794a8f69824dc9f6e45ffca09ca587a5"

URI_x86_64_v2_ghc9.8-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-prof-9.8.4-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-prof}"
SRC_URI[x86_64_v2_ghc9.8-prof.sha256sum] = "06f14d1dc0143ab38e23152aa058a0a84887e5e63881b152d3dfaa82383dcdde"

URI_x86_64_v2_ghc9.8-semaphore-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-semaphore-compat-1.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-semaphore-compat}"
SRC_URI[x86_64_v2_ghc9.8-semaphore-compat.sha256sum] = "7b8e12c91acd075bcf0735b232fe6b700052fb364211a1c80012bfa813ea2833"

URI_x86_64_v2_ghc9.8-semaphore-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-semaphore-compat-devel-1.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-semaphore-compat-devel}"
SRC_URI[x86_64_v2_ghc9.8-semaphore-compat-devel.sha256sum] = "7973139eaab76c2f7cc002c77a2ef00755d563746ebed26cc77cdba70cc5b5d6"

URI_x86_64_v2_ghc9.8-semaphore-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-semaphore-compat-doc-1.0.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-semaphore-compat-doc}"
SRC_URI[x86_64_v2_ghc9.8-semaphore-compat-doc.sha256sum] = "768ed9d39b1c2411d8d86e13d54640f1f5e6ddd5a1342da676f910e3f1bc9343"

URI_x86_64_v2_ghc9.8-semaphore-compat-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-semaphore-compat-prof-1.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-semaphore-compat-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-semaphore-compat-prof}"
SRC_URI[x86_64_v2_ghc9.8-semaphore-compat-prof.sha256sum] = "05013c269594b0a3b70a94940de1f38ed011696237ac5fb00f435dca8c39fcea"

URI_x86_64_v2_ghc9.8-stm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-stm-2.5.3.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-stm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-stm}"
SRC_URI[x86_64_v2_ghc9.8-stm.sha256sum] = "47dadc6702c5dbdc4400fdd0fc241cfd306e7b985164857b45061831a7535099"

URI_x86_64_v2_ghc9.8-stm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-stm-devel-2.5.3.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-stm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-stm-devel}"
SRC_URI[x86_64_v2_ghc9.8-stm-devel.sha256sum] = "6fb03b430ddfbcdd620b0ce4fc6d0dd7a880e12162a45596e56231938f47f8ae"

URI_x86_64_v2_ghc9.8-stm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-stm-doc-2.5.3.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-stm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-stm-doc}"
SRC_URI[x86_64_v2_ghc9.8-stm-doc.sha256sum] = "08bc48c55665c6bf9c567e342bd31e129b5cefba0ad7a24fa961a59dd335cd22"

URI_x86_64_v2_ghc9.8-stm-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-stm-prof-2.5.3.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-stm-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-stm-prof}"
SRC_URI[x86_64_v2_ghc9.8-stm-prof.sha256sum] = "6f17f4ec825d62c8bce14c38f0445635a1defd8ece7dd57ec1a6d6dd9028545d"

URI_x86_64_v2_ghc9.8-template-haskell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-template-haskell-2.21.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-template-haskell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-template-haskell}"
SRC_URI[x86_64_v2_ghc9.8-template-haskell.sha256sum] = "94003e09911bfa84e4c47661ee712815cb825c9ae2713cd80f968495355a024b"

URI_x86_64_v2_ghc9.8-template-haskell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-template-haskell-devel-2.21.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-template-haskell-devel}"
SRC_URI[x86_64_v2_ghc9.8-template-haskell-devel.sha256sum] = "01d1fb3383f616a3790e54a3ef0a1337d68564f8ff902233609faa0aea3cd250"

URI_x86_64_v2_ghc9.8-template-haskell-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-template-haskell-doc-2.21.0.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-template-haskell-doc}"
SRC_URI[x86_64_v2_ghc9.8-template-haskell-doc.sha256sum] = "4918a0e70df10c975e02c23669beb32df27c694f2d241473695ea8863bf37b48"

URI_x86_64_v2_ghc9.8-template-haskell-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-template-haskell-prof-2.21.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-template-haskell-prof}"
SRC_URI[x86_64_v2_ghc9.8-template-haskell-prof.sha256sum] = "ad4642058344f7882f7eea2e23aaf97cdaf652dd3c971a98c93013170d4ca269"

URI_x86_64_v2_ghc9.8-terminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-terminfo-0.4.1.6-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-terminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-terminfo}"
SRC_URI[x86_64_v2_ghc9.8-terminfo.sha256sum] = "a463ae12978de531479acd201743e608bfbcc1cb16cf44c5f8a1c75fd613e608"

URI_x86_64_v2_ghc9.8-terminfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-terminfo-devel-0.4.1.6-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-terminfo-devel}"
SRC_URI[x86_64_v2_ghc9.8-terminfo-devel.sha256sum] = "11bca3331e117116b9ecf0650d18df362b625fce7ba05afe0422e211de2d579a"

URI_x86_64_v2_ghc9.8-terminfo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-terminfo-doc-0.4.1.6-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-terminfo-doc}"
SRC_URI[x86_64_v2_ghc9.8-terminfo-doc.sha256sum] = "509341c6c76b0efe75800a1dbc3a8bf2459c9bb2bd9b6ecdfee1db042ff9895f"

URI_x86_64_v2_ghc9.8-terminfo-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-terminfo-prof-0.4.1.6-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-terminfo-prof}"
SRC_URI[x86_64_v2_ghc9.8-terminfo-prof.sha256sum] = "29341acc68773341a3b9897d2373fc1a4bb601af38c6c98baa6c895c2b1d4154"

URI_x86_64_v2_ghc9.8-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-text-2.1.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-text}"
SRC_URI[x86_64_v2_ghc9.8-text.sha256sum] = "d8d2afd31b57ecb256b634ddc7afcba460ea74048d8944ed79cf47531f7e3714"

URI_x86_64_v2_ghc9.8-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-text-devel-2.1.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-text-devel}"
SRC_URI[x86_64_v2_ghc9.8-text-devel.sha256sum] = "4543c00becba0e3cf335c95dd799c6b0d650c7a2ca72cc4ae6e941347dd926dd"

URI_x86_64_v2_ghc9.8-text-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-text-doc-2.1.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-text-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-text-doc}"
SRC_URI[x86_64_v2_ghc9.8-text-doc.sha256sum] = "a15cabba7247e84e4e91902b2a2d2bcf33879916886cdf7990ee81940ed2abef"

URI_x86_64_v2_ghc9.8-text-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-text-prof-2.1.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-text-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-text-prof}"
SRC_URI[x86_64_v2_ghc9.8-text-prof.sha256sum] = "fa4897f3765b97ba120f9e9f5de59367d019e73e39c497874df629947aa5275d"

URI_x86_64_v2_ghc9.8-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-time-1.12.2-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-time}"
SRC_URI[x86_64_v2_ghc9.8-time.sha256sum] = "d4f68331350f3a29c0e82340d2fa859a8b5924f8ea64dd753361cfeed3aeb6ef"

URI_x86_64_v2_ghc9.8-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-time-devel-1.12.2-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-time-devel}"
SRC_URI[x86_64_v2_ghc9.8-time-devel.sha256sum] = "0f45708865ad9852cad046feb3921899f7584736c7e4bed56c660b1e15f07ee9"

URI_x86_64_v2_ghc9.8-time-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-time-doc-1.12.2-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-time-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-time-doc}"
SRC_URI[x86_64_v2_ghc9.8-time-doc.sha256sum] = "ceb33efe0fd4223abc2d2fb0c3f2b52bff21169ee6c7248aaa9185310837797c"

URI_x86_64_v2_ghc9.8-time-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-time-prof-1.12.2-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-time-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-time-prof}"
SRC_URI[x86_64_v2_ghc9.8-time-prof.sha256sum] = "86f72f25c33297d378d79cbf00ba4ed06ad75854cd455d417eb53c21ae13c958"

URI_x86_64_v2_ghc9.8-transformers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-transformers-0.6.1.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-transformers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-transformers}"
SRC_URI[x86_64_v2_ghc9.8-transformers.sha256sum] = "3c5257d1d0b08aa84f47d19470b691a587e2036cfe68ffe37473aa6ba7699d73"

URI_x86_64_v2_ghc9.8-transformers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-transformers-devel-0.6.1.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-transformers-devel}"
SRC_URI[x86_64_v2_ghc9.8-transformers-devel.sha256sum] = "1c9cda7fcb60c940c0edd0e47845c49cb1ab6ae5899e7e29cdfccb24fb31e97c"

URI_x86_64_v2_ghc9.8-transformers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-transformers-doc-0.6.1.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-transformers-doc}"
SRC_URI[x86_64_v2_ghc9.8-transformers-doc.sha256sum] = "8d1c46c4aa6e2840de9b1e6be6aa02f1886de07585acc019c2973ba890753d28"

URI_x86_64_v2_ghc9.8-transformers-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-transformers-prof-0.6.1.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-transformers-prof}"
SRC_URI[x86_64_v2_ghc9.8-transformers-prof.sha256sum] = "f0fa8d1c6059a9c55275f499a181fbcd319004d340c132232a65e4cb2f7b4868"

URI_x86_64_v2_ghc9.8-unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-unix-2.8.6.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-unix}"
SRC_URI[x86_64_v2_ghc9.8-unix.sha256sum] = "8bf09ca5fde916404c29cd8e3b3351a8ac5d718b0a991323c74f06e3c71c5d1a"

URI_x86_64_v2_ghc9.8-unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-unix-devel-2.8.6.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-unix-devel}"
SRC_URI[x86_64_v2_ghc9.8-unix-devel.sha256sum] = "0e7584ecde7c7a1e50428cfe1ada73d191228dabdcadac4c3a48580fe51f294f"

URI_x86_64_v2_ghc9.8-unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-unix-doc-2.8.6.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-unix-doc}"
SRC_URI[x86_64_v2_ghc9.8-unix-doc.sha256sum] = "ab4848ae688dca0381bee1c54947408122465bc6118a4034dd4442ba80315a96"

URI_x86_64_v2_ghc9.8-unix-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-unix-prof-2.8.6.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-unix-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-unix-prof}"
SRC_URI[x86_64_v2_ghc9.8-unix-prof.sha256sum] = "2494a080ef5c065c06c6898a6a3b10ab73834742b2d17c1db8af24efb70292fd"

URI_x86_64_v2_ghc9.8-xhtml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-xhtml-3000.2.2.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-xhtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-xhtml}"
SRC_URI[x86_64_v2_ghc9.8-xhtml.sha256sum] = "907d36fa3571cd321d413e5ed91f9edcb1ccc3b937a1a181b2625fbca1e30a13"

URI_x86_64_v2_ghc9.8-xhtml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-xhtml-devel-3000.2.2.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-xhtml-devel}"
SRC_URI[x86_64_v2_ghc9.8-xhtml-devel.sha256sum] = "5a61e676cfddf6f6efe7ad47c06e6838056fba688b8cfd817d4921defe6d0cd6"

URI_x86_64_v2_ghc9.8-xhtml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-xhtml-doc-3000.2.2.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.8-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-xhtml-doc}"
SRC_URI[x86_64_v2_ghc9.8-xhtml-doc.sha256sum] = "71fb0a0dc7002762756095c8dc642bee95ce95746e880023e139ff57aab3c311"

URI_x86_64_v2_ghc9.8-xhtml-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.8-xhtml-prof-3000.2.2.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.8-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.8-xhtml-prof}"
SRC_URI[x86_64_v2_ghc9.8-xhtml-prof.sha256sum] = "d22e6ce9ee77491419369aed3af9aeb963f61f01128d20cabe4d177ab387efa0"

URI_aarch64_ghc9.8 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8}"
SRC_URI[aarch64_ghc9.8.sha256sum] = "7c3885194b70d67062e12a1e68ee4ab0b188a68c1804ff46caafd07aba6a1465"

URI_aarch64_ghc9.8-Cabal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-Cabal-3.10.3.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-Cabal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-Cabal}"
SRC_URI[aarch64_ghc9.8-Cabal.sha256sum] = "9b1026d046026f0e0867f3819a88dfc3cc0cc9d11f42ed04e6bd6e689e72e02e"

URI_aarch64_ghc9.8-Cabal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-Cabal-devel-3.10.3.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-Cabal-devel}"
SRC_URI[aarch64_ghc9.8-Cabal-devel.sha256sum] = "8f84aabfbc4acd413bde1ec6eea0019b70a0327cf3e684becda5ece46fd33b2f"

URI_aarch64_ghc9.8-Cabal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-Cabal-doc-3.10.3.0-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-Cabal-doc}"
SRC_URI[aarch64_ghc9.8-Cabal-doc.sha256sum] = "af897b4aad479c26c4cbf7cc12fdacd346a0a09b563c883f3f3be2269bea1e3a"

URI_aarch64_ghc9.8-Cabal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-Cabal-prof-3.10.3.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-Cabal-prof}"
SRC_URI[aarch64_ghc9.8-Cabal-prof.sha256sum] = "5a3f834659606ab9874306b9ddeb60c6248b2891d64b75cfff735fe9e1fc937c"

URI_aarch64_ghc9.8-Cabal-syntax = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-Cabal-syntax-3.10.3.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-Cabal-syntax}"
SRC_URI[aarch64_ghc9.8-Cabal-syntax.sha256sum] = "06184baa1fd567f8ac87943630e54fad2492c49fd89144da71575d0cbf24bde2"

URI_aarch64_ghc9.8-Cabal-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-Cabal-syntax-devel-3.10.3.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-Cabal-syntax-devel}"
SRC_URI[aarch64_ghc9.8-Cabal-syntax-devel.sha256sum] = "8c683965abb7d3cd80a6323791b7baefa5fc34e61560380cade4e303a848fce2"

URI_aarch64_ghc9.8-Cabal-syntax-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-Cabal-syntax-doc-3.10.3.0-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-Cabal-syntax-doc}"
SRC_URI[aarch64_ghc9.8-Cabal-syntax-doc.sha256sum] = "be5763d5c89009c5df66a15c84c79f7f976aa765c87d178f5fa351aaf7cb5095"

URI_aarch64_ghc9.8-Cabal-syntax-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-Cabal-syntax-prof-3.10.3.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-Cabal-syntax-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-Cabal-syntax-prof}"
SRC_URI[aarch64_ghc9.8-Cabal-syntax-prof.sha256sum] = "07d24ace3b516109187fecc9340897238d4cc1b0bee2ddbfa6512775e589022c"

URI_aarch64_ghc9.8-array = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-array-0.5.8.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-array;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-array}"
SRC_URI[aarch64_ghc9.8-array.sha256sum] = "8dcaee22888b13a5b36634120f2cada076f53a356ac6e4cb72601cab79ba6611"

URI_aarch64_ghc9.8-array-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-array-devel-0.5.8.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-array-devel}"
SRC_URI[aarch64_ghc9.8-array-devel.sha256sum] = "6bad0312253a62449cdbe4294e0be03c995f881449f7460fbc9c2c16c759b3e2"

URI_aarch64_ghc9.8-array-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-array-doc-0.5.8.0-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-array-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-array-doc}"
SRC_URI[aarch64_ghc9.8-array-doc.sha256sum] = "3b2506d635f50167363f0f0dc39deb50769c36780b9377f0a1cdcbf1e234f9c8"

URI_aarch64_ghc9.8-array-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-array-prof-0.5.8.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-array-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-array-prof}"
SRC_URI[aarch64_ghc9.8-array-prof.sha256sum] = "0e756104c1e9ceabcfe15bf46cb8d5a141222228db403277b79afb3b0a1989e7"

URI_aarch64_ghc9.8-base = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-base-4.19.2.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-base}"
SRC_URI[aarch64_ghc9.8-base.sha256sum] = "fb314db52507eb775a98deab1209a09da611f1864ca4f1a0157763df98f70012"

URI_aarch64_ghc9.8-base-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-base-devel-4.19.2.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-base-devel}"
SRC_URI[aarch64_ghc9.8-base-devel.sha256sum] = "5ef6540865424228fc5728cdd93ecdb37cd660de079a4b1ef630e22bddc98cf5"

URI_aarch64_ghc9.8-base-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-base-doc-4.19.2.0-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-base-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-base-doc}"
SRC_URI[aarch64_ghc9.8-base-doc.sha256sum] = "d3d2aa0eb0258a7565e0a83f332736cff18f86ec2e222fb2c0618ffecac39142"

URI_aarch64_ghc9.8-base-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-base-prof-4.19.2.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-base-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-base-prof}"
SRC_URI[aarch64_ghc9.8-base-prof.sha256sum] = "c33a7cfd2338bdfd13bb41ea326b339afb3691e76e92369cc6ac038e84ed12ba"

URI_aarch64_ghc9.8-binary = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-binary-0.8.9.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-binary;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-binary}"
SRC_URI[aarch64_ghc9.8-binary.sha256sum] = "341657b022de10f8eeca14e5c7b689962925e392ea9db8b0bc4280bfb6bf0f2f"

URI_aarch64_ghc9.8-binary-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-binary-devel-0.8.9.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-binary-devel}"
SRC_URI[aarch64_ghc9.8-binary-devel.sha256sum] = "36fe340f464eabeadeb53337e1808d2771a1fc9503924ca1c066f2573bb0ce80"

URI_aarch64_ghc9.8-binary-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-binary-doc-0.8.9.1-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-binary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-binary-doc}"
SRC_URI[aarch64_ghc9.8-binary-doc.sha256sum] = "97eb5a6d7e28b164f8964c5ff7498411b0090dd463c615c59a148edf944c46ab"

URI_aarch64_ghc9.8-binary-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-binary-prof-0.8.9.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-binary-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-binary-prof}"
SRC_URI[aarch64_ghc9.8-binary-prof.sha256sum] = "f766634dc9accfa7b175b7c9e27115538ca8f7581e68eab503b437a2a8735fb7"

URI_aarch64_ghc9.8-bytestring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-bytestring-0.12.1.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-bytestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-bytestring}"
SRC_URI[aarch64_ghc9.8-bytestring.sha256sum] = "afaafc731feb12bf7e7bd1319cbe84e6effc2aa6d028785d38fbe69d47f24e7b"

URI_aarch64_ghc9.8-bytestring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-bytestring-devel-0.12.1.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-bytestring-devel}"
SRC_URI[aarch64_ghc9.8-bytestring-devel.sha256sum] = "658c3e6048ba8f1be84bb1f759dd2063d6994cf122d95770d10b35322f62b30a"

URI_aarch64_ghc9.8-bytestring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-bytestring-doc-0.12.1.0-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-bytestring-doc}"
SRC_URI[aarch64_ghc9.8-bytestring-doc.sha256sum] = "5964cd72874ec99cca23b4090f5448c3598329aaf4f819aff37f1fedc50bf418"

URI_aarch64_ghc9.8-bytestring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-bytestring-prof-0.12.1.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-bytestring-prof}"
SRC_URI[aarch64_ghc9.8-bytestring-prof.sha256sum] = "6786bc4c0aca2bd10e998bd67bdec0f7323660f5cf14e232f2e806eae333e706"

URI_aarch64_ghc9.8-compiler = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-compiler-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-compiler}"
SRC_URI[aarch64_ghc9.8-compiler.sha256sum] = "e83ad2c23650f241cd50708a3f96cf8d9381ee65bb5f1d4cf6e2861467c3a456"

URI_aarch64_ghc9.8-compiler-default = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-compiler-default-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-compiler-default;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-compiler-default}"
SRC_URI[aarch64_ghc9.8-compiler-default.sha256sum] = "c4f16113826cccc91d1ae4ea467da89bb8cd9a814c12c3b0a2a8b69088cad6c8"

URI_aarch64_ghc9.8-containers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-containers-0.6.8-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-containers}"
SRC_URI[aarch64_ghc9.8-containers.sha256sum] = "9cccd6d7411031da21134def803de5f65436772b080ebdb5ac1b7f71f34df026"

URI_aarch64_ghc9.8-containers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-containers-devel-0.6.8-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-containers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-containers-devel}"
SRC_URI[aarch64_ghc9.8-containers-devel.sha256sum] = "0a9289cda550cf68c4e0e0e8fe347552c17dacbcc8ad5852a8f560b693db6f05"

URI_aarch64_ghc9.8-containers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-containers-doc-0.6.8-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-containers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-containers-doc}"
SRC_URI[aarch64_ghc9.8-containers-doc.sha256sum] = "bbe2078acabb1327e66bfe92c6684ba8a6c48ed579306b2984c861e85fb88b8a"

URI_aarch64_ghc9.8-containers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-containers-prof-0.6.8-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-containers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-containers-prof}"
SRC_URI[aarch64_ghc9.8-containers-prof.sha256sum] = "c62b32ff6c06ea57f671631103c6f660fb29555c2d6fa32849fb86a600a41194"

URI_aarch64_ghc9.8-deepseq = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-deepseq-1.5.1.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-deepseq;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-deepseq}"
SRC_URI[aarch64_ghc9.8-deepseq.sha256sum] = "0dca09e2a7a97430b9aca19b8b989988e09837d9e6ec8067145b68846d6e0c81"

URI_aarch64_ghc9.8-deepseq-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-deepseq-devel-1.5.1.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-deepseq-devel}"
SRC_URI[aarch64_ghc9.8-deepseq-devel.sha256sum] = "f808cf68a5d554b5a0ce0011ceea74a6bb6bfc2ed9ea233fd2353c4cadd74673"

URI_aarch64_ghc9.8-deepseq-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-deepseq-doc-1.5.1.0-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-deepseq-doc}"
SRC_URI[aarch64_ghc9.8-deepseq-doc.sha256sum] = "4c16fba07fd139f20a059f9367d347e0990d6b3a4e35ac07d30f946f1ec259b3"

URI_aarch64_ghc9.8-deepseq-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-deepseq-prof-1.5.1.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-deepseq-prof}"
SRC_URI[aarch64_ghc9.8-deepseq-prof.sha256sum] = "ac8c8b3364f5667626d110fd7080771dfe432ec4a102c4433813b1d7952fbf6c"

URI_aarch64_ghc9.8-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-devel-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-devel}"
SRC_URI[aarch64_ghc9.8-devel.sha256sum] = "489ea2abecc16e32cab80597a84a99a17a2567e5c8745169791f6b8ee2cb185a"

URI_aarch64_ghc9.8-directory = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-directory-1.3.8.5-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-directory;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-directory}"
SRC_URI[aarch64_ghc9.8-directory.sha256sum] = "857163ef40e97711e60632f5d5f8554c1b6ff19e25f4154aad86eb976ca13670"

URI_aarch64_ghc9.8-directory-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-directory-devel-1.3.8.5-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-directory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-directory-devel}"
SRC_URI[aarch64_ghc9.8-directory-devel.sha256sum] = "3b92ec2ad3734a4438b0eb86b19b37dae8393401bb6a22585ca22eef49f444e4"

URI_aarch64_ghc9.8-directory-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-directory-doc-1.3.8.5-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-directory-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-directory-doc}"
SRC_URI[aarch64_ghc9.8-directory-doc.sha256sum] = "c9317e841966dac07a89da7499391a2ce516f10bee8015d39fa47cc76f64c227"

URI_aarch64_ghc9.8-directory-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-directory-prof-1.3.8.5-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-directory-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-directory-prof}"
SRC_URI[aarch64_ghc9.8-directory-prof.sha256sum] = "8ec27ac1c6eafa2cc1d09c9c8609729d318d8eb4edfcc6f3138190f3f036cedc"

URI_aarch64_ghc9.8-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-doc-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-doc}"
SRC_URI[aarch64_ghc9.8-doc.sha256sum] = "1f1aee3765703cfde8dc36cd93c2811a22d69fa4e0caec34030592ce4dec4279"

URI_aarch64_ghc9.8-doc-index = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-doc-index-9.8.4-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-doc-index;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-doc-index}"
SRC_URI[aarch64_ghc9.8-doc-index.sha256sum] = "47ac08370b413aea75507873181859364938e1835cb365b3f9532ef8ebb140aa"

URI_aarch64_ghc9.8-exceptions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-exceptions-0.10.7-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-exceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-exceptions}"
SRC_URI[aarch64_ghc9.8-exceptions.sha256sum] = "5fc5683cd10f3b5e77bbd8cf80d39490ac5c98bae6974276df79dff3e0192972"

URI_aarch64_ghc9.8-exceptions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-exceptions-devel-0.10.7-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-exceptions-devel}"
SRC_URI[aarch64_ghc9.8-exceptions-devel.sha256sum] = "be0fcdc6a6bc656c43dce3f3f85e1a955a9eb62b3b8aa333d38714c1ce11e6f3"

URI_aarch64_ghc9.8-exceptions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-exceptions-doc-0.10.7-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-exceptions-doc}"
SRC_URI[aarch64_ghc9.8-exceptions-doc.sha256sum] = "96927715bc8da97d3a5869c923620bc2af3aa0767c79aae79b33239e66de66d2"

URI_aarch64_ghc9.8-exceptions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-exceptions-prof-0.10.7-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-exceptions-prof}"
SRC_URI[aarch64_ghc9.8-exceptions-prof.sha256sum] = "70eb4f1502e8969af729b77106624e2b8aad5aabd63c36a83d429a06a454927e"

URI_aarch64_ghc9.8-filepath = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-filepath-1.4.301.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-filepath;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-filepath}"
SRC_URI[aarch64_ghc9.8-filepath.sha256sum] = "867870e7f18d9325d428233c335f830311ab78583a7258cec8dc1965dcbf8276"

URI_aarch64_ghc9.8-filepath-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-filepath-devel-1.4.301.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-filepath-devel}"
SRC_URI[aarch64_ghc9.8-filepath-devel.sha256sum] = "ca83237ee02ea8230601bcfa11ffb09acad94ed71018dfe9aa4ea4b7bad2b2fb"

URI_aarch64_ghc9.8-filepath-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-filepath-doc-1.4.301.0-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-filepath-doc}"
SRC_URI[aarch64_ghc9.8-filepath-doc.sha256sum] = "5bb8c63837a79998d0968340f01919071270560ef95eb59456a872babce29dcb"

URI_aarch64_ghc9.8-filepath-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-filepath-prof-1.4.301.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-filepath-prof}"
SRC_URI[aarch64_ghc9.8-filepath-prof.sha256sum] = "b273c80a70718ef71961fe8143925dfdddf7edeed7469638d0e89d3e30d65bfc"

URI_aarch64_ghc9.8-filesystem = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-filesystem-9.8.4-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-filesystem}"
SRC_URI[aarch64_ghc9.8-filesystem.sha256sum] = "f0f698ff724d9ce085dc8bf28b2846f2c37bd99807ff29a7e40250e52d2370f7"

URI_aarch64_ghc9.8-ghc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc}"
SRC_URI[aarch64_ghc9.8-ghc.sha256sum] = "7f57f409eceb3573d084b4efaf160cbb6c0e0e5869794a71b152273ea1ca8be0"

URI_aarch64_ghc9.8-ghc-bignum = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-bignum-1.3-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-bignum}"
SRC_URI[aarch64_ghc9.8-ghc-bignum.sha256sum] = "192be027715dc7bc1c1a870a5079d40f3f11dfdd59e8604acf69da798598616f"

URI_aarch64_ghc9.8-ghc-bignum-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-bignum-devel-1.3-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-bignum-devel}"
SRC_URI[aarch64_ghc9.8-ghc-bignum-devel.sha256sum] = "4560de1e9425d69dd0f489c9138277e76918dbf9021007f4127f3bd7a2788eea"

URI_aarch64_ghc9.8-ghc-bignum-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-bignum-doc-1.3-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-bignum-doc}"
SRC_URI[aarch64_ghc9.8-ghc-bignum-doc.sha256sum] = "4241ae36e4933786168fcb44ecb58a25a83e42bf8c0a59019d851d247d872f6a"

URI_aarch64_ghc9.8-ghc-bignum-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-bignum-prof-1.3-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-bignum-prof}"
SRC_URI[aarch64_ghc9.8-ghc-bignum-prof.sha256sum] = "03f08eb866fadba23af79ec929c9034eb014f823e938ea92e930964338529b09"

URI_aarch64_ghc9.8-ghc-boot = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-boot-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-boot}"
SRC_URI[aarch64_ghc9.8-ghc-boot.sha256sum] = "2af90ee6f572fbf0fc793b4e316a2dce3e59abbe083ecffd61c11a33055882a4"

URI_aarch64_ghc9.8-ghc-boot-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-boot-devel-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-boot-devel}"
SRC_URI[aarch64_ghc9.8-ghc-boot-devel.sha256sum] = "4f3ecb36bf42f4c4e45a3d67ea58e9225cf0b3197abe97ad55bec5b5ea8b35f5"

URI_aarch64_ghc9.8-ghc-boot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-boot-doc-9.8.4-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-boot-doc}"
SRC_URI[aarch64_ghc9.8-ghc-boot-doc.sha256sum] = "efc7b708806429e8cff71457bf7637385d95059f1ffed9f1706eef74057fecfe"

URI_aarch64_ghc9.8-ghc-boot-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-boot-prof-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-boot-prof}"
SRC_URI[aarch64_ghc9.8-ghc-boot-prof.sha256sum] = "3e517bd5960e27c447bd9e3ff8e00e8ded131da76a3a6bf2aea004b68eb6c477"

URI_aarch64_ghc9.8-ghc-boot-th = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-boot-th-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-boot-th}"
SRC_URI[aarch64_ghc9.8-ghc-boot-th.sha256sum] = "6a8da56256395f12d1fe228bf96f970993bc3989ff53d628b2f277ef2c99122c"

URI_aarch64_ghc9.8-ghc-boot-th-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-boot-th-devel-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-boot-th-devel}"
SRC_URI[aarch64_ghc9.8-ghc-boot-th-devel.sha256sum] = "93451ffc08047bb065b5f83197ccbff31501807bd079fc4fc5cd537b3320e997"

URI_aarch64_ghc9.8-ghc-boot-th-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-boot-th-doc-9.8.4-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-boot-th-doc}"
SRC_URI[aarch64_ghc9.8-ghc-boot-th-doc.sha256sum] = "54f8f1025a8fafef42255abc1ee0616997f2704f2e03ec0989ce48df96e06ee2"

URI_aarch64_ghc9.8-ghc-boot-th-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-boot-th-prof-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-boot-th-prof}"
SRC_URI[aarch64_ghc9.8-ghc-boot-th-prof.sha256sum] = "3d8193c60db0b19bbc52e6cd50e7023a88d2868c9c239ea4d2aa29208c925f33"

URI_aarch64_ghc9.8-ghc-compact = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-compact-0.1.0.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-compact}"
SRC_URI[aarch64_ghc9.8-ghc-compact.sha256sum] = "ac188eef973f0d9308247f2463d1de903faa9e13fef6d5d91b19562d0d34f695"

URI_aarch64_ghc9.8-ghc-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-compact-devel-0.1.0.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-compact-devel}"
SRC_URI[aarch64_ghc9.8-ghc-compact-devel.sha256sum] = "b121c29c132ae7883c849daf67377937bfe1fea8f998f78128047647c2ec10d5"

URI_aarch64_ghc9.8-ghc-compact-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-compact-doc-0.1.0.0-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-compact-doc}"
SRC_URI[aarch64_ghc9.8-ghc-compact-doc.sha256sum] = "c4e2c63b99f0b26b5d2cb2c6d98ce854d0148ec78495c8a577bb52f0e7fc9e17"

URI_aarch64_ghc9.8-ghc-compact-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-compact-prof-0.1.0.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-compact-prof}"
SRC_URI[aarch64_ghc9.8-ghc-compact-prof.sha256sum] = "6a773d4aa7c7f9ab4bd889112f93a5fba4b6c3f87088f73459eec7cd1fdeec9d"

URI_aarch64_ghc9.8-ghc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-devel-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-devel}"
SRC_URI[aarch64_ghc9.8-ghc-devel.sha256sum] = "b3ff2893d361ca87e875f15a65c6d235a25bcb74d329b83c52bcb9251e612956"

URI_aarch64_ghc9.8-ghc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-doc-9.8.4-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-doc}"
SRC_URI[aarch64_ghc9.8-ghc-doc.sha256sum] = "35a0eafbb4dbe2c39f3026345758613b576b27108a95f57ad537a8c59e71cd73"

URI_aarch64_ghc9.8-ghc-heap = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-heap-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-heap}"
SRC_URI[aarch64_ghc9.8-ghc-heap.sha256sum] = "d89e4cd571a4100f8ab4ac292bbb59c7df383c6188d6b0c840113aa61f15a1c0"

URI_aarch64_ghc9.8-ghc-heap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-heap-devel-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-heap-devel}"
SRC_URI[aarch64_ghc9.8-ghc-heap-devel.sha256sum] = "7b80d297a4e3b1ebcaa0062008be51ebaa8c4311766acbbd8d6f3ca25919cefb"

URI_aarch64_ghc9.8-ghc-heap-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-heap-doc-9.8.4-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-heap-doc}"
SRC_URI[aarch64_ghc9.8-ghc-heap-doc.sha256sum] = "faa6a361c010faaad9600a5f4706480017515078393f31493a6f3ac489de88a2"

URI_aarch64_ghc9.8-ghc-heap-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-heap-prof-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-heap-prof}"
SRC_URI[aarch64_ghc9.8-ghc-heap-prof.sha256sum] = "e159ed143f9031461cf8ce11bc240445ce8db17b60663396a74c1e68474960d7"

URI_aarch64_ghc9.8-ghc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghc-prof-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghc-prof}"
SRC_URI[aarch64_ghc9.8-ghc-prof.sha256sum] = "f2a89e6da1e5e7999c22bab1dc2db94029f1c4e0c27bc5bd5be6be92ed0e4412"

URI_aarch64_ghc9.8-ghci = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghci-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghci;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghci}"
SRC_URI[aarch64_ghc9.8-ghci.sha256sum] = "85832093ae65daa685a3ab1942eb9d023367ab47c0bb2adbba530e94fbb22140"

URI_aarch64_ghc9.8-ghci-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghci-devel-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghci-devel}"
SRC_URI[aarch64_ghc9.8-ghci-devel.sha256sum] = "47f8fdbfe13b594e6a21767688a6efe03470ff8dfd4691fe5be1971db7bf8823"

URI_aarch64_ghc9.8-ghci-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghci-doc-9.8.4-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghci-doc}"
SRC_URI[aarch64_ghc9.8-ghci-doc.sha256sum] = "caebce998bcfc20d4399ed967bc6380bae25f56905c1613e6404129ddbb796ba"

URI_aarch64_ghc9.8-ghci-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-ghci-prof-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-ghci-prof}"
SRC_URI[aarch64_ghc9.8-ghci-prof.sha256sum] = "85a5727bc3dec0e0a947225dd0b7ab986ad3b3cc187b75aa0e6da27523c23d15"

URI_aarch64_ghc9.8-hadrian = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-hadrian-0.1.0.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-hadrian;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-hadrian}"
SRC_URI[aarch64_ghc9.8-hadrian.sha256sum] = "ae1af74447128243edf3428c3ff8d1553ec6d2219f969162bf3f5683b30aa9bd"

URI_aarch64_ghc9.8-haskeline = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-haskeline-0.8.2.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-haskeline;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-haskeline}"
SRC_URI[aarch64_ghc9.8-haskeline.sha256sum] = "d1caeb7c7ceca383bbf49c84ddb19ad7c4d332c130abc01042638f665976d177"

URI_aarch64_ghc9.8-haskeline-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-haskeline-devel-0.8.2.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-haskeline-devel}"
SRC_URI[aarch64_ghc9.8-haskeline-devel.sha256sum] = "23a5ad080d6e1699b9137a76fbff4b51e5e31677a8f71676072a807c4736d7f0"

URI_aarch64_ghc9.8-haskeline-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-haskeline-doc-0.8.2.1-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-haskeline-doc}"
SRC_URI[aarch64_ghc9.8-haskeline-doc.sha256sum] = "fdfeed704c656030c82b2029a6dd180f36a07a3aa4bef07114328837b60604b3"

URI_aarch64_ghc9.8-haskeline-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-haskeline-prof-0.8.2.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-haskeline-prof}"
SRC_URI[aarch64_ghc9.8-haskeline-prof.sha256sum] = "5001f3da9162c6ed574cccb0fce0d8509f6f476dc5717f4328d09248ced3612c"

URI_aarch64_ghc9.8-hpc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-hpc-0.7.0.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-hpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-hpc}"
SRC_URI[aarch64_ghc9.8-hpc.sha256sum] = "a256dda8ddd32d50edd59ab8151bc58331a1b64082245352cc82744190c8e90c"

URI_aarch64_ghc9.8-hpc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-hpc-devel-0.7.0.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-hpc-devel}"
SRC_URI[aarch64_ghc9.8-hpc-devel.sha256sum] = "569d1b4bf6eba6e3b18d6e52ae7e248088598409d513247f07bf4266db909fa3"

URI_aarch64_ghc9.8-hpc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-hpc-doc-0.7.0.0-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-hpc-doc}"
SRC_URI[aarch64_ghc9.8-hpc-doc.sha256sum] = "0f1438b4cb3630eaed3472d4b62269067de30130d647dd0684d609d941e745f1"

URI_aarch64_ghc9.8-hpc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-hpc-prof-0.7.0.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-hpc-prof}"
SRC_URI[aarch64_ghc9.8-hpc-prof.sha256sum] = "02c6abb673e6cd6e6a886150d608e9abf265964f6f128b7bec714d7f7b305b2c"

URI_aarch64_ghc9.8-manual = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-manual-9.8.4-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-manual}"
SRC_URI[aarch64_ghc9.8-manual.sha256sum] = "f9ba191509028282761f5eca49021780c721b9e973da1502d9fef195919625dd"

URI_aarch64_ghc9.8-mtl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-mtl-2.3.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-mtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-mtl}"
SRC_URI[aarch64_ghc9.8-mtl.sha256sum] = "ad6e460770edef01a184ec496f866dbb073fdb396f4dc6662dbf6f2687841446"

URI_aarch64_ghc9.8-mtl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-mtl-devel-2.3.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-mtl-devel}"
SRC_URI[aarch64_ghc9.8-mtl-devel.sha256sum] = "729588dd084866d63bb6f7c3ebba2c17d43898c7a3ab3fe6096ab8c46f329cd5"

URI_aarch64_ghc9.8-mtl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-mtl-doc-2.3.1-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-mtl-doc}"
SRC_URI[aarch64_ghc9.8-mtl-doc.sha256sum] = "501e97224555fa8eef2c96c97e791fffb02bf92b2ddd06ebece7e49f0ee3725a"

URI_aarch64_ghc9.8-mtl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-mtl-prof-2.3.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-mtl-prof}"
SRC_URI[aarch64_ghc9.8-mtl-prof.sha256sum] = "1aa263ba2847f1488640a69eceb0689cd352c1fede3934587cbec9100bcdf64e"

URI_aarch64_ghc9.8-parsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-parsec-3.1.17.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-parsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-parsec}"
SRC_URI[aarch64_ghc9.8-parsec.sha256sum] = "b923b43643e9b30cc4d44f3f32037d7f299c0a75686c2289c9d11babb89bd7b6"

URI_aarch64_ghc9.8-parsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-parsec-devel-3.1.17.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-parsec-devel}"
SRC_URI[aarch64_ghc9.8-parsec-devel.sha256sum] = "198eb331a48ab7ef14fb795f06dba40892bfc9554abebb3a33e335eb1a064f67"

URI_aarch64_ghc9.8-parsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-parsec-doc-3.1.17.0-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-parsec-doc}"
SRC_URI[aarch64_ghc9.8-parsec-doc.sha256sum] = "59f0023d7e3a5b9d310bd6aa22c9a2e5284be87a1776ab56e22a1bb43a14cfa7"

URI_aarch64_ghc9.8-parsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-parsec-prof-3.1.17.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-parsec-prof}"
SRC_URI[aarch64_ghc9.8-parsec-prof.sha256sum] = "107401f9a7c35a1e725d69f4c49fc845c93addeb69f84baf2f8c4715afa7004b"

URI_aarch64_ghc9.8-pretty = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-pretty-1.1.3.6-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-pretty;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-pretty}"
SRC_URI[aarch64_ghc9.8-pretty.sha256sum] = "b66df5f8c1f15189111bf65f1cc2e6b5199e962c66ab25355544cd39d2802275"

URI_aarch64_ghc9.8-pretty-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-pretty-devel-1.1.3.6-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-pretty-devel}"
SRC_URI[aarch64_ghc9.8-pretty-devel.sha256sum] = "b4608fa9780d2b53d8929190ff11ddf28bf577f599ee2f5b6aa3bc008e7f254b"

URI_aarch64_ghc9.8-pretty-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-pretty-doc-1.1.3.6-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-pretty-doc}"
SRC_URI[aarch64_ghc9.8-pretty-doc.sha256sum] = "e37f8978e17e20317785b389b01b04668bc5b3e0688dd016082aa8b6ad148f4a"

URI_aarch64_ghc9.8-pretty-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-pretty-prof-1.1.3.6-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-pretty-prof}"
SRC_URI[aarch64_ghc9.8-pretty-prof.sha256sum] = "2adc0f4da16409bd2b981a706325f244564e1b336c87477cc87393453d2032a9"

URI_aarch64_ghc9.8-process = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-process-1.6.25.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-process}"
SRC_URI[aarch64_ghc9.8-process.sha256sum] = "3197e1b0c00d5d910e26eda737fad93d41f623308f9d2541a993eb90b59a4c91"

URI_aarch64_ghc9.8-process-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-process-devel-1.6.25.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-process-devel}"
SRC_URI[aarch64_ghc9.8-process-devel.sha256sum] = "a9163c6c91910c98dfa681498332b3d650e925f9fec7f9f268ef0a274ae265a7"

URI_aarch64_ghc9.8-process-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-process-doc-1.6.25.0-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-process-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-process-doc}"
SRC_URI[aarch64_ghc9.8-process-doc.sha256sum] = "dffb34341cdb27b574ca458d0393b3bd3f4484d55cf02f7ad2bf447320a0e31b"

URI_aarch64_ghc9.8-process-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-process-prof-1.6.25.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-process-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-process-prof}"
SRC_URI[aarch64_ghc9.8-process-prof.sha256sum] = "a2679e18ed8f6748162f8eb0d185c3b04b826a2be4f28e414106dca4db32fe98"

URI_aarch64_ghc9.8-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-prof-9.8.4-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-prof}"
SRC_URI[aarch64_ghc9.8-prof.sha256sum] = "1b5c796fbdd50273dfc9e659fd9aa28328476ec19032ea246e4a2b600756f16e"

URI_aarch64_ghc9.8-semaphore-compat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-semaphore-compat-1.0.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-semaphore-compat}"
SRC_URI[aarch64_ghc9.8-semaphore-compat.sha256sum] = "35e6329a70aa30ee7cf683529113da7eb4a2b8d35a0498c2c53ddda082131605"

URI_aarch64_ghc9.8-semaphore-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-semaphore-compat-devel-1.0.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-semaphore-compat-devel}"
SRC_URI[aarch64_ghc9.8-semaphore-compat-devel.sha256sum] = "f2bdd28cf8fa020ed24b9a695511223c8e1d29e4f3452a0a0d8928b7bb8b470c"

URI_aarch64_ghc9.8-semaphore-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-semaphore-compat-doc-1.0.0-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-semaphore-compat-doc}"
SRC_URI[aarch64_ghc9.8-semaphore-compat-doc.sha256sum] = "d6e1feea27db2b5432180384df4667e7726f7ec706bec0079c3568072b7c38ee"

URI_aarch64_ghc9.8-semaphore-compat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-semaphore-compat-prof-1.0.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-semaphore-compat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-semaphore-compat-prof}"
SRC_URI[aarch64_ghc9.8-semaphore-compat-prof.sha256sum] = "2a49548e93bbbd7af90f963d2f40f58aeb3a74c6366554b734c06ba118d78e55"

URI_aarch64_ghc9.8-stm = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-stm-2.5.3.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-stm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-stm}"
SRC_URI[aarch64_ghc9.8-stm.sha256sum] = "fa647831fb816f41ba2bbacf0441502c04cc0f26f9e5884539a270114d7590bd"

URI_aarch64_ghc9.8-stm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-stm-devel-2.5.3.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-stm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-stm-devel}"
SRC_URI[aarch64_ghc9.8-stm-devel.sha256sum] = "3f398b37d262b8433d435a48e52eb8498ef136a34bc94c13d396fffeac2dcc75"

URI_aarch64_ghc9.8-stm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-stm-doc-2.5.3.1-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-stm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-stm-doc}"
SRC_URI[aarch64_ghc9.8-stm-doc.sha256sum] = "7722bb90b4ed40af17b95636b1f29d6936d225fc994180911f12096d937b8ebf"

URI_aarch64_ghc9.8-stm-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-stm-prof-2.5.3.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-stm-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-stm-prof}"
SRC_URI[aarch64_ghc9.8-stm-prof.sha256sum] = "40fea4f6791e7025d8ec75f55782ee28c03c1c557578628be7e4681d8650d7b4"

URI_aarch64_ghc9.8-template-haskell = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-template-haskell-2.21.0.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-template-haskell;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-template-haskell}"
SRC_URI[aarch64_ghc9.8-template-haskell.sha256sum] = "992ca2692a5d2c802b0913b5f47a8d980a50c322a09ed50c5027098783b00e8b"

URI_aarch64_ghc9.8-template-haskell-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-template-haskell-devel-2.21.0.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-template-haskell-devel}"
SRC_URI[aarch64_ghc9.8-template-haskell-devel.sha256sum] = "acb14e461952e3b745bbdca466acc2b4884dcf32a55501806aac87f5a6892b8c"

URI_aarch64_ghc9.8-template-haskell-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-template-haskell-doc-2.21.0.0-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-template-haskell-doc}"
SRC_URI[aarch64_ghc9.8-template-haskell-doc.sha256sum] = "50e70dc8a8eadbfeaa1fed06d54414050744bce3e98256dbee1806c6fac0d9d5"

URI_aarch64_ghc9.8-template-haskell-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-template-haskell-prof-2.21.0.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-template-haskell-prof}"
SRC_URI[aarch64_ghc9.8-template-haskell-prof.sha256sum] = "6dbc3567ca527885f258a2d8854c29f456f9fd68508a8e228b15e1a6afc0c3cc"

URI_aarch64_ghc9.8-terminfo = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-terminfo-0.4.1.6-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-terminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-terminfo}"
SRC_URI[aarch64_ghc9.8-terminfo.sha256sum] = "a8e44418ceac407b87041dbba72eab605eaa58c28bf814bd5654c97b52099681"

URI_aarch64_ghc9.8-terminfo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-terminfo-devel-0.4.1.6-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-terminfo-devel}"
SRC_URI[aarch64_ghc9.8-terminfo-devel.sha256sum] = "51636b076008824c75c60b9d0d4b598c8f16c7720defc842a1329af9d937c183"

URI_aarch64_ghc9.8-terminfo-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-terminfo-doc-0.4.1.6-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-terminfo-doc}"
SRC_URI[aarch64_ghc9.8-terminfo-doc.sha256sum] = "270ca8807b1cc4613ffd380eebf9a5df28658666027b0dd1bb6c6e74494e7b65"

URI_aarch64_ghc9.8-terminfo-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-terminfo-prof-0.4.1.6-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-terminfo-prof}"
SRC_URI[aarch64_ghc9.8-terminfo-prof.sha256sum] = "32bd14f7faf53760d96ddc274790b0e0d63a6922072f3a0e0aa08d9d6c2572e9"

URI_aarch64_ghc9.8-text = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-text-2.1.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-text}"
SRC_URI[aarch64_ghc9.8-text.sha256sum] = "e699bb0ffa8f031736a7c60b70fdd26bc4529e682ca4491efa02cc7436cc99c9"

URI_aarch64_ghc9.8-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-text-devel-2.1.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-text-devel}"
SRC_URI[aarch64_ghc9.8-text-devel.sha256sum] = "d44736fc8d267ac7196223a681d7df2fe5f3f2f59f310c50a63fb206e8bff93d"

URI_aarch64_ghc9.8-text-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-text-doc-2.1.1-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-text-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-text-doc}"
SRC_URI[aarch64_ghc9.8-text-doc.sha256sum] = "7b78a1ebaca384c03d68143728fc7257e7b87687eac0501aa9cfd579100a708e"

URI_aarch64_ghc9.8-text-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-text-prof-2.1.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-text-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-text-prof}"
SRC_URI[aarch64_ghc9.8-text-prof.sha256sum] = "9f4175711fe602abb8aeeabe6b3a3390a596a8d3f1ce8d05a722d933f69d2017"

URI_aarch64_ghc9.8-time = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-time-1.12.2-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-time}"
SRC_URI[aarch64_ghc9.8-time.sha256sum] = "1e507d1bfa94d8296b8f636d52c521040ee07ede40da9ef20d23fed70196c6b2"

URI_aarch64_ghc9.8-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-time-devel-1.12.2-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-time-devel}"
SRC_URI[aarch64_ghc9.8-time-devel.sha256sum] = "94018d41edfdb07313be6dcc68edeb08e8ade945c992d08fe3ed427e41827518"

URI_aarch64_ghc9.8-time-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-time-doc-1.12.2-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-time-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-time-doc}"
SRC_URI[aarch64_ghc9.8-time-doc.sha256sum] = "39ed2bc53e9938f2d4ac25e9e0d8278810ace33fabc2890eac288861c8db9ed3"

URI_aarch64_ghc9.8-time-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-time-prof-1.12.2-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-time-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-time-prof}"
SRC_URI[aarch64_ghc9.8-time-prof.sha256sum] = "fe629a175414e785c8ab3980b798838d54890f66a6a1e2426aa20925f14c43db"

URI_aarch64_ghc9.8-transformers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-transformers-0.6.1.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-transformers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-transformers}"
SRC_URI[aarch64_ghc9.8-transformers.sha256sum] = "498eb608f8bdd191cf1d2237dccf946e86cd6804fe2d17128e1b9fad074bb759"

URI_aarch64_ghc9.8-transformers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-transformers-devel-0.6.1.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-transformers-devel}"
SRC_URI[aarch64_ghc9.8-transformers-devel.sha256sum] = "d1f17679ff5c570672822707ac71c869773203f676a8d448f7e8ee9f296873ed"

URI_aarch64_ghc9.8-transformers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-transformers-doc-0.6.1.0-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-transformers-doc}"
SRC_URI[aarch64_ghc9.8-transformers-doc.sha256sum] = "6b861beba4c7c336431e2f0dae2067f75d1254ddc3b294c5f98fd5c9fdee6426"

URI_aarch64_ghc9.8-transformers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-transformers-prof-0.6.1.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-transformers-prof}"
SRC_URI[aarch64_ghc9.8-transformers-prof.sha256sum] = "f51a126d7e92fcedf973be025f3cc21caa18a7096b9703d8544b7526ab88f53d"

URI_aarch64_ghc9.8-unix = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-unix-2.8.6.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-unix}"
SRC_URI[aarch64_ghc9.8-unix.sha256sum] = "83d395f833bc4daa1e064c726470336b88945aacc6f15aa6a9ec7c0d10ed5947"

URI_aarch64_ghc9.8-unix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-unix-devel-2.8.6.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-unix-devel}"
SRC_URI[aarch64_ghc9.8-unix-devel.sha256sum] = "1baf6e9aec8f5b0c164e4b7a4ddb96a442467f066b2362ec2397537e11ee8794"

URI_aarch64_ghc9.8-unix-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-unix-doc-2.8.6.0-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-unix-doc}"
SRC_URI[aarch64_ghc9.8-unix-doc.sha256sum] = "026b346607369519e73f82ad29a18dff154796276cbb580105bc6e922239dfe8"

URI_aarch64_ghc9.8-unix-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-unix-prof-2.8.6.0-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-unix-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-unix-prof}"
SRC_URI[aarch64_ghc9.8-unix-prof.sha256sum] = "5dda94ce9b25fa25ef43a764837d88916bf1ed14cc27c1d3e6faba673a8dcbef"

URI_aarch64_ghc9.8-xhtml = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-xhtml-3000.2.2.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-xhtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-xhtml}"
SRC_URI[aarch64_ghc9.8-xhtml.sha256sum] = "c2e3bcfa76f8071b140865bd87965b5a46529a787c2be940b559c5135f243c17"

URI_aarch64_ghc9.8-xhtml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-xhtml-devel-3000.2.2.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-xhtml-devel}"
SRC_URI[aarch64_ghc9.8-xhtml-devel.sha256sum] = "960924018c777104477d93aa6398238ce0309bb366f61d33b210b705b88c02dc"

URI_aarch64_ghc9.8-xhtml-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-xhtml-doc-3000.2.2.1-14.el10_0.noarch.rpm;name=aarch64_ghc9.8-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-xhtml-doc}"
SRC_URI[aarch64_ghc9.8-xhtml-doc.sha256sum] = "005410d4d24b849f6ae5bb756d6ad2ff42d2e722a3c20e5a6025c68dfd68bd61"

URI_aarch64_ghc9.8-xhtml-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.8-xhtml-prof-3000.2.2.1-14.el10_0.aarch64.rpm;name=aarch64_ghc9.8-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.8-xhtml-prof}"
SRC_URI[aarch64_ghc9.8-xhtml-prof.sha256sum] = "0305a60af3df4da9b3ea1d26aa675a0b9629c484c8358e220247da94c8e7f6e9"

RDEPENDS:ghc9.8 = " \
 ghc9.8-compiler \
 ghc9.8-devel \
 ghc9.8-ghc-boot-devel \
 ghc9.8-ghc-compact-devel \
 ghc9.8-ghc-devel \
 ghc9.8-ghc-heap-devel \
 ghc9.8-ghci-devel \
 ghc9.8-hpc-devel \
 "
RDEPENDS:ghc9.8-Cabal = " \
 ghc9.8-Cabal-syntax \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-binary \
 ghc9.8-bytestring \
 ghc9.8-containers \
 ghc9.8-deepseq \
 ghc9.8-directory \
 ghc9.8-exceptions \
 ghc9.8-filepath \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-mtl \
 ghc9.8-parsec \
 ghc9.8-pretty \
 ghc9.8-process \
 ghc9.8-stm \
 ghc9.8-template-haskell \
 ghc9.8-text \
 ghc9.8-time \
 ghc9.8-transformers \
 ghc9.8-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-Cabal-devel = " \
 ghc9.8-Cabal \
 ghc9.8-Cabal-syntax-devel \
 ghc9.8-array-devel \
 ghc9.8-base-devel \
 ghc9.8-bytestring-devel \
 ghc9.8-compiler \
 ghc9.8-containers-devel \
 ghc9.8-deepseq-devel \
 ghc9.8-directory-devel \
 ghc9.8-filepath-devel \
 ghc9.8-mtl-devel \
 ghc9.8-parsec-devel \
 ghc9.8-pretty-devel \
 ghc9.8-process-devel \
 ghc9.8-text-devel \
 ghc9.8-time-devel \
 ghc9.8-transformers-devel \
 ghc9.8-unix-devel \
 "
RDEPENDS:ghc9.8-Cabal-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-Cabal-prof = " \
 ghc9.8-Cabal-devel \
 ghc9.8-Cabal-syntax-prof \
 ghc9.8-array-prof \
 ghc9.8-base-prof \
 ghc9.8-bytestring-prof \
 ghc9.8-containers-prof \
 ghc9.8-deepseq-prof \
 ghc9.8-directory-prof \
 ghc9.8-filepath-prof \
 ghc9.8-mtl-prof \
 ghc9.8-parsec-prof \
 ghc9.8-pretty-prof \
 ghc9.8-process-prof \
 ghc9.8-text-prof \
 ghc9.8-time-prof \
 ghc9.8-transformers-prof \
 ghc9.8-unix-prof \
 "
RDEPENDS:ghc9.8-Cabal-syntax = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-binary \
 ghc9.8-bytestring \
 ghc9.8-containers \
 ghc9.8-deepseq \
 ghc9.8-directory \
 ghc9.8-exceptions \
 ghc9.8-filepath \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-mtl \
 ghc9.8-parsec \
 ghc9.8-pretty \
 ghc9.8-stm \
 ghc9.8-template-haskell \
 ghc9.8-text \
 ghc9.8-time \
 ghc9.8-transformers \
 ghc9.8-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-Cabal-syntax-devel = " \
 ghc9.8-Cabal-syntax \
 ghc9.8-array-devel \
 ghc9.8-base-devel \
 ghc9.8-binary-devel \
 ghc9.8-bytestring-devel \
 ghc9.8-compiler \
 ghc9.8-containers-devel \
 ghc9.8-deepseq-devel \
 ghc9.8-directory-devel \
 ghc9.8-filepath-devel \
 ghc9.8-mtl-devel \
 ghc9.8-parsec-devel \
 ghc9.8-pretty-devel \
 ghc9.8-text-devel \
 ghc9.8-time-devel \
 ghc9.8-transformers-devel \
 ghc9.8-unix-devel \
 "
RDEPENDS:ghc9.8-Cabal-syntax-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-Cabal-syntax-prof = " \
 ghc9.8-Cabal-syntax-devel \
 ghc9.8-array-prof \
 ghc9.8-base-prof \
 ghc9.8-binary-prof \
 ghc9.8-bytestring-prof \
 ghc9.8-containers-prof \
 ghc9.8-deepseq-prof \
 ghc9.8-directory-prof \
 ghc9.8-filepath-prof \
 ghc9.8-mtl-prof \
 ghc9.8-parsec-prof \
 ghc9.8-pretty-prof \
 ghc9.8-text-prof \
 ghc9.8-time-prof \
 ghc9.8-transformers-prof \
 ghc9.8-unix-prof \
 "
RDEPENDS:ghc9.8-array = " \
 ghc9.8-base \
 ghc9.8-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-array-devel = " \
 ghc9.8-array \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 "
RDEPENDS:ghc9.8-array-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-array-prof = " \
 ghc9.8-array-devel \
 ghc9.8-base-prof \
 "
RDEPENDS:ghc9.8-base = " \
 ghc9.8-ghc-bignum \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.8-base-devel = " \
 ghc9.8-base \
 ghc9.8-compiler \
 ghc9.8-ghc-bignum-devel \
 gmp-devel \
 libffi-devel \
 "
RDEPENDS:ghc9.8-base-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-base-prof = " \
 ghc9.8-base-devel \
 ghc9.8-ghc-bignum-prof \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.8-binary = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-bytestring \
 ghc9.8-containers \
 ghc9.8-deepseq \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-pretty \
 ghc9.8-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-binary-devel = " \
 ghc9.8-array-devel \
 ghc9.8-base-devel \
 ghc9.8-binary \
 ghc9.8-bytestring-devel \
 ghc9.8-compiler \
 ghc9.8-containers-devel \
 "
RDEPENDS:ghc9.8-binary-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-binary-prof = " \
 ghc9.8-array-prof \
 ghc9.8-base-prof \
 ghc9.8-binary-devel \
 ghc9.8-bytestring-prof \
 ghc9.8-containers-prof \
 "
RDEPENDS:ghc9.8-bytestring = " \
 ghc9.8-base \
 ghc9.8-deepseq \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-pretty \
 ghc9.8-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-bytestring-devel = " \
 ghc9.8-base-devel \
 ghc9.8-bytestring \
 ghc9.8-compiler \
 ghc9.8-deepseq-devel \
 ghc9.8-template-haskell-devel \
 "
RDEPENDS:ghc9.8-bytestring-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-bytestring-prof = " \
 ghc9.8-base-prof \
 ghc9.8-bytestring-devel \
 ghc9.8-deepseq-prof \
 ghc9.8-template-haskell-prof \
 "
RDEPENDS:ghc9.8-compiler = " \
 bash \
 binutils \
 gcc \
 ghc9.8-Cabal \
 ghc9.8-Cabal-syntax \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-base-devel \
 ghc9.8-binary \
 ghc9.8-bytestring \
 ghc9.8-containers \
 ghc9.8-deepseq \
 ghc9.8-directory \
 ghc9.8-exceptions \
 ghc9.8-filepath \
 ghc9.8-filesystem \
 ghc9.8-ghc \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot \
 ghc9.8-ghc-boot-th \
 ghc9.8-ghc-heap \
 ghc9.8-ghci \
 ghc9.8-haskeline \
 ghc9.8-hpc \
 ghc9.8-mtl \
 ghc9.8-parsec \
 ghc9.8-pretty \
 ghc9.8-process \
 ghc9.8-semaphore-compat \
 ghc9.8-stm \
 ghc9.8-template-haskell \
 ghc9.8-terminfo \
 ghc9.8-text \
 ghc9.8-time \
 ghc9.8-transformers \
 ghc9.8-unix \
 ghc9.8-xhtml \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 "
RDEPENDS:ghc9.8-compiler-default = " \
 bash \
 ghc9.8-compiler \
 "
RDEPENDS:ghc9.8-containers = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-deepseq \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-pretty \
 ghc9.8-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-containers-devel = " \
 ghc9.8-array-devel \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-containers \
 ghc9.8-deepseq-devel \
 ghc9.8-template-haskell-devel \
 "
RDEPENDS:ghc9.8-containers-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-containers-prof = " \
 ghc9.8-array-prof \
 ghc9.8-base-prof \
 ghc9.8-containers-devel \
 ghc9.8-deepseq-prof \
 ghc9.8-template-haskell-prof \
 "
RDEPENDS:ghc9.8-deepseq = " \
 ghc9.8-base \
 ghc9.8-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-deepseq-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-deepseq \
 "
RDEPENDS:ghc9.8-deepseq-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-deepseq-prof = " \
 ghc9.8-base-prof \
 ghc9.8-deepseq-devel \
 "
RDEPENDS:ghc9.8-devel = " \
 ghc9.8-Cabal-devel \
 ghc9.8-Cabal-syntax-devel \
 ghc9.8-array-devel \
 ghc9.8-base-devel \
 ghc9.8-binary-devel \
 ghc9.8-bytestring-devel \
 ghc9.8-compiler \
 ghc9.8-containers-devel \
 ghc9.8-deepseq-devel \
 ghc9.8-directory-devel \
 ghc9.8-exceptions-devel \
 ghc9.8-filepath-devel \
 ghc9.8-ghc-boot-th-devel \
 ghc9.8-haskeline-devel \
 ghc9.8-mtl-devel \
 ghc9.8-parsec-devel \
 ghc9.8-pretty-devel \
 ghc9.8-process-devel \
 ghc9.8-semaphore-compat-devel \
 ghc9.8-stm-devel \
 ghc9.8-template-haskell-devel \
 ghc9.8-terminfo-devel \
 ghc9.8-text-devel \
 ghc9.8-time-devel \
 ghc9.8-transformers-devel \
 ghc9.8-unix-devel \
 ghc9.8-xhtml-devel \
 "
RDEPENDS:ghc9.8-directory = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-bytestring \
 ghc9.8-deepseq \
 ghc9.8-exceptions \
 ghc9.8-filepath \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-mtl \
 ghc9.8-pretty \
 ghc9.8-stm \
 ghc9.8-template-haskell \
 ghc9.8-time \
 ghc9.8-transformers \
 ghc9.8-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-directory-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-directory \
 ghc9.8-filepath-devel \
 ghc9.8-time-devel \
 ghc9.8-unix-devel \
 "
RDEPENDS:ghc9.8-directory-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-directory-prof = " \
 ghc9.8-base-prof \
 ghc9.8-directory-devel \
 ghc9.8-filepath-prof \
 ghc9.8-time-prof \
 ghc9.8-unix-prof \
 "
RDEPENDS:ghc9.8-doc = " \
 "
RDEPENDS:ghc9.8-doc-index = " \
 ghc9.8-compiler \
 "
RDEPENDS:ghc9.8-exceptions = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-deepseq \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-mtl \
 ghc9.8-pretty \
 ghc9.8-stm \
 ghc9.8-template-haskell \
 ghc9.8-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-exceptions-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-exceptions \
 ghc9.8-mtl-devel \
 ghc9.8-stm-devel \
 ghc9.8-template-haskell-devel \
 ghc9.8-transformers-devel \
 "
RDEPENDS:ghc9.8-exceptions-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-exceptions-prof = " \
 ghc9.8-base-prof \
 ghc9.8-exceptions-devel \
 ghc9.8-mtl-prof \
 ghc9.8-stm-prof \
 ghc9.8-template-haskell-prof \
 ghc9.8-transformers-prof \
 "
RDEPENDS:ghc9.8-filepath = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-bytestring \
 ghc9.8-deepseq \
 ghc9.8-exceptions \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-mtl \
 ghc9.8-pretty \
 ghc9.8-stm \
 ghc9.8-template-haskell \
 ghc9.8-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-filepath-devel = " \
 ghc9.8-base-devel \
 ghc9.8-bytestring-devel \
 ghc9.8-compiler \
 ghc9.8-deepseq-devel \
 ghc9.8-exceptions-devel \
 ghc9.8-filepath \
 ghc9.8-template-haskell-devel \
 "
RDEPENDS:ghc9.8-filepath-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-filepath-prof = " \
 ghc9.8-base-prof \
 ghc9.8-bytestring-prof \
 ghc9.8-deepseq-prof \
 ghc9.8-exceptions-prof \
 ghc9.8-filepath-devel \
 ghc9.8-template-haskell-prof \
 "
RDEPENDS:ghc9.8-filesystem = " \
 "
RDEPENDS:ghc9.8-ghc = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-binary \
 ghc9.8-bytestring \
 ghc9.8-containers \
 ghc9.8-deepseq \
 ghc9.8-directory \
 ghc9.8-exceptions \
 ghc9.8-filepath \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot \
 ghc9.8-ghc-boot-th \
 ghc9.8-ghc-heap \
 ghc9.8-ghci \
 ghc9.8-hpc \
 ghc9.8-mtl \
 ghc9.8-pretty \
 ghc9.8-process \
 ghc9.8-semaphore-compat \
 ghc9.8-stm \
 ghc9.8-template-haskell \
 ghc9.8-time \
 ghc9.8-transformers \
 ghc9.8-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-ghc-bignum = " \
 ghc9.8-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-ghc-bignum-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-ghc-bignum \
 "
RDEPENDS:ghc9.8-ghc-bignum-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-ghc-bignum-prof = " \
 ghc9.8-base-prof \
 ghc9.8-ghc-bignum-devel \
 "
RDEPENDS:ghc9.8-ghc-boot = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-binary \
 ghc9.8-bytestring \
 ghc9.8-containers \
 ghc9.8-deepseq \
 ghc9.8-directory \
 ghc9.8-exceptions \
 ghc9.8-filepath \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-mtl \
 ghc9.8-pretty \
 ghc9.8-stm \
 ghc9.8-template-haskell \
 ghc9.8-time \
 ghc9.8-transformers \
 ghc9.8-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-ghc-boot-devel = " \
 ghc9.8-base-devel \
 ghc9.8-binary-devel \
 ghc9.8-bytestring-devel \
 ghc9.8-compiler \
 ghc9.8-containers-devel \
 ghc9.8-deepseq-devel \
 ghc9.8-directory-devel \
 ghc9.8-filepath-devel \
 ghc9.8-ghc-boot \
 ghc9.8-ghc-boot-th-devel \
 ghc9.8-unix-devel \
 "
RDEPENDS:ghc9.8-ghc-boot-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-ghc-boot-prof = " \
 ghc9.8-base-prof \
 ghc9.8-binary-prof \
 ghc9.8-bytestring-prof \
 ghc9.8-containers-prof \
 ghc9.8-deepseq-prof \
 ghc9.8-directory-prof \
 ghc9.8-filepath-prof \
 ghc9.8-ghc-boot-devel \
 ghc9.8-ghc-boot-th-prof \
 ghc9.8-unix-prof \
 "
RDEPENDS:ghc9.8-ghc-boot-th = " \
 ghc9.8-base \
 ghc9.8-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-ghc-boot-th-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-ghc-boot-th \
 "
RDEPENDS:ghc9.8-ghc-boot-th-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-ghc-boot-th-prof = " \
 ghc9.8-base-prof \
 ghc9.8-ghc-boot-th-devel \
 "
RDEPENDS:ghc9.8-ghc-compact = " \
 ghc9.8-base \
 ghc9.8-bytestring \
 ghc9.8-deepseq \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-pretty \
 ghc9.8-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-ghc-compact-devel = " \
 ghc9.8-base-devel \
 ghc9.8-bytestring-devel \
 ghc9.8-compiler \
 ghc9.8-ghc-compact \
 "
RDEPENDS:ghc9.8-ghc-compact-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-ghc-compact-prof = " \
 ghc9.8-base-prof \
 ghc9.8-bytestring-prof \
 ghc9.8-ghc-compact-devel \
 "
RDEPENDS:ghc9.8-ghc-devel = " \
 ghc9.8-array-devel \
 ghc9.8-base-devel \
 ghc9.8-binary-devel \
 ghc9.8-bytestring-devel \
 ghc9.8-compiler \
 ghc9.8-containers-devel \
 ghc9.8-deepseq-devel \
 ghc9.8-directory-devel \
 ghc9.8-exceptions-devel \
 ghc9.8-filepath-devel \
 ghc9.8-ghc \
 ghc9.8-ghc-boot-devel \
 ghc9.8-ghc-heap-devel \
 ghc9.8-ghci-devel \
 ghc9.8-hpc-devel \
 ghc9.8-process-devel \
 ghc9.8-semaphore-compat-devel \
 ghc9.8-stm-devel \
 ghc9.8-template-haskell-devel \
 ghc9.8-time-devel \
 ghc9.8-transformers-devel \
 ghc9.8-unix-devel \
 "
RDEPENDS:ghc9.8-ghc-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-ghc-heap = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-containers \
 ghc9.8-deepseq \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-pretty \
 ghc9.8-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-ghc-heap-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-containers-devel \
 ghc9.8-ghc-heap \
 "
RDEPENDS:ghc9.8-ghc-heap-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-ghc-heap-prof = " \
 ghc9.8-base-prof \
 ghc9.8-containers-prof \
 ghc9.8-ghc-heap-devel \
 "
RDEPENDS:ghc9.8-ghc-prof = " \
 ghc9.8-array-prof \
 ghc9.8-base-prof \
 ghc9.8-binary-prof \
 ghc9.8-bytestring-prof \
 ghc9.8-containers-prof \
 ghc9.8-deepseq-prof \
 ghc9.8-directory-prof \
 ghc9.8-exceptions-prof \
 ghc9.8-filepath-prof \
 ghc9.8-ghc-boot-prof \
 ghc9.8-ghc-devel \
 ghc9.8-ghc-heap-prof \
 ghc9.8-ghci-prof \
 ghc9.8-hpc-prof \
 ghc9.8-process-prof \
 ghc9.8-semaphore-compat-prof \
 ghc9.8-stm-prof \
 ghc9.8-template-haskell-prof \
 ghc9.8-time-prof \
 ghc9.8-transformers-prof \
 ghc9.8-unix-prof \
 "
RDEPENDS:ghc9.8-ghci = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-binary \
 ghc9.8-bytestring \
 ghc9.8-containers \
 ghc9.8-deepseq \
 ghc9.8-directory \
 ghc9.8-exceptions \
 ghc9.8-filepath \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot \
 ghc9.8-ghc-boot-th \
 ghc9.8-ghc-heap \
 ghc9.8-mtl \
 ghc9.8-pretty \
 ghc9.8-stm \
 ghc9.8-template-haskell \
 ghc9.8-time \
 ghc9.8-transformers \
 ghc9.8-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-ghci-devel = " \
 ghc9.8-array-devel \
 ghc9.8-base-devel \
 ghc9.8-binary-devel \
 ghc9.8-bytestring-devel \
 ghc9.8-compiler \
 ghc9.8-containers-devel \
 ghc9.8-deepseq-devel \
 ghc9.8-filepath-devel \
 ghc9.8-ghc-boot-devel \
 ghc9.8-ghc-heap-devel \
 ghc9.8-ghci \
 ghc9.8-template-haskell-devel \
 ghc9.8-transformers-devel \
 ghc9.8-unix-devel \
 "
RDEPENDS:ghc9.8-ghci-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-ghci-prof = " \
 ghc9.8-array-prof \
 ghc9.8-base-prof \
 ghc9.8-binary-prof \
 ghc9.8-bytestring-prof \
 ghc9.8-containers-prof \
 ghc9.8-deepseq-prof \
 ghc9.8-filepath-prof \
 ghc9.8-ghc-boot-prof \
 ghc9.8-ghc-heap-prof \
 ghc9.8-ghci-devel \
 ghc9.8-template-haskell-prof \
 ghc9.8-transformers-prof \
 ghc9.8-unix-prof \
 "
RDEPENDS:ghc9.8-hadrian = " \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.8-haskeline = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-bytestring \
 ghc9.8-containers \
 ghc9.8-deepseq \
 ghc9.8-directory \
 ghc9.8-exceptions \
 ghc9.8-filepath \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-mtl \
 ghc9.8-pretty \
 ghc9.8-process \
 ghc9.8-stm \
 ghc9.8-template-haskell \
 ghc9.8-terminfo \
 ghc9.8-time \
 ghc9.8-transformers \
 ghc9.8-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.8-haskeline-devel = " \
 ghc9.8-base-devel \
 ghc9.8-bytestring-devel \
 ghc9.8-compiler \
 ghc9.8-containers-devel \
 ghc9.8-directory-devel \
 ghc9.8-exceptions-devel \
 ghc9.8-filepath-devel \
 ghc9.8-haskeline \
 ghc9.8-process-devel \
 ghc9.8-stm-devel \
 ghc9.8-terminfo-devel \
 ghc9.8-transformers-devel \
 ghc9.8-unix-devel \
 "
RDEPENDS:ghc9.8-haskeline-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-haskeline-prof = " \
 ghc9.8-base-prof \
 ghc9.8-bytestring-prof \
 ghc9.8-containers-prof \
 ghc9.8-directory-prof \
 ghc9.8-exceptions-prof \
 ghc9.8-filepath-prof \
 ghc9.8-haskeline-devel \
 ghc9.8-process-prof \
 ghc9.8-stm-prof \
 ghc9.8-terminfo-prof \
 ghc9.8-transformers-prof \
 ghc9.8-unix-prof \
 "
RDEPENDS:ghc9.8-hpc = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-bytestring \
 ghc9.8-containers \
 ghc9.8-deepseq \
 ghc9.8-directory \
 ghc9.8-exceptions \
 ghc9.8-filepath \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-mtl \
 ghc9.8-pretty \
 ghc9.8-stm \
 ghc9.8-template-haskell \
 ghc9.8-time \
 ghc9.8-transformers \
 ghc9.8-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-hpc-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-containers-devel \
 ghc9.8-deepseq-devel \
 ghc9.8-directory-devel \
 ghc9.8-filepath-devel \
 ghc9.8-hpc \
 ghc9.8-time-devel \
 "
RDEPENDS:ghc9.8-hpc-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-hpc-prof = " \
 ghc9.8-base-prof \
 ghc9.8-containers-prof \
 ghc9.8-deepseq-prof \
 ghc9.8-directory-prof \
 ghc9.8-filepath-prof \
 ghc9.8-hpc-devel \
 ghc9.8-time-prof \
 "
RDEPENDS:ghc9.8-manual = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-mtl = " \
 ghc9.8-base \
 ghc9.8-ghc-bignum \
 ghc9.8-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-mtl-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-mtl \
 ghc9.8-transformers-devel \
 "
RDEPENDS:ghc9.8-mtl-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-mtl-prof = " \
 ghc9.8-base-prof \
 ghc9.8-mtl-devel \
 ghc9.8-transformers-prof \
 "
RDEPENDS:ghc9.8-parsec = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-binary \
 ghc9.8-bytestring \
 ghc9.8-containers \
 ghc9.8-deepseq \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-mtl \
 ghc9.8-pretty \
 ghc9.8-template-haskell \
 ghc9.8-text \
 ghc9.8-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-parsec-devel = " \
 ghc9.8-base-devel \
 ghc9.8-bytestring-devel \
 ghc9.8-compiler \
 ghc9.8-mtl-devel \
 ghc9.8-parsec \
 ghc9.8-text-devel \
 "
RDEPENDS:ghc9.8-parsec-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-parsec-prof = " \
 ghc9.8-base-prof \
 ghc9.8-bytestring-prof \
 ghc9.8-mtl-prof \
 ghc9.8-parsec-devel \
 ghc9.8-text-prof \
 "
RDEPENDS:ghc9.8-pretty = " \
 ghc9.8-base \
 ghc9.8-deepseq \
 ghc9.8-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-pretty-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-deepseq-devel \
 ghc9.8-pretty \
 "
RDEPENDS:ghc9.8-pretty-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-pretty-prof = " \
 ghc9.8-base-prof \
 ghc9.8-deepseq-prof \
 ghc9.8-pretty-devel \
 "
RDEPENDS:ghc9.8-process = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-bytestring \
 ghc9.8-deepseq \
 ghc9.8-directory \
 ghc9.8-exceptions \
 ghc9.8-filepath \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-mtl \
 ghc9.8-pretty \
 ghc9.8-stm \
 ghc9.8-template-haskell \
 ghc9.8-time \
 ghc9.8-transformers \
 ghc9.8-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-process-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-deepseq-devel \
 ghc9.8-directory-devel \
 ghc9.8-filepath-devel \
 ghc9.8-process \
 ghc9.8-unix-devel \
 "
RDEPENDS:ghc9.8-process-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-process-prof = " \
 ghc9.8-base-prof \
 ghc9.8-deepseq-prof \
 ghc9.8-directory-prof \
 ghc9.8-filepath-prof \
 ghc9.8-process-devel \
 ghc9.8-unix-prof \
 "
RDEPENDS:ghc9.8-prof = " \
 ghc9.8-compiler \
 "
RDEPENDS:ghc9.8-semaphore-compat = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-bytestring \
 ghc9.8-deepseq \
 ghc9.8-exceptions \
 ghc9.8-filepath \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-mtl \
 ghc9.8-pretty \
 ghc9.8-stm \
 ghc9.8-template-haskell \
 ghc9.8-time \
 ghc9.8-transformers \
 ghc9.8-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-semaphore-compat-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-exceptions-devel \
 ghc9.8-semaphore-compat \
 ghc9.8-unix-devel \
 "
RDEPENDS:ghc9.8-semaphore-compat-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-semaphore-compat-prof = " \
 ghc9.8-base-prof \
 ghc9.8-exceptions-prof \
 ghc9.8-semaphore-compat-devel \
 ghc9.8-unix-prof \
 "
RDEPENDS:ghc9.8-stm = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-stm-devel = " \
 ghc9.8-array-devel \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-stm \
 "
RDEPENDS:ghc9.8-stm-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-stm-prof = " \
 ghc9.8-array-prof \
 ghc9.8-base-prof \
 ghc9.8-stm-devel \
 "
RDEPENDS:ghc9.8-template-haskell = " \
 ghc9.8-base \
 ghc9.8-deepseq \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-template-haskell-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-ghc-boot-th-devel \
 ghc9.8-pretty-devel \
 ghc9.8-template-haskell \
 "
RDEPENDS:ghc9.8-template-haskell-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-template-haskell-prof = " \
 ghc9.8-base-prof \
 ghc9.8-ghc-boot-th-prof \
 ghc9.8-pretty-prof \
 ghc9.8-template-haskell-devel \
 "
RDEPENDS:ghc9.8-terminfo = " \
 ghc9.8-base \
 ghc9.8-ghc-bignum \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.8-terminfo-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-terminfo \
 ncurses-devel \
 "
RDEPENDS:ghc9.8-terminfo-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-terminfo-prof = " \
 ghc9.8-base-prof \
 ghc9.8-terminfo-devel \
 "
RDEPENDS:ghc9.8-text = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-binary \
 ghc9.8-bytestring \
 ghc9.8-containers \
 ghc9.8-deepseq \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-pretty \
 ghc9.8-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-text-devel = " \
 ghc9.8-array-devel \
 ghc9.8-base-devel \
 ghc9.8-binary-devel \
 ghc9.8-bytestring-devel \
 ghc9.8-compiler \
 ghc9.8-deepseq-devel \
 ghc9.8-template-haskell-devel \
 ghc9.8-text \
 "
RDEPENDS:ghc9.8-text-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-text-prof = " \
 ghc9.8-array-prof \
 ghc9.8-base-prof \
 ghc9.8-binary-prof \
 ghc9.8-bytestring-prof \
 ghc9.8-deepseq-prof \
 ghc9.8-template-haskell-prof \
 ghc9.8-text-devel \
 "
RDEPENDS:ghc9.8-time = " \
 ghc9.8-base \
 ghc9.8-deepseq \
 ghc9.8-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-time-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-deepseq-devel \
 ghc9.8-time \
 "
RDEPENDS:ghc9.8-time-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-time-prof = " \
 ghc9.8-base-prof \
 ghc9.8-deepseq-prof \
 ghc9.8-time-devel \
 "
RDEPENDS:ghc9.8-transformers = " \
 ghc9.8-base \
 ghc9.8-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-transformers-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-transformers \
 "
RDEPENDS:ghc9.8-transformers-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-transformers-prof = " \
 ghc9.8-base-prof \
 ghc9.8-transformers-devel \
 "
RDEPENDS:ghc9.8-unix = " \
 ghc9.8-array \
 ghc9.8-base \
 ghc9.8-bytestring \
 ghc9.8-deepseq \
 ghc9.8-exceptions \
 ghc9.8-filepath \
 ghc9.8-ghc-bignum \
 ghc9.8-ghc-boot-th \
 ghc9.8-mtl \
 ghc9.8-pretty \
 ghc9.8-stm \
 ghc9.8-template-haskell \
 ghc9.8-time \
 ghc9.8-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-unix-devel = " \
 ghc9.8-base-devel \
 ghc9.8-bytestring-devel \
 ghc9.8-compiler \
 ghc9.8-filepath-devel \
 ghc9.8-time-devel \
 ghc9.8-unix \
 "
RDEPENDS:ghc9.8-unix-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-unix-prof = " \
 ghc9.8-base-prof \
 ghc9.8-bytestring-prof \
 ghc9.8-filepath-prof \
 ghc9.8-time-prof \
 ghc9.8-unix-devel \
 "
RDEPENDS:ghc9.8-xhtml = " \
 ghc9.8-base \
 ghc9.8-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.8-xhtml-devel = " \
 ghc9.8-base-devel \
 ghc9.8-compiler \
 ghc9.8-xhtml \
 "
RDEPENDS:ghc9.8-xhtml-doc = " \
 ghc9.8-filesystem \
 "
RDEPENDS:ghc9.8-xhtml-prof = " \
 ghc9.8-base-prof \
 ghc9.8-xhtml-devel \
 "
