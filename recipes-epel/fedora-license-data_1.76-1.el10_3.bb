# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-license-data"
PV = "1.76"
PR = "1.el10_3"
PACKAGES = " \
 fedora-license-data \
 rpmlint-fedora-license-data \
 rpmlint-fedora-license-data-legacy \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fedora-license-data-1.76-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "69c376729e343b9c972ab9b9c5a5faa6f27f49249437340d2c3e6e5a6a85e878"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-license-data-1.76-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-license-data;unpack=0"
SRC_URI[x86_64_v2_fedora-license-data.sha256sum] = "85da16cee204920744360d0152014b114d7db9e72201686c7eaa44006bb4ac4b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmlint-fedora-license-data-1.76-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rpmlint-fedora-license-data;unpack=0"
SRC_URI[x86_64_v2_rpmlint-fedora-license-data.sha256sum] = "8325346b381a759c38ed3cc5f71831eb627f6192da549275ecb621eefec9ab2e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmlint-fedora-license-data-legacy-1.76-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rpmlint-fedora-license-data-legacy;unpack=0"
SRC_URI[x86_64_v2_rpmlint-fedora-license-data-legacy.sha256sum] = "51db1f0598baba166acde002aeaffa96ee19d76ee2640421da378104fc408fd1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fedora-license-data-1.76-1.el10_3.noarch.rpm;name=aarch64_fedora-license-data;unpack=0"
SRC_URI[aarch64_fedora-license-data.sha256sum] = "49c2348ba444b58b60cb0a6564aac2f22d1239ffc89f3d532ee8b1c6cf6fcbcf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rpmlint-fedora-license-data-1.76-1.el10_3.noarch.rpm;name=aarch64_rpmlint-fedora-license-data;unpack=0"
SRC_URI[aarch64_rpmlint-fedora-license-data.sha256sum] = "06add7f06f5b794ab659e41076c3eb15e678efe4b6835e3214d09bf11bf95d55"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rpmlint-fedora-license-data-legacy-1.76-1.el10_3.noarch.rpm;name=aarch64_rpmlint-fedora-license-data-legacy;unpack=0"
SRC_URI[aarch64_rpmlint-fedora-license-data-legacy.sha256sum] = "3e52a317f6c6e7633ff48e0879fb75ee05ffc0f300df198e0192aab26cce6019"

RDEPENDS:fedora-license-data = " \
 "
RDEPENDS:rpmlint-fedora-license-data = " \
 rpmlint \
 "
RDEPENDS:rpmlint-fedora-license-data-legacy = " \
 rpmlint \
 "
