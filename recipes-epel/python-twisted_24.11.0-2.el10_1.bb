# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-twisted"
PV = "24.11.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-twisted \
 python3-twisted+tls \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-twisted-24.11.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb2866280c0a7405aaaa3a47652eb23bd5ea899b9b3e716cab6d9083ffe5caf5"

URI_x86_64_v2_python3-twisted = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-twisted-24.11.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-twisted;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-twisted}"
SRC_URI[x86_64_v2_python3-twisted.sha256sum] = "95eb1245841b8bbb8f5bde40fda2185d23ef15af5e5612b0efb9ea1de9cf16bd"

URI_x86_64_v2_python3-twisted+tls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-twisted+tls-24.11.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-twisted+tls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-twisted+tls}"
SRC_URI[x86_64_v2_python3-twisted+tls.sha256sum] = "219d0a3cb669aca08c0df195f4f7f42d4b2b3419b8767bc1dc644eb2abe7fdd8"

URI_aarch64_python3-twisted = "${EPEL_MIRROR}/aarch64/Packages/p/python3-twisted-24.11.0-2.el10_1.noarch.rpm;name=aarch64_python3-twisted;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-twisted}"
SRC_URI[aarch64_python3-twisted.sha256sum] = "95236dab73512b40dbbbe554b26a42786202b74643f4bfaf00a2c248e46a0d6d"

URI_aarch64_python3-twisted+tls = "${EPEL_MIRROR}/aarch64/Packages/p/python3-twisted+tls-24.11.0-2.el10_1.noarch.rpm;name=aarch64_python3-twisted+tls;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-twisted+tls}"
SRC_URI[aarch64_python3-twisted+tls.sha256sum] = "4bfbe0ef42591dacd19d24a44be46d7413197b85fa2b6d3ae3a344a71079e0e9"

RDEPENDS:python3-twisted = " \
 python3 \
 python3-Automat \
 python3-attrs \
 python3-constantly \
 python3-hyperlink \
 python3-incremental \
 python3-typing-extensions \
 python3-zope-interface \
 "
RDEPENDS:python3-twisted+tls = " \
 python3 \
 python3-idna \
 python3-pyOpenSSL \
 python3-service-identity \
 python3-twisted \
 "
