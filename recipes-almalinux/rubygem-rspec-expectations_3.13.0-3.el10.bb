# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-rspec-expectations"
PV = "3.13.0"
PR = "3.el10"
PACKAGES = " \
 rubygem-rspec-expectations \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/rubygem-rspec-expectations-3.13.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "787c8876a6b56ed609b69d0275889434eb133ccc9836f7c6513cf09f0460db68"

URI_x86_64_v2_rubygem-rspec-expectations = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rubygem-rspec-expectations-3.13.0-3.el10.noarch.rpm;name=x86_64_v2_rubygem-rspec-expectations;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rspec-expectations}"
SRC_URI[x86_64_v2_rubygem-rspec-expectations.sha256sum] = "ff5bed8bb05ef080d4dc87ba6e7e846f2b597eb169556ce3736fb95c3b347954"

URI_aarch64_rubygem-rspec-expectations = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rubygem-rspec-expectations-3.13.0-3.el10.noarch.rpm;name=aarch64_rubygem-rspec-expectations;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rspec-expectations}"
SRC_URI[aarch64_rubygem-rspec-expectations.sha256sum] = "ff5bed8bb05ef080d4dc87ba6e7e846f2b597eb169556ce3736fb95c3b347954"

RDEPENDS:rubygem-rspec-expectations = " \
 rubygem-diff-lcs \
 rubygem-rspec-support \
 rubygems \
 "
