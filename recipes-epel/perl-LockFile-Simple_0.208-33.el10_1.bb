# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-LockFile-Simple"
PV = "0.208"
PR = "33.el10_1"
PACKAGES = " \
 perl-LockFile-Simple \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-LockFile-Simple-0.208-33.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40a8ba21ea62fc51f5506c058e6a1ba3bc7a6b230a01784c1cb9452539faa88f"

URI_x86_64_v2_perl-LockFile-Simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-LockFile-Simple-0.208-33.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-LockFile-Simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-LockFile-Simple}"
SRC_URI[x86_64_v2_perl-LockFile-Simple.sha256sum] = "b2c127cbfe6a0948194a80062c10ec1b23a05927a8742b7d7285b6aa55d312cd"

URI_aarch64_perl-LockFile-Simple = "${EPEL_MIRROR}/aarch64/Packages/p/perl-LockFile-Simple-0.208-33.el10_1.noarch.rpm;name=aarch64_perl-LockFile-Simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-LockFile-Simple}"
SRC_URI[aarch64_perl-LockFile-Simple.sha256sum] = "88a4db812b79d8acba5e316f214bf0db639ac96096ee285f6840db3ff7ad6a3f"

RDEPENDS:perl-LockFile-Simple = " \
 perl-Exporter \
 perl-Sys-Hostname \
 perl-libs \
 perl-vars \
 "
