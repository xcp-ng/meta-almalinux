# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "corosync"
PV = "3.1.9"
PR = "1.el10_0.1"
PACKAGES = " \
 corosync-vqsim \
 corosynclib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/corosync-3.1.9-1.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7da082523f4d97aa1977b41953664a1a55cd25d16acd035e91618918acc32403"

URI_x86_64_v2_corosync-vqsim = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/corosync-vqsim-3.1.9-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_corosync-vqsim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_corosync-vqsim}"
SRC_URI[x86_64_v2_corosync-vqsim.sha256sum] = "1bd1c5bec6b2383b0c017ec77a0ce536a7e633658ced3cd8307ed2bbd93fc6fb"

URI_x86_64_v2_corosynclib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/corosynclib-3.1.9-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_corosynclib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_corosynclib}"
SRC_URI[x86_64_v2_corosynclib.sha256sum] = "0b10f9c4a4a26284d3c8b1ecdffd9e430e656d5e7c7962663179f15a2b8dfdf6"

URI_aarch64_corosync-vqsim = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/corosync-vqsim-3.1.9-1.el10_0.1.aarch64.rpm;name=aarch64_corosync-vqsim;unpack=0"
SRC_URI:append = " ${URI_aarch64_corosync-vqsim}"
SRC_URI[aarch64_corosync-vqsim.sha256sum] = "265aefc13e2396ebcd65b2cfe38d36520158c30d353b2e350558a5532c0fad21"

URI_aarch64_corosynclib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/corosynclib-3.1.9-1.el10_0.1.aarch64.rpm;name=aarch64_corosynclib;unpack=0"
SRC_URI:append = " ${URI_aarch64_corosynclib}"
SRC_URI[aarch64_corosynclib.sha256sum] = "a2c77fa9a0510f747facc9b557b7f6d0c8aa5a99f4007f64fae4e2abffaf9a84"

RDEPENDS:corosync-vqsim = " \
 corosynclib \
 glibc \
 libknet1 \
 libqb \
 pkgconf-pkg-config \
 readline \
 "
RDEPENDS:corosynclib = " \
 glibc \
 libqb \
 "
