# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-gpu-stats"
PV = "0.9.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-below-gpu-stats+default-devel \
 rust-below-gpu-stats-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-gpu-stats-0.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18c9f77929a2a09ed4fea02d92885e4cf3bbede03cf18828faf8878d5e70c495"

URI_x86_64_v2_rust-below-gpu-stats+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-gpu-stats+default-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-gpu-stats+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-gpu-stats+default-devel}"
SRC_URI[x86_64_v2_rust-below-gpu-stats+default-devel.sha256sum] = "c037cbb33dcc761fcad7c78bc56fe5b4d4eb9ea2556b81fe64bcb14ab3ac48a0"

URI_x86_64_v2_rust-below-gpu-stats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-gpu-stats-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-gpu-stats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-gpu-stats-devel}"
SRC_URI[x86_64_v2_rust-below-gpu-stats-devel.sha256sum] = "1b0ec622c8e24378107f7a35a8f4e13641c6983202b1e570117df9ecf0cbe586"

URI_aarch64_rust-below-gpu-stats+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-gpu-stats+default-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below-gpu-stats+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-gpu-stats+default-devel}"
SRC_URI[aarch64_rust-below-gpu-stats+default-devel.sha256sum] = "acdd4fd1a7c94704d6ee48ca75517cd36dde5cfe54b08dfcf5893071cf8358ce"

URI_aarch64_rust-below-gpu-stats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-gpu-stats-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below-gpu-stats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-gpu-stats-devel}"
SRC_URI[aarch64_rust-below-gpu-stats-devel.sha256sum] = "2a839fd4c1304ed377e5ca5610559599ccd764db52f58f3402cfd5a7672da9b1"

RDEPENDS:rust-below-gpu-stats+default-devel = " \
 cargo \
 rust-below-gpu-stats-devel \
 "
RDEPENDS:rust-below-gpu-stats-devel = " \
 cargo \
 rust-below-common+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 "
