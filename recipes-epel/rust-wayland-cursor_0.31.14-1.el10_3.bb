# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-cursor"
PV = "0.31.14"
PR = "1.el10_3"
PACKAGES = " \
 rust-wayland-cursor+default-devel \
 rust-wayland-cursor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-cursor-0.31.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00d96a0a8d2f3da27b6bab0669131d0881d5ccb8ee33895e5f13685222e7d589"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-wayland-cursor-devel: (crate(xcursor/default) >= 0.3.1 with crate(xcursor/default) < 0.4.0~)

URI_x86_64_v2_rust-wayland-cursor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-cursor+default-devel-0.31.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-cursor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-cursor+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-cursor+default-devel.sha256sum] = "ffcae2e45a784121ebe5be851d8c0fa7d463b92fc2ebad3498c3822ea33d84cf"

URI_x86_64_v2_rust-wayland-cursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-cursor-devel-0.31.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-cursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-cursor-devel}"
SRC_URI[x86_64_v2_rust-wayland-cursor-devel.sha256sum] = "6c856251981bd6a9ea5645d9a203107d8d34b092a88b6e5c336fc2ccf0b3b04a"

URI_aarch64_rust-wayland-cursor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-cursor+default-devel-0.31.14-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-cursor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-cursor+default-devel}"
SRC_URI[aarch64_rust-wayland-cursor+default-devel.sha256sum] = "89336cecb777ee2be4b3945daf85d7fc967b2b4b9d30d4e72b33adff9c950216"

URI_aarch64_rust-wayland-cursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-cursor-devel-0.31.14-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-cursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-cursor-devel}"
SRC_URI[aarch64_rust-wayland-cursor-devel.sha256sum] = "65e0f677bf2e302604f9a56826aec5f73057215c175795383a4e17b63185f589"

RDEPENDS:rust-wayland-cursor+default-devel = " \
 cargo \
 rust-wayland-cursor-devel \
 "
RDEPENDS:rust-wayland-cursor-devel:x86_64_v2 = " \
 cargo \
 rust \
 rust-rustix+default-devel \
 rust-rustix+shm-devel \
 rust-wayland-client+default-devel \
"
RDEPENDS:rust-wayland-cursor-devel:aarch64 = " \
 cargo \
 rust \
 rust-rustix+default-devel \
 rust-rustix+shm-devel \
 rust-wayland-client+default-devel \
 rust-xcursor+default-devel \
"
