# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdav"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kdav \
 kf6-kdav-devel \
 kf6-kdav-doc \
 kf6-kdav-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdav-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07863992ef70945d07c9bb2911c3eec093890308ac002378f1c20e419d053cbb"

URI_x86_64_v2_kf6-kdav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdav}"
SRC_URI[x86_64_v2_kf6-kdav.sha256sum] = "54bfb56826bb519cb43d023dcdc08046b73fdcaa45f3d8931fafdad945dfde35"

URI_x86_64_v2_kf6-kdav-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdav-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdav-devel}"
SRC_URI[x86_64_v2_kf6-kdav-devel.sha256sum] = "490f79f793c33c90b1031702abbd3ee9a1d7900427450a5b6d1a3deaffbfb5a3"

URI_x86_64_v2_kf6-kdav-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdav-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdav-doc}"
SRC_URI[x86_64_v2_kf6-kdav-doc.sha256sum] = "869279927a10d64c7af5b1bf58ddbe99f97069e2b4ad6cd5f3598d4203ed6917"

URI_x86_64_v2_kf6-kdav-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdav-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdav-html}"
SRC_URI[x86_64_v2_kf6-kdav-html.sha256sum] = "b89766163ebd6e9f22f882f4642a3e3fb57c4aac9d3dcd971899e0852a0e909d"

URI_aarch64_kf6-kdav = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kdav;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdav}"
SRC_URI[aarch64_kf6-kdav.sha256sum] = "c20c5badc22a8b3f6fb4bc7ccae2be05eade041d625dd2686d03d3014756aea2"

URI_aarch64_kf6-kdav-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kdav-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdav-devel}"
SRC_URI[aarch64_kf6-kdav-devel.sha256sum] = "ccd0522271e31c207ff8234ccfb3d1a3cb6f59961df4c342ea438b96aba280dc"

URI_aarch64_kf6-kdav-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kdav-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdav-doc}"
SRC_URI[aarch64_kf6-kdav-doc.sha256sum] = "bcbf913ada061d5db5f498c87f03f649a2599a95acab107fe210ff4a80e43eb3"

URI_aarch64_kf6-kdav-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kdav-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdav-html}"
SRC_URI[aarch64_kf6-kdav-html.sha256sum] = "01ecbb41efd1aa01538735bac0432971bc7e58517211e544c386bf6eea02c296"

RDEPENDS:kf6-kdav = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kdav-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kdav \
 "
RDEPENDS:kf6-kdav-doc = " \
 "
RDEPENDS:kf6-kdav-html = " \
 "
