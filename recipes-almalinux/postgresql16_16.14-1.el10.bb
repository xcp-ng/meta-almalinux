# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql16"
PV = "16.14"
PR = "1.el10"
PACKAGES = " \
 postgresql \
 postgresql-contrib \
 postgresql-docs \
 postgresql-plperl \
 postgresql-plpython3 \
 postgresql-pltcl \
 postgresql-private-devel \
 postgresql-private-libs \
 postgresql-server \
 postgresql-server-devel \
 postgresql-static \
 postgresql-test \
 postgresql-test-rpm-macros \
 postgresql-upgrade \
 postgresql-upgrade-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql16-16.14-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50c2b3c48e588c0a41ef4c96077d90b54846ebe8681925ec902ba8cea572bcad"

URI_x86_64_v2_postgresql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-16.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql}"
SRC_URI[x86_64_v2_postgresql.sha256sum] = "9c10890afb72e2c5a561e9bd7b257c91d96051ca38a3642b93b9a08086e43f94"

URI_x86_64_v2_postgresql-contrib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-contrib-16.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-contrib}"
SRC_URI[x86_64_v2_postgresql-contrib.sha256sum] = "d63cc178ee659967d18aaef4970030e28b75f06604cc9d085c68b8d418a3ef7c"

URI_x86_64_v2_postgresql-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-docs-16.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-docs}"
SRC_URI[x86_64_v2_postgresql-docs.sha256sum] = "10335856f5bfb91e751b4aba16c1882d4822f44df5fc1515158a25c76236b4a9"

URI_x86_64_v2_postgresql-plperl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-plperl-16.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-plperl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-plperl}"
SRC_URI[x86_64_v2_postgresql-plperl.sha256sum] = "bb515fc8a8cdcfe1b5a6010655fa75ef0839790ed867698346ff10d9030ecfcf"

URI_x86_64_v2_postgresql-plpython3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-plpython3-16.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-plpython3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-plpython3}"
SRC_URI[x86_64_v2_postgresql-plpython3.sha256sum] = "2ecf9888c1beb9610a565a2c5230b61ff1617dc2c5c113d7736c39a094eaf1e2"

URI_x86_64_v2_postgresql-pltcl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-pltcl-16.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-pltcl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-pltcl}"
SRC_URI[x86_64_v2_postgresql-pltcl.sha256sum] = "d6341a0c93183c64ca5f5b3dccbacb94c6ec30eeb035584398dc42a41125d82b"

URI_x86_64_v2_postgresql-private-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-private-devel-16.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-private-devel}"
SRC_URI[x86_64_v2_postgresql-private-devel.sha256sum] = "5264daf8ffad33f979c6264f6b252424d825a098f6f8aeb62dbda69256b9b316"

URI_x86_64_v2_postgresql-private-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-private-libs-16.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-private-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-private-libs}"
SRC_URI[x86_64_v2_postgresql-private-libs.sha256sum] = "cf6db0d7ed42ca17b4c8df7c1f4e4e9d2979e2482415c4701354984a177fcb2b"

URI_x86_64_v2_postgresql-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-server-16.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-server}"
SRC_URI[x86_64_v2_postgresql-server.sha256sum] = "7ff91a498e3e37ee2cea36723a2095c9cde579419a16f93972206e6ea3a76b73"

URI_x86_64_v2_postgresql-server-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-server-devel-16.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-server-devel}"
SRC_URI[x86_64_v2_postgresql-server-devel.sha256sum] = "27205a65aaaa59fd9f36c7ac1be0f3601946c9e505d4290f675a06dc6cffae4a"

URI_x86_64_v2_postgresql-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-static-16.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-static}"
SRC_URI[x86_64_v2_postgresql-static.sha256sum] = "3eb80c2e0ff7b2fb6901acf372fa7ea353e40bd725a2218de910293203925126"

URI_x86_64_v2_postgresql-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-test-16.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-test}"
SRC_URI[x86_64_v2_postgresql-test.sha256sum] = "441688fad76335a99e5a8ccd65077d15871273e0feda836de6b0aef8599dc5ca"

URI_x86_64_v2_postgresql-test-rpm-macros = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/postgresql-test-rpm-macros-16.14-1.el10.noarch.rpm;name=x86_64_v2_postgresql-test-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-test-rpm-macros}"
SRC_URI[x86_64_v2_postgresql-test-rpm-macros.sha256sum] = "baa2056f2721936554eff523eacb21fb548dc8290ceb21f237e08ee2deaed47a"

URI_x86_64_v2_postgresql-upgrade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-upgrade-16.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-upgrade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-upgrade}"
SRC_URI[x86_64_v2_postgresql-upgrade.sha256sum] = "37c189fa116f67a4c259dad88a3cf1d4d3c5930e46a4c6937b1047ede9945941"

URI_x86_64_v2_postgresql-upgrade-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-upgrade-devel-16.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-upgrade-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-upgrade-devel}"
SRC_URI[x86_64_v2_postgresql-upgrade-devel.sha256sum] = "f1a0b445357dcd8decaf03a7738227028565068c6907ae9b47a6718f5af7e214"

URI_aarch64_postgresql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-16.14-1.el10.aarch64.rpm;name=aarch64_postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql}"
SRC_URI[aarch64_postgresql.sha256sum] = "de43e786ece5f58e986585eb79d1690e858076333d221989399979678f24aafb"

URI_aarch64_postgresql-contrib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-contrib-16.14-1.el10.aarch64.rpm;name=aarch64_postgresql-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-contrib}"
SRC_URI[aarch64_postgresql-contrib.sha256sum] = "61cf6ee607e70c4e9c308f4dd71c76370d8162a51812311dc607436f2f4b37f5"

URI_aarch64_postgresql-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-docs-16.14-1.el10.aarch64.rpm;name=aarch64_postgresql-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-docs}"
SRC_URI[aarch64_postgresql-docs.sha256sum] = "afdef4bf8a63f8e05b22210371b8f52ef3577c7eb0fab81045661c8175eaa056"

URI_aarch64_postgresql-plperl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-plperl-16.14-1.el10.aarch64.rpm;name=aarch64_postgresql-plperl;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-plperl}"
SRC_URI[aarch64_postgresql-plperl.sha256sum] = "085b08f0f59a24611aefe76d1fe06b2bfdae726dd8b0fbeebd77f1682fc93199"

URI_aarch64_postgresql-plpython3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-plpython3-16.14-1.el10.aarch64.rpm;name=aarch64_postgresql-plpython3;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-plpython3}"
SRC_URI[aarch64_postgresql-plpython3.sha256sum] = "e68b5dee849d9d3c450a7189af100014d705afbcbb31b1a81644abc4d596ee25"

URI_aarch64_postgresql-pltcl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-pltcl-16.14-1.el10.aarch64.rpm;name=aarch64_postgresql-pltcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-pltcl}"
SRC_URI[aarch64_postgresql-pltcl.sha256sum] = "09367ee0abe2a04bca0c5cf4c9d48ffbd0b476094f3f846ccbb657256e4e1f70"

URI_aarch64_postgresql-private-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-private-devel-16.14-1.el10.aarch64.rpm;name=aarch64_postgresql-private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-private-devel}"
SRC_URI[aarch64_postgresql-private-devel.sha256sum] = "bbc6c508d384f1668cbcb7b9e995c3bbad190d31e1a8f8a64fc612a29586361a"

URI_aarch64_postgresql-private-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-private-libs-16.14-1.el10.aarch64.rpm;name=aarch64_postgresql-private-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-private-libs}"
SRC_URI[aarch64_postgresql-private-libs.sha256sum] = "4e95ffeff2c2c2a003d84bab8dcb09d9cd1be727bfe9237506893f2f5de13331"

URI_aarch64_postgresql-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-server-16.14-1.el10.aarch64.rpm;name=aarch64_postgresql-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-server}"
SRC_URI[aarch64_postgresql-server.sha256sum] = "f1190afbdcdab023576277fd906fb599b20f57ea7e42dcf2aba4026fbff9d91f"

URI_aarch64_postgresql-server-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-server-devel-16.14-1.el10.aarch64.rpm;name=aarch64_postgresql-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-server-devel}"
SRC_URI[aarch64_postgresql-server-devel.sha256sum] = "52b69c8483c98d814e7f16772a7d2a4ed0ea640a0c4dfa0f93b13281c213437b"

URI_aarch64_postgresql-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-static-16.14-1.el10.aarch64.rpm;name=aarch64_postgresql-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-static}"
SRC_URI[aarch64_postgresql-static.sha256sum] = "e5ab6db812f5934b2ec802010e6b42a0bb28eef25f1e9c09b6d7c0b81a6308b5"

URI_aarch64_postgresql-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-test-16.14-1.el10.aarch64.rpm;name=aarch64_postgresql-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-test}"
SRC_URI[aarch64_postgresql-test.sha256sum] = "c2bc917bac1d5d34c99fb3c81f51cbdcfed0b7a82d74890963dbd745db116f6b"

URI_aarch64_postgresql-test-rpm-macros = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/postgresql-test-rpm-macros-16.14-1.el10.noarch.rpm;name=aarch64_postgresql-test-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-test-rpm-macros}"
SRC_URI[aarch64_postgresql-test-rpm-macros.sha256sum] = "baa2056f2721936554eff523eacb21fb548dc8290ceb21f237e08ee2deaed47a"

URI_aarch64_postgresql-upgrade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-upgrade-16.14-1.el10.aarch64.rpm;name=aarch64_postgresql-upgrade;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-upgrade}"
SRC_URI[aarch64_postgresql-upgrade.sha256sum] = "4fe9beb6a28af6296a870612af24200a62c03e65635dc9121b547e92fa55e0e4"

URI_aarch64_postgresql-upgrade-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-upgrade-devel-16.14-1.el10.aarch64.rpm;name=aarch64_postgresql-upgrade-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-upgrade-devel}"
SRC_URI[aarch64_postgresql-upgrade-devel.sha256sum] = "d4948408ce500fed7c60524057270b5fe56a4056abe7f59002168b00bfcf1b3d"

RDEPENDS:postgresql = " \
 glibc \
 libzstd \
 lz4-libs \
 openssl-libs \
 postgresql-private-libs \
 readline \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-contrib = " \
 glibc \
 libselinux \
 libxml2 \
 libxslt \
 libzstd \
 lz4-libs \
 openssl-libs \
 perl-libs \
 postgresql \
 postgresql-private-libs \
 python3-libs \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-docs = " \
 glibc \
 postgresql \
 "
RDEPENDS:postgresql-plperl = " \
 glibc \
 perl-libs \
 postgresql-server \
 "
RDEPENDS:postgresql-plpython3 = " \
 glibc \
 postgresql-server \
 python3-libs \
 "
RDEPENDS:postgresql-pltcl = " \
 glibc \
 postgresql-server \
 tcl \
 "
RDEPENDS:postgresql-private-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 postgresql-private-libs \
 "
RDEPENDS:postgresql-private-libs = " \
 glibc \
 krb5-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:postgresql-server = " \
 bash \
 glibc \
 krb5-libs \
 libicu \
 libxml2 \
 libzstd \
 lz4-libs \
 openldap \
 openssl-libs \
 pam-libs \
 postgresql \
 postgresql-private-libs \
 shadow-utils \
 systemd \
 systemd-libs \
 util-linux \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-server-devel = " \
 bash \
 glibc \
 krb5-devel \
 libicu-devel \
 postgresql-private-devel \
 postgresql-private-libs \
 "
RDEPENDS:postgresql-static = " \
 postgresql-server-devel \
 "
RDEPENDS:postgresql-test = " \
 bash \
 glibc \
 postgresql-contrib \
 postgresql-server \
 postgresql-server-devel \
 "
RDEPENDS:postgresql-test-rpm-macros = " \
 postgresql-server \
 "
RDEPENDS:postgresql-upgrade = " \
 glibc \
 krb5-libs \
 libicu \
 libselinux \
 libxml2 \
 libxslt \
 openldap \
 openssl-libs \
 pam-libs \
 perl-libs \
 postgresql-private-libs \
 postgresql-server \
 python3-libs \
 tcl \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-upgrade-devel = " \
 bash \
 glibc \
 postgresql-upgrade \
 "
