# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-puerkitobio-urlesc"
PV = "0"
PR = "17.20190628gitde5bf2a.el10_0"
PACKAGES = " \
 golang-github-puerkitobio-urlesc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-puerkitobio-urlesc-0-17.20190628gitde5bf2a.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23c68a9365bc02d02259c4d635d552264d4a103c5cf941e56d4b8d1914c4403b"

URI_aarch64_golang-github-puerkitobio-urlesc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-puerkitobio-urlesc-devel-0-17.20190628gitde5bf2a.el10_0.noarch.rpm;name=aarch64_golang-github-puerkitobio-urlesc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-puerkitobio-urlesc-devel}"
SRC_URI[aarch64_golang-github-puerkitobio-urlesc-devel.sha256sum] = "1828ed3207d8b74e1b302ccff9db1fca92ea061e21ba661c8c03c810a5e07e0b"

RDEPENDS:golang-github-puerkitobio-urlesc-devel = " \
 go-filesystem \
 "
