# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librsync"
PV = "2.3.4"
PR = "5.el10_0"
PACKAGES = " \
 librsync \
 librsync-devel \
 librsync-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/librsync-2.3.4-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96fafa402fb9cb832243f8263e0adb7ac16a7486f6d4b70bee2a08d20baa72ba"

URI_x86_64_v2_librsync = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librsync-2.3.4-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librsync;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librsync}"
SRC_URI[x86_64_v2_librsync.sha256sum] = "b95ee6c7ab2f80957222679afbd7999931a214cd5b94d61ee3f99ea54caa5bf7"

URI_x86_64_v2_librsync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librsync-devel-2.3.4-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librsync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librsync-devel}"
SRC_URI[x86_64_v2_librsync-devel.sha256sum] = "022d0cc2ed3374855d214c78a4b727ce37c341f053cb67573b017ea316c23826"

URI_x86_64_v2_librsync-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librsync-doc-2.3.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_librsync-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librsync-doc}"
SRC_URI[x86_64_v2_librsync-doc.sha256sum] = "1f7a756193b5f95deeaf7f9a66a4f695b96a2e64b30ee2403a54b73433e4531a"

URI_aarch64_librsync = "${EPEL_MIRROR}/aarch64/Packages/l/librsync-2.3.4-5.el10_0.aarch64.rpm;name=aarch64_librsync;unpack=0"
SRC_URI:append = " ${URI_aarch64_librsync}"
SRC_URI[aarch64_librsync.sha256sum] = "b714658f7d869c0aca52fe8265b02d67a038f5151b0da72693a6058d688ca9cb"

URI_aarch64_librsync-devel = "${EPEL_MIRROR}/aarch64/Packages/l/librsync-devel-2.3.4-5.el10_0.aarch64.rpm;name=aarch64_librsync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librsync-devel}"
SRC_URI[aarch64_librsync-devel.sha256sum] = "010f2c28c100fa57373ef79044ec9b7427230419eeb6dc4c5803dbb4ed9d7e0e"

URI_aarch64_librsync-doc = "${EPEL_MIRROR}/aarch64/Packages/l/librsync-doc-2.3.4-5.el10_0.noarch.rpm;name=aarch64_librsync-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_librsync-doc}"
SRC_URI[aarch64_librsync-doc.sha256sum] = "4636a4c42c1a0932ddc79f6031a1bc2b196d926e9749ac98954dd0d6999c7a46"

RDEPENDS:librsync = " \
 glibc \
 popt \
 "
RDEPENDS:librsync-devel = " \
 librsync \
 "
RDEPENDS:librsync-doc = " \
 "
