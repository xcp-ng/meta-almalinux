# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cairosvg"
PV = "2.9.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-cairosvg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cairosvg-2.9.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7936c7e5e94ea4e025a75a0918ff02661bc4843e570d8e4809e29da6dc7513e"

URI_x86_64_v2_python3-cairosvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cairosvg-2.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cairosvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cairosvg}"
SRC_URI[x86_64_v2_python3-cairosvg.sha256sum] = "4e088af8718f5ece41cb3ac5057edb08b2ebf9b05b65848d39458236dd909a2a"

URI_aarch64_python3-cairosvg = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cairosvg-2.9.0-1.el10_2.noarch.rpm;name=aarch64_python3-cairosvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cairosvg}"
SRC_URI[aarch64_python3-cairosvg.sha256sum] = "46f26387d6637b2e595c07a493cb485f9315ef568856b1f7c3ee373e09dc2692"

RDEPENDS:python3-cairosvg = " \
 python3 \
 python3-cairocffi \
 python3-cssselect2 \
 python3-defusedxml \
 python3-pillow \
 python3-tinycss2 \
 "
