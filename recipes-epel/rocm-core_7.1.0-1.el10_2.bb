# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-core"
PV = "7.1.0"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 rocm-core \
 rocm-core-devel \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rocm-core-7.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "76c3e6384c0af93ffdcf6278d034a0291baf826998fe242d81b73f15d4dc089b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-core-7.1.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-core;unpack=0"
SRC_URI[x86_64_v2_rocm-core.sha256sum] = "c62df6f0c41529870e56b76eb3d2cd5041ad4fae95ebf3fdee32a99c5b612fe4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-core-devel-7.1.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-core-devel;unpack=0"
SRC_URI[x86_64_v2_rocm-core-devel.sha256sum] = "54243f896e3a7630ae0e122f85ced0bd3b275bf83ada5428cdae337c68e6d41c"

RDEPENDS:rocm-core = " \
 glibc \
 "
RDEPENDS:rocm-core-devel = " \
 cmake-filesystem \
 rocm-core \
 "
