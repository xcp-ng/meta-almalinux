# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apptainer"
PV = "1.5.0"
PR = "1.el10_1"
PACKAGES = " \
 apptainer \
 apptainer-suid \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/apptainer-1.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34e32261031671d3169e97d172a5264b0f8cdfe382a049f1c9c0f2a538db5754"

URI_x86_64_v2_apptainer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apptainer-1.5.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apptainer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apptainer}"
SRC_URI[x86_64_v2_apptainer.sha256sum] = "582fcb90bf9efb031e6d3c10540022d7d2f87d7f06a7717183faad29f789bcc9"

URI_x86_64_v2_apptainer-suid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apptainer-suid-1.5.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apptainer-suid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apptainer-suid}"
SRC_URI[x86_64_v2_apptainer-suid.sha256sum] = "2da12d5783ae2712dc872fc5fff3cd38fc9e2ec4daa0e5b13753b06c9e7df4f4"

URI_aarch64_apptainer = "${EPEL_MIRROR}/aarch64/Packages/a/apptainer-1.5.0-1.el10_1.aarch64.rpm;name=aarch64_apptainer;unpack=0"
SRC_URI:append = " ${URI_aarch64_apptainer}"
SRC_URI[aarch64_apptainer.sha256sum] = "945b89308ee7465781cc04eb12d209cf50ac734630eb99258b5bc4d1042a9754"

URI_aarch64_apptainer-suid = "${EPEL_MIRROR}/aarch64/Packages/a/apptainer-suid-1.5.0-1.el10_1.aarch64.rpm;name=aarch64_apptainer-suid;unpack=0"
SRC_URI:append = " ${URI_aarch64_apptainer-suid}"
SRC_URI[aarch64_apptainer-suid.sha256sum] = "7e92e0cb95381201f6e3b0236a498bda175cd66b33cb1cf4e2a412af5198c152"

RDEPENDS:apptainer = " \
 bash \
 fakeroot \
 fuse3-libs \
 glibc \
 libgcc \
 libseccomp \
 libtalloc \
 libzstd \
 lz4-libs \
 lzo \
 protobuf-c \
 shadow-utils-subid \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:apptainer-suid = " \
 apptainer \
 fuse3-libs \
 glibc \
 libseccomp \
 shadow-utils-subid \
 "
