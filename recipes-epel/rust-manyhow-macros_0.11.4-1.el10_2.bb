# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-manyhow-macros"
PV = "0.11.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-manyhow-macros+default-devel \
 rust-manyhow-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-manyhow-macros-0.11.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b104cbb4ed6a2aa1c41da1d7836ccd86aa5cfb3093967b244959c2f25758335"

URI_x86_64_v2_rust-manyhow-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-manyhow-macros+default-devel-0.11.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-manyhow-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-manyhow-macros+default-devel}"
SRC_URI[x86_64_v2_rust-manyhow-macros+default-devel.sha256sum] = "1061b0e6f168088e6a80665df9ed10c613507e34d22827310f476cd31a13341e"

URI_x86_64_v2_rust-manyhow-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-manyhow-macros-devel-0.11.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-manyhow-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-manyhow-macros-devel}"
SRC_URI[x86_64_v2_rust-manyhow-macros-devel.sha256sum] = "374a30c8dc8305e58251d57ee2885c94cca6668d8d27afa9183c719ea388bd39"

URI_aarch64_rust-manyhow-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-manyhow-macros+default-devel-0.11.4-1.el10_2.noarch.rpm;name=aarch64_rust-manyhow-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-manyhow-macros+default-devel}"
SRC_URI[aarch64_rust-manyhow-macros+default-devel.sha256sum] = "694d9c480082a8137cc00f97822f596745f003871abb45911af0ebfe2d8f0c62"

URI_aarch64_rust-manyhow-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-manyhow-macros-devel-0.11.4-1.el10_2.noarch.rpm;name=aarch64_rust-manyhow-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-manyhow-macros-devel}"
SRC_URI[aarch64_rust-manyhow-macros-devel.sha256sum] = "02b13f1ab8a8e40eec1d85b586512bc178ce3bb261b5f3df4b68829873157e1c"

RDEPENDS:rust-manyhow-macros+default-devel = " \
 cargo \
 rust-manyhow-macros-devel \
 "
RDEPENDS:rust-manyhow-macros-devel = " \
 cargo \
 rust-proc-macro-utils+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
