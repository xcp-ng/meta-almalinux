# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lxcfs"
PV = "6.0.6"
PR = "1.el10_1"
PACKAGES = " \
 lxcfs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/lxcfs-6.0.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b0599f31fc0b1c64c07d8b397ae9d4a49748c610e076e76f472d2eb87b49a6a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxcfs-6.0.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxcfs;unpack=0"
SRC_URI[x86_64_v2_lxcfs.sha256sum] = "d7ea4e0aeace75d1fe67c79ac4f7e750494896118ab699737be109c5b464af9e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lxcfs-6.0.6-1.el10_1.aarch64.rpm;name=aarch64_lxcfs;unpack=0"
SRC_URI[aarch64_lxcfs.sha256sum] = "d73512d7e748398b1ebd85373fa3149cc583f1816b38f75344a7810abee8c233"

RDEPENDS:lxcfs = " \
 bash \
 fuse3-libs \
 glibc \
 libgcc \
 lxc-templates \
 systemd \
 "
