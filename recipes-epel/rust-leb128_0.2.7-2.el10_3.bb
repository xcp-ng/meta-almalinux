# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-leb128"
PV = "0.2.7"
PR = "2.el10_3"
PACKAGES = " \
 leb128 \
 rust-leb128+default-devel \
 rust-leb128+nightly-devel \
 rust-leb128-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-leb128-0.2.7-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e458caf5967bb6abb270d9f84a1e519fc7d7acb07e9451d193d7c2527260aa51"

URI_x86_64_v2_leb128 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/leb128-0.2.7-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_leb128;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_leb128}"
SRC_URI[x86_64_v2_leb128.sha256sum] = "6d529a52557931491fbda9baaa9f0b5244b30c76ff2bfbca83473821d9f756e1"

URI_x86_64_v2_rust-leb128+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-leb128+default-devel-0.2.7-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-leb128+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-leb128+default-devel}"
SRC_URI[x86_64_v2_rust-leb128+default-devel.sha256sum] = "2f6d99d08b4a9e7fcd5507be5289e93fa2d76e209cbacabb20b698fc84bc7d86"

URI_x86_64_v2_rust-leb128+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-leb128+nightly-devel-0.2.7-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-leb128+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-leb128+nightly-devel}"
SRC_URI[x86_64_v2_rust-leb128+nightly-devel.sha256sum] = "964cb1acdd719362a6ea6f685d8366c79a71611c91af579b2fc3e98d44dca795"

URI_x86_64_v2_rust-leb128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-leb128-devel-0.2.7-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-leb128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-leb128-devel}"
SRC_URI[x86_64_v2_rust-leb128-devel.sha256sum] = "b2cfdee52c4047deec734cd9f523917d32b1740b118af533fea00379ffee583c"

URI_aarch64_leb128 = "${EPEL_MIRROR}/aarch64/Packages/l/leb128-0.2.7-2.el10_3.aarch64.rpm;name=aarch64_leb128;unpack=0"
SRC_URI:append = " ${URI_aarch64_leb128}"
SRC_URI[aarch64_leb128.sha256sum] = "b7c87f3372d732a2d7a9ec411f95fe2b467f5096ceeb3a9c763b7ba04f72af11"

URI_aarch64_rust-leb128+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-leb128+default-devel-0.2.7-2.el10_3.noarch.rpm;name=aarch64_rust-leb128+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-leb128+default-devel}"
SRC_URI[aarch64_rust-leb128+default-devel.sha256sum] = "b47c0238eff209307b5ae55e710b8da16fe740359b140fc1179513730bacfb49"

URI_aarch64_rust-leb128+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-leb128+nightly-devel-0.2.7-2.el10_3.noarch.rpm;name=aarch64_rust-leb128+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-leb128+nightly-devel}"
SRC_URI[aarch64_rust-leb128+nightly-devel.sha256sum] = "94141e16bdeeb0dd65c246898a1b6e425fae3a0eabd1c0031e875f3f728ce11c"

URI_aarch64_rust-leb128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-leb128-devel-0.2.7-2.el10_3.noarch.rpm;name=aarch64_rust-leb128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-leb128-devel}"
SRC_URI[aarch64_rust-leb128-devel.sha256sum] = "85d5e9639208606efc6326ae29cf6174433756dad2abbc3b200980e01823fae1"

RDEPENDS:leb128 = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-leb128+default-devel = " \
 cargo \
 rust-leb128-devel \
 "
RDEPENDS:rust-leb128+nightly-devel = " \
 cargo \
 rust-leb128-devel \
 "
RDEPENDS:rust-leb128-devel = " \
 cargo \
 "
