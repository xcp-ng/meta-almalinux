# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crun"
PV = "1.28"
PR = "1.el10"
PACKAGES = " \
 crun \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/crun-1.28-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e331812fdbafd03500ab0acac7fa0d6e0a46bb3b6e112272de3407852c463e4f"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - crun: libcap.so.2()(64bit)

URI_x86_64_v2_crun = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crun-1.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_crun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crun}"
SRC_URI[x86_64_v2_crun.sha256sum] = "ac69d9242360310b1779be152c40e350c81233dd7c81a54cc9dcf4010de310cd"
RPROVIDES:crun:x86_64_v2 = "virtual/oci-runtime"

URI_aarch64_crun = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crun-1.28-1.el10.aarch64.rpm;name=aarch64_crun;unpack=0"
SRC_URI:append = " ${URI_aarch64_crun}"
SRC_URI[aarch64_crun.sha256sum] = "7c7bc1fd7ceae06bb5e50df82a126c5bcbf6bd33611f995c0914be53f6b2f22c"
RPROVIDES:crun:aarch64 = "virtual/oci-runtime"

RDEPENDS:crun:x86_64_v2 = " \
 container-selinux \
 glibc \
 json-c \
 libcap \
 libgcc \
 libseccomp \
 systemd-libs \
"
RDEPENDS:crun:aarch64 = " \
 container-selinux \
 glibc \
 json-c \
 libgcc \
 libseccomp \
 systemd-libs \
"

PROVIDES:append:x86_64_v2 = " rpm/virtual/oci-runtime"

PROVIDES:append:aarch64 = " rpm/virtual/oci-runtime"
