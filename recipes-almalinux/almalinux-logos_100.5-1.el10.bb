# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "almalinux-logos"
PV = "100.5"
PR = "1.el10"
PACKAGES = " \
 almalinux-backgrounds \
 almalinux-logos \
 almalinux-logos-httpd \
 almalinux-logos-ipa \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/almalinux-logos-100.5-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9d82c17621ae7b66d6584a97d6518a67ac7c676c51f0d6e6343fea5f3712cf52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/almalinux-backgrounds-100.5-1.el10.noarch.rpm;name=x86_64_v2_almalinux-backgrounds;unpack=0"
SRC_URI[x86_64_v2_almalinux-backgrounds.sha256sum] = "0121a1394359a006d2422d97e064643824654cd2312dc459f3d2e0cd14c73b31"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/almalinux-logos-100.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_almalinux-logos;unpack=0"
SRC_URI[x86_64_v2_almalinux-logos.sha256sum] = "117c2f25d4c96bdeaee6677402a196bfb97dac6f1edb139e9b3873d338f476f6"
RPROVIDES:almalinux-logos:append:x86_64_v2 = " virtual/desktop-backgrounds-compat virtual/system-backgrounds-kde"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/almalinux-logos-httpd-100.5-1.el10.noarch.rpm;name=x86_64_v2_almalinux-logos-httpd;unpack=0"
SRC_URI[x86_64_v2_almalinux-logos-httpd.sha256sum] = "d175ab4a0868a92f3f4b8dad1e16d1492ee6f435f09e8579d9505f2348b6014b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/almalinux-logos-ipa-100.5-1.el10.noarch.rpm;name=x86_64_v2_almalinux-logos-ipa;unpack=0"
SRC_URI[x86_64_v2_almalinux-logos-ipa.sha256sum] = "ec55adfe69eeba5c5109a76126e29d7efbff48ca4fed2371a87f342bedf8a2f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/almalinux-backgrounds-100.5-1.el10.noarch.rpm;name=aarch64_almalinux-backgrounds;unpack=0"
SRC_URI[aarch64_almalinux-backgrounds.sha256sum] = "0121a1394359a006d2422d97e064643824654cd2312dc459f3d2e0cd14c73b31"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/almalinux-logos-100.5-1.el10.aarch64.rpm;name=aarch64_almalinux-logos;unpack=0"
SRC_URI[aarch64_almalinux-logos.sha256sum] = "bf8dee8041bb96242fb218e184ede036a16491eb4a9b8cfddc62a5bd2739e400"
RPROVIDES:almalinux-logos:append:aarch64 = " virtual/desktop-backgrounds-compat virtual/system-backgrounds-kde"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/almalinux-logos-httpd-100.5-1.el10.noarch.rpm;name=aarch64_almalinux-logos-httpd;unpack=0"
SRC_URI[aarch64_almalinux-logos-httpd.sha256sum] = "d175ab4a0868a92f3f4b8dad1e16d1492ee6f435f09e8579d9505f2348b6014b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/almalinux-logos-ipa-100.5-1.el10.noarch.rpm;name=aarch64_almalinux-logos-ipa;unpack=0"
SRC_URI[aarch64_almalinux-logos-ipa.sha256sum] = "ec55adfe69eeba5c5109a76126e29d7efbff48ca4fed2371a87f342bedf8a2f2"

RDEPENDS:almalinux-backgrounds = " \
 almalinux-logos \
 "
RDEPENDS:almalinux-logos = " \
 bash \
 virtual/coreutils \
 "
RDEPENDS:almalinux-logos-httpd = " \
 "
RDEPENDS:almalinux-logos-ipa = " \
 "
