# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chromium"
PV = "151.0.7922.169"
PR = "1.el10_3"
PACKAGES = " \
 chromedriver \
 chromium \
 chromium-common \
 chromium-headless \
 chromium-qt5-ui \
 chromium-qt6-ui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/chromium-151.0.7922.169-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f705c06c93e88196c83d97cb12b94c511f5d90d015deaa6a699538eb4253641"

URI_aarch64_chromedriver = "${EPEL_MIRROR}/aarch64/Packages/c/chromedriver-151.0.7922.169-1.el10_3.aarch64.rpm;name=aarch64_chromedriver;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromedriver}"
SRC_URI[aarch64_chromedriver.sha256sum] = "0a22848043fca3eb72a1694e397d060cdb056053c82404b76bb821ec661aa743"

URI_aarch64_chromium = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-151.0.7922.169-1.el10_3.aarch64.rpm;name=aarch64_chromium;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium}"
SRC_URI[aarch64_chromium.sha256sum] = "a1f7226ad2576d9021990c1425f61bb0cbcca97cc8d3434273efaa71643ff2d8"

URI_aarch64_chromium-common = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-common-151.0.7922.169-1.el10_3.aarch64.rpm;name=aarch64_chromium-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-common}"
SRC_URI[aarch64_chromium-common.sha256sum] = "c28568dd3a3f111b18e782dcc2660986d6a4668de979b047e9abb774b6d5c9ff"

URI_aarch64_chromium-headless = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-headless-151.0.7922.169-1.el10_3.aarch64.rpm;name=aarch64_chromium-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-headless}"
SRC_URI[aarch64_chromium-headless.sha256sum] = "8604142bf0831624bd1c19e115d8e4dfa503689d4ed2b004510b3fbb48dc8665"

URI_aarch64_chromium-qt5-ui = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-qt5-ui-151.0.7922.169-1.el10_3.aarch64.rpm;name=aarch64_chromium-qt5-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-qt5-ui}"
SRC_URI[aarch64_chromium-qt5-ui.sha256sum] = "2fc3d016f81d95aa76caf7617eca6069c95debdd7b6aecfa545a128199b5d023"

URI_aarch64_chromium-qt6-ui = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-qt6-ui-151.0.7922.169-1.el10_3.aarch64.rpm;name=aarch64_chromium-qt6-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-qt6-ui}"
SRC_URI[aarch64_chromium-qt6-ui.sha256sum] = "fcfb081cdb284a693bab4a7e7799801166f53776c3feb692af95e57f62db536f"

RDEPENDS:chromedriver = " \
 chromium-common \
 double-conversion \
 glib2 \
 glibc \
 libbrotli \
 libgcc \
 libxcb \
 libzstd \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:chromium = " \
 alsa-lib \
 at-spi2-atk \
 at-spi2-core \
 atk \
 bash \
 cairo \
 chromium-common \
 cups-libs \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 gtk4 \
 harfbuzz \
 lcms2 \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbrotli \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libusb1 \
 libwebp \
 libxcb \
 libxkbcommon \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-mdns \
 nss-util \
 openjpeg2 \
 opus \
 pango \
 pipewire-libs \
 policycoreutils \
 policycoreutils-python-utils \
 systemd-libs \
 "
RDEPENDS:chromium-common = " \
 glibc \
 libgcc \
 "
RDEPENDS:chromium-headless = " \
 alsa-lib \
 at-spi2-core \
 atk \
 chromium-common \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 harfbuzz \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbrotli \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libwebp \
 libxcb \
 libxkbcommon \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-util \
 opus \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:chromium-qt5-ui = " \
 chromium \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:chromium-qt6-ui = " \
 chromium \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
