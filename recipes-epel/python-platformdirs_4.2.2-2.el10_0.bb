# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-platformdirs"
PV = "4.2.2"
PR = "2.el10_0"
PACKAGES = " \
 python3-platformdirs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-platformdirs-4.2.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b18d8bb7e35f5c1a0961162b299d3adabef02bba69e32c31ef83cc98caf1c85"

URI_x86_64_v2_python3-platformdirs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-platformdirs-4.2.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-platformdirs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-platformdirs}"
SRC_URI[x86_64_v2_python3-platformdirs.sha256sum] = "52e3b1887fb6e03b18b23c679a51bee19aa1f50570ae20ac7413ffa66464d9b6"

URI_aarch64_python3-platformdirs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-platformdirs-4.2.2-2.el10_0.noarch.rpm;name=aarch64_python3-platformdirs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-platformdirs}"
SRC_URI[aarch64_python3-platformdirs.sha256sum] = "a2df000703daa151df42e1e16db80e5c151d28c883f54bbf839f75aa53dac37e"

RDEPENDS:python3-platformdirs = " \
 python3 \
 "
