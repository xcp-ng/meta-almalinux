# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gd"
PV = "2.3.3"
PR = "20.el10_0"
PACKAGES = " \
 gd \
 gd-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gd-2.3.3-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cabd68275825bc0b2590a24098202a4075e8c7d562d74e761525eb21164f7f6"

URI_x86_64_v2_gd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gd-2.3.3-20.el10_0.x86_64_v2.rpm;name=x86_64_v2_gd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gd}"
SRC_URI[x86_64_v2_gd.sha256sum] = "637b324de27b54360de5b7a033ab09012bbf020cd9a107c3e71e121caee264fa"

URI_x86_64_v2_gd-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gd-devel-2.3.3-20.el10_0.x86_64_v2.rpm;name=x86_64_v2_gd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gd-devel}"
SRC_URI[x86_64_v2_gd-devel.sha256sum] = "c2b183560f0e4af235cf8cb3772c78675ffb96b69ea2eccc32aa8460a7beafaa"

URI_aarch64_gd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gd-2.3.3-20.el10_0.aarch64.rpm;name=aarch64_gd;unpack=0"
SRC_URI:append = " ${URI_aarch64_gd}"
SRC_URI[aarch64_gd.sha256sum] = "e2c516f01c2a547e2e3654af6cd7e71cfa07f8146c532576a27af3cf4a18482f"

URI_aarch64_gd-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gd-devel-2.3.3-20.el10_0.aarch64.rpm;name=aarch64_gd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gd-devel}"
SRC_URI[aarch64_gd-devel.sha256sum] = "62b7397d7d4f036db1b8956812b4e21a1769a0843b3600437990d203b058b7f6"

RDEPENDS:gd = " \
 fontconfig \
 freetype \
 glibc \
 libX11 \
 libXpm \
 libjpeg-turbo \
 libpng \
 libtiff \
 libwebp \
 zlib-ng-compat \
 "
RDEPENDS:gd-devel = " \
 fontconfig-devel \
 freetype-devel \
 gd \
 libX11-devel \
 libXpm-devel \
 libjpeg-turbo-devel \
 libpng-devel \
 libtiff-devel \
 libwebp-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
