# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-diskus"
PV = "0.9.0"
PR = "3.el10_1"
PACKAGES = " \
 diskus \
 rust-diskus+cli-devel \
 rust-diskus+default-devel \
 rust-diskus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-diskus-0.9.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8cc062de86e3593a75e0ab90dd5313cb080fdacc3b55b6e662318f3268987f1"

URI_x86_64_v2_diskus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/diskus-0.9.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_diskus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_diskus}"
SRC_URI[x86_64_v2_diskus.sha256sum] = "dd485c617d53f80755887190c7def06741f67d08f69a49cdd71be6876307e75f"

URI_x86_64_v2_rust-diskus+cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-diskus+cli-devel-0.9.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-diskus+cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-diskus+cli-devel}"
SRC_URI[x86_64_v2_rust-diskus+cli-devel.sha256sum] = "2e5f3ec5b281c4e86d13f810f5c58c83235323ea8483a81aa3d6fcdc4286a078"

URI_x86_64_v2_rust-diskus+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-diskus+default-devel-0.9.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-diskus+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-diskus+default-devel}"
SRC_URI[x86_64_v2_rust-diskus+default-devel.sha256sum] = "bdea91423a1b5be21b190050da5fba58f07bc08f1b2fac03434f8d361ec0abab"

URI_x86_64_v2_rust-diskus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-diskus-devel-0.9.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-diskus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-diskus-devel}"
SRC_URI[x86_64_v2_rust-diskus-devel.sha256sum] = "7336b2f623d6acded30f8fab16f83b9707be9a3fc104f019f79efe19f2f89d6f"

URI_aarch64_diskus = "${EPEL_MIRROR}/aarch64/Packages/d/diskus-0.9.0-3.el10_1.aarch64.rpm;name=aarch64_diskus;unpack=0"
SRC_URI:append = " ${URI_aarch64_diskus}"
SRC_URI[aarch64_diskus.sha256sum] = "2516b49a5662789facd02212eedef61874b49192a69607a7eda7ffaf3d343b46"

URI_aarch64_rust-diskus+cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-diskus+cli-devel-0.9.0-3.el10_1.noarch.rpm;name=aarch64_rust-diskus+cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-diskus+cli-devel}"
SRC_URI[aarch64_rust-diskus+cli-devel.sha256sum] = "88ee88088b273750ff58a51b6c7379e8b604b1943f899315a4f0c8f06ed47164"

URI_aarch64_rust-diskus+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-diskus+default-devel-0.9.0-3.el10_1.noarch.rpm;name=aarch64_rust-diskus+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-diskus+default-devel}"
SRC_URI[aarch64_rust-diskus+default-devel.sha256sum] = "d91fea258afcc1c861e01a17d35c148ea36186bc531c63cf27f6aa72b83fa693"

URI_aarch64_rust-diskus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-diskus-devel-0.9.0-3.el10_1.noarch.rpm;name=aarch64_rust-diskus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-diskus-devel}"
SRC_URI[aarch64_rust-diskus-devel.sha256sum] = "e53bd59d2423a3051a9eab9fd3e48f024bf30d9562aa185137237678becd6e3d"

RDEPENDS:diskus = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-diskus+cli-devel = " \
 cargo \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+suggestions-devel \
 rust-clap+wrap_help-devel \
 rust-diskus-devel \
 rust-humansize+default-devel \
 rust-num-format+default-devel \
 "
RDEPENDS:rust-diskus+default-devel = " \
 cargo \
 rust-diskus+cli-devel \
 rust-diskus-devel \
 "
RDEPENDS:rust-diskus-devel = " \
 cargo \
 rust \
 rust-crossbeam-channel+default-devel \
 rust-rayon+default-devel \
 "
