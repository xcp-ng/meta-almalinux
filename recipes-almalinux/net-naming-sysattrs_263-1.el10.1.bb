# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "net-naming-sysattrs"
PV = "263"
PR = "1.el10.1"
PACKAGES = " \
 net-naming-sysattrs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/net-naming-sysattrs-263-1.el10.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50e83c61a6e48b73a03133c8597ebe50411fd626bb8fcfc181c75b7a42e385ad"

URI_x86_64_v2_net-naming-sysattrs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/net-naming-sysattrs-263-1.el10.1.noarch.rpm;name=x86_64_v2_net-naming-sysattrs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-naming-sysattrs}"
SRC_URI[x86_64_v2_net-naming-sysattrs.sha256sum] = "2b295119db5471276c990c34ec0a7804ef96c282345e5d4d01d5eb4985e153ab"

URI_aarch64_net-naming-sysattrs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/net-naming-sysattrs-263-1.el10.1.noarch.rpm;name=aarch64_net-naming-sysattrs;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-naming-sysattrs}"
SRC_URI[aarch64_net-naming-sysattrs.sha256sum] = "2b295119db5471276c990c34ec0a7804ef96c282345e5d4d01d5eb4985e153ab"

RDEPENDS:net-naming-sysattrs = " \
 bash \
 dracut \
 systemd-udev \
 "
