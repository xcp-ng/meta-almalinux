# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pim-sieve-editor"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 pim-sieve-editor \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pim-sieve-editor-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "04414013c5fb8723cb24ce991b279176ecf1fb51d92ee12a06287c6e3431db58"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pim-sieve-editor-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pim-sieve-editor;unpack=0"
SRC_URI[x86_64_v2_pim-sieve-editor.sha256sum] = "f3d7cf4d840a9d2de60b60bb47a1d7d93e519a1b8720f991ce18a044c8334a27"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pim-sieve-editor-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_pim-sieve-editor;unpack=0"
SRC_URI[aarch64_pim-sieve-editor.sha256sum] = "eb810c7ed88bac83ae9a0b518aa7f9fa4b604b59ae02d8a50a5633bd303ae5d5"

RDEPENDS:pim-sieve-editor = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kmailtransport \
 ktextaddons-qt6 \
 libksieve \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
