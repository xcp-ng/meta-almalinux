# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openssl"
PE = "1"
PV = "3.2.2"
PR = "16.el10_0.4.alma.1"
PACKAGES = " \
 openssl \
 openssl-devel \
 openssl-libs \
 openssl-perl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openssl-3.2.2-16.el10_0.4.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6125da460ec83736af5ce6dbaf0593692175fed73ff40fd7e548bef33b390165"

URI_x86_64_v2_openssl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-3.2.2-16.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl}"
SRC_URI[x86_64_v2_openssl.sha256sum] = "f9a00323dc0f3faada1e8b61ddf885c4118c63ed9c4df322229737ced6ec102f"

URI_x86_64_v2_openssl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssl-devel-3.2.2-16.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-devel}"
SRC_URI[x86_64_v2_openssl-devel.sha256sum] = "97f57f18ea3ff8ed1b0de6d8162f1dbee4198ef6a55cbefd7a70cd984241e686"

URI_x86_64_v2_openssl-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-libs-3.2.2-16.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-libs}"
SRC_URI[x86_64_v2_openssl-libs.sha256sum] = "e5bc310f9691a35e77babba26c6309bc5529ac5371900a6150043cca9b6693c1"

URI_x86_64_v2_openssl-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssl-perl-3.2.2-16.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-perl}"
SRC_URI[x86_64_v2_openssl-perl.sha256sum] = "b4758606304d0ef233d12078edb6d272b0e5ee20966d9503d87cc9755faaeae6"

URI_aarch64_openssl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-3.2.2-16.el10_0.4.alma.1.aarch64.rpm;name=aarch64_openssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl}"
SRC_URI[aarch64_openssl.sha256sum] = "0651dc828364f57997addc04cc677393d6a4b3a9e12f6a1fd1aafac3498015ec"

URI_aarch64_openssl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssl-devel-3.2.2-16.el10_0.4.alma.1.aarch64.rpm;name=aarch64_openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-devel}"
SRC_URI[aarch64_openssl-devel.sha256sum] = "c6a1ebc168544f941502d60865b01539bfcce8762ad760d4ad837d651fdf9e26"

URI_aarch64_openssl-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-libs-3.2.2-16.el10_0.4.alma.1.aarch64.rpm;name=aarch64_openssl-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-libs}"
SRC_URI[aarch64_openssl-libs.sha256sum] = "174f26db9918739d9359a355ecd8d21495e1f8b2104d31d7112a5382a457a842"

URI_aarch64_openssl-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssl-perl-3.2.2-16.el10_0.4.alma.1.aarch64.rpm;name=aarch64_openssl-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-perl}"
SRC_URI[aarch64_openssl-perl.sha256sum] = "52adba8a11069cb20993d282262fca5cca586777337f586cb704287b3f4d67b4"

RDEPENDS:openssl = " \
 bash \
 glibc \
 openssl-libs \
 virtual/coreutils \
 "
RDEPENDS:openssl-devel = " \
 openssl-devel \
 openssl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openssl-libs = " \
 ca-certificates \
 crypto-policies \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:openssl-perl = " \
 openssl \
 perl-interpreter \
 "
