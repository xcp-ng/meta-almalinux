# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-schemars_derive0.8"
PV = "0.8.22"
PR = "1.el10_1"
PACKAGES = " \
 rust-schemars_derive0.8+default-devel \
 rust-schemars_derive0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-schemars_derive0.8-0.8.22-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f4c6fe0b9546ced48de746e0f83f5b53fd3e2500f11274cf8d1c299b33842b8"

URI_x86_64_v2_rust-schemars_derive0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars_derive0.8+default-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars_derive0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars_derive0.8+default-devel}"
SRC_URI[x86_64_v2_rust-schemars_derive0.8+default-devel.sha256sum] = "6a8dee556287c43acdbd6b605eff41733cb05cb71276cc1a0ba73496924b8ec6"

URI_x86_64_v2_rust-schemars_derive0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars_derive0.8-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars_derive0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars_derive0.8-devel}"
SRC_URI[x86_64_v2_rust-schemars_derive0.8-devel.sha256sum] = "58c5d6a24813832dcfd75a01f0fb8719020b961dbe4d2d0c79e3c635559a8c93"

URI_aarch64_rust-schemars_derive0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars_derive0.8+default-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars_derive0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars_derive0.8+default-devel}"
SRC_URI[aarch64_rust-schemars_derive0.8+default-devel.sha256sum] = "6f0393faf066326ed8d830aa4191716ea8fcf3dc3c38d2359c32d2b3c58f32ae"

URI_aarch64_rust-schemars_derive0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars_derive0.8-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars_derive0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars_derive0.8-devel}"
SRC_URI[aarch64_rust-schemars_derive0.8-devel.sha256sum] = "c0e20d3db2794984e9481682f8a8a9346560b8d458a07cbe7d237a091da9541e"

RDEPENDS:rust-schemars_derive0.8+default-devel = " \
 cargo \
 rust-schemars_derive0.8-devel \
 "
RDEPENDS:rust-schemars_derive0.8-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-serde_derive_internals+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 "
