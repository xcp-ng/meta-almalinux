# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blobby"
PV = "0.3.1"
PR = "8.el10_0"
PACKAGES = " \
 rust-blobby+default-devel \
 rust-blobby-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blobby-0.3.1-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5ae926091ec6096a17e8aebe93f3ab699716e55ebca3fc10767a87303abf81e"

URI_x86_64_v2_rust-blobby+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blobby+default-devel-0.3.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blobby+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blobby+default-devel}"
SRC_URI[x86_64_v2_rust-blobby+default-devel.sha256sum] = "327805c70a5039e9977698f6c623f87e4b9407385e7391b56a201525e2e7fa7c"

URI_x86_64_v2_rust-blobby-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blobby-devel-0.3.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blobby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blobby-devel}"
SRC_URI[x86_64_v2_rust-blobby-devel.sha256sum] = "dfef4b3466dc43273db48f694f68b855c8c5c1a1ddd892427afca175a7000389"

URI_aarch64_rust-blobby+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blobby+default-devel-0.3.1-8.el10_0.noarch.rpm;name=aarch64_rust-blobby+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blobby+default-devel}"
SRC_URI[aarch64_rust-blobby+default-devel.sha256sum] = "c70ae27e309e9b719b8fcc326ee9cf981237dae6d222db6f58cac49a4a76f4d3"

URI_aarch64_rust-blobby-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blobby-devel-0.3.1-8.el10_0.noarch.rpm;name=aarch64_rust-blobby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blobby-devel}"
SRC_URI[aarch64_rust-blobby-devel.sha256sum] = "0fad6d5d57e2224807be965b7762538e0a0872e0d5db928768602f1d1a88f54d"

RDEPENDS:rust-blobby+default-devel = " \
 cargo \
 rust-blobby-devel \
 "
RDEPENDS:rust-blobby-devel = " \
 cargo \
 "
