# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arcstr"
PV = "1.2.0"
PR = "5.el10_0"
PACKAGES = " \
 rust-arcstr+default-devel \
 rust-arcstr+serde-devel \
 rust-arcstr+std-devel \
 rust-arcstr+substr-devel \
 rust-arcstr+substr-usize-indices-devel \
 rust-arcstr-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-arcstr-1.2.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c434de0af4a802144c14cf4a6b40bd60992add2912e24dcc96f1eaa2886732aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr+default-devel-1.2.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-arcstr+default-devel.sha256sum] = "31feba7b0726aee318ee039316603ceb59718bbda8bdc08962e0a89a96699e4b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr+serde-devel-1.2.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-arcstr+serde-devel.sha256sum] = "c21d8c85d2586a750e31927560ab9da6a550d6792bc0c4d03c90be7e2eb375f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr+std-devel-1.2.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-arcstr+std-devel.sha256sum] = "b5f01d62601a6e8a79f6e24d600182744918fa4efba4dfa44614c9bf073ba501"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr+substr-devel-1.2.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr+substr-devel;unpack=0"
SRC_URI[x86_64_v2_rust-arcstr+substr-devel.sha256sum] = "4871f39d8f1289c76d3c6e40c263dc8d74f0b0224b04d9d6f244bdfc3c487154"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr+substr-usize-indices-devel-1.2.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr+substr-usize-indices-devel;unpack=0"
SRC_URI[x86_64_v2_rust-arcstr+substr-usize-indices-devel.sha256sum] = "38be81aba4760317c6d9e9275c5f12fbc4317034fbb6e565e07db13fa04a1c09"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr-devel-1.2.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr-devel;unpack=0"
SRC_URI[x86_64_v2_rust-arcstr-devel.sha256sum] = "4300d1eabda3458b735ec9e372933d4916d06628f246d8314886b33055ced7aa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr+default-devel-1.2.0-5.el10_0.noarch.rpm;name=aarch64_rust-arcstr+default-devel;unpack=0"
SRC_URI[aarch64_rust-arcstr+default-devel.sha256sum] = "9ab7baaa9a6a6fec19e168a42a9e277f4add682ce5897907e4e06277467f63ff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr+serde-devel-1.2.0-5.el10_0.noarch.rpm;name=aarch64_rust-arcstr+serde-devel;unpack=0"
SRC_URI[aarch64_rust-arcstr+serde-devel.sha256sum] = "bde6e3c41adc4b548040dac61fdc61c25a62111ad566b9f9bc40597caf93e726"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr+std-devel-1.2.0-5.el10_0.noarch.rpm;name=aarch64_rust-arcstr+std-devel;unpack=0"
SRC_URI[aarch64_rust-arcstr+std-devel.sha256sum] = "596e91b847d04337af0e1d0487d43c2ff2f99c911ab568198c1d546416a1f942"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr+substr-devel-1.2.0-5.el10_0.noarch.rpm;name=aarch64_rust-arcstr+substr-devel;unpack=0"
SRC_URI[aarch64_rust-arcstr+substr-devel.sha256sum] = "abc219316cabc4b8fc33d5ae4d432f789a4cdcac88159ddec32b105d2e87ca53"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr+substr-usize-indices-devel-1.2.0-5.el10_0.noarch.rpm;name=aarch64_rust-arcstr+substr-usize-indices-devel;unpack=0"
SRC_URI[aarch64_rust-arcstr+substr-usize-indices-devel.sha256sum] = "b5e2f234901dc2cbc66187c650901233cc6d020f418447461a2f50c776bb2b75"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr-devel-1.2.0-5.el10_0.noarch.rpm;name=aarch64_rust-arcstr-devel;unpack=0"
SRC_URI[aarch64_rust-arcstr-devel.sha256sum] = "62b5690659216822705b03dea36973defa84dc266e5fc5bf68cb51c2b70edc4f"

RDEPENDS:rust-arcstr+default-devel = " \
 cargo \
 rust-arcstr+substr-devel \
 rust-arcstr-devel \
 "
RDEPENDS:rust-arcstr+serde-devel = " \
 cargo \
 rust-arcstr-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-arcstr+std-devel = " \
 cargo \
 rust-arcstr-devel \
 "
RDEPENDS:rust-arcstr+substr-devel = " \
 cargo \
 rust-arcstr-devel \
 "
RDEPENDS:rust-arcstr+substr-usize-indices-devel = " \
 cargo \
 rust-arcstr+substr-devel \
 rust-arcstr-devel \
 "
RDEPENDS:rust-arcstr-devel = " \
 cargo \
 rust \
 "
