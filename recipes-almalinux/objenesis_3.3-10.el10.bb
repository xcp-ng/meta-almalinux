# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "objenesis"
PV = "3.3"
PR = "10.el10"
PACKAGES = " \
 objenesis \
 objenesis-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/objenesis-3.3-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b289db051a8fe8e0d57b232e558218fe435b11a5ef7f58eecce98e0d9a39530"

URI_x86_64_v2_objenesis = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/objenesis-3.3-10.el10.noarch.rpm;name=x86_64_v2_objenesis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_objenesis}"
SRC_URI[x86_64_v2_objenesis.sha256sum] = "4b475e3e8966ac0dafc3eef980303c630ad139a3acb289fa7b8b5f29e8511e8e"

URI_x86_64_v2_objenesis-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/objenesis-javadoc-3.3-10.el10.noarch.rpm;name=x86_64_v2_objenesis-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_objenesis-javadoc}"
SRC_URI[x86_64_v2_objenesis-javadoc.sha256sum] = "583d483203cc889e67bbcda8f7cd9c8ffdf509cadf7ccc88fc2a48dcc7002087"

URI_aarch64_objenesis = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/objenesis-3.3-10.el10.noarch.rpm;name=aarch64_objenesis;unpack=0"
SRC_URI:append = " ${URI_aarch64_objenesis}"
SRC_URI[aarch64_objenesis.sha256sum] = "4b475e3e8966ac0dafc3eef980303c630ad139a3acb289fa7b8b5f29e8511e8e"

URI_aarch64_objenesis-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/objenesis-javadoc-3.3-10.el10.noarch.rpm;name=aarch64_objenesis-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_objenesis-javadoc}"
SRC_URI[aarch64_objenesis-javadoc.sha256sum] = "583d483203cc889e67bbcda8f7cd9c8ffdf509cadf7ccc88fc2a48dcc7002087"

RDEPENDS:objenesis = " \
 javapackages-filesystem \
 "
RDEPENDS:objenesis-javadoc = " \
 javapackages-filesystem \
 "
