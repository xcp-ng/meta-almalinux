# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-system-deps"
PV = "7.0.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-system-deps+default-devel \
 rust-system-deps-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-system-deps-7.0.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94a9485066ac42429b1071c0e0dbd61dcddd07414762583da786425044bb1ad9"

URI_x86_64_v2_rust-system-deps+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-system-deps+default-devel-7.0.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-system-deps+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-system-deps+default-devel}"
SRC_URI[x86_64_v2_rust-system-deps+default-devel.sha256sum] = "b7f97926438c7515e8b9399635a39d49e980c5bbafeefdc70914a3d2bade5102"

URI_x86_64_v2_rust-system-deps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-system-deps-devel-7.0.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-system-deps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-system-deps-devel}"
SRC_URI[x86_64_v2_rust-system-deps-devel.sha256sum] = "206c3e9a7bad2afe9f4d166cb2d993fca0bbefca3be445caa946f48a55fcb6f3"

URI_aarch64_rust-system-deps+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-system-deps+default-devel-7.0.8-1.el10_2.noarch.rpm;name=aarch64_rust-system-deps+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-system-deps+default-devel}"
SRC_URI[aarch64_rust-system-deps+default-devel.sha256sum] = "910ba8dc43cc0c3d87e45816d651a1fa37a2344053d85551e14cc4fd2508a5d5"

URI_aarch64_rust-system-deps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-system-deps-devel-7.0.8-1.el10_2.noarch.rpm;name=aarch64_rust-system-deps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-system-deps-devel}"
SRC_URI[aarch64_rust-system-deps-devel.sha256sum] = "8eaed45a5a597fc5f77cedab29a1c3afdf03ae0cf7d1d6381a3d0b4d466aa7f7"

RDEPENDS:rust-system-deps+default-devel = " \
 cargo \
 rust-system-deps-devel \
 "
RDEPENDS:rust-system-deps-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-pkg-config+default-devel \
 rust-toml+parse-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 rust-version-compare+default-devel \
 virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~ \
 virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~ \
 "
