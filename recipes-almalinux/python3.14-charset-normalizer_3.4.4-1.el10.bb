# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-charset-normalizer"
PV = "3.4.4"
PR = "1.el10"
PACKAGES = " \
 python3.14-charset-normalizer \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-charset-normalizer-3.4.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c4b4158e0dc3cbb15610853d86406948ca8bb31ee1da314ffa972353c9a5d1e"

URI_x86_64_v2_python3.14-charset-normalizer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-charset-normalizer-3.4.4-1.el10.noarch.rpm;name=x86_64_v2_python3.14-charset-normalizer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-charset-normalizer}"
SRC_URI[x86_64_v2_python3.14-charset-normalizer.sha256sum] = "d9db155f9910a85d9991232ddbbd0155a5ba02b7ed1a218b4648a7bef95b0b6f"

URI_aarch64_python3.14-charset-normalizer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-charset-normalizer-3.4.4-1.el10.noarch.rpm;name=aarch64_python3.14-charset-normalizer;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-charset-normalizer}"
SRC_URI[aarch64_python3.14-charset-normalizer.sha256sum] = "d9db155f9910a85d9991232ddbbd0155a5ba02b7ed1a218b4648a7bef95b0b6f"

RDEPENDS:python3.14-charset-normalizer = " \
 python3.14 \
 "
