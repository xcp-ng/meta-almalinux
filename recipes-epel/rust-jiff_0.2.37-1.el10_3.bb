# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jiff"
PV = "0.2.37"
PR = "1.el10_3"
PACKAGES = " \
 rust-jiff+alloc-devel \
 rust-jiff+arbitrary-devel \
 rust-jiff+default-devel \
 rust-jiff+logging-devel \
 rust-jiff+perf-inline-devel \
 rust-jiff+serde-devel \
 rust-jiff+std-devel \
 rust-jiff+tz-fat-devel \
 rust-jiff+tz-system-devel \
 rust-jiff+tzdb-bundle-platform-devel \
 rust-jiff+tzdb-concatenated-devel \
 rust-jiff+tzdb-zoneinfo-devel \
 rust-jiff-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-jiff-0.2.37-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8471d457f675a52db7344c6d8a92f9d625ce25db96eb662b6424e14659082818"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+alloc-devel-0.2.37-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff+alloc-devel.sha256sum] = "7c63eb5af32ce4a4542356b5e6bb8bdedf6b1893acd2c35ab36e21216c32d4b0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+arbitrary-devel-0.2.37-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff+arbitrary-devel.sha256sum] = "4cb991e60ce5c4211d7996fe8107267544a542b21fbad61d50c68904e5dba6b1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+default-devel-0.2.37-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff+default-devel.sha256sum] = "6fa738ff9282c30364c00f838f00f8490c22d2d5a84cc7873024253054556635"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+logging-devel-0.2.37-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+logging-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff+logging-devel.sha256sum] = "e3a2956a0879a565c6cd9e7f3a45981d31a9cea2a3abf946a933d7075cee1fa2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+perf-inline-devel-0.2.37-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+perf-inline-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff+perf-inline-devel.sha256sum] = "a6479705a7b57450542b3332b1f75c709cea5f933e6a19f3aa8445e57b83bbfc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+serde-devel-0.2.37-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff+serde-devel.sha256sum] = "790f1147796b4cfc63358cbde6f7711ec8a4b5b0a23305c7e63d39734b4b95e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+std-devel-0.2.37-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff+std-devel.sha256sum] = "b0a679a07d536acf2b8bb698eb01c456c49456d121e97b67d2c12272d45507ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tz-fat-devel-0.2.37-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tz-fat-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff+tz-fat-devel.sha256sum] = "c276224262db024eb0d3a4b4be6bf2c4239a444bc98cdbd5ced0a082101bb2a5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tz-system-devel-0.2.37-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tz-system-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff+tz-system-devel.sha256sum] = "e9818a0f26231ea5f29bbbefe40054c7b2e8081a872a4feb05fb8f2b9dbe65d2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tzdb-bundle-platform-devel-0.2.37-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tzdb-bundle-platform-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff+tzdb-bundle-platform-devel.sha256sum] = "ffe89d36696b767ded78141cb920d095018b58fbfc5d8f5c733af51f0bc6726d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tzdb-concatenated-devel-0.2.37-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tzdb-concatenated-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff+tzdb-concatenated-devel.sha256sum] = "888694dd8c635bcac63c166b6f342d79abc3d7232ac444839718059dd4626908"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tzdb-zoneinfo-devel-0.2.37-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tzdb-zoneinfo-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff+tzdb-zoneinfo-devel.sha256sum] = "815ce3b6078c547c2405f4fd64a28be37f4bc837d531f34f32eb67b36b3e408b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-devel-0.2.37-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff-devel.sha256sum] = "ec83b00b98414a77ea59bcc9779fae2cef02e1fae1e50d4fa97e2eb2f78185cb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+alloc-devel-0.2.37-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-jiff+alloc-devel.sha256sum] = "6d5c987d2b84913eceebf275731011158d7ba1582692c78ab20df1ed0c64e9b2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+arbitrary-devel-0.2.37-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-jiff+arbitrary-devel.sha256sum] = "07edcf8402c54d394dd48d976570042d4e092d7655c461c9af727a392e048c66"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+default-devel-0.2.37-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+default-devel;unpack=0"
SRC_URI[aarch64_rust-jiff+default-devel.sha256sum] = "532c2b47494c2990f8faa52703cb38f09b327804c547c01d8f25fad94fc21927"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+logging-devel-0.2.37-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+logging-devel;unpack=0"
SRC_URI[aarch64_rust-jiff+logging-devel.sha256sum] = "9e58c007f1c1a6b0f66ce5b2e2a5ef852154637c4a4dbce211dff27e195c474c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+perf-inline-devel-0.2.37-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+perf-inline-devel;unpack=0"
SRC_URI[aarch64_rust-jiff+perf-inline-devel.sha256sum] = "4d3b0d90e7f5c43f38e23bf347c00811608961d829483e0770bb833c8b43888a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+serde-devel-0.2.37-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+serde-devel;unpack=0"
SRC_URI[aarch64_rust-jiff+serde-devel.sha256sum] = "fb82dfb4f4f2afdd730e6abafd4c05f82a2858bd36d755647f4866287fa06d48"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+std-devel-0.2.37-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+std-devel;unpack=0"
SRC_URI[aarch64_rust-jiff+std-devel.sha256sum] = "b15cbe1ef83f2f143570efbf7ff7bed9a005a722db9f68ecb59d388108d72017"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tz-fat-devel-0.2.37-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+tz-fat-devel;unpack=0"
SRC_URI[aarch64_rust-jiff+tz-fat-devel.sha256sum] = "f187c60709492a831c2578c668b953533bd94fa14d0121c1325e2ce2d6ac7a58"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tz-system-devel-0.2.37-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+tz-system-devel;unpack=0"
SRC_URI[aarch64_rust-jiff+tz-system-devel.sha256sum] = "40d8acf0ae56cc778618f5099d082fa971d348470dbce495626a71f8f9bac0d6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tzdb-bundle-platform-devel-0.2.37-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+tzdb-bundle-platform-devel;unpack=0"
SRC_URI[aarch64_rust-jiff+tzdb-bundle-platform-devel.sha256sum] = "ab448b841ccbcecab8f0c6b691dcb85ef88aa4812fccebc3a467ea60ec09315b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tzdb-concatenated-devel-0.2.37-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+tzdb-concatenated-devel;unpack=0"
SRC_URI[aarch64_rust-jiff+tzdb-concatenated-devel.sha256sum] = "eeee22a4cf999eecbcfc003f0e557e29d1ca14befb94d4682ca480df52b5b2d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tzdb-zoneinfo-devel-0.2.37-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+tzdb-zoneinfo-devel;unpack=0"
SRC_URI[aarch64_rust-jiff+tzdb-zoneinfo-devel.sha256sum] = "cb2929ec433ad814556d8ccaa8d9d7d705aad59965c80950def4c72731047559"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-devel-0.2.37-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-devel;unpack=0"
SRC_URI[aarch64_rust-jiff-devel.sha256sum] = "acbb8e60edb53bfac8e36459d5df652c7fa11799b40ab75b141a186e2bb29871"

RDEPENDS:rust-jiff+alloc-devel = " \
 cargo \
 rust-jiff-core+alloc-devel \
 rust-jiff-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-jiff+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-jiff+std-devel \
 rust-jiff-core+arbitrary-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+default-devel = " \
 cargo \
 rust-jiff+perf-inline-devel \
 rust-jiff+std-devel \
 rust-jiff+tz-fat-devel \
 rust-jiff+tz-system-devel \
 rust-jiff+tzdb-bundle-platform-devel \
 rust-jiff+tzdb-concatenated-devel \
 rust-jiff+tzdb-zoneinfo-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+logging-devel = " \
 cargo \
 rust-jiff-core+logging-devel \
 rust-jiff-devel \
 rust-log-devel \
 "
RDEPENDS:rust-jiff+perf-inline-devel = " \
 cargo \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+serde-devel = " \
 cargo \
 rust-jiff-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-jiff+std-devel = " \
 cargo \
 rust-jiff+alloc-devel \
 rust-jiff-core+std-devel \
 rust-jiff-devel \
 rust-log+std-devel \
 rust-log-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-jiff+tz-fat-devel = " \
 cargo \
 rust-jiff-core+tz-fat-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tz-system-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tzdb-bundle-platform-devel = " \
 cargo \
 rust-jiff+alloc-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tzdb-concatenated-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tzdb-zoneinfo-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff-devel = " \
 cargo \
 rust \
 rust-jiff-core-devel \
 "
