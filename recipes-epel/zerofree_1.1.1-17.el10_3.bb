# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zerofree"
PV = "1.1.1"
PR = "17.el10_3"
PACKAGES = " \
 zerofree \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zerofree-1.1.1-17.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6e438456c84e1d534f7e00de29f7680a9e0b6fa2842b83214418901a23fc393"

URI_x86_64_v2_zerofree = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zerofree-1.1.1-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zerofree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zerofree}"
SRC_URI[x86_64_v2_zerofree.sha256sum] = "8b81fcc43d9c485bdf3350883923c09fbe62ead217a82ded38f4116860d9dfe8"

URI_aarch64_zerofree = "${EPEL_MIRROR}/aarch64/Packages/z/zerofree-1.1.1-17.el10_3.aarch64.rpm;name=aarch64_zerofree;unpack=0"
SRC_URI:append = " ${URI_aarch64_zerofree}"
SRC_URI[aarch64_zerofree.sha256sum] = "2ef9d783642b1b7bfffabdb706abc24fad2d5d586f41224b4d6e87f622709ceb"

RDEPENDS:zerofree = " \
 e2fsprogs-libs \
 glibc \
 "
