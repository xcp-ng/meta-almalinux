# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-absl-py"
PV = "2.5.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-absl-py \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-absl-py-2.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d8059fec70c8d5bc324225065deb96e2bf853eda0b505f97c927d7c2ca22c6b"

URI_x86_64_v2_python3-absl-py = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-absl-py-2.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-absl-py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-absl-py}"
SRC_URI[x86_64_v2_python3-absl-py.sha256sum] = "89d12dc7c81724fbf79adf42f0a80f7908892b7b012c825241aaaee12beb1d6a"

URI_aarch64_python3-absl-py = "${EPEL_MIRROR}/aarch64/Packages/p/python3-absl-py-2.5.0-1.el10_2.noarch.rpm;name=aarch64_python3-absl-py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-absl-py}"
SRC_URI[aarch64_python3-absl-py.sha256sum] = "62a256cd4929e11bfa78e4d0bb4cb1ad2dfc35da00493737d2dc7f14b49b1e82"

RDEPENDS:python3-absl-py = " \
 python3 \
 "
