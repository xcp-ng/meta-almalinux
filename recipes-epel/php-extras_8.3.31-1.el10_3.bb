# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-extras"
PV = "8.3.31"
PR = "1.el10_3"
PACKAGES = " \
 php-pdo-dblib \
 php-pdo-firebird \
 php-pspell \
 php-sodium \
 php-tidy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-extras-8.3.31-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31279ad462a47add317ed3b17999fa966dbdbe840e251072009d197bc7905f49"

URI_x86_64_v2_php-pdo-dblib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pdo-dblib-8.3.31-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pdo-dblib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pdo-dblib}"
SRC_URI[x86_64_v2_php-pdo-dblib.sha256sum] = "403895b88107271095749782d6368dfab1078f8b7f6c8b7a7293e43931df2665"

URI_x86_64_v2_php-pdo-firebird = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pdo-firebird-8.3.31-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pdo-firebird;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pdo-firebird}"
SRC_URI[x86_64_v2_php-pdo-firebird.sha256sum] = "0d7ccaa9589dc11cd2b8273239e6fa243bb0bbca364fd4c3a6ae0afdfc3c174d"

URI_x86_64_v2_php-pspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pspell-8.3.31-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pspell}"
SRC_URI[x86_64_v2_php-pspell.sha256sum] = "d007958bdc659cb9a9fd9d8ffc0078470d0eb05ca03d328a63f279c4903c2b6c"

URI_x86_64_v2_php-sodium = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-sodium-8.3.31-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-sodium;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-sodium}"
SRC_URI[x86_64_v2_php-sodium.sha256sum] = "01d7bbb9108daea6e0ce71c4aa1ad795f98712250ad14b1385e9823c1d776b7e"
RPROVIDES:php-sodium:x86_64_v2 = "virtual/php-sodium"

URI_x86_64_v2_php-tidy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-tidy-8.3.31-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-tidy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-tidy}"
SRC_URI[x86_64_v2_php-tidy.sha256sum] = "bba55fc04c237bd649165082b1cdae5728a1758f4034b2770c3e3b4f9e705492"

URI_aarch64_php-pdo-dblib = "${EPEL_MIRROR}/aarch64/Packages/p/php-pdo-dblib-8.3.31-1.el10_3.aarch64.rpm;name=aarch64_php-pdo-dblib;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pdo-dblib}"
SRC_URI[aarch64_php-pdo-dblib.sha256sum] = "37a3680ba170abc0308f7357b78e109ceebb941c19e2fd8aeb8035ccef80a8db"

URI_aarch64_php-pdo-firebird = "${EPEL_MIRROR}/aarch64/Packages/p/php-pdo-firebird-8.3.31-1.el10_3.aarch64.rpm;name=aarch64_php-pdo-firebird;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pdo-firebird}"
SRC_URI[aarch64_php-pdo-firebird.sha256sum] = "3d16ff9d03fcec43c785a42ccfac4695fa793810a9702693e33aa91f53b47886"

URI_aarch64_php-pspell = "${EPEL_MIRROR}/aarch64/Packages/p/php-pspell-8.3.31-1.el10_3.aarch64.rpm;name=aarch64_php-pspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pspell}"
SRC_URI[aarch64_php-pspell.sha256sum] = "40efbf5be2595810dccd23f68307c2218256f4a86f85d6876f0420760fa423cc"

URI_aarch64_php-sodium = "${EPEL_MIRROR}/aarch64/Packages/p/php-sodium-8.3.31-1.el10_3.aarch64.rpm;name=aarch64_php-sodium;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-sodium}"
SRC_URI[aarch64_php-sodium.sha256sum] = "d590723a3de5a26b0e2bd3121445d60f1e71714b9512c383c1af48d24987e3fc"
RPROVIDES:php-sodium:aarch64 = "virtual/php-sodium"

URI_aarch64_php-tidy = "${EPEL_MIRROR}/aarch64/Packages/p/php-tidy-8.3.31-1.el10_3.aarch64.rpm;name=aarch64_php-tidy;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-tidy}"
SRC_URI[aarch64_php-tidy.sha256sum] = "60c8db268a3e6cc9e48732c74d1a3e7f4288404df7cc63a195c43cafb97486b7"

RDEPENDS:php-pdo-dblib = " \
 freetds-libs \
 glibc \
 php-common \
 php-pdo \
 "
RDEPENDS:php-pdo-firebird = " \
 glibc \
 libfbclient2 \
 php-common \
 php-pdo \
 "
RDEPENDS:php-pspell = " \
 aspell \
 glibc \
 php-common \
 "
RDEPENDS:php-sodium = " \
 glibc \
 libsodium \
 php-common \
 "
RDEPENDS:php-tidy = " \
 glibc \
 libtidy \
 php-common \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/php-sodium"

PROVIDES:append:aarch64 = " rpm/virtual/php-sodium"
