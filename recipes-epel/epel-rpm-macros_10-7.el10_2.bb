# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "epel-rpm-macros"
PV = "10"
PR = "7.el10_2"
PACKAGES = " \
 epel-rpm-macros \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/epel-rpm-macros-10-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f1807b33a387b2611cccd88caf2fdd8c7b104f37b037a9ba4fc134c723382aec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/epel-rpm-macros-10-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_epel-rpm-macros;unpack=0"
SRC_URI[x86_64_v2_epel-rpm-macros.sha256sum] = "4712369bae640bf7dc0e6fa26674ed7c60c229fc04b731a16b36118df3512a1a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/epel-rpm-macros-10-7.el10_2.noarch.rpm;name=aarch64_epel-rpm-macros;unpack=0"
SRC_URI[aarch64_epel-rpm-macros.sha256sum] = "b943274bb3d035944d9bd0c33ebb41efdc0e63afef5eec8a8095196c6888a6d9"

RDEPENDS:epel-rpm-macros = " \
 R-srpm-macros \
 almalinux-release \
 ansible-srpm-macros \
 fpc-srpm-macros \
 ghc-srpm-macros \
 "
