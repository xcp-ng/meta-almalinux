# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "weldr-client"
PV = "35.11"
PR = "4.el10"
PACKAGES = " \
 weldr-client \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/weldr-client-35.11-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75a08e6c458a4fe38872cd20f18410ec4a135841782538569f2df73aa2e2ce81"

URI_x86_64_v2_weldr-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/weldr-client-35.11-4.el10.x86_64_v2.rpm;name=x86_64_v2_weldr-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_weldr-client}"
SRC_URI[x86_64_v2_weldr-client.sha256sum] = "9f2127a5850e84a2adfac131143d4c2e7731a163d53a89b08c0c9b10787ae33e"

URI_aarch64_weldr-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/weldr-client-35.11-4.el10.aarch64.rpm;name=aarch64_weldr-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_weldr-client}"
SRC_URI[aarch64_weldr-client.sha256sum] = "d8177f37ae521b8d021ff70110332e2dae53b022539f7fbde2ff72cfb97bb196"

RDEPENDS:weldr-client = " \
 diffutils \
 glibc \
 "
