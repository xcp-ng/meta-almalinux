# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-scanner"
PV = "0.31.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-wayland-scanner+default-devel \
 rust-wayland-scanner-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-scanner-0.31.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f4731067d2116056d625713ae31a8c2fd7b0904e2b272e756b4a2c2b52d3cc7"

URI_x86_64_v2_rust-wayland-scanner+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-scanner+default-devel-0.31.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-scanner+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-scanner+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-scanner+default-devel.sha256sum] = "9e25941f30eb4b5788f244c40633deeb5faca0564e0dd33be669f12e598e61c7"

URI_x86_64_v2_rust-wayland-scanner-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-scanner-devel-0.31.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-scanner-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-scanner-devel}"
SRC_URI[x86_64_v2_rust-wayland-scanner-devel.sha256sum] = "c48063a993e3c8eb744a8f4b7e6a1b938b759fa2fac04a4b51cdf02d9de247e8"

URI_aarch64_rust-wayland-scanner+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-scanner+default-devel-0.31.8-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-scanner+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-scanner+default-devel}"
SRC_URI[aarch64_rust-wayland-scanner+default-devel.sha256sum] = "8bbdc9760509767b0bc34b67de6662c1cde803d24c2d62161231b21ed1a3b2bf"

URI_aarch64_rust-wayland-scanner-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-scanner-devel-0.31.8-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-scanner-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-scanner-devel}"
SRC_URI[aarch64_rust-wayland-scanner-devel.sha256sum] = "0b8f9b7a22aeebe685b40c1661b9d0742e964e029bd147f2a4ac81af5711dff9"

RDEPENDS:rust-wayland-scanner+default-devel = " \
 cargo \
 rust-wayland-scanner-devel \
 "
RDEPENDS:rust-wayland-scanner-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quick-xml+default-devel \
 rust-quote+default-devel \
 "
