# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxx"
PV = "1.0.168"
PR = "1.el10_1"
PACKAGES = " \
 rust-cxx+alloc-devel \
 rust-cxx+c++14-devel \
 rust-cxx+c++17-devel \
 rust-cxx+c++20-devel \
 rust-cxx+default-devel \
 rust-cxx+std-devel \
 rust-cxx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxx-1.0.168-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2976cbe88a8f07c6492d970d89b892901aa4b1ca245161e134798ab848427eb4"

URI_x86_64_v2_rust-cxx+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+alloc-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+alloc-devel}"
SRC_URI[x86_64_v2_rust-cxx+alloc-devel.sha256sum] = "c3ae648f28f9f51ca059f8f362604761e71ba1ed0eea04613041245a04aeba85"

URI_x86_64_v2_rust-cxx+c++14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+c++14-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+c++14-devel}"
SRC_URI[x86_64_v2_rust-cxx+c++14-devel.sha256sum] = "2a7542677a99685b41911d111c562dfdeaeaa43c39e1600f2fbcb9f8168e8941"

URI_x86_64_v2_rust-cxx+c++17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+c++17-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+c++17-devel}"
SRC_URI[x86_64_v2_rust-cxx+c++17-devel.sha256sum] = "b1c648444ce77f300316843727726fb768c249ebfe1ac7213982e84dfcce11d7"

URI_x86_64_v2_rust-cxx+c++20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+c++20-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+c++20-devel}"
SRC_URI[x86_64_v2_rust-cxx+c++20-devel.sha256sum] = "de01d34b89e529ee323ed62725a498d67db4e5b2300f356636a29094f7721243"

URI_x86_64_v2_rust-cxx+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+default-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+default-devel}"
SRC_URI[x86_64_v2_rust-cxx+default-devel.sha256sum] = "e0fc86162e67b0647c7233f28bdeb38c30937fc9c97bbbdcb1752f39f876f853"

URI_x86_64_v2_rust-cxx+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+std-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+std-devel}"
SRC_URI[x86_64_v2_rust-cxx+std-devel.sha256sum] = "9f285e6eafa35815481cef9e2e0097ce53cc78a103866345d4f9ee0b5af93a2c"

URI_x86_64_v2_rust-cxx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-devel}"
SRC_URI[x86_64_v2_rust-cxx-devel.sha256sum] = "96df484b1fd9db2866c14567c131ced843ceb2f6e69c520166a327fbfa02ab4d"

URI_aarch64_rust-cxx+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+alloc-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxx+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+alloc-devel}"
SRC_URI[aarch64_rust-cxx+alloc-devel.sha256sum] = "5378ebdc7a7d9e119cc6a0188b8bd2f81e020936779232ea381117985757a198"

URI_aarch64_rust-cxx+c++14-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+c++14-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxx+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+c++14-devel}"
SRC_URI[aarch64_rust-cxx+c++14-devel.sha256sum] = "9e3c8d7907d44e9b00c1b9d57659c51070f0fbdfb0c903de78d4ce093dc76116"

URI_aarch64_rust-cxx+c++17-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+c++17-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxx+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+c++17-devel}"
SRC_URI[aarch64_rust-cxx+c++17-devel.sha256sum] = "edf4b307985eefd4965661aec331dffca78adc1443c1e8e05a2442ce49045e07"

URI_aarch64_rust-cxx+c++20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+c++20-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxx+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+c++20-devel}"
SRC_URI[aarch64_rust-cxx+c++20-devel.sha256sum] = "4ed4230e7631e77f96b1871907fc8bddeaae1dcd79cc5dee81e34883c564fb0f"

URI_aarch64_rust-cxx+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+default-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxx+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+default-devel}"
SRC_URI[aarch64_rust-cxx+default-devel.sha256sum] = "9c721cb7c03648a1cc141817e1d8d88e4140ec4c72f66658ef8833c337aa72db"

URI_aarch64_rust-cxx+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+std-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxx+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+std-devel}"
SRC_URI[aarch64_rust-cxx+std-devel.sha256sum] = "dfcc4bb91bdc601fb751d87bbda4e47631ed26b32efe906cbaa6c55e8c430696"

URI_aarch64_rust-cxx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-devel}"
SRC_URI[aarch64_rust-cxx-devel.sha256sum] = "6e02ccae6d61a2c044ba8df538ae7706f74bbf79987a7e7a3b6ceb96fd8da544"

RDEPENDS:rust-cxx+alloc-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+c++14-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+c++17-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+c++20-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+default-devel = " \
 cargo \
 rust-cxx+std-devel \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+std-devel = " \
 cargo \
 rust-cxx+alloc-devel \
 rust-cxx-devel \
 rust-foldhash0.1+std-devel \
 "
RDEPENDS:rust-cxx-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-cxxbridge-flags-devel \
 rust-cxxbridge-macro+default-devel \
 rust-foldhash0.1-devel \
 rust-link-cplusplus+default-devel \
 "
