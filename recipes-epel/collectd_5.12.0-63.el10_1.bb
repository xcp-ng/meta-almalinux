# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "collectd"
PV = "5.12.0"
PR = "63.el10_1"
PACKAGES = " \
 collectd \
 collectd-amqp \
 collectd-amqp1 \
 collectd-apache \
 collectd-ascent \
 collectd-bind \
 collectd-chrony \
 collectd-curl \
 collectd-curl_xml \
 collectd-dbi \
 collectd-disk \
 collectd-dns \
 collectd-drbd \
 collectd-email \
 collectd-generic-jmx \
 collectd-gps \
 collectd-hugepages \
 collectd-infiniband \
 collectd-ipmi \
 collectd-ipvs \
 collectd-java \
 collectd-lua \
 collectd-mcelog \
 collectd-mdevents \
 collectd-memcachec \
 collectd-modbus \
 collectd-mysql \
 collectd-netlink \
 collectd-nginx \
 collectd-notify_desktop \
 collectd-notify_email \
 collectd-nut \
 collectd-openldap \
 collectd-pinba \
 collectd-ping \
 collectd-postgresql \
 collectd-python \
 collectd-redis \
 collectd-rrdcached \
 collectd-rrdtool \
 collectd-sensors \
 collectd-smart \
 collectd-snmp \
 collectd-snmp_agent \
 collectd-synproxy \
 collectd-utils \
 collectd-varnish \
 collectd-virt \
 collectd-web \
 collectd-write_http \
 collectd-write_kafka \
 collectd-write_prometheus \
 collectd-write_redis \
 collectd-write_riemann \
 collectd-write_sensu \
 collectd-write_syslog \
 collectd-write_tsdb \
 collectd-zookeeper \
 libcollectdclient \
 libcollectdclient-devel \
 perl-Collectd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/collectd-5.12.0-63.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77a1be35c1b9bf2f04ac77cd681b139718a2d5bba0bf88e2d22ece356ec4bc25"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - collectd-nut: libupsclient.so.6()(64bit)

URI_x86_64_v2_collectd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd}"
SRC_URI[x86_64_v2_collectd.sha256sum] = "714fe23499e569dc11a9f181cf92bb45960cd7a0a70d2050407c964f89b05c7a"

URI_x86_64_v2_collectd-amqp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-amqp-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-amqp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-amqp}"
SRC_URI[x86_64_v2_collectd-amqp.sha256sum] = "a18ca539da16a2a82fa0e8804c7288627dc91ddd6254491a728ca4714539ac71"

URI_x86_64_v2_collectd-amqp1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-amqp1-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-amqp1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-amqp1}"
SRC_URI[x86_64_v2_collectd-amqp1.sha256sum] = "5db5477141127add41e52222f669a3c10464160819eeeb64359c7148d4542e5b"

URI_x86_64_v2_collectd-apache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-apache-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-apache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-apache}"
SRC_URI[x86_64_v2_collectd-apache.sha256sum] = "7c0271edcb461d5e769a71599c15931268d83930fdde99848e1d3b5dc168cba6"

URI_x86_64_v2_collectd-ascent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-ascent-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-ascent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-ascent}"
SRC_URI[x86_64_v2_collectd-ascent.sha256sum] = "96c6c926ae01f2bba1632c3946ee6c471d9e1fba68114a690a05d786b0a68b1d"

URI_x86_64_v2_collectd-bind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-bind-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-bind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-bind}"
SRC_URI[x86_64_v2_collectd-bind.sha256sum] = "45b3ddc1679f61a01c5acfafd7554e39bc1f0f28970317dac39fa5fc8162d40b"

URI_x86_64_v2_collectd-chrony = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-chrony-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-chrony;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-chrony}"
SRC_URI[x86_64_v2_collectd-chrony.sha256sum] = "c2fcf842d3152314bfd656146c8044d231d181bd9b9c7390eda80aacfcf87a46"

URI_x86_64_v2_collectd-curl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-curl-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-curl}"
SRC_URI[x86_64_v2_collectd-curl.sha256sum] = "012fcb518f9cae5d6c68b91fd06b17203d8994830472484f97759137b88cc174"

URI_x86_64_v2_collectd-curl_xml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-curl_xml-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-curl_xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-curl_xml}"
SRC_URI[x86_64_v2_collectd-curl_xml.sha256sum] = "6494e1b5667c0c1bfaa13b675c5e175fe9486e59531cd626f00295df91b9be49"

URI_x86_64_v2_collectd-dbi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-dbi-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-dbi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-dbi}"
SRC_URI[x86_64_v2_collectd-dbi.sha256sum] = "b095e7cc355f0cdb8fa6321897d7b7ec408f018216452a04423d7659a0fc9db0"

URI_x86_64_v2_collectd-disk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-disk-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-disk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-disk}"
SRC_URI[x86_64_v2_collectd-disk.sha256sum] = "ecb01984ba1826f51d2a33dec0dc777d3d58e8bdd90d24e8034853cb21cb03a2"

URI_x86_64_v2_collectd-dns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-dns-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-dns}"
SRC_URI[x86_64_v2_collectd-dns.sha256sum] = "7805ccd6511fd047b7c18f09653be8dc1f9b4dd5f407ca2f81f43bcc592c866e"

URI_x86_64_v2_collectd-drbd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-drbd-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-drbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-drbd}"
SRC_URI[x86_64_v2_collectd-drbd.sha256sum] = "3adb0aea7778fae83761197a23a1fbc1e63578d2ec725a77469752c8e75551c7"

URI_x86_64_v2_collectd-email = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-email-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-email;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-email}"
SRC_URI[x86_64_v2_collectd-email.sha256sum] = "5642dcc93a78f36678b12f46c7c878df80f7bf6ecadb6e90fed655d8d14b274a"

URI_x86_64_v2_collectd-generic-jmx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-generic-jmx-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-generic-jmx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-generic-jmx}"
SRC_URI[x86_64_v2_collectd-generic-jmx.sha256sum] = "d165c4f3b72ec711c23d7d392c0a18bdfac87f8e0096881cd33664dc25462889"

URI_x86_64_v2_collectd-gps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-gps-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-gps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-gps}"
SRC_URI[x86_64_v2_collectd-gps.sha256sum] = "3e73d91c94c343a2185aea7b6708c74fb8a6a6e3b93041477fa46cc04d63446b"

URI_x86_64_v2_collectd-hugepages = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-hugepages-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-hugepages;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-hugepages}"
SRC_URI[x86_64_v2_collectd-hugepages.sha256sum] = "ddc52c3764a255a52da3799362616c3efd347d1c49837494d976c92360407743"

URI_x86_64_v2_collectd-infiniband = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-infiniband-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-infiniband;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-infiniband}"
SRC_URI[x86_64_v2_collectd-infiniband.sha256sum] = "ba447713f28e362b9475216667452fef513853ab4fbb79d1248f7bf5b7adcd06"

URI_x86_64_v2_collectd-ipmi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-ipmi-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-ipmi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-ipmi}"
SRC_URI[x86_64_v2_collectd-ipmi.sha256sum] = "f101d35459be47cab50ec0b93604ffbb72e5f3134c5c0c0856bf333e52e36778"

URI_x86_64_v2_collectd-ipvs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-ipvs-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-ipvs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-ipvs}"
SRC_URI[x86_64_v2_collectd-ipvs.sha256sum] = "10c13f000c63edbb9541e120c69746487637553cf893b1ee21594bec8c218ea5"

URI_x86_64_v2_collectd-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-java-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-java}"
SRC_URI[x86_64_v2_collectd-java.sha256sum] = "72cb20b3825a5cbf3df38bea63d44477c1aac560e663dcfa8f425e19f8bca56f"

URI_x86_64_v2_collectd-lua = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-lua-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-lua}"
SRC_URI[x86_64_v2_collectd-lua.sha256sum] = "e6c8cd4e3a171f1aa2f345cb41c52f1efaa799bb248e7134d678c51c4005dbe7"

URI_x86_64_v2_collectd-mcelog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-mcelog-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-mcelog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-mcelog}"
SRC_URI[x86_64_v2_collectd-mcelog.sha256sum] = "05bd1f0852b16cac94166bca6d1553260dbcf2a584330c0b2867b3b413716d58"

URI_x86_64_v2_collectd-mdevents = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-mdevents-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-mdevents;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-mdevents}"
SRC_URI[x86_64_v2_collectd-mdevents.sha256sum] = "3ee5b09785ef93a98c3c32303b8d0822e0e6aec42eca10bf0ce68af04f0e8b6d"

URI_x86_64_v2_collectd-memcachec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-memcachec-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-memcachec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-memcachec}"
SRC_URI[x86_64_v2_collectd-memcachec.sha256sum] = "86a36625deaed0bb655e5d16362bf18ef7908041696338e2da399f477448e225"

URI_x86_64_v2_collectd-modbus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-modbus-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-modbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-modbus}"
SRC_URI[x86_64_v2_collectd-modbus.sha256sum] = "eaec80ecb4a2e2324f099d1d6cf7937f93263ce180491954146e35e4003eca58"

URI_x86_64_v2_collectd-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-mysql-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-mysql}"
SRC_URI[x86_64_v2_collectd-mysql.sha256sum] = "c4fef779fa98ca4f9463ae672455fb10e0565336d14e5ec6934c5a3963657fe2"

URI_x86_64_v2_collectd-netlink = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-netlink-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-netlink;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-netlink}"
SRC_URI[x86_64_v2_collectd-netlink.sha256sum] = "ce9a12ccb19bb55bcf6f3bc33602e023299d27ad0f5be8d83d23395c04d621cd"

URI_x86_64_v2_collectd-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-nginx-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-nginx}"
SRC_URI[x86_64_v2_collectd-nginx.sha256sum] = "11213ba39038ff55a7a635c3a066d46a4aac7fda7834d8d877be5e0ed871cd65"

URI_x86_64_v2_collectd-notify_desktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-notify_desktop-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-notify_desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-notify_desktop}"
SRC_URI[x86_64_v2_collectd-notify_desktop.sha256sum] = "75aa4fffe5981d5c14fda3097c2b12e0493cf0bcb21990ef1e99556f12ef8f18"

URI_x86_64_v2_collectd-notify_email = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-notify_email-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-notify_email;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-notify_email}"
SRC_URI[x86_64_v2_collectd-notify_email.sha256sum] = "af6abb2eb5b699c0f126993c285741ac0e5030ed8ea60ee30b823cdfc45584ad"

URI_x86_64_v2_collectd-nut = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-nut-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-nut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-nut}"
SRC_URI[x86_64_v2_collectd-nut.sha256sum] = "24096c1ffb24219c601f75a5b7e44f643f9acc53b07f58a87e5a603a2ceab7e7"

URI_x86_64_v2_collectd-openldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-openldap-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-openldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-openldap}"
SRC_URI[x86_64_v2_collectd-openldap.sha256sum] = "b8076d849cc7c2fb8b3e1ead99b7d6caf57864e7c0267261135bd629b372e997"

URI_x86_64_v2_collectd-pinba = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-pinba-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-pinba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-pinba}"
SRC_URI[x86_64_v2_collectd-pinba.sha256sum] = "3c1c7993b09266cd3b0e421e44cf26edbe18135bafdbb404516523ff90678bc3"

URI_x86_64_v2_collectd-ping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-ping-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-ping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-ping}"
SRC_URI[x86_64_v2_collectd-ping.sha256sum] = "11bff33c7bf385731418d75fb78c30c73aba5670c579eac2ea051da503306a45"

URI_x86_64_v2_collectd-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-postgresql-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-postgresql}"
SRC_URI[x86_64_v2_collectd-postgresql.sha256sum] = "2e7a64eba683d39d3b8eeece0b401830e720b48b8ebf9c92a19bfcd26b1bc817"

URI_x86_64_v2_collectd-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-python-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-python}"
SRC_URI[x86_64_v2_collectd-python.sha256sum] = "0217a86d2ff3a19517d1b2c526194b45afef73a87909223169fb1455431a57e7"

URI_x86_64_v2_collectd-redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-redis-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-redis}"
SRC_URI[x86_64_v2_collectd-redis.sha256sum] = "cdb5d7bad0e7860031a78ab251de57f2d58f98b531317812c6339e2d084ea4fb"

URI_x86_64_v2_collectd-rrdcached = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-rrdcached-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-rrdcached;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-rrdcached}"
SRC_URI[x86_64_v2_collectd-rrdcached.sha256sum] = "0aa522a2a813e45702c14302a92b41a5936aadee60fcd651ac6f1bf561e30e21"

URI_x86_64_v2_collectd-rrdtool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-rrdtool-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-rrdtool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-rrdtool}"
SRC_URI[x86_64_v2_collectd-rrdtool.sha256sum] = "bcfbab4819a351c7b3679f35b490193c66a25eb61853e77403703e85433bad90"

URI_x86_64_v2_collectd-sensors = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-sensors-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-sensors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-sensors}"
SRC_URI[x86_64_v2_collectd-sensors.sha256sum] = "5cd93427920453c27d899b0978a35cef003b6a8f99a8ec79ec949ed43f432a52"

URI_x86_64_v2_collectd-smart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-smart-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-smart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-smart}"
SRC_URI[x86_64_v2_collectd-smart.sha256sum] = "cf0e9aff4f9ea023b708a3b482aa53e6c31efc37913e0a2ad1b6a2c439af64c0"

URI_x86_64_v2_collectd-snmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-snmp-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-snmp}"
SRC_URI[x86_64_v2_collectd-snmp.sha256sum] = "af425b1bf176f7a6c1e1d7d1ed508b63a88dc06ebc563f7d5032408c4d768f79"

URI_x86_64_v2_collectd-snmp_agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-snmp_agent-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-snmp_agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-snmp_agent}"
SRC_URI[x86_64_v2_collectd-snmp_agent.sha256sum] = "7f4dd8b39b634630e98e542fdf95621872d8e66601dfcb41ab2d8f5793ff03d8"

URI_x86_64_v2_collectd-synproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-synproxy-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-synproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-synproxy}"
SRC_URI[x86_64_v2_collectd-synproxy.sha256sum] = "4f242fe74dec7b5e5e44de1ef7cce9e091a282e111ecc5dead28c51381f21496"

URI_x86_64_v2_collectd-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-utils-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-utils}"
SRC_URI[x86_64_v2_collectd-utils.sha256sum] = "05acd3b08afc99b6e275a05a720413ce2cb2bb0bac5e77f4da4bbae397cdd13e"

URI_x86_64_v2_collectd-varnish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-varnish-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-varnish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-varnish}"
SRC_URI[x86_64_v2_collectd-varnish.sha256sum] = "391add4f47b7b9e4c06018fa25f4587119c4cae2105076bb57a97a64953fd4de"

URI_x86_64_v2_collectd-virt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-virt-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-virt}"
SRC_URI[x86_64_v2_collectd-virt.sha256sum] = "17229599762e33256271d3cf495afea63c75d8e7de1a9d34e3f26086afcbb531"

URI_x86_64_v2_collectd-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-web-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-web}"
SRC_URI[x86_64_v2_collectd-web.sha256sum] = "93a1f0a8648e80c96e563812b6bdec79a92ef32a9eee6ff7c63beab5144a15f3"

URI_x86_64_v2_collectd-write_http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_http-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_http}"
SRC_URI[x86_64_v2_collectd-write_http.sha256sum] = "02c7b8eb233882e81243933283686ed7a92ea9f39fe66426caa39dd729166923"

URI_x86_64_v2_collectd-write_kafka = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_kafka-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_kafka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_kafka}"
SRC_URI[x86_64_v2_collectd-write_kafka.sha256sum] = "cc28f6219e480c6036bd61ee1cd9ad9700269ad5b6b3be1a11f7d9b0c2525d16"

URI_x86_64_v2_collectd-write_prometheus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_prometheus-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_prometheus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_prometheus}"
SRC_URI[x86_64_v2_collectd-write_prometheus.sha256sum] = "14e032dc821e89c3d5712d2e128ce2f7ef011b580088eda13622af82aa7519bf"

URI_x86_64_v2_collectd-write_redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_redis-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_redis}"
SRC_URI[x86_64_v2_collectd-write_redis.sha256sum] = "33e97b5373e707133bb4bd4ebdad2039b2e4db95acad6ca065443ef1a3c65caa"

URI_x86_64_v2_collectd-write_riemann = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_riemann-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_riemann;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_riemann}"
SRC_URI[x86_64_v2_collectd-write_riemann.sha256sum] = "373d618dce35d201886a23a3aa6abb63383f8fe3db2b97201e4075106951f4cb"

URI_x86_64_v2_collectd-write_sensu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_sensu-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_sensu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_sensu}"
SRC_URI[x86_64_v2_collectd-write_sensu.sha256sum] = "ff3486c2c7c67d3e03a378e1c64c6e731e8ca86af45eb6713bf904ae4ca228de"

URI_x86_64_v2_collectd-write_syslog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_syslog-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_syslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_syslog}"
SRC_URI[x86_64_v2_collectd-write_syslog.sha256sum] = "5914ca4313e5026e63898adae121c3f20a5aa4a5b56f674e4e7e6e945698f884"

URI_x86_64_v2_collectd-write_tsdb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_tsdb-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_tsdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_tsdb}"
SRC_URI[x86_64_v2_collectd-write_tsdb.sha256sum] = "21159ba649234a7802fb789370299ec5350957f28f82aa61670ee419bf7288e1"

URI_x86_64_v2_collectd-zookeeper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-zookeeper-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-zookeeper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-zookeeper}"
SRC_URI[x86_64_v2_collectd-zookeeper.sha256sum] = "8383cf994f0c7d6507cbd169523b7744cf35e99c2f5e6a75c590c0a21c2a8efc"

URI_x86_64_v2_libcollectdclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcollectdclient-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcollectdclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcollectdclient}"
SRC_URI[x86_64_v2_libcollectdclient.sha256sum] = "84dc1b53dc795b2bf6eb4c9694089125671cdb33dd6f35893eb1912372e51bca"

URI_x86_64_v2_libcollectdclient-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcollectdclient-devel-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcollectdclient-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcollectdclient-devel}"
SRC_URI[x86_64_v2_libcollectdclient-devel.sha256sum] = "4d86fb3e38c94889f2ee98052f63ce637d13f4a3e23b20056374f59c6ecee622"

URI_x86_64_v2_perl-Collectd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Collectd-5.12.0-63.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Collectd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Collectd}"
SRC_URI[x86_64_v2_perl-Collectd.sha256sum] = "8dadbe8815913dc3bfd6dcbf654a7d398dc4e358420709094772614a03fb5f85"

URI_aarch64_collectd = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd}"
SRC_URI[aarch64_collectd.sha256sum] = "a91e96e2578c7a1c707b04bf5f52657d79eb8fce3cb458c859ac4e52c705d779"

URI_aarch64_collectd-amqp = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-amqp-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-amqp;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-amqp}"
SRC_URI[aarch64_collectd-amqp.sha256sum] = "0cea1a0198bef0a826faa18d5c43b416639db4503e71b51d08f3ead8fc1ea93d"

URI_aarch64_collectd-amqp1 = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-amqp1-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-amqp1;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-amqp1}"
SRC_URI[aarch64_collectd-amqp1.sha256sum] = "10c9629e2a0cf642068163a482564c303b418d422f9f1f43c22b4d55b96900a3"

URI_aarch64_collectd-apache = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-apache-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-apache;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-apache}"
SRC_URI[aarch64_collectd-apache.sha256sum] = "bf1e0cf03e6f60320987b3475631ebfad6631afdc3e57fa0d31da98b0b04a93d"

URI_aarch64_collectd-ascent = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-ascent-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-ascent;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-ascent}"
SRC_URI[aarch64_collectd-ascent.sha256sum] = "f9f9bce03e2e9be4a25d0253957b6d55adee950042d2faa73c9c394147c3df81"

URI_aarch64_collectd-bind = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-bind-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-bind;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-bind}"
SRC_URI[aarch64_collectd-bind.sha256sum] = "7326a81c97e2d44430d44c2d97228bad39b0c1d59f1e1838083a08fe2036bc34"

URI_aarch64_collectd-chrony = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-chrony-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-chrony;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-chrony}"
SRC_URI[aarch64_collectd-chrony.sha256sum] = "6cbd08429f82d3d04436fdcfc5f9c91b49ec5ddbaee8a7c8a27b2dea415721d6"

URI_aarch64_collectd-curl = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-curl-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-curl}"
SRC_URI[aarch64_collectd-curl.sha256sum] = "62f8dc4b253c814f22d7e0f6e742b6f9d93178d4d94cf3b3733b82caab5d7595"

URI_aarch64_collectd-curl_xml = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-curl_xml-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-curl_xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-curl_xml}"
SRC_URI[aarch64_collectd-curl_xml.sha256sum] = "f8f1f7fd35b435e462a2e215a1dcf4cf840103a05496387cc68d67fbab79b0e9"

URI_aarch64_collectd-dbi = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-dbi-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-dbi;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-dbi}"
SRC_URI[aarch64_collectd-dbi.sha256sum] = "2bf1ba1965bdf8b0b899ab3f28c79d6b5a28074bfb53549a444726634ee0147b"

URI_aarch64_collectd-disk = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-disk-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-disk;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-disk}"
SRC_URI[aarch64_collectd-disk.sha256sum] = "48a14e04a87325865d078cf7265a61bd6eefa12bfb760423ea025daaa3791fe9"

URI_aarch64_collectd-dns = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-dns-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-dns}"
SRC_URI[aarch64_collectd-dns.sha256sum] = "81703e47c87f822b999fa82540ac468125ad357a9be366bfdfd01af8da1b9d82"

URI_aarch64_collectd-drbd = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-drbd-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-drbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-drbd}"
SRC_URI[aarch64_collectd-drbd.sha256sum] = "17378fe54657954d03969630f5620fef96d253b070b0b1affdce0ba32236c76e"

URI_aarch64_collectd-email = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-email-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-email;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-email}"
SRC_URI[aarch64_collectd-email.sha256sum] = "b9cb72151f908c973c619416c91df8330ca4d942bdd07d56a2f41d779dd6f35c"

URI_aarch64_collectd-generic-jmx = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-generic-jmx-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-generic-jmx;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-generic-jmx}"
SRC_URI[aarch64_collectd-generic-jmx.sha256sum] = "9a843283c69020e10dd4d5fcabbabcdcb807590a685b03216ba0e8aad560712d"

URI_aarch64_collectd-gps = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-gps-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-gps;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-gps}"
SRC_URI[aarch64_collectd-gps.sha256sum] = "0ed26a302119baabfba5c169d3249f1176c8447c401b448e1d8af011ab10aeef"

URI_aarch64_collectd-hugepages = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-hugepages-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-hugepages;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-hugepages}"
SRC_URI[aarch64_collectd-hugepages.sha256sum] = "a8d50fe9a2d5a0778400dd826dfd64d0f72293dfeb6bcd905999f3fda17a2a8a"

URI_aarch64_collectd-infiniband = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-infiniband-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-infiniband;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-infiniband}"
SRC_URI[aarch64_collectd-infiniband.sha256sum] = "4438fc19e1bb097bed6f2bd11f178397b98f2ea25b3ca0896a98d6f0e21ce89f"

URI_aarch64_collectd-ipmi = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-ipmi-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-ipmi;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-ipmi}"
SRC_URI[aarch64_collectd-ipmi.sha256sum] = "7349749773788555fb83a4bc228e24ad5c0b1323f844484bfa061bc544a038e3"

URI_aarch64_collectd-ipvs = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-ipvs-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-ipvs;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-ipvs}"
SRC_URI[aarch64_collectd-ipvs.sha256sum] = "7fbda343bbdb8b639c54469168da3bfd79006f34c966382a4470529a0cc02b5b"

URI_aarch64_collectd-java = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-java-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-java}"
SRC_URI[aarch64_collectd-java.sha256sum] = "236acfcd44d67378e1f690644fffe4cfdd35c232c84ec3082f5f309cb8fd2928"

URI_aarch64_collectd-lua = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-lua-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-lua}"
SRC_URI[aarch64_collectd-lua.sha256sum] = "281f6add72e165e53a375d2a90c370f0ebf066a1f744b6325646faf9dfdd4735"

URI_aarch64_collectd-mcelog = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-mcelog-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-mcelog;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-mcelog}"
SRC_URI[aarch64_collectd-mcelog.sha256sum] = "165f521a1e8f829286ca38f28b0ba10a3176fe08c9a16a4ff2c552f732510c73"

URI_aarch64_collectd-mdevents = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-mdevents-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-mdevents;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-mdevents}"
SRC_URI[aarch64_collectd-mdevents.sha256sum] = "752ce777cad3d10aed0219af53022a3d952d54fd4d172f0a16454b2d39d3cc64"

URI_aarch64_collectd-memcachec = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-memcachec-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-memcachec;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-memcachec}"
SRC_URI[aarch64_collectd-memcachec.sha256sum] = "74b92cc1e5b9a5823af6280b1486cc1a9b6592b284bb52bb232cdf3aac10ccca"

URI_aarch64_collectd-modbus = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-modbus-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-modbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-modbus}"
SRC_URI[aarch64_collectd-modbus.sha256sum] = "3e31afc6b10edc4c854e28ae20f6fc67e8ced4b821b5f2ca5e619d4e462e3d10"

URI_aarch64_collectd-mysql = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-mysql-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-mysql}"
SRC_URI[aarch64_collectd-mysql.sha256sum] = "12c46c7a7400114bc6ff296e9fef940dc500b1c9bac5c08875c068b37a58cc79"

URI_aarch64_collectd-netlink = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-netlink-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-netlink;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-netlink}"
SRC_URI[aarch64_collectd-netlink.sha256sum] = "8c71b0703428229e8e5577cdcf89b5ad734b55017eee063392bf5b10d40b20a0"

URI_aarch64_collectd-nginx = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-nginx-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-nginx}"
SRC_URI[aarch64_collectd-nginx.sha256sum] = "288e369ca9bdd920bd60b207a8137f8285d6b538519ed20fd19b1f066f589fee"

URI_aarch64_collectd-notify_desktop = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-notify_desktop-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-notify_desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-notify_desktop}"
SRC_URI[aarch64_collectd-notify_desktop.sha256sum] = "fa3bb64b8a4665c723a7314cfb953b7ecd57d91d8ef2da78fff442334e1ed2c5"

URI_aarch64_collectd-notify_email = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-notify_email-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-notify_email;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-notify_email}"
SRC_URI[aarch64_collectd-notify_email.sha256sum] = "34006a04aaf12b28ece96527d939eac71ac2a005385355179a83babbae416473"

URI_aarch64_collectd-nut = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-nut-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-nut;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-nut}"
SRC_URI[aarch64_collectd-nut.sha256sum] = "f2451198e129b655c0227a7a4ca2c75d0ba03d8e6c4679ef2aff40338745669d"

URI_aarch64_collectd-openldap = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-openldap-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-openldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-openldap}"
SRC_URI[aarch64_collectd-openldap.sha256sum] = "f7aa191e9555374c0dee4580ce0a653116abb9eccc7eace7867f1612cad8fb7f"

URI_aarch64_collectd-pinba = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-pinba-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-pinba;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-pinba}"
SRC_URI[aarch64_collectd-pinba.sha256sum] = "ed1263d131516bb9c5a612b6046dcd6c54b6ee705877e74cc893c305f0871bc5"

URI_aarch64_collectd-ping = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-ping-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-ping;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-ping}"
SRC_URI[aarch64_collectd-ping.sha256sum] = "d7fe2f4bdfee8e8446c84039077b1cf0ead30b5be7bccd15bec4c26646110659"

URI_aarch64_collectd-postgresql = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-postgresql-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-postgresql}"
SRC_URI[aarch64_collectd-postgresql.sha256sum] = "c6d747b9031e7ddd34089d22bbed4b0f527bb37a5350f16434999f174c087b59"

URI_aarch64_collectd-python = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-python-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-python}"
SRC_URI[aarch64_collectd-python.sha256sum] = "296fc0982ba526bff0263c298c9294acb18b9e522708705b86b8f86c8b60e03d"

URI_aarch64_collectd-redis = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-redis-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-redis}"
SRC_URI[aarch64_collectd-redis.sha256sum] = "831e262996d29fa5c03a1dd7eef13b66a79ad8fcb67303beb6fa8a2b8697ced1"

URI_aarch64_collectd-rrdcached = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-rrdcached-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-rrdcached;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-rrdcached}"
SRC_URI[aarch64_collectd-rrdcached.sha256sum] = "90354b3165889a541e8125977d893b4dc1a966021db4cd15e3b0211a69453dca"

URI_aarch64_collectd-rrdtool = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-rrdtool-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-rrdtool;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-rrdtool}"
SRC_URI[aarch64_collectd-rrdtool.sha256sum] = "9cd5898b684b193ff72b7fa320c22abdc8524ccdc685b05e61b8880e513ad4b9"

URI_aarch64_collectd-sensors = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-sensors-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-sensors;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-sensors}"
SRC_URI[aarch64_collectd-sensors.sha256sum] = "efb0fcc0f118766c11f413ab22e8e17c6edaf74bf32738360cbfb8249ba3d955"

URI_aarch64_collectd-smart = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-smart-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-smart;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-smart}"
SRC_URI[aarch64_collectd-smart.sha256sum] = "118a55e8fcc8891369e27a78d1879ea31eb976bdd8068310d33d3b3f3d7ca3cf"

URI_aarch64_collectd-snmp = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-snmp-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-snmp}"
SRC_URI[aarch64_collectd-snmp.sha256sum] = "9e5482e00cb19b74254a9f650ec1b84c6025e8c181f4a03b6ed49fce5321ac3b"

URI_aarch64_collectd-snmp_agent = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-snmp_agent-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-snmp_agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-snmp_agent}"
SRC_URI[aarch64_collectd-snmp_agent.sha256sum] = "6ac6f97042c795577f889ff73f33c3b526ff977db387691ab609a3e9db1b6ad5"

URI_aarch64_collectd-synproxy = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-synproxy-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-synproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-synproxy}"
SRC_URI[aarch64_collectd-synproxy.sha256sum] = "35f583fb7d5431c92bc2fd615e05971ef56db494467abdd9b8623462bebec0d5"

URI_aarch64_collectd-utils = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-utils-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-utils}"
SRC_URI[aarch64_collectd-utils.sha256sum] = "1879ff191198b50fb910e3c82a5a653bfdddd49e30e27dd9935cc478f0f9a45a"

URI_aarch64_collectd-varnish = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-varnish-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-varnish;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-varnish}"
SRC_URI[aarch64_collectd-varnish.sha256sum] = "77667fa3b742d0482ebff32fb75c3ecaa927bc41d69f0446a2f27b24d7c9208d"

URI_aarch64_collectd-virt = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-virt-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-virt}"
SRC_URI[aarch64_collectd-virt.sha256sum] = "15f433e52d8370b4326d9a2749c2292a235cc592608efae8d1afb9df903a79d9"

URI_aarch64_collectd-web = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-web-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-web}"
SRC_URI[aarch64_collectd-web.sha256sum] = "30c06ac717d1988b92e5db52e7c70b1730bd11e8d2d76705a31b95ae148dce19"

URI_aarch64_collectd-write_http = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_http-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-write_http;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_http}"
SRC_URI[aarch64_collectd-write_http.sha256sum] = "1117b60d0210553eb30f3e10728ca7207ee5b19c2ecade3b52a3b290594296e7"

URI_aarch64_collectd-write_kafka = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_kafka-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-write_kafka;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_kafka}"
SRC_URI[aarch64_collectd-write_kafka.sha256sum] = "a2265ef74c35688669cc0cbed76ba6045c06d6e2624f6418a15bbff6c9c2117a"

URI_aarch64_collectd-write_prometheus = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_prometheus-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-write_prometheus;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_prometheus}"
SRC_URI[aarch64_collectd-write_prometheus.sha256sum] = "d5ead1e6c41ab4b866e3e0d40afd1e3eef2cdb39de95c5e1de6d85bc00e7459c"

URI_aarch64_collectd-write_redis = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_redis-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-write_redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_redis}"
SRC_URI[aarch64_collectd-write_redis.sha256sum] = "2dab9cc8ca75c327d944c85555d3520e799b60192fadc810817a8ca3c0d94ec1"

URI_aarch64_collectd-write_riemann = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_riemann-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-write_riemann;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_riemann}"
SRC_URI[aarch64_collectd-write_riemann.sha256sum] = "69d5cc78fc06ab911ee93ec6d074adb7fa62b1e83bfa3e2a79778c4e971997be"

URI_aarch64_collectd-write_sensu = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_sensu-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-write_sensu;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_sensu}"
SRC_URI[aarch64_collectd-write_sensu.sha256sum] = "4d5ad60975fde155fa49cc4b1da91b476a7541b282d9c45f945909080fe5ee81"

URI_aarch64_collectd-write_syslog = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_syslog-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-write_syslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_syslog}"
SRC_URI[aarch64_collectd-write_syslog.sha256sum] = "1de16ce77deacd138e1e7459c2f9fbb01dc02de36a7d4706b02b354cd69376bc"

URI_aarch64_collectd-write_tsdb = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_tsdb-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-write_tsdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_tsdb}"
SRC_URI[aarch64_collectd-write_tsdb.sha256sum] = "34260404437a3b7f09060232c20a121627bc5425fcde5aa8dbc0cf45e0d9fc14"

URI_aarch64_collectd-zookeeper = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-zookeeper-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_collectd-zookeeper;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-zookeeper}"
SRC_URI[aarch64_collectd-zookeeper.sha256sum] = "2d6d842948a84e0e7d99ea7d1305ac9b99e7663573bb7ac253c6acf57cb190ba"

URI_aarch64_libcollectdclient = "${EPEL_MIRROR}/aarch64/Packages/l/libcollectdclient-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_libcollectdclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcollectdclient}"
SRC_URI[aarch64_libcollectdclient.sha256sum] = "63ec7ea3c9d343e401e30c8682237e3874ef45480189cec44cfde4ce8ba0cab7"

URI_aarch64_libcollectdclient-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcollectdclient-devel-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_libcollectdclient-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcollectdclient-devel}"
SRC_URI[aarch64_libcollectdclient-devel.sha256sum] = "24a18e3c4035fef8cd4d7568fcd56c5cb3ba974300ecd9540ffe08addd692e63"

URI_aarch64_perl-Collectd = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Collectd-5.12.0-63.el10_1.aarch64.rpm;name=aarch64_perl-Collectd;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Collectd}"
SRC_URI[aarch64_perl-Collectd.sha256sum] = "ac3cfbe0e78bb69374e9e4e6bbb63d99dac2ea5a99713f0338b32cd02bf401a7"

RDEPENDS:collectd = " \
 bash \
 glibc \
 libgcrypt \
 libgpg-error \
 libmnl \
 systemd \
 "
RDEPENDS:collectd-amqp = " \
 collectd \
 glibc \
 librabbitmq \
 "
RDEPENDS:collectd-amqp1 = " \
 collectd \
 glibc \
 qpid-proton-c \
 "
RDEPENDS:collectd-apache = " \
 collectd \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-ascent = " \
 collectd \
 glibc \
 libxml2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-bind = " \
 collectd \
 glibc \
 libxml2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-chrony = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-curl = " \
 collectd \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-curl_xml = " \
 collectd \
 glibc \
 libxml2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-dbi = " \
 collectd \
 glibc \
 libdbi \
 "
RDEPENDS:collectd-disk = " \
 collectd \
 glibc \
 systemd-libs \
 "
RDEPENDS:collectd-dns = " \
 collectd \
 glibc \
 libpcap \
 "
RDEPENDS:collectd-drbd = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-email = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-generic-jmx = " \
 collectd \
 "
RDEPENDS:collectd-gps = " \
 collectd \
 glibc \
 gpsd-libs \
 "
RDEPENDS:collectd-hugepages = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-infiniband = " \
 glibc \
 "
RDEPENDS:collectd-ipmi = " \
 OpenIPMI-libs \
 collectd \
 glibc \
 "
RDEPENDS:collectd-ipvs = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-java = " \
 collectd \
 glibc \
 java-21-openjdk-headless \
 "
RDEPENDS:collectd-lua = " \
 collectd \
 glibc \
 lua-libs \
 "
RDEPENDS:collectd-mcelog = " \
 collectd \
 glibc \
 libgcc \
 "
RDEPENDS:collectd-mdevents = " \
 glibc \
 "
RDEPENDS:collectd-memcachec = " \
 collectd \
 glibc \
 libmemcached-awesome \
 "
RDEPENDS:collectd-modbus = " \
 collectd \
 glibc \
 libmodbus \
 "
RDEPENDS:collectd-mysql = " \
 collectd \
 glibc \
 mariadb-connector-c \
 "
RDEPENDS:collectd-netlink = " \
 collectd \
 glibc \
 libmnl \
 "
RDEPENDS:collectd-nginx = " \
 collectd \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-notify_desktop = " \
 collectd \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libnotify \
 "
RDEPENDS:collectd-notify_email = " \
 collectd \
 glibc \
 libesmtp \
 "
RDEPENDS:collectd-nut:x86_64_v2 = " \
 collectd \
 glibc \
 openssl-libs \
"
RDEPENDS:collectd-nut:aarch64 = " \
 collectd \
 glibc \
 nut-client \
 openssl-libs \
"
RDEPENDS:collectd-openldap = " \
 collectd \
 glibc \
 openldap \
 "
RDEPENDS:collectd-pinba = " \
 collectd \
 glibc \
 protobuf-c \
 "
RDEPENDS:collectd-ping = " \
 collectd \
 glibc \
 liboping \
 "
RDEPENDS:collectd-postgresql = " \
 collectd \
 glibc \
 libpq \
 "
RDEPENDS:collectd-python = " \
 collectd \
 glibc \
 python3-libs \
 "
RDEPENDS:collectd-redis = " \
 collectd \
 glibc \
 hiredis \
 "
RDEPENDS:collectd-rrdcached = " \
 collectd \
 glibc \
 rrdtool \
 "
RDEPENDS:collectd-rrdtool = " \
 collectd \
 glibc \
 rrdtool \
 "
RDEPENDS:collectd-sensors = " \
 collectd \
 glibc \
 lm_sensors-libs \
 "
RDEPENDS:collectd-smart = " \
 collectd \
 glibc \
 libatasmart \
 systemd-libs \
 "
RDEPENDS:collectd-snmp = " \
 collectd \
 glibc \
 net-snmp-libs \
 "
RDEPENDS:collectd-snmp_agent = " \
 collectd \
 glibc \
 net-snmp-agent-libs \
 "
RDEPENDS:collectd-synproxy = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-utils = " \
 collectd \
 glibc \
 libcollectdclient \
 "
RDEPENDS:collectd-varnish = " \
 collectd \
 glibc \
 varnish \
 "
RDEPENDS:collectd-virt = " \
 collectd \
 glibc \
 libvirt-libs \
 libxml2 \
 "
RDEPENDS:collectd-web = " \
 collectd \
 collectd-rrdtool \
 httpd \
 perl-CGI \
 perl-Carp \
 perl-Collectd \
 perl-Config-General \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Temp \
 perl-FindBin \
 perl-HTML-Parser \
 perl-JSON \
 perl-Regexp-Common \
 perl-URI \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 rrdtool-perl \
 "
RDEPENDS:collectd-write_http = " \
 collectd \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-write_kafka = " \
 collectd \
 glibc \
 librdkafka \
 "
RDEPENDS:collectd-write_prometheus = " \
 collectd \
 glibc \
 libmicrohttpd \
 protobuf-c \
 "
RDEPENDS:collectd-write_redis = " \
 collectd \
 glibc \
 hiredis \
 "
RDEPENDS:collectd-write_riemann = " \
 collectd \
 glibc \
 riemann-c-client \
 "
RDEPENDS:collectd-write_sensu = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-write_syslog = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-write_tsdb = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-zookeeper = " \
 collectd \
 glibc \
 "
RDEPENDS:libcollectdclient = " \
 glibc \
 libgcrypt \
 libgpg-error \
 "
RDEPENDS:libcollectdclient-devel = " \
 libcollectdclient \
 pkgconf-pkg-config \
 "
RDEPENDS:perl-Collectd = " \
 collectd \
 glibc \
 libxcrypt \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 "
