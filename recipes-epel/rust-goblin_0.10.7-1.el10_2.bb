# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-goblin"
PV = "0.10.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-goblin+alloc-devel \
 rust-goblin+archive-devel \
 rust-goblin+default-devel \
 rust-goblin+elf32-devel \
 rust-goblin+elf64-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin+log-devel \
 rust-goblin+mach32-devel \
 rust-goblin+mach64-devel \
 rust-goblin+pe32-devel \
 rust-goblin+pe64-devel \
 rust-goblin+std-devel \
 rust-goblin+te-devel \
 rust-goblin-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-goblin-0.10.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82ecddbb77d31e8fb6d9078933a3fd4ea4deb49ace9a4771d8dfde266d44b68c"

URI_x86_64_v2_rust-goblin+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+alloc-devel-0.10.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+alloc-devel}"
SRC_URI[x86_64_v2_rust-goblin+alloc-devel.sha256sum] = "ded65dae23e7ca1de41511a576ce434358edde550c47a8010dd2fdb3dc9ee0ca"

URI_x86_64_v2_rust-goblin+archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+archive-devel-0.10.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+archive-devel}"
SRC_URI[x86_64_v2_rust-goblin+archive-devel.sha256sum] = "71fd110d304a821d6bddf97c3c8d86e5abc6c552bd3d5f9b1159c7dbf332b1a0"

URI_x86_64_v2_rust-goblin+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+default-devel-0.10.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+default-devel}"
SRC_URI[x86_64_v2_rust-goblin+default-devel.sha256sum] = "a2f9148f11d73b1d093bb0f3ec8956b1d857368097cf3477d5c1e0c00d6263ed"

URI_x86_64_v2_rust-goblin+elf32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+elf32-devel-0.10.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+elf32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+elf32-devel}"
SRC_URI[x86_64_v2_rust-goblin+elf32-devel.sha256sum] = "924542833b0683588937caacc5e9229bd5b325bd74fa1b8f165bb2ab5baa79ea"

URI_x86_64_v2_rust-goblin+elf64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+elf64-devel-0.10.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+elf64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+elf64-devel}"
SRC_URI[x86_64_v2_rust-goblin+elf64-devel.sha256sum] = "adeea5553b38ca72542458a127a9ef1376321e7c6a2472fd4c2812725e27fe8f"

URI_x86_64_v2_rust-goblin+endian_fd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+endian_fd-devel-0.10.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+endian_fd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+endian_fd-devel}"
SRC_URI[x86_64_v2_rust-goblin+endian_fd-devel.sha256sum] = "5b14d11a2cdf7c22fc02c4dc57ffdb114d7af60ce640b912b583f3484d336205"

URI_x86_64_v2_rust-goblin+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+log-devel-0.10.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+log-devel}"
SRC_URI[x86_64_v2_rust-goblin+log-devel.sha256sum] = "c69bb0230925f8e2920857d50dc90b78ecb919339575ca75005fd4654c6a8782"

URI_x86_64_v2_rust-goblin+mach32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+mach32-devel-0.10.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+mach32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+mach32-devel}"
SRC_URI[x86_64_v2_rust-goblin+mach32-devel.sha256sum] = "c5c3fd1bb16a11902337d96f9b85b678dee3ab7245999b1435260889cb76f866"

URI_x86_64_v2_rust-goblin+mach64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+mach64-devel-0.10.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+mach64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+mach64-devel}"
SRC_URI[x86_64_v2_rust-goblin+mach64-devel.sha256sum] = "6ab511b9b954a90fa4f0999839f249d596a9214f908b8f46b99ec029fa99554e"

URI_x86_64_v2_rust-goblin+pe32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+pe32-devel-0.10.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+pe32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+pe32-devel}"
SRC_URI[x86_64_v2_rust-goblin+pe32-devel.sha256sum] = "33e721006879a8c2abcf881e337b30c423febdde6fb341b69a4f22c9f525acf2"

URI_x86_64_v2_rust-goblin+pe64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+pe64-devel-0.10.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+pe64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+pe64-devel}"
SRC_URI[x86_64_v2_rust-goblin+pe64-devel.sha256sum] = "ec54d9869c5aaeef6e77356443482bb0fb2689f02cc1f8b107fa17c8b4f7bb4a"

URI_x86_64_v2_rust-goblin+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+std-devel-0.10.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+std-devel}"
SRC_URI[x86_64_v2_rust-goblin+std-devel.sha256sum] = "a8545ca689c1e9783145d3dfb4621effbf205b56be6deca7022dd363efedc3b1"

URI_x86_64_v2_rust-goblin+te-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+te-devel-0.10.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+te-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+te-devel}"
SRC_URI[x86_64_v2_rust-goblin+te-devel.sha256sum] = "989fa9810d610a13c9d16b3dab889ba4d811fa007200076a4a011b3223a0abb8"

URI_x86_64_v2_rust-goblin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin-devel-0.10.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin-devel}"
SRC_URI[x86_64_v2_rust-goblin-devel.sha256sum] = "8d3eef005dd23666986702a33aa2653c70254f11855c8dcea1b81e3baa2a860e"

URI_aarch64_rust-goblin+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+alloc-devel-0.10.7-1.el10_2.noarch.rpm;name=aarch64_rust-goblin+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+alloc-devel}"
SRC_URI[aarch64_rust-goblin+alloc-devel.sha256sum] = "a33a3e27f83ec1145e25352193bc074eebe48ef561e2be2f2cd9a4f00072b636"

URI_aarch64_rust-goblin+archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+archive-devel-0.10.7-1.el10_2.noarch.rpm;name=aarch64_rust-goblin+archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+archive-devel}"
SRC_URI[aarch64_rust-goblin+archive-devel.sha256sum] = "3675e61349fff8b88e2ae22f008209107233df84d1e7287dfeb42877abde644b"

URI_aarch64_rust-goblin+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+default-devel-0.10.7-1.el10_2.noarch.rpm;name=aarch64_rust-goblin+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+default-devel}"
SRC_URI[aarch64_rust-goblin+default-devel.sha256sum] = "3914732bdf0025fcba5b4a3d883925d7f8f3052fecab02918bb227df5a373a3b"

URI_aarch64_rust-goblin+elf32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+elf32-devel-0.10.7-1.el10_2.noarch.rpm;name=aarch64_rust-goblin+elf32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+elf32-devel}"
SRC_URI[aarch64_rust-goblin+elf32-devel.sha256sum] = "f5a79fd62b43b343a020728d1e0557d21de93db8eb6a4aa44d69d4997bb251ba"

URI_aarch64_rust-goblin+elf64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+elf64-devel-0.10.7-1.el10_2.noarch.rpm;name=aarch64_rust-goblin+elf64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+elf64-devel}"
SRC_URI[aarch64_rust-goblin+elf64-devel.sha256sum] = "cf9b2da070c154552eabe916ba5c60eaa21edafc5d857606de9fc42a25a1fd5e"

URI_aarch64_rust-goblin+endian_fd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+endian_fd-devel-0.10.7-1.el10_2.noarch.rpm;name=aarch64_rust-goblin+endian_fd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+endian_fd-devel}"
SRC_URI[aarch64_rust-goblin+endian_fd-devel.sha256sum] = "7aa5bf24624a4d7de3f1c31ec958e657ed5fe5c33afef23a6c4b1d0976155398"

URI_aarch64_rust-goblin+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+log-devel-0.10.7-1.el10_2.noarch.rpm;name=aarch64_rust-goblin+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+log-devel}"
SRC_URI[aarch64_rust-goblin+log-devel.sha256sum] = "7b29f4245962733549004d22508911d51e4d29ed4e295eba185ab71dc4d4cd98"

URI_aarch64_rust-goblin+mach32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+mach32-devel-0.10.7-1.el10_2.noarch.rpm;name=aarch64_rust-goblin+mach32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+mach32-devel}"
SRC_URI[aarch64_rust-goblin+mach32-devel.sha256sum] = "0619ec7afef7ce89f62b573d3bd87210a10b583c427e74e75d1e81d3328f1877"

URI_aarch64_rust-goblin+mach64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+mach64-devel-0.10.7-1.el10_2.noarch.rpm;name=aarch64_rust-goblin+mach64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+mach64-devel}"
SRC_URI[aarch64_rust-goblin+mach64-devel.sha256sum] = "110286d3c9c42e24b5c4140a41c071af565afad5eed139789f2fe56198b2065f"

URI_aarch64_rust-goblin+pe32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+pe32-devel-0.10.7-1.el10_2.noarch.rpm;name=aarch64_rust-goblin+pe32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+pe32-devel}"
SRC_URI[aarch64_rust-goblin+pe32-devel.sha256sum] = "dabf12a0d0eb0b8ef4a2b50f1c166085365a6ea25112afd671c9a2e4e8aa1d7b"

URI_aarch64_rust-goblin+pe64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+pe64-devel-0.10.7-1.el10_2.noarch.rpm;name=aarch64_rust-goblin+pe64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+pe64-devel}"
SRC_URI[aarch64_rust-goblin+pe64-devel.sha256sum] = "38028099baa88cf1fdf7d56c37f9833caa9213fe0315f148e1114c568693cbda"

URI_aarch64_rust-goblin+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+std-devel-0.10.7-1.el10_2.noarch.rpm;name=aarch64_rust-goblin+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+std-devel}"
SRC_URI[aarch64_rust-goblin+std-devel.sha256sum] = "96f51f67c6a8759269f87f5120d040c3d461e40e36255c5c2d438261a999f0dd"

URI_aarch64_rust-goblin+te-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+te-devel-0.10.7-1.el10_2.noarch.rpm;name=aarch64_rust-goblin+te-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+te-devel}"
SRC_URI[aarch64_rust-goblin+te-devel.sha256sum] = "e6f138d78cc048c597d885ec32a9fdd8479728d3aa6a1c8edfaa5bb67f8b30d7"

URI_aarch64_rust-goblin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin-devel-0.10.7-1.el10_2.noarch.rpm;name=aarch64_rust-goblin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin-devel}"
SRC_URI[aarch64_rust-goblin-devel.sha256sum] = "e37d7eb77252861a7f9cb13f627ccc3ed7228419c35549165f734ebdb70d73f4"

RDEPENDS:rust-goblin+alloc-devel = " \
 cargo \
 rust-goblin+log-devel \
 rust-goblin-devel \
 rust-scroll+derive-devel \
 "
RDEPENDS:rust-goblin+archive-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+default-devel = " \
 cargo \
 rust-goblin+archive-devel \
 rust-goblin+elf32-devel \
 rust-goblin+elf64-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin+mach32-devel \
 rust-goblin+mach64-devel \
 rust-goblin+pe32-devel \
 rust-goblin+pe64-devel \
 rust-goblin+std-devel \
 rust-goblin+te-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+elf32-devel = " \
 cargo \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+elf64-devel = " \
 cargo \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+endian_fd-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+log-devel = " \
 cargo \
 rust-goblin-devel \
 rust-log-devel \
 "
RDEPENDS:rust-goblin+mach32-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+archive-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+mach64-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+archive-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+pe32-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+pe64-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+std-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin-devel \
 rust-scroll+std-devel \
 "
RDEPENDS:rust-goblin+te-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin-devel = " \
 cargo \
 rust \
 rust-plain+default-devel \
 rust-scroll-devel \
 "
