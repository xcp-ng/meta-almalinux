# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "systemd-extras"
PV = "257.9"
PR = "2.el10_0"
PACKAGES = " \
 systemd-networkd \
 systemd-networkd-defaults \
 systemd-timesyncd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/systemd-extras-257.9-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f19c4c0f83ca68bea31a6cf26d8d5501606bdbc515f3a4678d8de80debe4d6ca"

URI_x86_64_v2_systemd-networkd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/systemd-networkd-257.9-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_systemd-networkd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-networkd}"
SRC_URI[x86_64_v2_systemd-networkd.sha256sum] = "3002337190f45f26703da799a82d331516bcf962c33d54fd2c6b99136ff78893"

URI_x86_64_v2_systemd-networkd-defaults = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/systemd-networkd-defaults-257.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_systemd-networkd-defaults;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-networkd-defaults}"
SRC_URI[x86_64_v2_systemd-networkd-defaults.sha256sum] = "b835c8dcbbd602552e1a39bbbd14c681c6fccae2f04b6ca1ee797551fb23222b"

URI_x86_64_v2_systemd-timesyncd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/systemd-timesyncd-257.9-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_systemd-timesyncd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-timesyncd}"
SRC_URI[x86_64_v2_systemd-timesyncd.sha256sum] = "13ef07ab9ee2a4b7323cb4885256299c641eb82df31f2f40395f7d44a653a569"

URI_aarch64_systemd-networkd = "${EPEL_MIRROR}/aarch64/Packages/s/systemd-networkd-257.9-2.el10_0.aarch64.rpm;name=aarch64_systemd-networkd;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-networkd}"
SRC_URI[aarch64_systemd-networkd.sha256sum] = "16dbe09e163d07096bae24697b5df1e9d8308ca19840185d17d8a9214a55e409"

URI_aarch64_systemd-networkd-defaults = "${EPEL_MIRROR}/aarch64/Packages/s/systemd-networkd-defaults-257.9-2.el10_0.noarch.rpm;name=aarch64_systemd-networkd-defaults;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-networkd-defaults}"
SRC_URI[aarch64_systemd-networkd-defaults.sha256sum] = "01acd4372e38113d04589195ef51a6b1c7f47480b8e5d759c83e2265746acd85"

URI_aarch64_systemd-timesyncd = "${EPEL_MIRROR}/aarch64/Packages/s/systemd-timesyncd-257.9-2.el10_0.aarch64.rpm;name=aarch64_systemd-timesyncd;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-timesyncd}"
SRC_URI[aarch64_systemd-timesyncd.sha256sum] = "22d9c908ccb92baa58433a09e311b98db0e713ac6228f62b1b41a864a152dc6e"

RDEPENDS:systemd-networkd = " \
 bash \
 dbus \
 glibc \
 libcap \
 libgcc \
 libmount \
 libselinux \
 shadow-utils \
 systemd \
 virtual/util-linux-core_or_util-linux \
 "
RDEPENDS:systemd-networkd-defaults = " \
 systemd-networkd \
 "
RDEPENDS:systemd-timesyncd = " \
 bash \
 dbus \
 glibc \
 libcap \
 libgcc \
 libselinux \
 shadow-utils \
 systemd \
 virtual/util-linux-core_or_util-linux \
 "
