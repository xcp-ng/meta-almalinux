# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opendmarc"
PV = "1.4.2"
PR = "33.el10_1"
PACKAGES = " \
 libopendmarc \
 libopendmarc-devel \
 opendmarc \
 opendmarc-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opendmarc-1.4.2-33.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07b85e18cf7ec8ece80113ffe1dc7f91a2f5a4934607e3364b09855790d02d7f"

URI_x86_64_v2_libopendmarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopendmarc-1.4.2-33.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopendmarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopendmarc}"
SRC_URI[x86_64_v2_libopendmarc.sha256sum] = "500c3d02bade6fe3560c3bb47c3dfd7047c8d99272178e2167030a926746a75a"

URI_x86_64_v2_libopendmarc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopendmarc-devel-1.4.2-33.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopendmarc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopendmarc-devel}"
SRC_URI[x86_64_v2_libopendmarc-devel.sha256sum] = "a043c120b5493d81c1d0732bd981b8759379de0105de3c4a6cb84058cda4db0c"

URI_x86_64_v2_opendmarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendmarc-1.4.2-33.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendmarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendmarc}"
SRC_URI[x86_64_v2_opendmarc.sha256sum] = "4da8f2712144b65f65480c21e5bb8fcc792f394cabb6d952f75952b2668ff32a"

URI_x86_64_v2_opendmarc-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendmarc-tools-1.4.2-33.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendmarc-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendmarc-tools}"
SRC_URI[x86_64_v2_opendmarc-tools.sha256sum] = "097aa7fadab008bfe7c7a0e805dcf6c0705d1ee54183f0f7ccf666bd4ef34042"

URI_aarch64_libopendmarc = "${EPEL_MIRROR}/aarch64/Packages/l/libopendmarc-1.4.2-33.el10_1.aarch64.rpm;name=aarch64_libopendmarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopendmarc}"
SRC_URI[aarch64_libopendmarc.sha256sum] = "1c9266d163a1e964de4d80df342df5b4112d66722acef5084f7d70784c4e8c11"

URI_aarch64_libopendmarc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libopendmarc-devel-1.4.2-33.el10_1.aarch64.rpm;name=aarch64_libopendmarc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopendmarc-devel}"
SRC_URI[aarch64_libopendmarc-devel.sha256sum] = "8531921c8344c0d4d00d409ffc25717cde940dbe8161a96bf25dbb89bdff215d"

URI_aarch64_opendmarc = "${EPEL_MIRROR}/aarch64/Packages/o/opendmarc-1.4.2-33.el10_1.aarch64.rpm;name=aarch64_opendmarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendmarc}"
SRC_URI[aarch64_opendmarc.sha256sum] = "f9a0434c68fa8bdffa28bcbc8830e5060acb75db3d20c1ccaf8734a0855965a0"

URI_aarch64_opendmarc-tools = "${EPEL_MIRROR}/aarch64/Packages/o/opendmarc-tools-1.4.2-33.el10_1.aarch64.rpm;name=aarch64_opendmarc-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendmarc-tools}"
SRC_URI[aarch64_opendmarc-tools.sha256sum] = "8f0966f7963066fc924c630a6a9c55e819c885001f966504b16bb2f9fad6a314"

RDEPENDS:libopendmarc = " \
 glibc \
 libspf2 \
 "
RDEPENDS:libopendmarc-devel = " \
 libopendmarc \
 "
RDEPENDS:opendmarc = " \
 bash \
 glibc \
 libopendmarc \
 sendmail-milter \
 shadow-utils \
 "
RDEPENDS:opendmarc-tools = " \
 bash \
 libopendmarc \
 perl-DBD-MySQL \
 perl-DBI \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Compress \
 perl-JSON \
 perl-MIME-Base64 \
 perl-POSIX \
 perl-Switch \
 perl-Time-Local \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 "
