# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytesize"
PV = "1.3.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-bytesize+default-devel \
 rust-bytesize+serde-devel \
 rust-bytesize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytesize-1.3.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e9c136ed40692cea02556cbbc5feee92ef874a699cae562355abf19c5739a35"

URI_x86_64_v2_rust-bytesize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize+default-devel-1.3.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize+default-devel}"
SRC_URI[x86_64_v2_rust-bytesize+default-devel.sha256sum] = "c660f068eb3feab91f70182e38dcdc21fc171df4394f414931df4a9360bfbb05"

URI_x86_64_v2_rust-bytesize+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize+serde-devel-1.3.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize+serde-devel}"
SRC_URI[x86_64_v2_rust-bytesize+serde-devel.sha256sum] = "ff897ee5d46f0847dfb74011bd57c81c4e15f49973f0dbd8a5c169aecf3b32a2"

URI_x86_64_v2_rust-bytesize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize-devel-1.3.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize-devel}"
SRC_URI[x86_64_v2_rust-bytesize-devel.sha256sum] = "5eb2facdfac795c0726d8fba7ded9d5445e8336d9b861847d70de633fc4d06bd"

URI_aarch64_rust-bytesize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize+default-devel-1.3.3-1.el10_0.noarch.rpm;name=aarch64_rust-bytesize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize+default-devel}"
SRC_URI[aarch64_rust-bytesize+default-devel.sha256sum] = "d3213f884a87cddc226e42f0f8e46ac9fb3b2114f22a5459d0b22a414d0b01ab"

URI_aarch64_rust-bytesize+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize+serde-devel-1.3.3-1.el10_0.noarch.rpm;name=aarch64_rust-bytesize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize+serde-devel}"
SRC_URI[aarch64_rust-bytesize+serde-devel.sha256sum] = "c0e03a222c494d7789ce77ba7bbfe0493b115fc6e5b09584f2e19f49d2feab7c"

URI_aarch64_rust-bytesize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize-devel-1.3.3-1.el10_0.noarch.rpm;name=aarch64_rust-bytesize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize-devel}"
SRC_URI[aarch64_rust-bytesize-devel.sha256sum] = "d710145584b392191fe28401dc5c31f100717300733eda35097d05768edc4379"

RDEPENDS:rust-bytesize+default-devel = " \
 cargo \
 rust-bytesize-devel \
 "
RDEPENDS:rust-bytesize+serde-devel = " \
 cargo \
 rust-bytesize-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-bytesize-devel = " \
 cargo \
 rust \
 "
