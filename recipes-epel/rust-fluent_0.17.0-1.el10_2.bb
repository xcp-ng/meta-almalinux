# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fluent"
PV = "0.17.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-fluent+default-devel \
 rust-fluent-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fluent-0.17.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9d6f9aaa6bb3312148be4043aa6d1b3230b01bb282ae279972f169932fdc73a"

URI_x86_64_v2_rust-fluent+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent+default-devel-0.17.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent+default-devel}"
SRC_URI[x86_64_v2_rust-fluent+default-devel.sha256sum] = "7c45475cdfdf9c686b3e2b5c7e86619ad39312592243eb72e5698740ae17256d"

URI_x86_64_v2_rust-fluent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-devel-0.17.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-devel}"
SRC_URI[x86_64_v2_rust-fluent-devel.sha256sum] = "165254fb0022389464d1d083f104701a84da8f4aa04df356d1527b1c602d98bb"

URI_aarch64_rust-fluent+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent+default-devel-0.17.0-1.el10_2.noarch.rpm;name=aarch64_rust-fluent+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent+default-devel}"
SRC_URI[aarch64_rust-fluent+default-devel.sha256sum] = "86ea35666610b7fa634086f50e3b1bf7df5ea7f68869b3834f0848ed0d9f22b8"

URI_aarch64_rust-fluent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-devel-0.17.0-1.el10_2.noarch.rpm;name=aarch64_rust-fluent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-devel}"
SRC_URI[aarch64_rust-fluent-devel.sha256sum] = "27d7f2539f3481a5a265a497a77a49d21171ecf275b5f1f00ba85651e7398ff4"

RDEPENDS:rust-fluent+default-devel = " \
 cargo \
 rust-fluent-devel \
 "
RDEPENDS:rust-fluent-devel = " \
 cargo \
 rust \
 rust-fluent-bundle+default-devel \
 rust-unic-langid+default-devel \
 "
