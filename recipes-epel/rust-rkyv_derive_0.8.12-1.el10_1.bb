# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rkyv_derive"
PV = "0.8.12"
PR = "1.el10_1"
PACKAGES = " \
 rust-rkyv_derive+bytecheck-devel \
 rust-rkyv_derive+default-devel \
 rust-rkyv_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rkyv_derive-0.8.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4182d26c9fe2f0170ef46d58b1565717be27b1bb7d09283d8f005615292ff0ae"

URI_x86_64_v2_rust-rkyv_derive+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive+bytecheck-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive+bytecheck-devel.sha256sum] = "65f98758611bb026c803d1e544742cb94b29451765226bc9be380c2d972f9572"

URI_x86_64_v2_rust-rkyv_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive+default-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive+default-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive+default-devel.sha256sum] = "3a085d1a512f643988166c61852a7cb00f17e4c10ce7c52611198aeeabdec96e"

URI_x86_64_v2_rust-rkyv_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive-devel.sha256sum] = "b68ddcea5bf6b450cc20782a8467b709425993765b22ebf34342fd91d2756a75"

URI_aarch64_rust-rkyv_derive+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive+bytecheck-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv_derive+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive+bytecheck-devel}"
SRC_URI[aarch64_rust-rkyv_derive+bytecheck-devel.sha256sum] = "1f8e7fad60aa5607b404f9efa940fb5dc38fd0fab16b71cc30008b7f4720a6db"

URI_aarch64_rust-rkyv_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive+default-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive+default-devel}"
SRC_URI[aarch64_rust-rkyv_derive+default-devel.sha256sum] = "e0d2b058524806f1b0e59582731a6592f800cfa9ec51ee1002273919d76cbb5b"

URI_aarch64_rust-rkyv_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive-devel}"
SRC_URI[aarch64_rust-rkyv_derive-devel.sha256sum] = "5057e245ba9d88414bb1c8b0111545361c38c08eeb9ec8fbe0d3cd073b6dbcb2"

RDEPENDS:rust-rkyv_derive+bytecheck-devel = " \
 cargo \
 rust-rkyv_derive-devel \
 "
RDEPENDS:rust-rkyv_derive+default-devel = " \
 cargo \
 rust-rkyv_derive-devel \
 "
RDEPENDS:rust-rkyv_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
