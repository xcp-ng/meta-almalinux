# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cairomm1.16"
PV = "1.18.0"
PR = "6.el10"
PACKAGES = " \
 cairomm1.16 \
 cairomm1.16-devel \
 cairomm1.16-doc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cairomm1.16-1.18.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f24481458b644956f60e0bc5e3ac15807573f9df5526a17a0f5a049ff2b3779a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cairomm1.16-1.18.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_cairomm1.16;unpack=0"
SRC_URI[x86_64_v2_cairomm1.16.sha256sum] = "006aeba8ec89ec4e217ff7cbc3c1527a91a09423fbfa92bd884c3edee2d4e693"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cairomm1.16-devel-1.18.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_cairomm1.16-devel;unpack=0"
SRC_URI[x86_64_v2_cairomm1.16-devel.sha256sum] = "234fa180e688f4b72d3ff7dd561af4130d675e94cbc9631118987ee6fcdbef83"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cairomm1.16-doc-1.18.0-6.el10.noarch.rpm;name=x86_64_v2_cairomm1.16-doc;unpack=0"
SRC_URI[x86_64_v2_cairomm1.16-doc.sha256sum] = "f659e29bdbc0759cc159bae5309cea4583af97493b6d447f330692374cc08313"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cairomm1.16-1.18.0-6.el10.aarch64.rpm;name=aarch64_cairomm1.16;unpack=0"
SRC_URI[aarch64_cairomm1.16.sha256sum] = "4faf89075fe554b5548d7fe2d549aa55c5406abd3af90f84423b98f0bf16e6a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cairomm1.16-devel-1.18.0-6.el10.aarch64.rpm;name=aarch64_cairomm1.16-devel;unpack=0"
SRC_URI[aarch64_cairomm1.16-devel.sha256sum] = "a7e09daf214ff29d60a576b6f13e6048cc0cc24835098f5b3aa3bdaf344b60da"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cairomm1.16-doc-1.18.0-6.el10.noarch.rpm;name=aarch64_cairomm1.16-doc;unpack=0"
SRC_URI[aarch64_cairomm1.16-doc.sha256sum] = "f659e29bdbc0759cc159bae5309cea4583af97493b6d447f330692374cc08313"

RDEPENDS:cairomm1.16 = " \
 cairo \
 glibc \
 libgcc \
 libsigc++30 \
 libstdc++ \
 "
RDEPENDS:cairomm1.16-devel = " \
 cairo-devel \
 cairomm1.16 \
 cairomm1.16-devel \
 libsigc++30-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:cairomm1.16-doc = " \
 "
