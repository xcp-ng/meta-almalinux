# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-atoi"
PV = "2.0.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-atoi+default-devel \
 rust-atoi+std-devel \
 rust-atoi-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-atoi-2.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4c206419580db9d7a3ecdd43d6837fea993e079a3f7fbca7e982fd77313bbc7e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atoi+default-devel-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atoi+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-atoi+default-devel.sha256sum] = "d6022bfa4f20fe36f1f63955f4d36fda525a1bcc4661287462982184f7622724"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atoi+std-devel-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atoi+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-atoi+std-devel.sha256sum] = "dd1a487390f52ad98ec06f7c3178f0bca07c9f1708cfd251aa1e15ac88b4de9a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atoi-devel-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atoi-devel;unpack=0"
SRC_URI[x86_64_v2_rust-atoi-devel.sha256sum] = "7a4f9942d24acb2c1241f99b16d1450dacd5d349429680076d7489b89ac1fc08"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-atoi+default-devel-2.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-atoi+default-devel;unpack=0"
SRC_URI[aarch64_rust-atoi+default-devel.sha256sum] = "8788515da3c2afe48bbe2b4dd89b80e45e83eebb2ff9e65aa6de0901a22c5f41"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-atoi+std-devel-2.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-atoi+std-devel;unpack=0"
SRC_URI[aarch64_rust-atoi+std-devel.sha256sum] = "ecba77559590f611981876d15c7e8331be9eab7e41c301dee229c121546634de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-atoi-devel-2.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-atoi-devel;unpack=0"
SRC_URI[aarch64_rust-atoi-devel.sha256sum] = "6886b95d8c76de2a1dca77e54d4aa4dac352ce72378ca02fc8e3536b3c59dca1"

RDEPENDS:rust-atoi+default-devel = " \
 cargo \
 rust-atoi+std-devel \
 rust-atoi-devel \
 "
RDEPENDS:rust-atoi+std-devel = " \
 cargo \
 rust-atoi-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-atoi-devel = " \
 cargo \
 rust \
 rust-num-traits-devel \
 "
