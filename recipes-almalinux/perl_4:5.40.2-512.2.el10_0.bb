# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl"
PE = "4"
PV = "5.40.2"
PR = "512.2.el10_0"
PACKAGES = " \
 perl \
 perl-Attribute-Handlers \
 perl-AutoLoader \
 perl-AutoSplit \
 perl-B \
 perl-Benchmark \
 perl-Class-Struct \
 perl-Config-Extensions \
 perl-DBM_Filter \
 perl-Devel-Peek \
 perl-Devel-SelfStubber \
 perl-DirHandle \
 perl-Dumpvalue \
 perl-DynaLoader \
 perl-English \
 perl-Errno \
 perl-ExtUtils-Constant \
 perl-ExtUtils-Embed \
 perl-ExtUtils-Miniperl \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-DosGlob \
 perl-File-Find \
 perl-File-stat \
 perl-FileCache \
 perl-FileHandle \
 perl-FindBin \
 perl-GDBM_File \
 perl-Getopt-Std \
 perl-Hash-Util \
 perl-Hash-Util-FieldHash \
 perl-I18N-Collate \
 perl-I18N-LangTags \
 perl-I18N-Langinfo \
 perl-IO \
 perl-IPC-Open3 \
 perl-Locale-Maketext-Simple \
 perl-Math-Complex \
 perl-Memoize \
 perl-Module-Loaded \
 perl-NDBM_File \
 perl-NEXT \
 perl-Net \
 perl-ODBM_File \
 perl-Opcode \
 perl-POSIX \
 perl-Pod-Functions \
 perl-Pod-Html \
 perl-Safe \
 perl-Search-Dict \
 perl-SelectSaver \
 perl-SelfLoader \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Term-Complete \
 perl-Term-ReadLine \
 perl-Test \
 perl-Text-Abbrev \
 perl-Thread \
 perl-Thread-Semaphore \
 perl-Tie \
 perl-Tie-File \
 perl-Tie-Memoize \
 perl-Time \
 perl-Time-Piece \
 perl-Unicode-UCD \
 perl-User-pwent \
 perl-autouse \
 perl-base \
 perl-blib \
 perl-debugger \
 perl-deprecate \
 perl-devel \
 perl-diagnostics \
 perl-doc \
 perl-encoding-warnings \
 perl-fields \
 perl-filetest \
 perl-if \
 perl-interpreter \
 perl-less \
 perl-lib \
 perl-libnetcfg \
 perl-libs \
 perl-locale \
 perl-macros \
 perl-meta-notation \
 perl-mro \
 perl-open \
 perl-overload \
 perl-overloading \
 perl-ph \
 perl-sigtrap \
 perl-sort \
 perl-subs \
 perl-utils \
 perl-vars \
 perl-vmsish \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-5.40.2-512.2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e55a9a691c520f7a14a4789af3e8827d399d90ee880098d5d25f324dd3d9aa31"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-5.40.2-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl;unpack=0"
SRC_URI[x86_64_v2_perl.sha256sum] = "d835025bc423c8e6a71c0294d9bd57d269fa48f5b22619bff1e277817a378253"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Attribute-Handlers-1.03-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Attribute-Handlers;unpack=0"
SRC_URI[x86_64_v2_perl-Attribute-Handlers.sha256sum] = "b671a0b7f9c801750e8e19a30f8f379b4e7789802c6413fcac8f48ed2c4edca4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-AutoLoader-5.74-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-AutoLoader;unpack=0"
SRC_URI[x86_64_v2_perl-AutoLoader.sha256sum] = "53bc4548f39fb0a9fbd261f2e4b914ea585f18ad72767585809dc8cbfcfdf54e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-AutoSplit-5.74-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-AutoSplit;unpack=0"
SRC_URI[x86_64_v2_perl-AutoSplit.sha256sum] = "048997a89ebaf1ab8c1125ded3c79ca35dfe78a2358d062a4be7ab272eeabdaf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-B-1.89-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-B;unpack=0"
SRC_URI[x86_64_v2_perl-B.sha256sum] = "299c79fa327708340113c8716d9278876a6abc4da6e385f9c536114001241382"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Benchmark-1.25-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Benchmark;unpack=0"
SRC_URI[x86_64_v2_perl-Benchmark.sha256sum] = "37a875f24d8c59c1be3c37d56b140b8985ad8ea1b0c966eb509497a43b0eb5e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Class-Struct-0.68-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Class-Struct;unpack=0"
SRC_URI[x86_64_v2_perl-Class-Struct.sha256sum] = "63cac7d1530a3747e4933d761822e36848a41df4ddca9e92619fb03eabf30701"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Config-Extensions-0.03-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Config-Extensions;unpack=0"
SRC_URI[x86_64_v2_perl-Config-Extensions.sha256sum] = "223eb5b17a9e8b6117e00c64f1a53e87409e635df340119c73c378ce1fda5728"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DBM_Filter-0.06-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-DBM_Filter;unpack=0"
SRC_URI[x86_64_v2_perl-DBM_Filter.sha256sum] = "dffdf4725b8218c6475e02522be07c6797831b4d9eaa51b3479682a490b6abe5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Devel-Peek-1.34-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-Devel-Peek;unpack=0"
SRC_URI[x86_64_v2_perl-Devel-Peek.sha256sum] = "9530766366e750488cda62c51eec1730f883251778cd789ef1d0a82fa4ffa707"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Devel-SelfStubber-1.06-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Devel-SelfStubber;unpack=0"
SRC_URI[x86_64_v2_perl-Devel-SelfStubber.sha256sum] = "f0f5db2d1649e598dc78eb2772042d2b69672e5fd80fc6e73606e48b8e8dde18"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DirHandle-1.05-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-DirHandle;unpack=0"
SRC_URI[x86_64_v2_perl-DirHandle.sha256sum] = "5997885a83e4096f47516a8bd8a88cf47dbd220506c6cc95852e97a7465aa0a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Dumpvalue-2.27-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Dumpvalue;unpack=0"
SRC_URI[x86_64_v2_perl-Dumpvalue.sha256sum] = "9c060432fbf3cb704f3cf89cc6d7de6bb7027640a68b65f337f8604198fb9d10"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DynaLoader-1.56-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-DynaLoader;unpack=0"
SRC_URI[x86_64_v2_perl-DynaLoader.sha256sum] = "92a7e26562fb030b4f9792bc4b3649021bbd35a4ca8a894cf0ce173bf284a0ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-English-1.11-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-English;unpack=0"
SRC_URI[x86_64_v2_perl-English.sha256sum] = "c4f75ec15d4f116fcefb043c119694afddc539ec6ddca012e8a4cff52cc41574"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Errno-1.38-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-Errno;unpack=0"
SRC_URI[x86_64_v2_perl-Errno.sha256sum] = "5044f891cbfedea55516ab1fc01c41cee4d0646818f4b6b3f087803184e3dc35"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Constant-0.25-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Constant;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-Constant.sha256sum] = "1d38e0933868701cf484bf8d5890f6c156fd3c752a6830af3d89fce18023182d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Embed-1.35-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Embed;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-Embed.sha256sum] = "f2934b9b01b68603a1d0c578bada4296fec9973582b6a7f77ad374251e09fbd8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Miniperl-1.14-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Miniperl;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-Miniperl.sha256sum] = "14961e1af22b64acb19673097b7971d92b4b85e64c3ab50ac2f4f2631323b6f1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Fcntl-1.18-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-Fcntl;unpack=0"
SRC_URI[x86_64_v2_perl-Fcntl.sha256sum] = "85ebf9d3ab9fdf52e94d4757d066eaa0f55db13bf2882ce2e267dc3c6481b23d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Basename-2.86-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-File-Basename;unpack=0"
SRC_URI[x86_64_v2_perl-File-Basename.sha256sum] = "5598d9f2546e0c8f7a6e82d905419a8373d9f2ba4b9ae3dc2884a818ecfb6146"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Compare-1.100.800-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-File-Compare;unpack=0"
SRC_URI[x86_64_v2_perl-File-Compare.sha256sum] = "6e69452bc13d226a2618fffe2c76abc4fb0fe1a303f2e6bb9f4ed84c49a0b7ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Copy-2.41-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-File-Copy;unpack=0"
SRC_URI[x86_64_v2_perl-File-Copy.sha256sum] = "e74610604daf45aea68e0f6ae1a7c6981d153938f1735a6653f53d3c0d7466b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-DosGlob-1.12-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-File-DosGlob;unpack=0"
SRC_URI[x86_64_v2_perl-File-DosGlob.sha256sum] = "cd713340f6e7a211d378f2265dc87a38aeadbca7f375c1a38a6bf418713b07cc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Find-1.44-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-File-Find;unpack=0"
SRC_URI[x86_64_v2_perl-File-Find.sha256sum] = "5edeec3ce9dc61a46d51647ae2649ffd16116b8f5379d229f783a491d530dd4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-stat-1.14-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-File-stat;unpack=0"
SRC_URI[x86_64_v2_perl-File-stat.sha256sum] = "b2cdf08c9db15b3600cd09fd7d73bebd52b01e2c624344452ac707dca8b46807"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-FileCache-1.10-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-FileCache;unpack=0"
SRC_URI[x86_64_v2_perl-FileCache.sha256sum] = "64c3171882013c4402ec357a3765ae9275b1bc42953a3bbe496e33c4c6971045"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-FileHandle-2.05-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-FileHandle;unpack=0"
SRC_URI[x86_64_v2_perl-FileHandle.sha256sum] = "fe363bc7cd02e2327f6dc5d3683d2c1844bb9abb2773e62eeb2552537820806d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-FindBin-1.54-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-FindBin;unpack=0"
SRC_URI[x86_64_v2_perl-FindBin.sha256sum] = "b395447c9105957be78f21e694a114a411d6cd7661c0ad8669438dab91f4aa35"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-GDBM_File-1.24-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-GDBM_File;unpack=0"
SRC_URI[x86_64_v2_perl-GDBM_File.sha256sum] = "f067ddb040c88332a605a43cae40e4d67cfdcb968bdab5f020f37c79d363a944"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Getopt-Std-1.14-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Getopt-Std;unpack=0"
SRC_URI[x86_64_v2_perl-Getopt-Std.sha256sum] = "2dade822b0fbcec4e75d99cd1bafb900622189a8f5ecfa3e40aca5c9d4256eaf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Hash-Util-0.32-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-Hash-Util;unpack=0"
SRC_URI[x86_64_v2_perl-Hash-Util.sha256sum] = "1227832c9345ade68185a918cf13168258a2078ceb9d77ab9500a24efc44c0d7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Hash-Util-FieldHash-1.27-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-Hash-Util-FieldHash;unpack=0"
SRC_URI[x86_64_v2_perl-Hash-Util-FieldHash.sha256sum] = "157e895be2e4b02c252543c3bbe8c08208c15790ffb6fd17d056e33a34898cd8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-I18N-Collate-1.02-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-I18N-Collate;unpack=0"
SRC_URI[x86_64_v2_perl-I18N-Collate.sha256sum] = "939759f5a06d0b0f330bb0ce0f13d3a5627157247a7b0adc56ef69a55bddc3c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-I18N-LangTags-0.45-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-I18N-LangTags;unpack=0"
SRC_URI[x86_64_v2_perl-I18N-LangTags.sha256sum] = "e04165f70f30d473b7690185275149f79bff42212ccf7affce3896cf3572eda1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-I18N-Langinfo-0.24-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-I18N-Langinfo;unpack=0"
SRC_URI[x86_64_v2_perl-I18N-Langinfo.sha256sum] = "e566d75168c4b77823f881c642141fa996cac35380a834d5269608bbf0266d2e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-IO-1.55-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-IO;unpack=0"
SRC_URI[x86_64_v2_perl-IO.sha256sum] = "8b875342b4c5d6f5e9bc681e9f22059dfeba3518fd667d6f62a8df24d7f60363"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-IPC-Open3-1.22-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-IPC-Open3;unpack=0"
SRC_URI[x86_64_v2_perl-IPC-Open3.sha256sum] = "40995d475afb4445b4ad4fa52310d873c8814776de5c35be16de6fb6f1cf0c98"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Locale-Maketext-Simple-0.21-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Locale-Maketext-Simple;unpack=0"
SRC_URI[x86_64_v2_perl-Locale-Maketext-Simple.sha256sum] = "912b3b1496ce93980f16432e5db249038b2d2b896b481b125de8948ffe4fddb7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Math-Complex-1.62-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Math-Complex;unpack=0"
SRC_URI[x86_64_v2_perl-Math-Complex.sha256sum] = "22bdd66628ba9a425828abde67f00496ee1716e4d576c09d6ebdfa09695f3466"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Memoize-1.16-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Memoize;unpack=0"
SRC_URI[x86_64_v2_perl-Memoize.sha256sum] = "c377b1e0afc48190cc512e339e69a7bb43ea85235235dc62b985aa8b56348878"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Module-Loaded-0.08-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Module-Loaded;unpack=0"
SRC_URI[x86_64_v2_perl-Module-Loaded.sha256sum] = "4cc67d8f80d85af1172b7f4eedc1ad51e8cfcb1599a35fa292c429a3cc08769c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-NDBM_File-1.17-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-NDBM_File;unpack=0"
SRC_URI[x86_64_v2_perl-NDBM_File.sha256sum] = "bd97e0426e16d55c548a4f8e290398b73843238ac11d24481480ddbe63b07488"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-NEXT-0.69-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-NEXT;unpack=0"
SRC_URI[x86_64_v2_perl-NEXT.sha256sum] = "f29468443156b0ac7e028290e3a49ccebe224e9fa40f684e1f8ea242e29a8975"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Net-1.04-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Net;unpack=0"
SRC_URI[x86_64_v2_perl-Net.sha256sum] = "4b274944172be9d1bd3d908985dd39a30a41e694c9dbffa288c645d9cdff5c99"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ODBM_File-1.18-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-ODBM_File;unpack=0"
SRC_URI[x86_64_v2_perl-ODBM_File.sha256sum] = "98ceede037cda31f4332e6918af29ccd2c743b8621360d31da081f5e90190893"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Opcode-1.65-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-Opcode;unpack=0"
SRC_URI[x86_64_v2_perl-Opcode.sha256sum] = "77752937f75d640f13152d360aa3f6b4b051d583cf68ccf18f2a7e3f154ab83a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-POSIX-2.20-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-POSIX;unpack=0"
SRC_URI[x86_64_v2_perl-POSIX.sha256sum] = "8bafdc473de1a8fc7c922e9a5d21c1bf3457e41ee60ca7998e4c25ffa7c9c523"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Pod-Functions-1.14-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Pod-Functions;unpack=0"
SRC_URI[x86_64_v2_perl-Pod-Functions.sha256sum] = "3be3c74616e23076fa7d4d6c83766b1fcbcfc3e51195dc8e962791c9f2961c2b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Pod-Html-1.35-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Pod-Html;unpack=0"
SRC_URI[x86_64_v2_perl-Pod-Html.sha256sum] = "461454a236dc1a993701be0d6cb278150d98c5aa7fea8e3947c00dc714515454"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Safe-2.46-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Safe;unpack=0"
SRC_URI[x86_64_v2_perl-Safe.sha256sum] = "92c31e0067d3db5d3817ad19b081cfffd077bb7b6f1f60541df634495c4d43a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Search-Dict-1.07-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Search-Dict;unpack=0"
SRC_URI[x86_64_v2_perl-Search-Dict.sha256sum] = "0611f43fc65bc0d5ac1791e4d951ae8188797acdf04826258fd3afd8bd345f81"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-SelectSaver-1.02-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-SelectSaver;unpack=0"
SRC_URI[x86_64_v2_perl-SelectSaver.sha256sum] = "ed9a1aae73e2aef7263bde125096abdf124083fae7f41ac7f6f4bf92d687aa6f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-SelfLoader-1.27-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-SelfLoader;unpack=0"
SRC_URI[x86_64_v2_perl-SelfLoader.sha256sum] = "1f89970d6e9956a5fe7f1478551cb5137bf29e0621c6a7a154059af92b6e2ba4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Symbol-1.09-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Symbol;unpack=0"
SRC_URI[x86_64_v2_perl-Symbol.sha256sum] = "fc64a8a2eb0bfadbed283bcf9d73761818ba14be4b60093d3e7abeb311288afd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Sys-Hostname-1.25-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Hostname;unpack=0"
SRC_URI[x86_64_v2_perl-Sys-Hostname.sha256sum] = "8e6dca3a97059f0970b18c9b53f9005a609ea475733c861a233d3e8e4571d1f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Term-Complete-1.403-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Term-Complete;unpack=0"
SRC_URI[x86_64_v2_perl-Term-Complete.sha256sum] = "404b37425e12dde2d114a0502d3d8ce51d1849996ac4ebbfa90de49b86ded41f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Term-ReadLine-1.17-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Term-ReadLine;unpack=0"
SRC_URI[x86_64_v2_perl-Term-ReadLine.sha256sum] = "78bae3932bdec43fa2a2033341e3fd21296be3ce070071d063f534cbc6c4fd56"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Test-1.31-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Test;unpack=0"
SRC_URI[x86_64_v2_perl-Test.sha256sum] = "bdb23bce7b808d619f13404f2e55cc3c889066090b8265285900e6403ce0d6b5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Text-Abbrev-1.02-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Text-Abbrev;unpack=0"
SRC_URI[x86_64_v2_perl-Text-Abbrev.sha256sum] = "5da22eb4832fa4b4add1ff55afc8a2f519c9d26bf0acfc64656b4f7d22022789"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Thread-3.05-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Thread;unpack=0"
SRC_URI[x86_64_v2_perl-Thread.sha256sum] = "b45ce0309bb2378f245aa485f0511fd9e30567d775ffe725b4794a4b158837df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Thread-Semaphore-2.13-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Thread-Semaphore;unpack=0"
SRC_URI[x86_64_v2_perl-Thread-Semaphore.sha256sum] = "a21db28ebfc8319925884a632999e12062ec7fcbb7c6fac8d326e5eeedd82131"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Tie-4.6-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Tie;unpack=0"
SRC_URI[x86_64_v2_perl-Tie.sha256sum] = "acf14b4be52b41a651831afaf28dc9f16772ea55f609c7b69d6c75f4b4c70fb6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Tie-File-1.09-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Tie-File;unpack=0"
SRC_URI[x86_64_v2_perl-Tie-File.sha256sum] = "0dd814089ad9336cc5f908db5e3a58b2d37ca6c3d7e41d9f29adb1b0e27d9af8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Tie-Memoize-1.1-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Tie-Memoize;unpack=0"
SRC_URI[x86_64_v2_perl-Tie-Memoize.sha256sum] = "2c01a946d2f8f60d2dc635328f1ddee202ac8b0dda68067003919d3dbc563f1d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Time-1.04-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Time;unpack=0"
SRC_URI[x86_64_v2_perl-Time.sha256sum] = "0ae3057e0168e0b00d1127e667ebd581693aaffa0f6db386bdf30e19c49e8629"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Time-Piece-1.3401-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-Time-Piece;unpack=0"
SRC_URI[x86_64_v2_perl-Time-Piece.sha256sum] = "8d1e1e530b5ec298f512a46566676394efe12660b4d9cea87e414b70a4602df6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Unicode-UCD-0.78-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-Unicode-UCD;unpack=0"
SRC_URI[x86_64_v2_perl-Unicode-UCD.sha256sum] = "866d0ded31b8a1e582bd9aad5dab7c4da04f5c7ba439a2cb5d8a384eb0112d67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-User-pwent-1.05-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-User-pwent;unpack=0"
SRC_URI[x86_64_v2_perl-User-pwent.sha256sum] = "3905cab8deef2cc83a770366979b533b34d931bd7176abb7d7849ae7c6dd23c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-autouse-1.11-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-autouse;unpack=0"
SRC_URI[x86_64_v2_perl-autouse.sha256sum] = "fd6b85a8c16f2d4ffb1cf2ba8415b593def67ba439b0a55bed3eceadd055ef05"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-base-2.27-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-base;unpack=0"
SRC_URI[x86_64_v2_perl-base.sha256sum] = "641cde08c976a50c629cd7637affe32ad346d1dc3c92ac5211e61151318a7ddf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-blib-1.07-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-blib;unpack=0"
SRC_URI[x86_64_v2_perl-blib.sha256sum] = "4d99592c8e8ae0dfd9afdd00aeeec945bd8661dad634cdbfd0b55346df08c8bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-debugger-1.60-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-debugger;unpack=0"
SRC_URI[x86_64_v2_perl-debugger.sha256sum] = "cd8d7729c6a2abaf51a84643a640c2b1ce35754c46abc8f4a05a97df5ff43881"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-deprecate-0.04-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-deprecate;unpack=0"
SRC_URI[x86_64_v2_perl-deprecate.sha256sum] = "6a109c87391e7a0d50fbbb75cf2d853f5a512d213b9a7e672d65aa2f887995f1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-devel-5.40.2-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-devel;unpack=0"
SRC_URI[x86_64_v2_perl-devel.sha256sum] = "073bea1e0c8b2f0a661cbe4d18462850bf0e0be50949dd0f8b111be7b6494443"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-diagnostics-1.40-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-diagnostics;unpack=0"
SRC_URI[x86_64_v2_perl-diagnostics.sha256sum] = "236ade48d3a61b1370ffb047eff3d4967faf7b9b71578941074831936c117849"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-doc-5.40.2-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-doc;unpack=0"
SRC_URI[x86_64_v2_perl-doc.sha256sum] = "751a5de1e4ea89b827e4fec72a83a3defc5ca8e14a30c1378c8251fe53d878d9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-encoding-warnings-0.14-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-encoding-warnings;unpack=0"
SRC_URI[x86_64_v2_perl-encoding-warnings.sha256sum] = "3344bc9f86b6d37ad41d6cac87a2f59511b734e000bde88bc0599b83b2831e51"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-fields-2.27-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-fields;unpack=0"
SRC_URI[x86_64_v2_perl-fields.sha256sum] = "52754755e3017eb281df10d7747c05891247da5784bd01ac193d0afb2572f7d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-filetest-1.03-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-filetest;unpack=0"
SRC_URI[x86_64_v2_perl-filetest.sha256sum] = "f96011d3a911133c5b4b4f6cc67f487359655fd2785636644a98e4aefe7b84f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-if-0.61.000-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-if;unpack=0"
SRC_URI[x86_64_v2_perl-if.sha256sum] = "f59c4b48019089fcb5c778efc2e1b3dedbc2ac18e9ec0105f72c97b85acbb62d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-interpreter-5.40.2-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-interpreter;unpack=0"
SRC_URI[x86_64_v2_perl-interpreter.sha256sum] = "2167552555494c4a76deb4bd265110d8c413fce637c60720693fe409529e9d94"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-less-0.03-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-less;unpack=0"
SRC_URI[x86_64_v2_perl-less.sha256sum] = "7f3f1c6a710705f0f43ea72601f49e41df9c49c2f248f5d8d3de35538cccdb9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-lib-0.65-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-lib;unpack=0"
SRC_URI[x86_64_v2_perl-lib.sha256sum] = "9332b0858c0b49107ae28e0f6a3744c9af8ca0d7ab4fd65de5defd3141ce2f8c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-libnetcfg-5.40.2-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-libnetcfg;unpack=0"
SRC_URI[x86_64_v2_perl-libnetcfg.sha256sum] = "de5d590bb9d8ca5310e9c9504fc375a161f53d8072417047578e0e8bb6306c59"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-libs-5.40.2-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-libs;unpack=0"
SRC_URI[x86_64_v2_perl-libs.sha256sum] = "bd3d8bac9ba67878846c15a20d22d6774a8590ef9f68d565ef64019cedbbe1a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-locale-1.12-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-locale;unpack=0"
SRC_URI[x86_64_v2_perl-locale.sha256sum] = "ebf45a42c179fc9a71cc2addd597d0e584d13113b1d5854f20ba213a25357e3e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-macros-5.40.2-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-macros;unpack=0"
SRC_URI[x86_64_v2_perl-macros.sha256sum] = "73a8676afd8ca31e31af3fb81c4b4dcdb52a40629c7a126e849c71a7b750f35a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-meta-notation-5.40.2-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-meta-notation;unpack=0"
SRC_URI[x86_64_v2_perl-meta-notation.sha256sum] = "bf55895a1c45f9c84949681fdb1788cf16474b9cffdfaf951c0012bc3f5fea4c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-mro-1.29-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-mro;unpack=0"
SRC_URI[x86_64_v2_perl-mro.sha256sum] = "382c962b49a02533719327d332b5e97b1a567be0fc5406e0faea770dbd976b07"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-open-1.13-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-open;unpack=0"
SRC_URI[x86_64_v2_perl-open.sha256sum] = "97234a7bea13610db101d634c585ca991113a589311e898d611326c0197aa551"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-overload-1.37-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-overload;unpack=0"
SRC_URI[x86_64_v2_perl-overload.sha256sum] = "59b2c9966ff14087428f502eea14f82f95a072dd9fdfb82eed4db7c6c67efd22"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-overloading-0.02-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-overloading;unpack=0"
SRC_URI[x86_64_v2_perl-overloading.sha256sum] = "65652dda4e16f13ab1e413effb4d6886e446eef1950757befdf44a84d457602b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ph-5.40.2-512.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-ph;unpack=0"
SRC_URI[x86_64_v2_perl-ph.sha256sum] = "9647e6e98a81d964ded7cd6dcb2249e50c4dfa0a5c51652e71b95c5a91870d70"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-sigtrap-1.10-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-sigtrap;unpack=0"
SRC_URI[x86_64_v2_perl-sigtrap.sha256sum] = "e197f8a3435fadf4dacb0c5984112fa07fefd2f7a6136da75a048d58a855fcc6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-sort-2.05-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-sort;unpack=0"
SRC_URI[x86_64_v2_perl-sort.sha256sum] = "91dfd0eb881e4f3d5f23e9ffa575fce4cf5cfc21c0235383c9ef1bc1446d0da5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-subs-1.04-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-subs;unpack=0"
SRC_URI[x86_64_v2_perl-subs.sha256sum] = "16e9eae4ca86c30a37354a0041c2581a84a380e7f7667a8cdaf75c5ca286ce2c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-utils-5.40.2-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-utils;unpack=0"
SRC_URI[x86_64_v2_perl-utils.sha256sum] = "65550ed46617d52d3747c5730f4ec10e61a204a55e85574f1e7aa56172498f9e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-vars-1.05-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-vars;unpack=0"
SRC_URI[x86_64_v2_perl-vars.sha256sum] = "39940dd1ba24c74f5c869ceb974b344432c9ca1eaece7b0d94e2bfd96d9831b9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-vmsish-1.04-512.2.el10_0.noarch.rpm;name=x86_64_v2_perl-vmsish;unpack=0"
SRC_URI[x86_64_v2_perl-vmsish.sha256sum] = "cdb5064b8979c0e4ca6838d7976e6bb898ac734655e1c7cbec225c83b688c578"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-5.40.2-512.2.el10_0.aarch64.rpm;name=aarch64_perl;unpack=0"
SRC_URI[aarch64_perl.sha256sum] = "92207840abce8f6883d58a185ba5c65861687f816e9646b101ff82174dffde01"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Attribute-Handlers-1.03-512.2.el10_0.noarch.rpm;name=aarch64_perl-Attribute-Handlers;unpack=0"
SRC_URI[aarch64_perl-Attribute-Handlers.sha256sum] = "b671a0b7f9c801750e8e19a30f8f379b4e7789802c6413fcac8f48ed2c4edca4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-AutoLoader-5.74-512.2.el10_0.noarch.rpm;name=aarch64_perl-AutoLoader;unpack=0"
SRC_URI[aarch64_perl-AutoLoader.sha256sum] = "53bc4548f39fb0a9fbd261f2e4b914ea585f18ad72767585809dc8cbfcfdf54e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-AutoSplit-5.74-512.2.el10_0.noarch.rpm;name=aarch64_perl-AutoSplit;unpack=0"
SRC_URI[aarch64_perl-AutoSplit.sha256sum] = "048997a89ebaf1ab8c1125ded3c79ca35dfe78a2358d062a4be7ab272eeabdaf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-B-1.89-512.2.el10_0.aarch64.rpm;name=aarch64_perl-B;unpack=0"
SRC_URI[aarch64_perl-B.sha256sum] = "402e58b3a141a3d8123acaa8023a64ea02b3464422c6141563cec2b374c794ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Benchmark-1.25-512.2.el10_0.noarch.rpm;name=aarch64_perl-Benchmark;unpack=0"
SRC_URI[aarch64_perl-Benchmark.sha256sum] = "37a875f24d8c59c1be3c37d56b140b8985ad8ea1b0c966eb509497a43b0eb5e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Class-Struct-0.68-512.2.el10_0.noarch.rpm;name=aarch64_perl-Class-Struct;unpack=0"
SRC_URI[aarch64_perl-Class-Struct.sha256sum] = "63cac7d1530a3747e4933d761822e36848a41df4ddca9e92619fb03eabf30701"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Config-Extensions-0.03-512.2.el10_0.noarch.rpm;name=aarch64_perl-Config-Extensions;unpack=0"
SRC_URI[aarch64_perl-Config-Extensions.sha256sum] = "223eb5b17a9e8b6117e00c64f1a53e87409e635df340119c73c378ce1fda5728"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DBM_Filter-0.06-512.2.el10_0.noarch.rpm;name=aarch64_perl-DBM_Filter;unpack=0"
SRC_URI[aarch64_perl-DBM_Filter.sha256sum] = "dffdf4725b8218c6475e02522be07c6797831b4d9eaa51b3479682a490b6abe5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Devel-Peek-1.34-512.2.el10_0.aarch64.rpm;name=aarch64_perl-Devel-Peek;unpack=0"
SRC_URI[aarch64_perl-Devel-Peek.sha256sum] = "fec23c72cb03c90c97cdde216316091da925f42adbed228fbc1f1d6a3ebfc71a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Devel-SelfStubber-1.06-512.2.el10_0.noarch.rpm;name=aarch64_perl-Devel-SelfStubber;unpack=0"
SRC_URI[aarch64_perl-Devel-SelfStubber.sha256sum] = "f0f5db2d1649e598dc78eb2772042d2b69672e5fd80fc6e73606e48b8e8dde18"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DirHandle-1.05-512.2.el10_0.noarch.rpm;name=aarch64_perl-DirHandle;unpack=0"
SRC_URI[aarch64_perl-DirHandle.sha256sum] = "5997885a83e4096f47516a8bd8a88cf47dbd220506c6cc95852e97a7465aa0a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Dumpvalue-2.27-512.2.el10_0.noarch.rpm;name=aarch64_perl-Dumpvalue;unpack=0"
SRC_URI[aarch64_perl-Dumpvalue.sha256sum] = "9c060432fbf3cb704f3cf89cc6d7de6bb7027640a68b65f337f8604198fb9d10"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DynaLoader-1.56-512.2.el10_0.aarch64.rpm;name=aarch64_perl-DynaLoader;unpack=0"
SRC_URI[aarch64_perl-DynaLoader.sha256sum] = "44250387d64b96770988fcf3374aa5db61c847dd2f2c0cf18bef9859fd4aaa71"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-English-1.11-512.2.el10_0.noarch.rpm;name=aarch64_perl-English;unpack=0"
SRC_URI[aarch64_perl-English.sha256sum] = "c4f75ec15d4f116fcefb043c119694afddc539ec6ddca012e8a4cff52cc41574"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Errno-1.38-512.2.el10_0.aarch64.rpm;name=aarch64_perl-Errno;unpack=0"
SRC_URI[aarch64_perl-Errno.sha256sum] = "34ff677681c38b87d3da575e826e60f9439bb41848f2bc949f1a5b008958aefc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ExtUtils-Constant-0.25-512.2.el10_0.noarch.rpm;name=aarch64_perl-ExtUtils-Constant;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-Constant.sha256sum] = "1d38e0933868701cf484bf8d5890f6c156fd3c752a6830af3d89fce18023182d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ExtUtils-Embed-1.35-512.2.el10_0.noarch.rpm;name=aarch64_perl-ExtUtils-Embed;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-Embed.sha256sum] = "f2934b9b01b68603a1d0c578bada4296fec9973582b6a7f77ad374251e09fbd8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ExtUtils-Miniperl-1.14-512.2.el10_0.noarch.rpm;name=aarch64_perl-ExtUtils-Miniperl;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-Miniperl.sha256sum] = "14961e1af22b64acb19673097b7971d92b4b85e64c3ab50ac2f4f2631323b6f1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Fcntl-1.18-512.2.el10_0.aarch64.rpm;name=aarch64_perl-Fcntl;unpack=0"
SRC_URI[aarch64_perl-Fcntl.sha256sum] = "e603b8036f1bf63c983c8ed3bd3deecff7ac530cbb652c2b147f819cc031630e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Basename-2.86-512.2.el10_0.noarch.rpm;name=aarch64_perl-File-Basename;unpack=0"
SRC_URI[aarch64_perl-File-Basename.sha256sum] = "5598d9f2546e0c8f7a6e82d905419a8373d9f2ba4b9ae3dc2884a818ecfb6146"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Compare-1.100.800-512.2.el10_0.noarch.rpm;name=aarch64_perl-File-Compare;unpack=0"
SRC_URI[aarch64_perl-File-Compare.sha256sum] = "6e69452bc13d226a2618fffe2c76abc4fb0fe1a303f2e6bb9f4ed84c49a0b7ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Copy-2.41-512.2.el10_0.noarch.rpm;name=aarch64_perl-File-Copy;unpack=0"
SRC_URI[aarch64_perl-File-Copy.sha256sum] = "e74610604daf45aea68e0f6ae1a7c6981d153938f1735a6653f53d3c0d7466b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-DosGlob-1.12-512.2.el10_0.aarch64.rpm;name=aarch64_perl-File-DosGlob;unpack=0"
SRC_URI[aarch64_perl-File-DosGlob.sha256sum] = "1e71dabcf4256a3ae25f06a470e5b8fff28e719e67eb00521607b9ce1ab7d76c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Find-1.44-512.2.el10_0.noarch.rpm;name=aarch64_perl-File-Find;unpack=0"
SRC_URI[aarch64_perl-File-Find.sha256sum] = "5edeec3ce9dc61a46d51647ae2649ffd16116b8f5379d229f783a491d530dd4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-stat-1.14-512.2.el10_0.noarch.rpm;name=aarch64_perl-File-stat;unpack=0"
SRC_URI[aarch64_perl-File-stat.sha256sum] = "b2cdf08c9db15b3600cd09fd7d73bebd52b01e2c624344452ac707dca8b46807"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-FileCache-1.10-512.2.el10_0.noarch.rpm;name=aarch64_perl-FileCache;unpack=0"
SRC_URI[aarch64_perl-FileCache.sha256sum] = "64c3171882013c4402ec357a3765ae9275b1bc42953a3bbe496e33c4c6971045"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-FileHandle-2.05-512.2.el10_0.noarch.rpm;name=aarch64_perl-FileHandle;unpack=0"
SRC_URI[aarch64_perl-FileHandle.sha256sum] = "fe363bc7cd02e2327f6dc5d3683d2c1844bb9abb2773e62eeb2552537820806d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-FindBin-1.54-512.2.el10_0.noarch.rpm;name=aarch64_perl-FindBin;unpack=0"
SRC_URI[aarch64_perl-FindBin.sha256sum] = "b395447c9105957be78f21e694a114a411d6cd7661c0ad8669438dab91f4aa35"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-GDBM_File-1.24-512.2.el10_0.aarch64.rpm;name=aarch64_perl-GDBM_File;unpack=0"
SRC_URI[aarch64_perl-GDBM_File.sha256sum] = "c4c8296e4257ec34a80e8b14dd85596c8277ddb867d934b51316ff187fb06812"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Getopt-Std-1.14-512.2.el10_0.noarch.rpm;name=aarch64_perl-Getopt-Std;unpack=0"
SRC_URI[aarch64_perl-Getopt-Std.sha256sum] = "2dade822b0fbcec4e75d99cd1bafb900622189a8f5ecfa3e40aca5c9d4256eaf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Hash-Util-0.32-512.2.el10_0.aarch64.rpm;name=aarch64_perl-Hash-Util;unpack=0"
SRC_URI[aarch64_perl-Hash-Util.sha256sum] = "b6711f2d17589c5a3d08ed2dc119f62abf371ff5b056b6ed01b16a2b1b074067"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Hash-Util-FieldHash-1.27-512.2.el10_0.aarch64.rpm;name=aarch64_perl-Hash-Util-FieldHash;unpack=0"
SRC_URI[aarch64_perl-Hash-Util-FieldHash.sha256sum] = "64387ad44d1e28502f8b5fed3fdf02b6c6262675244deacc7943f6d2bfdbf021"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-I18N-Collate-1.02-512.2.el10_0.noarch.rpm;name=aarch64_perl-I18N-Collate;unpack=0"
SRC_URI[aarch64_perl-I18N-Collate.sha256sum] = "939759f5a06d0b0f330bb0ce0f13d3a5627157247a7b0adc56ef69a55bddc3c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-I18N-LangTags-0.45-512.2.el10_0.noarch.rpm;name=aarch64_perl-I18N-LangTags;unpack=0"
SRC_URI[aarch64_perl-I18N-LangTags.sha256sum] = "e04165f70f30d473b7690185275149f79bff42212ccf7affce3896cf3572eda1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-I18N-Langinfo-0.24-512.2.el10_0.aarch64.rpm;name=aarch64_perl-I18N-Langinfo;unpack=0"
SRC_URI[aarch64_perl-I18N-Langinfo.sha256sum] = "38d184deed8aa717b325724fcf889243e014a78240036af30fc205a0adb10e73"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-IO-1.55-512.2.el10_0.aarch64.rpm;name=aarch64_perl-IO;unpack=0"
SRC_URI[aarch64_perl-IO.sha256sum] = "35fbb9672200f22ef86d37a28aa06e16f15996ffc56cddfae640e8a311b50f62"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-IPC-Open3-1.22-512.2.el10_0.noarch.rpm;name=aarch64_perl-IPC-Open3;unpack=0"
SRC_URI[aarch64_perl-IPC-Open3.sha256sum] = "40995d475afb4445b4ad4fa52310d873c8814776de5c35be16de6fb6f1cf0c98"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Locale-Maketext-Simple-0.21-512.2.el10_0.noarch.rpm;name=aarch64_perl-Locale-Maketext-Simple;unpack=0"
SRC_URI[aarch64_perl-Locale-Maketext-Simple.sha256sum] = "912b3b1496ce93980f16432e5db249038b2d2b896b481b125de8948ffe4fddb7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Math-Complex-1.62-512.2.el10_0.noarch.rpm;name=aarch64_perl-Math-Complex;unpack=0"
SRC_URI[aarch64_perl-Math-Complex.sha256sum] = "22bdd66628ba9a425828abde67f00496ee1716e4d576c09d6ebdfa09695f3466"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Memoize-1.16-512.2.el10_0.noarch.rpm;name=aarch64_perl-Memoize;unpack=0"
SRC_URI[aarch64_perl-Memoize.sha256sum] = "c377b1e0afc48190cc512e339e69a7bb43ea85235235dc62b985aa8b56348878"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Module-Loaded-0.08-512.2.el10_0.noarch.rpm;name=aarch64_perl-Module-Loaded;unpack=0"
SRC_URI[aarch64_perl-Module-Loaded.sha256sum] = "4cc67d8f80d85af1172b7f4eedc1ad51e8cfcb1599a35fa292c429a3cc08769c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-NDBM_File-1.17-512.2.el10_0.aarch64.rpm;name=aarch64_perl-NDBM_File;unpack=0"
SRC_URI[aarch64_perl-NDBM_File.sha256sum] = "8e004216550e38eacdf4b6880f6c3e846ea4149e5e3d67bcce5839d431cf225c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-NEXT-0.69-512.2.el10_0.noarch.rpm;name=aarch64_perl-NEXT;unpack=0"
SRC_URI[aarch64_perl-NEXT.sha256sum] = "f29468443156b0ac7e028290e3a49ccebe224e9fa40f684e1f8ea242e29a8975"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Net-1.04-512.2.el10_0.noarch.rpm;name=aarch64_perl-Net;unpack=0"
SRC_URI[aarch64_perl-Net.sha256sum] = "4b274944172be9d1bd3d908985dd39a30a41e694c9dbffa288c645d9cdff5c99"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ODBM_File-1.18-512.2.el10_0.aarch64.rpm;name=aarch64_perl-ODBM_File;unpack=0"
SRC_URI[aarch64_perl-ODBM_File.sha256sum] = "fe8cd01a6d47e82320f862828ff7d605bf100fb2b83179a1cf6d34093d7718bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Opcode-1.65-512.2.el10_0.aarch64.rpm;name=aarch64_perl-Opcode;unpack=0"
SRC_URI[aarch64_perl-Opcode.sha256sum] = "ace4d195f8400cfb7d83d9dc987d0229c69248ff6daaabe7294cd045c2b23980"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-POSIX-2.20-512.2.el10_0.aarch64.rpm;name=aarch64_perl-POSIX;unpack=0"
SRC_URI[aarch64_perl-POSIX.sha256sum] = "741bcc147cca69e140494e85b17c63277417ec63b2b38ec18a7e0d874a550390"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Pod-Functions-1.14-512.2.el10_0.noarch.rpm;name=aarch64_perl-Pod-Functions;unpack=0"
SRC_URI[aarch64_perl-Pod-Functions.sha256sum] = "3be3c74616e23076fa7d4d6c83766b1fcbcfc3e51195dc8e962791c9f2961c2b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Pod-Html-1.35-512.2.el10_0.noarch.rpm;name=aarch64_perl-Pod-Html;unpack=0"
SRC_URI[aarch64_perl-Pod-Html.sha256sum] = "461454a236dc1a993701be0d6cb278150d98c5aa7fea8e3947c00dc714515454"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Safe-2.46-512.2.el10_0.noarch.rpm;name=aarch64_perl-Safe;unpack=0"
SRC_URI[aarch64_perl-Safe.sha256sum] = "92c31e0067d3db5d3817ad19b081cfffd077bb7b6f1f60541df634495c4d43a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Search-Dict-1.07-512.2.el10_0.noarch.rpm;name=aarch64_perl-Search-Dict;unpack=0"
SRC_URI[aarch64_perl-Search-Dict.sha256sum] = "0611f43fc65bc0d5ac1791e4d951ae8188797acdf04826258fd3afd8bd345f81"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-SelectSaver-1.02-512.2.el10_0.noarch.rpm;name=aarch64_perl-SelectSaver;unpack=0"
SRC_URI[aarch64_perl-SelectSaver.sha256sum] = "ed9a1aae73e2aef7263bde125096abdf124083fae7f41ac7f6f4bf92d687aa6f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-SelfLoader-1.27-512.2.el10_0.noarch.rpm;name=aarch64_perl-SelfLoader;unpack=0"
SRC_URI[aarch64_perl-SelfLoader.sha256sum] = "1f89970d6e9956a5fe7f1478551cb5137bf29e0621c6a7a154059af92b6e2ba4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Symbol-1.09-512.2.el10_0.noarch.rpm;name=aarch64_perl-Symbol;unpack=0"
SRC_URI[aarch64_perl-Symbol.sha256sum] = "fc64a8a2eb0bfadbed283bcf9d73761818ba14be4b60093d3e7abeb311288afd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Sys-Hostname-1.25-512.2.el10_0.aarch64.rpm;name=aarch64_perl-Sys-Hostname;unpack=0"
SRC_URI[aarch64_perl-Sys-Hostname.sha256sum] = "15761b85df1ef7b561ca1104032438711fb7bbf721a87a0a25b1ca1cd799ff81"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Term-Complete-1.403-512.2.el10_0.noarch.rpm;name=aarch64_perl-Term-Complete;unpack=0"
SRC_URI[aarch64_perl-Term-Complete.sha256sum] = "404b37425e12dde2d114a0502d3d8ce51d1849996ac4ebbfa90de49b86ded41f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Term-ReadLine-1.17-512.2.el10_0.noarch.rpm;name=aarch64_perl-Term-ReadLine;unpack=0"
SRC_URI[aarch64_perl-Term-ReadLine.sha256sum] = "78bae3932bdec43fa2a2033341e3fd21296be3ce070071d063f534cbc6c4fd56"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Test-1.31-512.2.el10_0.noarch.rpm;name=aarch64_perl-Test;unpack=0"
SRC_URI[aarch64_perl-Test.sha256sum] = "bdb23bce7b808d619f13404f2e55cc3c889066090b8265285900e6403ce0d6b5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Text-Abbrev-1.02-512.2.el10_0.noarch.rpm;name=aarch64_perl-Text-Abbrev;unpack=0"
SRC_URI[aarch64_perl-Text-Abbrev.sha256sum] = "5da22eb4832fa4b4add1ff55afc8a2f519c9d26bf0acfc64656b4f7d22022789"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Thread-3.05-512.2.el10_0.noarch.rpm;name=aarch64_perl-Thread;unpack=0"
SRC_URI[aarch64_perl-Thread.sha256sum] = "b45ce0309bb2378f245aa485f0511fd9e30567d775ffe725b4794a4b158837df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Thread-Semaphore-2.13-512.2.el10_0.noarch.rpm;name=aarch64_perl-Thread-Semaphore;unpack=0"
SRC_URI[aarch64_perl-Thread-Semaphore.sha256sum] = "a21db28ebfc8319925884a632999e12062ec7fcbb7c6fac8d326e5eeedd82131"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Tie-4.6-512.2.el10_0.noarch.rpm;name=aarch64_perl-Tie;unpack=0"
SRC_URI[aarch64_perl-Tie.sha256sum] = "acf14b4be52b41a651831afaf28dc9f16772ea55f609c7b69d6c75f4b4c70fb6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Tie-File-1.09-512.2.el10_0.noarch.rpm;name=aarch64_perl-Tie-File;unpack=0"
SRC_URI[aarch64_perl-Tie-File.sha256sum] = "0dd814089ad9336cc5f908db5e3a58b2d37ca6c3d7e41d9f29adb1b0e27d9af8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Tie-Memoize-1.1-512.2.el10_0.noarch.rpm;name=aarch64_perl-Tie-Memoize;unpack=0"
SRC_URI[aarch64_perl-Tie-Memoize.sha256sum] = "2c01a946d2f8f60d2dc635328f1ddee202ac8b0dda68067003919d3dbc563f1d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Time-1.04-512.2.el10_0.noarch.rpm;name=aarch64_perl-Time;unpack=0"
SRC_URI[aarch64_perl-Time.sha256sum] = "0ae3057e0168e0b00d1127e667ebd581693aaffa0f6db386bdf30e19c49e8629"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Time-Piece-1.3401-512.2.el10_0.aarch64.rpm;name=aarch64_perl-Time-Piece;unpack=0"
SRC_URI[aarch64_perl-Time-Piece.sha256sum] = "10a9640bceb8857b060b74ba29ddda3adb2f3cc9e9ebb1bf03828ad85bdcec2f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Unicode-UCD-0.78-512.2.el10_0.noarch.rpm;name=aarch64_perl-Unicode-UCD;unpack=0"
SRC_URI[aarch64_perl-Unicode-UCD.sha256sum] = "866d0ded31b8a1e582bd9aad5dab7c4da04f5c7ba439a2cb5d8a384eb0112d67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-User-pwent-1.05-512.2.el10_0.noarch.rpm;name=aarch64_perl-User-pwent;unpack=0"
SRC_URI[aarch64_perl-User-pwent.sha256sum] = "3905cab8deef2cc83a770366979b533b34d931bd7176abb7d7849ae7c6dd23c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-autouse-1.11-512.2.el10_0.noarch.rpm;name=aarch64_perl-autouse;unpack=0"
SRC_URI[aarch64_perl-autouse.sha256sum] = "fd6b85a8c16f2d4ffb1cf2ba8415b593def67ba439b0a55bed3eceadd055ef05"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-base-2.27-512.2.el10_0.noarch.rpm;name=aarch64_perl-base;unpack=0"
SRC_URI[aarch64_perl-base.sha256sum] = "641cde08c976a50c629cd7637affe32ad346d1dc3c92ac5211e61151318a7ddf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-blib-1.07-512.2.el10_0.noarch.rpm;name=aarch64_perl-blib;unpack=0"
SRC_URI[aarch64_perl-blib.sha256sum] = "4d99592c8e8ae0dfd9afdd00aeeec945bd8661dad634cdbfd0b55346df08c8bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-debugger-1.60-512.2.el10_0.noarch.rpm;name=aarch64_perl-debugger;unpack=0"
SRC_URI[aarch64_perl-debugger.sha256sum] = "cd8d7729c6a2abaf51a84643a640c2b1ce35754c46abc8f4a05a97df5ff43881"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-deprecate-0.04-512.2.el10_0.noarch.rpm;name=aarch64_perl-deprecate;unpack=0"
SRC_URI[aarch64_perl-deprecate.sha256sum] = "6a109c87391e7a0d50fbbb75cf2d853f5a512d213b9a7e672d65aa2f887995f1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-devel-5.40.2-512.2.el10_0.aarch64.rpm;name=aarch64_perl-devel;unpack=0"
SRC_URI[aarch64_perl-devel.sha256sum] = "fb0bb9fb4f982d69032d27e574c5c318a54f4d43b1afd2c366472c0dbcc1398f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-diagnostics-1.40-512.2.el10_0.noarch.rpm;name=aarch64_perl-diagnostics;unpack=0"
SRC_URI[aarch64_perl-diagnostics.sha256sum] = "236ade48d3a61b1370ffb047eff3d4967faf7b9b71578941074831936c117849"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-doc-5.40.2-512.2.el10_0.noarch.rpm;name=aarch64_perl-doc;unpack=0"
SRC_URI[aarch64_perl-doc.sha256sum] = "751a5de1e4ea89b827e4fec72a83a3defc5ca8e14a30c1378c8251fe53d878d9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-encoding-warnings-0.14-512.2.el10_0.noarch.rpm;name=aarch64_perl-encoding-warnings;unpack=0"
SRC_URI[aarch64_perl-encoding-warnings.sha256sum] = "3344bc9f86b6d37ad41d6cac87a2f59511b734e000bde88bc0599b83b2831e51"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-fields-2.27-512.2.el10_0.noarch.rpm;name=aarch64_perl-fields;unpack=0"
SRC_URI[aarch64_perl-fields.sha256sum] = "52754755e3017eb281df10d7747c05891247da5784bd01ac193d0afb2572f7d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-filetest-1.03-512.2.el10_0.noarch.rpm;name=aarch64_perl-filetest;unpack=0"
SRC_URI[aarch64_perl-filetest.sha256sum] = "f96011d3a911133c5b4b4f6cc67f487359655fd2785636644a98e4aefe7b84f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-if-0.61.000-512.2.el10_0.noarch.rpm;name=aarch64_perl-if;unpack=0"
SRC_URI[aarch64_perl-if.sha256sum] = "f59c4b48019089fcb5c778efc2e1b3dedbc2ac18e9ec0105f72c97b85acbb62d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-interpreter-5.40.2-512.2.el10_0.aarch64.rpm;name=aarch64_perl-interpreter;unpack=0"
SRC_URI[aarch64_perl-interpreter.sha256sum] = "01e1f44e4fb5463b2e9ad1ddde4e7b2ce91ef415eafddf3594a490834c748a10"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-less-0.03-512.2.el10_0.noarch.rpm;name=aarch64_perl-less;unpack=0"
SRC_URI[aarch64_perl-less.sha256sum] = "7f3f1c6a710705f0f43ea72601f49e41df9c49c2f248f5d8d3de35538cccdb9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-lib-0.65-512.2.el10_0.aarch64.rpm;name=aarch64_perl-lib;unpack=0"
SRC_URI[aarch64_perl-lib.sha256sum] = "aa5a43c442dc0a440c091d164c366cfa8d3158a6060a5e31c2650114dbf76577"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-libnetcfg-5.40.2-512.2.el10_0.noarch.rpm;name=aarch64_perl-libnetcfg;unpack=0"
SRC_URI[aarch64_perl-libnetcfg.sha256sum] = "de5d590bb9d8ca5310e9c9504fc375a161f53d8072417047578e0e8bb6306c59"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-libs-5.40.2-512.2.el10_0.aarch64.rpm;name=aarch64_perl-libs;unpack=0"
SRC_URI[aarch64_perl-libs.sha256sum] = "20b40a76dfd72c74ad6dc802b665e1794f4abd594bfe8046daca65776028d22e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-locale-1.12-512.2.el10_0.noarch.rpm;name=aarch64_perl-locale;unpack=0"
SRC_URI[aarch64_perl-locale.sha256sum] = "ebf45a42c179fc9a71cc2addd597d0e584d13113b1d5854f20ba213a25357e3e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-macros-5.40.2-512.2.el10_0.noarch.rpm;name=aarch64_perl-macros;unpack=0"
SRC_URI[aarch64_perl-macros.sha256sum] = "73a8676afd8ca31e31af3fb81c4b4dcdb52a40629c7a126e849c71a7b750f35a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-meta-notation-5.40.2-512.2.el10_0.noarch.rpm;name=aarch64_perl-meta-notation;unpack=0"
SRC_URI[aarch64_perl-meta-notation.sha256sum] = "bf55895a1c45f9c84949681fdb1788cf16474b9cffdfaf951c0012bc3f5fea4c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-mro-1.29-512.2.el10_0.aarch64.rpm;name=aarch64_perl-mro;unpack=0"
SRC_URI[aarch64_perl-mro.sha256sum] = "cd848e76d930534c35885c8aac9b5dd1c46a2db28dcdb0c7d8da378a9fae93b9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-open-1.13-512.2.el10_0.noarch.rpm;name=aarch64_perl-open;unpack=0"
SRC_URI[aarch64_perl-open.sha256sum] = "97234a7bea13610db101d634c585ca991113a589311e898d611326c0197aa551"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-overload-1.37-512.2.el10_0.noarch.rpm;name=aarch64_perl-overload;unpack=0"
SRC_URI[aarch64_perl-overload.sha256sum] = "59b2c9966ff14087428f502eea14f82f95a072dd9fdfb82eed4db7c6c67efd22"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-overloading-0.02-512.2.el10_0.noarch.rpm;name=aarch64_perl-overloading;unpack=0"
SRC_URI[aarch64_perl-overloading.sha256sum] = "65652dda4e16f13ab1e413effb4d6886e446eef1950757befdf44a84d457602b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ph-5.40.2-512.2.el10_0.aarch64.rpm;name=aarch64_perl-ph;unpack=0"
SRC_URI[aarch64_perl-ph.sha256sum] = "461174e17cca56047f23f63719ae8ca934e9b4e311c455d5a7bb2375fe0dbc96"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-sigtrap-1.10-512.2.el10_0.noarch.rpm;name=aarch64_perl-sigtrap;unpack=0"
SRC_URI[aarch64_perl-sigtrap.sha256sum] = "e197f8a3435fadf4dacb0c5984112fa07fefd2f7a6136da75a048d58a855fcc6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-sort-2.05-512.2.el10_0.noarch.rpm;name=aarch64_perl-sort;unpack=0"
SRC_URI[aarch64_perl-sort.sha256sum] = "91dfd0eb881e4f3d5f23e9ffa575fce4cf5cfc21c0235383c9ef1bc1446d0da5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-subs-1.04-512.2.el10_0.noarch.rpm;name=aarch64_perl-subs;unpack=0"
SRC_URI[aarch64_perl-subs.sha256sum] = "16e9eae4ca86c30a37354a0041c2581a84a380e7f7667a8cdaf75c5ca286ce2c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-utils-5.40.2-512.2.el10_0.noarch.rpm;name=aarch64_perl-utils;unpack=0"
SRC_URI[aarch64_perl-utils.sha256sum] = "65550ed46617d52d3747c5730f4ec10e61a204a55e85574f1e7aa56172498f9e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-vars-1.05-512.2.el10_0.noarch.rpm;name=aarch64_perl-vars;unpack=0"
SRC_URI[aarch64_perl-vars.sha256sum] = "39940dd1ba24c74f5c869ceb974b344432c9ca1eaece7b0d94e2bfd96d9831b9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-vmsish-1.04-512.2.el10_0.noarch.rpm;name=aarch64_perl-vmsish;unpack=0"
SRC_URI[aarch64_perl-vmsish.sha256sum] = "cdb5064b8979c0e4ca6838d7976e6bb898ac734655e1c7cbec225c83b688c578"

RDEPENDS:perl = " \
 perl-Archive-Tar \
 perl-Attribute-Handlers \
 perl-AutoLoader \
 perl-AutoSplit \
 perl-B \
 perl-Benchmark \
 perl-CPAN \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-CPAN-Meta-YAML \
 perl-Carp \
 perl-Class-Struct \
 perl-Compress-Raw-Bzip2 \
 perl-Compress-Raw-Zlib \
 perl-Config-Extensions \
 perl-Config-Perl-V \
 perl-DBM_Filter \
 perl-Data-Dumper \
 perl-Devel-PPPort \
 perl-Devel-Peek \
 perl-Devel-SelfStubber \
 perl-Digest \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-DirHandle \
 perl-Dumpvalue \
 perl-DynaLoader \
 perl-Encode \
 perl-Encode-devel \
 perl-English \
 perl-Env \
 perl-Errno \
 perl-Exporter \
 perl-ExtUtils-CBuilder \
 perl-ExtUtils-Command \
 perl-ExtUtils-Constant \
 perl-ExtUtils-Embed \
 perl-ExtUtils-Install \
 perl-ExtUtils-MM-Utils \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-ExtUtils-Miniperl \
 perl-ExtUtils-ParseXS \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-DosGlob \
 perl-File-Fetch \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-File-stat \
 perl-FileCache \
 perl-FileHandle \
 perl-Filter \
 perl-Filter-Simple \
 perl-FindBin \
 perl-GDBM_File \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-HTTP-Tiny \
 perl-Hash-Util \
 perl-Hash-Util-FieldHash \
 perl-I18N-Collate \
 perl-I18N-LangTags \
 perl-I18N-Langinfo \
 perl-IO \
 perl-IO-Compress \
 perl-IO-Socket-IP \
 perl-IO-Zlib \
 perl-IPC-Cmd \
 perl-IPC-Open3 \
 perl-IPC-SysV \
 perl-JSON-PP \
 perl-Locale-Maketext \
 perl-Locale-Maketext-Simple \
 perl-MIME-Base64 \
 perl-Math-BigInt \
 perl-Math-BigInt-FastCalc \
 perl-Math-Complex \
 perl-Memoize \
 perl-Module-CoreList \
 perl-Module-CoreList-tools \
 perl-Module-Load \
 perl-Module-Load-Conditional \
 perl-Module-Loaded \
 perl-Module-Metadata \
 perl-NDBM_File \
 perl-NEXT \
 perl-Net \
 perl-Net-Ping \
 perl-ODBM_File \
 perl-Opcode \
 perl-POSIX \
 perl-Params-Check \
 perl-PathTools \
 perl-Perl-OSType \
 perl-PerlIO-via-QuotedPrint \
 perl-Pod-Checker \
 perl-Pod-Escapes \
 perl-Pod-Functions \
 perl-Pod-Html \
 perl-Pod-Perldoc \
 perl-Pod-Simple \
 perl-Pod-Usage \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Search-Dict \
 perl-SelectSaver \
 perl-SelfLoader \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Term-ANSIColor \
 perl-Term-Cap \
 perl-Term-Complete \
 perl-Term-ReadLine \
 perl-Term-Table \
 perl-Test \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Test2-Suite \
 perl-Text-Abbrev \
 perl-Text-Balanced \
 perl-Text-ParseWords \
 perl-Text-Tabs+Wrap \
 perl-Thread \
 perl-Thread-Queue \
 perl-Thread-Semaphore \
 perl-Tie \
 perl-Tie-File \
 perl-Tie-Memoize \
 perl-Tie-RefHash \
 perl-Time \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-Time-Piece \
 perl-Unicode-Collate \
 perl-Unicode-Normalize \
 perl-Unicode-UCD \
 perl-User-pwent \
 perl-autodie \
 perl-autouse \
 perl-base \
 perl-bignum \
 perl-blib \
 perl-constant \
 perl-debugger \
 perl-deprecate \
 perl-devel \
 perl-diagnostics \
 perl-doc \
 perl-encoding \
 perl-encoding-warnings \
 perl-experimental \
 perl-fields \
 perl-filetest \
 perl-if \
 perl-interpreter \
 perl-less \
 perl-lib \
 perl-libnet \
 perl-libnetcfg \
 perl-libs \
 perl-locale \
 perl-macros \
 perl-meta-notation \
 perl-mro \
 perl-open \
 perl-overload \
 perl-overloading \
 perl-parent \
 perl-perlfaq \
 perl-ph \
 perl-podlators \
 perl-sigtrap \
 perl-sort \
 perl-subs \
 perl-threads \
 perl-threads-shared \
 perl-utils \
 perl-vars \
 perl-version \
 perl-vmsish \
 "
RDEPENDS:perl-Attribute-Handlers = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-AutoLoader = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-AutoSplit = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Path \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-B = " \
 glibc \
 perl-B \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-if \
 perl-libs \
 perl-overloading \
 "
RDEPENDS:perl-Benchmark = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Class-Struct = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Config-Extensions = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-DBM_Filter = " \
 perl-Carp \
 perl-Encode \
 perl-IO-Compress \
 perl-libs \
 "
RDEPENDS:perl-Devel-Peek = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Devel-SelfStubber = " \
 perl-PathTools \
 perl-SelfLoader \
 perl-libs \
 "
RDEPENDS:perl-DirHandle = " \
 perl-Carp \
 perl-Symbol \
 perl-libs \
 "
RDEPENDS:perl-Dumpvalue = " \
 perl-libs \
 "
RDEPENDS:perl-DynaLoader = " \
 perl-Carp \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-English = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Errno = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-ExtUtils-Constant = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-ExtUtils-Constant \
 perl-Text-Tabs+Wrap \
 perl-constant \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-ExtUtils-Embed = " \
 perl-Exporter \
 perl-PathTools \
 perl-devel \
 perl-libs \
 "
RDEPENDS:perl-ExtUtils-Miniperl = " \
 perl-Exporter \
 perl-ExtUtils-Embed \
 perl-devel \
 perl-libs \
 "
RDEPENDS:perl-Fcntl = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-File-Basename = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-File-Compare = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-File-Copy = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-File-DosGlob = " \
 glibc \
 perl-Text-ParseWords \
 perl-libs \
 "
RDEPENDS:perl-File-Find = " \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-File-stat = " \
 perl-Carp \
 perl-Class-Struct \
 perl-Exporter \
 perl-Fcntl \
 perl-Symbol \
 perl-constant \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-FileCache = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-FileHandle = " \
 perl-Exporter \
 perl-IO \
 perl-libs \
 "
RDEPENDS:perl-FindBin = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-GDBM_File = " \
 gdbm-libs \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Getopt-Std = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Hash-Util = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Hash-Util-FieldHash \
 perl-libs \
 "
RDEPENDS:perl-Hash-Util-FieldHash = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-I18N-Collate = " \
 perl-Exporter \
 perl-POSIX \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-I18N-LangTags = " \
 perl-Exporter \
 perl-I18N-LangTags \
 perl-libs \
 "
RDEPENDS:perl-I18N-Langinfo = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-IO = " \
 glibc \
 perl-Carp \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-stat \
 perl-IO \
 perl-PathTools \
 perl-SelectSaver \
 perl-Socket \
 perl-Symbol \
 perl-libs \
 "
RDEPENDS:perl-IPC-Open3 = " \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-IO \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-Symbol \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Locale-Maketext-Simple = " \
 perl-Locale-Maketext \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-Math-Complex = " \
 perl-Exporter \
 perl-Math-Complex \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Memoize = " \
 perl-Carp \
 perl-Exporter \
 perl-NDBM_File \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-libs \
 "
RDEPENDS:perl-Module-Loaded = " \
 perl-Carp \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-NDBM_File = " \
 gdbm-libs \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-NEXT = " \
 perl-Carp \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Net = " \
 perl-Class-Struct \
 perl-Exporter \
 perl-Socket \
 perl-libs \
 "
RDEPENDS:perl-ODBM_File = " \
 gdbm-libs \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-Opcode = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Opcode \
 perl-libs \
 perl-subs \
 "
RDEPENDS:perl-POSIX = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-libs \
 perl-locale \
 "
RDEPENDS:perl-Pod-Functions = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Pod-Html = " \
 perl-Exporter \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Html \
 perl-Pod-Simple \
 perl-Text-Tabs+Wrap \
 perl-interpreter \
 perl-libs \
 perl-locale \
 perl-parent \
 "
RDEPENDS:perl-Safe = " \
 perl-B \
 perl-Carp \
 perl-Opcode \
 perl-Scalar-List-Utils \
 perl-libs \
 "
RDEPENDS:perl-Search-Dict = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-SelectSaver = " \
 perl-Carp \
 perl-Symbol \
 perl-libs \
 "
RDEPENDS:perl-SelfLoader = " \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-libs \
 "
RDEPENDS:perl-Symbol = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Sys-Hostname = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Term-Complete = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Term-ReadLine = " \
 perl-Term-Cap \
 perl-libs \
 "
RDEPENDS:perl-Test = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Temp \
 perl-libs \
 "
RDEPENDS:perl-Text-Abbrev = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Thread = " \
 perl-Exporter \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 "
RDEPENDS:perl-Thread-Semaphore = " \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-threads-shared \
 "
RDEPENDS:perl-Tie = " \
 perl-Carp \
 perl-Tie \
 perl-libs \
 "
RDEPENDS:perl-Tie-File = " \
 perl-Carp \
 perl-Fcntl \
 perl-POSIX \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Tie-Memoize = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-Time = " \
 perl-Class-Struct \
 perl-Exporter \
 perl-Time \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-Time-Piece = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-Time-Local \
 perl-Time-Piece \
 perl-constant \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Unicode-UCD = " \
 perl-Carp \
 perl-Exporter \
 perl-PathTools \
 perl-Storable \
 perl-Unicode-Normalize \
 perl-if \
 perl-libs \
 "
RDEPENDS:perl-User-pwent = " \
 perl-Carp \
 perl-Class-Struct \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-autouse = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-base = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-blib = " \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-debugger = " \
 perl-IO \
 perl-PathTools \
 perl-Term-ReadLine \
 perl-libs \
 perl-meta-notation \
 perl-mro \
 perl-threads \
 perl-threads-shared \
 perl-vars \
 "
RDEPENDS:perl-deprecate = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-devel = " \
 libxcrypt-devel \
 perl-Devel-PPPort \
 perl-ExtUtils-Constant \
 perl-ExtUtils-Install \
 perl-ExtUtils-ParseXS \
 perl-File-Compare \
 perl-File-Path \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Text-Tabs+Wrap \
 perl-interpreter \
 perl-libs \
 perl-vars \
 redhat-rpm-config \
 systemtap-sdt-devel \
 systemtap-sdt-dtrace \
 "
RDEPENDS:perl-diagnostics = " \
 perl-Carp \
 perl-Getopt-Std \
 perl-Text-Tabs+Wrap \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-doc = " \
 perl-libs \
 "
RDEPENDS:perl-encoding-warnings = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-fields = " \
 perl-Carp \
 perl-Hash-Util \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-filetest = " \
 perl-libs \
 "
RDEPENDS:perl-if = " \
 perl-libs \
 "
RDEPENDS:perl-interpreter = " \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-less = " \
 perl-libs \
 "
RDEPENDS:perl-lib = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-libnetcfg = " \
 perl-ExtUtils-MakeMaker \
 perl-Getopt-Std \
 perl-IO \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-libs = " \
 glibc \
 libxcrypt \
 perl-Carp \
 perl-DynaLoader \
 perl-Encode \
 perl-Exporter \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-locale = " \
 perl-Carp \
 perl-POSIX \
 perl-libs \
 "
RDEPENDS:perl-macros = " \
 perl-interpreter \
 "
RDEPENDS:perl-meta-notation = " \
 perl-libs \
 "
RDEPENDS:perl-mro = " \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-open = " \
 perl-Carp \
 perl-Encode \
 perl-encoding \
 perl-libs \
 "
RDEPENDS:perl-overload = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-mro \
 perl-overloading \
 "
RDEPENDS:perl-overloading = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-ph = " \
 perl-libs \
 "
RDEPENDS:perl-sigtrap = " \
 perl-Carp \
 perl-Symbol \
 perl-libs \
 perl-meta-notation \
 "
RDEPENDS:perl-sort = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-subs = " \
 perl-libs \
 "
RDEPENDS:perl-utils = " \
 perl-File-Basename \
 perl-File-Path \
 perl-Getopt-Std \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-vars = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-vmsish = " \
 perl-libs \
 "
