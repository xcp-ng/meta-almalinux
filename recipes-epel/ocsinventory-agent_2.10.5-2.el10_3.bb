# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ocsinventory-agent"
PV = "2.10.5"
PR = "2.el10_3"
PACKAGES = " \
 ocsinventory-agent \
 perl-Ocsinventory-Agent \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/ocsinventory-agent-2.10.5-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "211a751d4743fc7e314308ca321f0a892a0636d4e79ea37f6f6fa0003b990223"

URI_x86_64_v2_ocsinventory-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ocsinventory-agent-2.10.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ocsinventory-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocsinventory-agent}"
SRC_URI[x86_64_v2_ocsinventory-agent.sha256sum] = "e943911b467f8a4e10ccbde0cdc5ac3ac42b462ad3c0ca07c801a6dfef806467"

URI_x86_64_v2_perl-Ocsinventory-Agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Ocsinventory-Agent-2.10.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Ocsinventory-Agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Ocsinventory-Agent}"
SRC_URI[x86_64_v2_perl-Ocsinventory-Agent.sha256sum] = "6aa5234a477e3aca72f27c67d08cb79b10738a76a71b33781d1e9d93a6ec20d3"

URI_aarch64_ocsinventory-agent = "${EPEL_MIRROR}/aarch64/Packages/o/ocsinventory-agent-2.10.5-2.el10_3.aarch64.rpm;name=aarch64_ocsinventory-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocsinventory-agent}"
SRC_URI[aarch64_ocsinventory-agent.sha256sum] = "b470c26360ed40eda2f24ca4a1bcd84be6c87e08ff98c4f8dd155313746fa5d9"

URI_aarch64_perl-Ocsinventory-Agent = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Ocsinventory-Agent-2.10.5-2.el10_3.noarch.rpm;name=aarch64_perl-Ocsinventory-Agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Ocsinventory-Agent}"
SRC_URI[aarch64_perl-Ocsinventory-Agent.sha256sum] = "b62898ec3cc52e73398985e55b2c0e59cfa253ebbf7bdb329fbcc07a68932818"

RDEPENDS:ocsinventory-agent:x86_64_v2 = " \
 bash \
 dmidecode \
 logrotate \
 perl-Ocsinventory-Agent \
 systemd \
"
RDEPENDS:ocsinventory-agent:aarch64 = " \
 bash \
 logrotate \
 perl-Ocsinventory-Agent \
 systemd \
"
RDEPENDS:perl-Ocsinventory-Agent = " \
 net-tools \
 pciutils \
 perl-Carp \
 perl-Data-Dumper \
 perl-Data-UUID \
 perl-Digest-MD5 \
 perl-Encode \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-FcntlLock \
 perl-File-Path \
 perl-File-Temp \
 perl-File-stat \
 perl-Getopt-Long \
 perl-HTTP-Message \
 perl-IO-Compress \
 perl-IO-Socket-SSL \
 perl-LWP-Protocol-https \
 perl-MIME-Base64 \
 perl-Net-IP \
 perl-Net-Netmask \
 perl-Net-SNMP \
 perl-Net-SSLeay \
 perl-Ocsinventory-Agent \
 perl-POSIX \
 perl-Parse-EDID \
 perl-Socket \
 perl-Sys-Syslog \
 perl-Time-Local \
 perl-XML-Parser \
 perl-XML-Simple \
 perl-constant \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 smartmontools \
 which \
 "
