# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-packetline"
PV = "0.21.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-packetline+async-io-devel \
 rust-gix-packetline+blocking-io-devel \
 rust-gix-packetline+default-devel \
 rust-gix-packetline+document-features-devel \
 rust-gix-packetline+futures-lite-devel \
 rust-gix-packetline+serde-devel \
 rust-gix-packetline-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-packetline-0.21.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7620a5fa64faa9f795b46161f47b4058a8b329db6a6ccaf08e2c3c4b1979ea2d"

URI_x86_64_v2_rust-gix-packetline+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+async-io-devel-0.21.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+async-io-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+async-io-devel.sha256sum] = "6621764e2f17c1a083be385e3e2a1fdd955c5ad2b567d58a2283673a0d891873"

URI_x86_64_v2_rust-gix-packetline+blocking-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+blocking-io-devel-0.21.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+blocking-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+blocking-io-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+blocking-io-devel.sha256sum] = "e3412db4f65b93ee87fea87398c40ac4c5f2a544288866579f4acb87ec2fd16f"

URI_x86_64_v2_rust-gix-packetline+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+default-devel-0.21.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+default-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+default-devel.sha256sum] = "ab6054b91b7049a2e6dc16f3a3192409c19aa1b9d22e37cb8094c67ce69e05b8"

URI_x86_64_v2_rust-gix-packetline+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+document-features-devel-0.21.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+document-features-devel.sha256sum] = "3b39637db87bff587dd8013759a8499b7827cbae6d009f0abd71390b0679761c"

URI_x86_64_v2_rust-gix-packetline+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+futures-lite-devel-0.21.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+futures-lite-devel.sha256sum] = "1c9de1ae26d47c93f05840278ad58295d1d6705eb4bf763f6bc03488b533a54d"

URI_x86_64_v2_rust-gix-packetline+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+serde-devel-0.21.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+serde-devel.sha256sum] = "7e46233a46f79f8de83d759d3dcf93eb0bf59341aed2b473c854e3b062ebbbfd"

URI_x86_64_v2_rust-gix-packetline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-devel-0.21.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-devel.sha256sum] = "2b3298fe9d85ab93a95fc7c0626592dc01138c6697936d02fb530fe7f45034b0"

URI_aarch64_rust-gix-packetline+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+async-io-devel-0.21.5-1.el10_3.noarch.rpm;name=aarch64_rust-gix-packetline+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+async-io-devel}"
SRC_URI[aarch64_rust-gix-packetline+async-io-devel.sha256sum] = "1c959338e4bf367b2abf9d0a0e50ead4788ab072e65fd3178586ed3527624925"

URI_aarch64_rust-gix-packetline+blocking-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+blocking-io-devel-0.21.5-1.el10_3.noarch.rpm;name=aarch64_rust-gix-packetline+blocking-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+blocking-io-devel}"
SRC_URI[aarch64_rust-gix-packetline+blocking-io-devel.sha256sum] = "a735f97430ad409c81aebc1bb43f772efdf721efee00edef4a12f73d29057beb"

URI_aarch64_rust-gix-packetline+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+default-devel-0.21.5-1.el10_3.noarch.rpm;name=aarch64_rust-gix-packetline+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+default-devel}"
SRC_URI[aarch64_rust-gix-packetline+default-devel.sha256sum] = "f5ed9ecc2346f1be57e16111a37e8f2f055d07461f0cf7c6d7cbfcb9a16b2f5b"

URI_aarch64_rust-gix-packetline+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+document-features-devel-0.21.5-1.el10_3.noarch.rpm;name=aarch64_rust-gix-packetline+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+document-features-devel}"
SRC_URI[aarch64_rust-gix-packetline+document-features-devel.sha256sum] = "42da8fa40b5ead4158cbef0d1205e2f9bfa306e01ff0d020386ef20b9cc8a141"

URI_aarch64_rust-gix-packetline+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+futures-lite-devel-0.21.5-1.el10_3.noarch.rpm;name=aarch64_rust-gix-packetline+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+futures-lite-devel}"
SRC_URI[aarch64_rust-gix-packetline+futures-lite-devel.sha256sum] = "12f3b4a3a10a369a23ce501e3771e26dcbe1972217bf97f1010cb9e307ccb898"

URI_aarch64_rust-gix-packetline+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+serde-devel-0.21.5-1.el10_3.noarch.rpm;name=aarch64_rust-gix-packetline+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+serde-devel}"
SRC_URI[aarch64_rust-gix-packetline+serde-devel.sha256sum] = "04002a64c557933f549e35ecd88b501b27277d4dfdc3d58279b247bac4b88f96"

URI_aarch64_rust-gix-packetline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-devel-0.21.5-1.el10_3.noarch.rpm;name=aarch64_rust-gix-packetline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-devel}"
SRC_URI[aarch64_rust-gix-packetline-devel.sha256sum] = "56df9bc62db8220bea33afa60abf9d2534a3688ab437b0f23ee94e65869ab2d2"

RDEPENDS:rust-gix-packetline+async-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-gix-packetline+futures-lite-devel \
 rust-gix-packetline-devel \
 rust-pin-project-lite+default-devel \
 "
RDEPENDS:rust-gix-packetline+blocking-io-devel = " \
 cargo \
 rust-gix-packetline-devel \
 "
RDEPENDS:rust-gix-packetline+default-devel = " \
 cargo \
 rust-gix-packetline-devel \
 "
RDEPENDS:rust-gix-packetline+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-packetline-devel \
 "
RDEPENDS:rust-gix-packetline+futures-lite-devel = " \
 cargo \
 rust-futures-lite+default-devel \
 rust-gix-packetline-devel \
 "
RDEPENDS:rust-gix-packetline+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-faster-hex+serde-devel \
 rust-gix-packetline-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-packetline-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-faster-hex+std-devel \
 rust-faster-hex-devel \
 rust-gix-trace+default-devel \
 rust-thiserror+default-devel \
 "
