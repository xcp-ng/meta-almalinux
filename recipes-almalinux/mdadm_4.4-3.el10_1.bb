# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mdadm"
PV = "4.4"
PR = "3.el10_1"
PACKAGES = " \
 mdadm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mdadm-4.4-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e0db0752b25f5d3db685a5df1c3969e588e38656c227d2d9f30e8843ee1d84a"

URI_x86_64_v2_mdadm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mdadm-4.4-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_mdadm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mdadm}"
SRC_URI[x86_64_v2_mdadm.sha256sum] = "4bc074c349a52c5b7caaf1137dc6672aaec75ffad2545a1cb4bf8a9cf677c449"

URI_aarch64_mdadm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mdadm-4.4-3.el10_1.aarch64.rpm;name=aarch64_mdadm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mdadm}"
SRC_URI[aarch64_mdadm.sha256sum] = "be69fef93135aeeeddc25534bced67d056304442dcd03c4a760ac84ad3e9c0f2"

RDEPENDS:mdadm = " \
 bash \
 glibc \
 systemd \
 systemd-libs \
 virtual/coreutils \
 "
