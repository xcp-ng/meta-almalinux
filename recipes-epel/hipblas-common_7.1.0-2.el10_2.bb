# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipblas-common"
PV = "7.1.0"
PR = "2.el10_2"
PACKAGES:x86_64_v2 = " \
 hipblas-common-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipblas-common-7.1.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7a17c77ba4ed0824617d6733a9013d2b34a60e726e79fdf082637ff84b70053"

URI_x86_64_v2_hipblas-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipblas-common-devel-7.1.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_hipblas-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipblas-common-devel}"
SRC_URI[x86_64_v2_hipblas-common-devel.sha256sum] = "8ed5dc32b027ed0373caf53f1ed9edf54fc5f6f5bdf8944e8fe6e9ab27eb0369"

RDEPENDS:hipblas-common-devel = " \
 cmake-filesystem \
 "
