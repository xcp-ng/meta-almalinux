# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R"
PV = "4.5.3"
PR = "1.el10_2"
PACKAGES = " \
 R \
 R-core \
 R-core-devel \
 R-devel \
 R-java \
 R-java-devel \
 libRmath \
 libRmath-devel \
 libRmath-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-4.5.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe47016d7c2abc45cb10c04bbb8c586716ae58b58b73efcc42234fb5e2519598"

URI_x86_64_v2_R = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-4.5.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R}"
SRC_URI[x86_64_v2_R.sha256sum] = "b44532dca595c6a4e152de6197c92fe8a0a0e3697ef636a7bffadeb9db6c6f88"

URI_x86_64_v2_R-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-core-4.5.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-core}"
SRC_URI[x86_64_v2_R-core.sha256sum] = "5a68f7d249cd7944e86be60884a39582dbbfdcf097ea5e0ee7e25b9612a69566"

URI_x86_64_v2_R-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-core-devel-4.5.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-core-devel}"
SRC_URI[x86_64_v2_R-core-devel.sha256sum] = "4138b8e56c237b5cd664d68263e6445312a89c7f0880ac15a98fd088dbda16e0"

URI_x86_64_v2_R-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-devel-4.5.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-devel}"
SRC_URI[x86_64_v2_R-devel.sha256sum] = "e4c969196b40a32a5b665de52df998ce9a917cb2f14f8f8da97ac43f4306d883"

URI_x86_64_v2_R-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-java-4.5.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-java}"
SRC_URI[x86_64_v2_R-java.sha256sum] = "351128eea56f396bc524ca66728c4f5315bdbbc41b1c1cf63ba1d82689a04b68"

URI_x86_64_v2_R-java-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-java-devel-4.5.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-java-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-java-devel}"
SRC_URI[x86_64_v2_R-java-devel.sha256sum] = "63085a9a1207975ace9710c8c1f5976de2d325e8f461529458670f42e71785bc"

URI_x86_64_v2_libRmath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libRmath-4.5.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libRmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libRmath}"
SRC_URI[x86_64_v2_libRmath.sha256sum] = "f4e130f07120414a239cb18c35b7dea7bf1389dec198d369df114de6f1229527"

URI_x86_64_v2_libRmath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libRmath-devel-4.5.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libRmath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libRmath-devel}"
SRC_URI[x86_64_v2_libRmath-devel.sha256sum] = "c7a6df888fe184eb936f79151a55729b5a3174b11831964cddc9809b587e59ce"

URI_x86_64_v2_libRmath-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libRmath-static-4.5.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libRmath-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libRmath-static}"
SRC_URI[x86_64_v2_libRmath-static.sha256sum] = "8d3663e4e999cae734ab714e837a4b4c2110cee94e3768d2e593725361106672"

URI_aarch64_R = "${EPEL_MIRROR}/aarch64/Packages/r/R-4.5.3-1.el10_2.aarch64.rpm;name=aarch64_R;unpack=0"
SRC_URI:append = " ${URI_aarch64_R}"
SRC_URI[aarch64_R.sha256sum] = "16661a2057ab50468da74e525cc8edafdbee1d63d230763022759ecb44cdce79"

URI_aarch64_R-core = "${EPEL_MIRROR}/aarch64/Packages/r/R-core-4.5.3-1.el10_2.aarch64.rpm;name=aarch64_R-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-core}"
SRC_URI[aarch64_R-core.sha256sum] = "2f76abcb2cbf98ce282a50c4d233e2fa0652900e01595d6bb0b6c2ba89205208"

URI_aarch64_R-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/R-core-devel-4.5.3-1.el10_2.aarch64.rpm;name=aarch64_R-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-core-devel}"
SRC_URI[aarch64_R-core-devel.sha256sum] = "4f45d05ce34a51a2132c923d79eeae40ac176af665e524048fdeca807fb4c9dc"

URI_aarch64_R-devel = "${EPEL_MIRROR}/aarch64/Packages/r/R-devel-4.5.3-1.el10_2.aarch64.rpm;name=aarch64_R-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-devel}"
SRC_URI[aarch64_R-devel.sha256sum] = "94f01189e9c7d558f244055f038dc83d0be716a6d9073c9e52b7303cc9d8f5ae"

URI_aarch64_R-java = "${EPEL_MIRROR}/aarch64/Packages/r/R-java-4.5.3-1.el10_2.aarch64.rpm;name=aarch64_R-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-java}"
SRC_URI[aarch64_R-java.sha256sum] = "7880f636fbbb0f91ec99425bbf24ecef8b60fb734af4a03d59247e838a697fd6"

URI_aarch64_R-java-devel = "${EPEL_MIRROR}/aarch64/Packages/r/R-java-devel-4.5.3-1.el10_2.aarch64.rpm;name=aarch64_R-java-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-java-devel}"
SRC_URI[aarch64_R-java-devel.sha256sum] = "8fc252529545e271d696b38fa249a398f31b5b1de4fc0ffbe397a0d13d88389f"

URI_aarch64_libRmath = "${EPEL_MIRROR}/aarch64/Packages/l/libRmath-4.5.3-1.el10_2.aarch64.rpm;name=aarch64_libRmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_libRmath}"
SRC_URI[aarch64_libRmath.sha256sum] = "0574f687cfcb203c65e69e017cfbbfafbe475f3e657a8271beeca4f2a5f7f717"

URI_aarch64_libRmath-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libRmath-devel-4.5.3-1.el10_2.aarch64.rpm;name=aarch64_libRmath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libRmath-devel}"
SRC_URI[aarch64_libRmath-devel.sha256sum] = "6412e2e5c7d720de8c7faebd12015678ff680437062a7baf982f4889fe75821c"

URI_aarch64_libRmath-static = "${EPEL_MIRROR}/aarch64/Packages/l/libRmath-static-4.5.3-1.el10_2.aarch64.rpm;name=aarch64_libRmath-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libRmath-static}"
SRC_URI[aarch64_libRmath-static.sha256sum] = "702d1233b2de9b78450e1458a9ca0132bd22c0f8ffe1f82bf7a597365bb6660d"

RDEPENDS:R = " \
 R-devel \
 "
RDEPENDS:R-core = " \
 bash \
 bzip2-libs \
 cairo \
 flexiblas-netlib \
 glib2 \
 glibc \
 less \
 libRmath \
 libX11 \
 libXmu \
 libXt \
 libdeflate \
 libgcc \
 libgomp \
 libicu \
 libjpeg-turbo \
 libpng \
 libtiff \
 libtirpc \
 libzstd \
 pango \
 pcre2 \
 readline \
 tcl \
 tk \
 tre \
 tzdata \
 unzip \
 virtual/libcurl.so.4___64bit_ \
 xdg-utils \
 xz-libs \
 zip \
 zlib-ng-compat \
 "
RDEPENDS:R-core-devel = " \
 R-core \
 bzip2-devel \
 flexiblas-devel \
 gcc-c++ \
 gcc-gfortran \
 libRmath-devel \
 libX11-devel \
 libdeflate-devel \
 libicu-devel \
 libtirpc-devel \
 libzstd-devel \
 make \
 pcre2-devel \
 pkgconf-pkg-config \
 redhat-rpm-config \
 tre-devel \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:R-devel = " \
 R-core-devel \
 R-java-devel \
 R-rpm-macros \
 "
RDEPENDS:R-java = " \
 R-core \
 java-21-openjdk-headless \
 "
RDEPENDS:R-java-devel = " \
 R-core-devel \
 R-java \
 java-21-openjdk-devel \
 "
RDEPENDS:libRmath = " \
 glibc \
 "
RDEPENDS:libRmath-devel = " \
 libRmath \
 pkgconf-pkg-config \
 "
RDEPENDS:libRmath-static = " \
 libRmath-devel \
 "
