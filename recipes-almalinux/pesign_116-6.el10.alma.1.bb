# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pesign"
PV = "116"
PR = "6.el10.alma.1"
PACKAGES = " \
 pesign \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pesign-116-6.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "967bb3b5bf1297de5e804fc79465875a407aca27b5a12c773fa09f70fd552d4b"

URI_x86_64_v2_pesign = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pesign-116-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_pesign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pesign}"
SRC_URI[x86_64_v2_pesign.sha256sum] = "14575391c554de0aec3fb86935ddcf971fdfeccf628073c7827b7a9e7ee77c48"

URI_aarch64_pesign = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pesign-116-6.el10.alma.1.aarch64.rpm;name=aarch64_pesign;unpack=0"
SRC_URI:append = " ${URI_aarch64_pesign}"
SRC_URI[aarch64_pesign.sha256sum] = "4b546f3ae1f50b38e7cc849d3cf2027395ac36437494656c2c62f9977df89f4e"

RDEPENDS:pesign = " \
 bash \
 efivar-libs \
 glibc \
 libuuid \
 nspr \
 nss \
 nss-tools \
 nss-util \
 popt \
 python3 \
 rpm \
 shadow-utils \
 "
