# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stratisd"
PV = "3.8.6"
PR = "2.el10"
PACKAGES = " \
 stratisd \
 stratisd-dracut \
 stratisd-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/stratisd-3.8.6-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d76d812b19f5b7a999f818bacda4fbaddb9edd288188101889a640319caa5e57"

URI_x86_64_v2_stratisd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/stratisd-3.8.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_stratisd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stratisd}"
SRC_URI[x86_64_v2_stratisd.sha256sum] = "b8f76364fc0f230eeda52e855fe0f18d1e3ea287ec5e316f965823d89ee8c9f9"

URI_x86_64_v2_stratisd-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/stratisd-dracut-3.8.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_stratisd-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stratisd-dracut}"
SRC_URI[x86_64_v2_stratisd-dracut.sha256sum] = "e1df1ec21b6f24ce07e97edb6927123e87583b9489c3f0899955541354bf92fd"

URI_x86_64_v2_stratisd-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/stratisd-tools-3.8.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_stratisd-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stratisd-tools}"
SRC_URI[x86_64_v2_stratisd-tools.sha256sum] = "ff6b7f144abe017a80ad1d2722e44af741df02956d7c0d7e2e8c83ca36f944b6"

URI_aarch64_stratisd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/stratisd-3.8.6-2.el10.aarch64.rpm;name=aarch64_stratisd;unpack=0"
SRC_URI:append = " ${URI_aarch64_stratisd}"
SRC_URI[aarch64_stratisd.sha256sum] = "4338bf31e3c4a2d8974cdf259cc73cc4b9afbd68c4560c70579f30c3639f7a8c"

URI_aarch64_stratisd-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/stratisd-dracut-3.8.6-2.el10.aarch64.rpm;name=aarch64_stratisd-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_stratisd-dracut}"
SRC_URI[aarch64_stratisd-dracut.sha256sum] = "9d1826d60f102ab3152ffd01ee7ab5e91976972c547e8a9e280c84972dda9c98"

URI_aarch64_stratisd-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/stratisd-tools-3.8.6-2.el10.aarch64.rpm;name=aarch64_stratisd-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_stratisd-tools}"
SRC_URI[aarch64_stratisd-tools.sha256sum] = "24384a2cd581da094afb17e3cdabbab3467bde714a02dcf26ab89afb09f570ca"

RDEPENDS:stratisd = " \
 bash \
 cryptsetup-libs \
 dbus-libs \
 device-mapper-persistent-data \
 glibc \
 libblkid \
 libgcc \
 python3 \
 systemd-libs \
 xfsprogs \
 "
RDEPENDS:stratisd-dracut = " \
 bash \
 cryptsetup-libs \
 dracut \
 glibc \
 libblkid \
 libgcc \
 stratisd \
 systemd \
 systemd-libs \
 "
RDEPENDS:stratisd-tools = " \
 cryptsetup-libs \
 glibc \
 libblkid \
 libgcc \
 stratisd \
 systemd-libs \
 "
