# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flamethrower"
PV = "0.12.0"
PR = "3.el10_2"
PACKAGES = " \
 flamethrower \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/flamethrower-0.12.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cef3d4368d12be917b1dfd68073276188ee02991122b076bbbcc670f79cf6e9"

URI_x86_64_v2_flamethrower = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flamethrower-0.12.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flamethrower;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flamethrower}"
SRC_URI[x86_64_v2_flamethrower.sha256sum] = "2ece92ec097cd45066e5900f2d8a965f54b6530e24383087656efbfaba53db59"

URI_aarch64_flamethrower = "${EPEL_MIRROR}/aarch64/Packages/f/flamethrower-0.12.0-3.el10_2.aarch64.rpm;name=aarch64_flamethrower;unpack=0"
SRC_URI:append = " ${URI_aarch64_flamethrower}"
SRC_URI[aarch64_flamethrower.sha256sum] = "e875e8dedb35b531f782104e46f3af93a1990accd11e69b308ff081827103d0e"

RDEPENDS:flamethrower = " \
 docopt-cpp \
 glibc \
 gnutls \
 ldns \
 libbrotli \
 libgcc \
 libnghttp2 \
 libstdc++ \
 libuv \
 openssl-libs \
 zlib-ng-compat \
 "
