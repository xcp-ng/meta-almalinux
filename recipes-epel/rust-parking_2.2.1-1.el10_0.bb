# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-parking"
PV = "2.2.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-parking+default-devel \
 rust-parking-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-parking-2.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "042e0020078de6185a7bb332f1c4ffe9e2dc30efd9f48cbaef8046e45707aedc"

URI_x86_64_v2_rust-parking+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking+default-devel-2.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking+default-devel}"
SRC_URI[x86_64_v2_rust-parking+default-devel.sha256sum] = "081ead6a6edf088467789529622d5b14bdec5bb01007da6f3e6205e222cf9acd"

URI_x86_64_v2_rust-parking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking-devel-2.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking-devel}"
SRC_URI[x86_64_v2_rust-parking-devel.sha256sum] = "c5d9424b32d2586868211739d10747cf708cd49c212a85953685e653ba1cafab"

URI_aarch64_rust-parking+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking+default-devel-2.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-parking+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking+default-devel}"
SRC_URI[aarch64_rust-parking+default-devel.sha256sum] = "3c7313764b75501f751d25a3d5dfcd36477beb2a98565769becded1cc15b0bed"

URI_aarch64_rust-parking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking-devel-2.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-parking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking-devel}"
SRC_URI[aarch64_rust-parking-devel.sha256sum] = "2e6d5b7e50efab29563860e7703e7bbbdcb6ea040b7b9902219fa6fc481a5abe"

RDEPENDS:rust-parking+default-devel = " \
 cargo \
 rust-parking-devel \
 "
RDEPENDS:rust-parking-devel = " \
 cargo \
 rust \
 "
