# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-collectd_puppet"
PV = "2.1.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-collectd_puppet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-collectd_puppet-2.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0373af109065f4c6c1a491c10eb673333e35dc8c1f3e8e20d31c9762f0f0e8f7"

URI_x86_64_v2_python3-collectd_puppet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-collectd_puppet-2.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-collectd_puppet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-collectd_puppet}"
SRC_URI[x86_64_v2_python3-collectd_puppet.sha256sum] = "df745d8686378067cbdb00c578185f0f35e5a9738c12b5c45303e2a143903ce5"

URI_aarch64_python3-collectd_puppet = "${EPEL_MIRROR}/aarch64/Packages/p/python3-collectd_puppet-2.1.1-1.el10_0.noarch.rpm;name=aarch64_python3-collectd_puppet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-collectd_puppet}"
SRC_URI[aarch64_python3-collectd_puppet.sha256sum] = "2f951841e8249067bb2b45487d947b82c0dc340b0b41888ca9a749cdda98ce5e"

RDEPENDS:python3-collectd_puppet = " \
 python3 \
 python3-pyyaml \
 "
