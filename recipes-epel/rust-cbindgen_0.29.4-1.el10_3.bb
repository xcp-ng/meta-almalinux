# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cbindgen"
PV = "0.29.4"
PR = "1.el10_3"
PACKAGES = " \
 cbindgen \
 rust-cbindgen+clap-devel \
 rust-cbindgen+default-devel \
 rust-cbindgen+unstable_ir-devel \
 rust-cbindgen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cbindgen-0.29.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26cea5d839e775144aefd4f08aa3ca5b3a9b1eae82da25018a905a501c1f3b44"

URI_x86_64_v2_cbindgen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cbindgen-0.29.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cbindgen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cbindgen}"
SRC_URI[x86_64_v2_cbindgen.sha256sum] = "004596caa1f6ea2037800e0e2b92f5787c7cb4a4c7d26175e6590ec617b302f9"

URI_x86_64_v2_rust-cbindgen+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbindgen+clap-devel-0.29.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbindgen+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbindgen+clap-devel}"
SRC_URI[x86_64_v2_rust-cbindgen+clap-devel.sha256sum] = "7aeb8e65a04c99b91fa5e8f7ac166fc6de7cdf52951d3cf69e61adc5cdfc0415"

URI_x86_64_v2_rust-cbindgen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbindgen+default-devel-0.29.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbindgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbindgen+default-devel}"
SRC_URI[x86_64_v2_rust-cbindgen+default-devel.sha256sum] = "b1d41715f9969f8d3d041502236db3e8eb08fd47f3184fbe8ad866efbc5e9d0a"

URI_x86_64_v2_rust-cbindgen+unstable_ir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbindgen+unstable_ir-devel-0.29.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbindgen+unstable_ir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbindgen+unstable_ir-devel}"
SRC_URI[x86_64_v2_rust-cbindgen+unstable_ir-devel.sha256sum] = "fe5ad487f6a09b2c6681b027f258b9aa2dc7dbb97d31f2a40a9674f13b591139"

URI_x86_64_v2_rust-cbindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbindgen-devel-0.29.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbindgen-devel}"
SRC_URI[x86_64_v2_rust-cbindgen-devel.sha256sum] = "4f2c6a681b918f1586e8baef61a9ad849761177e391afb492a6d0a2afb51c25d"

URI_aarch64_cbindgen = "${EPEL_MIRROR}/aarch64/Packages/c/cbindgen-0.29.4-1.el10_3.aarch64.rpm;name=aarch64_cbindgen;unpack=0"
SRC_URI:append = " ${URI_aarch64_cbindgen}"
SRC_URI[aarch64_cbindgen.sha256sum] = "edf7f3e7e78511ea81a8e4dbc0df0a01e41065b2a4686ce9359c077194721774"

URI_aarch64_rust-cbindgen+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbindgen+clap-devel-0.29.4-1.el10_3.noarch.rpm;name=aarch64_rust-cbindgen+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbindgen+clap-devel}"
SRC_URI[aarch64_rust-cbindgen+clap-devel.sha256sum] = "cb981b8b8282496553dd79e7dca07ea6c39fc4f046c5104dc27498be9dc95cee"

URI_aarch64_rust-cbindgen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbindgen+default-devel-0.29.4-1.el10_3.noarch.rpm;name=aarch64_rust-cbindgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbindgen+default-devel}"
SRC_URI[aarch64_rust-cbindgen+default-devel.sha256sum] = "d22db18a5209346dae471da0f8d355b41af54f6b54713eb28661e2c5b23e5c60"

URI_aarch64_rust-cbindgen+unstable_ir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbindgen+unstable_ir-devel-0.29.4-1.el10_3.noarch.rpm;name=aarch64_rust-cbindgen+unstable_ir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbindgen+unstable_ir-devel}"
SRC_URI[aarch64_rust-cbindgen+unstable_ir-devel.sha256sum] = "0d2a5428342046355321d6726eb26c69b41d236b3bd64fee0c8a57c7bf9e0ca3"

URI_aarch64_rust-cbindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbindgen-devel-0.29.4-1.el10_3.noarch.rpm;name=aarch64_rust-cbindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbindgen-devel}"
SRC_URI[aarch64_rust-cbindgen-devel.sha256sum] = "a9bd3d0f8c6f1cf9046fcb1d60a783655d203adcd4cd41eb781a2f9f39818581"

RDEPENDS:cbindgen = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-cbindgen+clap-devel = " \
 cargo \
 rust-cbindgen-devel \
 rust-clap+default-devel \
 "
RDEPENDS:rust-cbindgen+default-devel = " \
 cargo \
 rust-cbindgen+clap-devel \
 rust-cbindgen-devel \
 "
RDEPENDS:rust-cbindgen+unstable_ir-devel = " \
 cargo \
 rust-cbindgen-devel \
 "
RDEPENDS:rust-cbindgen-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-indexmap+default-devel \
 rust-log+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-serde_json+default-devel \
 rust-syn2+clone-impls-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+fold-devel \
 rust-syn2+full-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2-devel \
 rust-tempfile+default-devel \
 rust-toml0.9+parse-devel \
 rust-toml0.9+serde-devel \
 rust-toml0.9+std-devel \
 rust-toml0.9-devel \
 "
