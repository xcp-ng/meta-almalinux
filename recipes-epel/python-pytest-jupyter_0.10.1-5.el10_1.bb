# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-jupyter"
PV = "0.10.1"
PR = "5.el10_1"
PACKAGES = " \
 python3-pytest-jupyter \
 python3-pytest-jupyter+client \
 python3-pytest-jupyter+server \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-jupyter-0.10.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7498cfef573a54fae8aa0dbb9b8177a4dba794b57f46c47d238eebc95838ccff"

URI_x86_64_v2_python3-pytest-jupyter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-jupyter-0.10.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-jupyter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-jupyter}"
SRC_URI[x86_64_v2_python3-pytest-jupyter.sha256sum] = "380508d8f14eb7d0f95ee9698098d591cb794d3c397331d6a849120e9a4d9bb8"

URI_x86_64_v2_python3-pytest-jupyter+client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-jupyter+client-0.10.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-jupyter+client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-jupyter+client}"
SRC_URI[x86_64_v2_python3-pytest-jupyter+client.sha256sum] = "26b12330f49a22fbffae09696fcf994366cc8b3d26f37e7234217636222f1561"

URI_x86_64_v2_python3-pytest-jupyter+server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-jupyter+server-0.10.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-jupyter+server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-jupyter+server}"
SRC_URI[x86_64_v2_python3-pytest-jupyter+server.sha256sum] = "228abffbd9917777e8647fc0a191cabd79496cb78075995be0c29d535f8410ee"

URI_aarch64_python3-pytest-jupyter = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-jupyter-0.10.1-5.el10_1.noarch.rpm;name=aarch64_python3-pytest-jupyter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-jupyter}"
SRC_URI[aarch64_python3-pytest-jupyter.sha256sum] = "148c181c84edd439db82af76ced61c95591cd1f06a7fd0bb2c8293b862a8c1b2"

URI_aarch64_python3-pytest-jupyter+client = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-jupyter+client-0.10.1-5.el10_1.noarch.rpm;name=aarch64_python3-pytest-jupyter+client;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-jupyter+client}"
SRC_URI[aarch64_python3-pytest-jupyter+client.sha256sum] = "fe33bcc7fd8be1765805dd77d702b7d67361dee5572dd94cb911aa1b5f29f94c"

URI_aarch64_python3-pytest-jupyter+server = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-jupyter+server-0.10.1-5.el10_1.noarch.rpm;name=aarch64_python3-pytest-jupyter+server;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-jupyter+server}"
SRC_URI[aarch64_python3-pytest-jupyter+server.sha256sum] = "9d56fcab6b9d5b2aab59f5cdc138f159f433ba0c4861fd3a126cfb66d763c96d"

RDEPENDS:python3-pytest-jupyter = " \
 python3 \
 python3-jupyter-core \
 python3-pytest \
 "
RDEPENDS:python3-pytest-jupyter+client = " \
 python3 \
 python3-ipykernel \
 python3-jupyter-client \
 python3-nbformat \
 python3-pytest-jupyter \
 "
RDEPENDS:python3-pytest-jupyter+server = " \
 python3 \
 python3-ipykernel \
 python3-jupyter-client \
 python3-jupyter-server \
 python3-nbformat \
 python3-pytest-jupyter \
 "
