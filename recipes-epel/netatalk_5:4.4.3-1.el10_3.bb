# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netatalk"
PE = "5"
PV = "4.4.3"
PR = "1.el10_3"
PACKAGES = " \
 netatalk \
 netatalk-afptest \
 netatalk-devel \
 netatalk-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netatalk-4.4.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c3c3265be9c6e750e78af7f15fa17def0a867278822ccf870f1ccc1f7aba35b"

URI_x86_64_v2_netatalk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-4.4.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netatalk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netatalk}"
SRC_URI[x86_64_v2_netatalk.sha256sum] = "114017da4af8b4b41d2cc57c2d1b75e6c098aac6da9a948a3c6cd8efd547e1a4"

URI_x86_64_v2_netatalk-afptest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-afptest-4.4.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netatalk-afptest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netatalk-afptest}"
SRC_URI[x86_64_v2_netatalk-afptest.sha256sum] = "5e2473a0d22af9ff04051aa5cf1a14d059b408acabb1f9b13a56e5055d96c006"

URI_x86_64_v2_netatalk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-devel-4.4.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netatalk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netatalk-devel}"
SRC_URI[x86_64_v2_netatalk-devel.sha256sum] = "415ab0fd0145ba69ae3e7cdb09c3d79e9af97fbd566a75d40df4090eda1c6d0a"

URI_x86_64_v2_netatalk-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-doc-4.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_netatalk-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netatalk-doc}"
SRC_URI[x86_64_v2_netatalk-doc.sha256sum] = "ffb61dbfa1989bac9a20d20bab1bfdc992817e49b3bc74226a45a941a0914d71"

URI_aarch64_netatalk = "${EPEL_MIRROR}/aarch64/Packages/n/netatalk-4.4.3-1.el10_3.aarch64.rpm;name=aarch64_netatalk;unpack=0"
SRC_URI:append = " ${URI_aarch64_netatalk}"
SRC_URI[aarch64_netatalk.sha256sum] = "c297fa4a0e0013566fe9af13dec167b000758d93ef79b1e51556bbc9775ffe2f"

URI_aarch64_netatalk-afptest = "${EPEL_MIRROR}/aarch64/Packages/n/netatalk-afptest-4.4.3-1.el10_3.aarch64.rpm;name=aarch64_netatalk-afptest;unpack=0"
SRC_URI:append = " ${URI_aarch64_netatalk-afptest}"
SRC_URI[aarch64_netatalk-afptest.sha256sum] = "0be2883f67d4c2b5775aa931cd79c913ee3b2423cc4977eeea3fa7071d57394d"

URI_aarch64_netatalk-devel = "${EPEL_MIRROR}/aarch64/Packages/n/netatalk-devel-4.4.3-1.el10_3.aarch64.rpm;name=aarch64_netatalk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netatalk-devel}"
SRC_URI[aarch64_netatalk-devel.sha256sum] = "7fdce081ef00524a6fe3790e17e5ae9d36d51f19e5b38b2d7c8ced939bad33ca"

URI_aarch64_netatalk-doc = "${EPEL_MIRROR}/aarch64/Packages/n/netatalk-doc-4.4.3-1.el10_3.noarch.rpm;name=aarch64_netatalk-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_netatalk-doc}"
SRC_URI[aarch64_netatalk-doc.sha256sum] = "8dbc92387187d02154df66f5cae5ecfbb10a04fd43f1ed35269c4b8998e80a3b"

RDEPENDS:netatalk = " \
 avahi-libs \
 bash \
 bstring \
 cracklib \
 dconf \
 glib2 \
 glibc \
 iniparser \
 krb5-libs \
 libacl \
 libdb \
 libevent \
 libgcrypt \
 libtalloc \
 libtirpc \
 libtracker-sparql \
 libxcrypt \
 mariadb-connector-c \
 openldap \
 pam-libs \
 perl-File-Basename \
 perl-File-Temp \
 perl-IO-Socket-IP \
 perl-IPC-Open3 \
 perl-Net-DBus \
 perl-PathTools \
 perl-Socket \
 perl-bignum \
 perl-interpreter \
 perl-libs \
 perl-vars \
 python3-dbus \
 sqlite-libs \
 systemd \
 "
RDEPENDS:netatalk-afptest = " \
 glibc \
 iniparser \
 netatalk \
 "
RDEPENDS:netatalk-devel = " \
 netatalk \
 "
RDEPENDS:netatalk-doc = " \
 "
