# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "3proxy"
PV = "0.9.7"
PR = "1.el10_3"
PACKAGES = " \
 3proxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/3/3proxy-0.9.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0e4f3baeb112e070b44eb3cf5cf2b58bf29aef84b6c5d8f6b369ecdd4aa94ab"

URI_x86_64_v2_3proxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/3proxy-0.9.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_3proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_3proxy}"
SRC_URI[x86_64_v2_3proxy.sha256sum] = "acfcb43f16737a2b4b6003f1eae6fc466f8d04758eaabc87b89b08a6b7673b00"

URI_aarch64_3proxy = "${EPEL_MIRROR}/aarch64/Packages/3/3proxy-0.9.7-1.el10_3.aarch64.rpm;name=aarch64_3proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_3proxy}"
SRC_URI[aarch64_3proxy.sha256sum] = "06688a94e85cdcd66f5db2305cd40ec498e3623901c6a63c520acc7ae253eb07"

RDEPENDS:3proxy = " \
 bash \
 glibc \
 "
