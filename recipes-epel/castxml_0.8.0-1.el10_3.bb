# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "castxml"
PV = "0.8.0"
PR = "1.el10_3"
PACKAGES = " \
 castxml \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/castxml-0.8.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "61187da27b25de64df7dcd69c46548c36a05babd2f612620bef2b00dcce5ca9f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/castxml-0.8.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_castxml;unpack=0"
SRC_URI[x86_64_v2_castxml.sha256sum] = "d1e6cf235531237edf48f779f4f65c1886683b9dba9571a1682a6dbac8f3c4cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/castxml-0.8.0-1.el10_3.aarch64.rpm;name=aarch64_castxml;unpack=0"
SRC_URI[aarch64_castxml.sha256sum] = "f31b0d584a92d54492b336da4b826d30657dd84650c9390fda159acc5c06959a"

RDEPENDS:castxml = " \
 clang-libs \
 glibc \
 libstdc++ \
 llvm-libs \
 "
