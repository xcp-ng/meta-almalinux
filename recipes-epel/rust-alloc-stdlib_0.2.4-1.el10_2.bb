# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-alloc-stdlib"
PV = "0.2.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-alloc-stdlib+default-devel \
 rust-alloc-stdlib+unsafe-devel \
 rust-alloc-stdlib-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-alloc-stdlib-0.2.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e723699e1bc22216679954c2271b24c895cdf53b78d23bec3db78e8da9d69144"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alloc-stdlib+default-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alloc-stdlib+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-alloc-stdlib+default-devel.sha256sum] = "44f19cd1c359d2002498eb7e6a84a619cd76a0595965507c16c09c278387895b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alloc-stdlib+unsafe-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alloc-stdlib+unsafe-devel;unpack=0"
SRC_URI[x86_64_v2_rust-alloc-stdlib+unsafe-devel.sha256sum] = "87f02276572d362abe63b9994acf2cf3e1195f2c58616bf32dc4fbcba00d0a59"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alloc-stdlib-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alloc-stdlib-devel;unpack=0"
SRC_URI[x86_64_v2_rust-alloc-stdlib-devel.sha256sum] = "05f41f7cb087dcc4b01f947b502b98003b6b1d4b72f73afa1a1f7e8e695edfb8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-alloc-stdlib+default-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-alloc-stdlib+default-devel;unpack=0"
SRC_URI[aarch64_rust-alloc-stdlib+default-devel.sha256sum] = "ed35081425be72f2b87309ce355d2c94b7f551f0765cd0ab65b28277a66346e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-alloc-stdlib+unsafe-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-alloc-stdlib+unsafe-devel;unpack=0"
SRC_URI[aarch64_rust-alloc-stdlib+unsafe-devel.sha256sum] = "f27f01d9e87f20d5206fe3e4a08c134020ab0936b89736a5190b95eeb900323a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-alloc-stdlib-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-alloc-stdlib-devel;unpack=0"
SRC_URI[aarch64_rust-alloc-stdlib-devel.sha256sum] = "6f3d7dcc5677a1d8a54fe5a5ed1c63d9ad70671c784251e367ec556cfc990591"

RDEPENDS:rust-alloc-stdlib+default-devel = " \
 cargo \
 rust-alloc-stdlib-devel \
 "
RDEPENDS:rust-alloc-stdlib+unsafe-devel = " \
 cargo \
 rust-alloc-no-stdlib+unsafe-devel \
 rust-alloc-stdlib-devel \
 "
RDEPENDS:rust-alloc-stdlib-devel = " \
 cargo \
 rust-alloc-no-stdlib+default-devel \
 "
