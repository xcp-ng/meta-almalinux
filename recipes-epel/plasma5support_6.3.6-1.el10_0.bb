# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma5support"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma5support \
 plasma5support-devel \
 plasma5support-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma5support-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f3887b1169892d30923de4efdefb32107de5fe2b19111e061064d140bf8fbd2"

URI_x86_64_v2_plasma5support = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma5support-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma5support;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma5support}"
SRC_URI[x86_64_v2_plasma5support.sha256sum] = "8fa7ba3760fb80f8ecdaaea196a29514235b772638d8b64cdf001a95c0790456"

URI_x86_64_v2_plasma5support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma5support-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma5support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma5support-devel}"
SRC_URI[x86_64_v2_plasma5support-devel.sha256sum] = "aa1e44bfc2c3f7022ebfc72a50239b853baed730451ef2e514dbcde01037ac6e"

URI_x86_64_v2_plasma5support-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma5support-doc-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_plasma5support-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma5support-doc}"
SRC_URI[x86_64_v2_plasma5support-doc.sha256sum] = "5ffb0e95ce4dabc87b4cb6ecd8150f5e8acd2d37223e87c042e0181df4601c18"

URI_aarch64_plasma5support = "${EPEL_MIRROR}/aarch64/Packages/p/plasma5support-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma5support;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma5support}"
SRC_URI[aarch64_plasma5support.sha256sum] = "1a9265c8d05d77ca8f2d8f4d742dafc45d02fc3e4891e86b5866a77701ba45af"

URI_aarch64_plasma5support-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma5support-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma5support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma5support-devel}"
SRC_URI[aarch64_plasma5support-devel.sha256sum] = "86f46782b5df5d630fcdd5b6120ad62d4fe6b72a24c2c04c62260e1f76d1493b"

URI_aarch64_plasma5support-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma5support-doc-6.3.6-1.el10_0.noarch.rpm;name=aarch64_plasma5support-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma5support-doc}"
SRC_URI[aarch64_plasma5support-doc.sha256sum] = "445b1b0b530f1ba7b6dd864cda0933311ffc6850677f2e296f439ebc58a7d578"

RDEPENDS:plasma5support = " \
 glibc \
 gpsd-libs \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-networkmanager-qt \
 kf6-solid \
 libX11 \
 libXfixes \
 libksysguard \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma5support-devel = " \
 cmake-filesystem \
 plasma5support \
 qt6-qtbase-devel \
 "
RDEPENDS:plasma5support-doc = " \
 "
