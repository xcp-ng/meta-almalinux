# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-validate"
PV = "0.10.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-validate+default-devel \
 rust-gix-validate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-validate-0.10.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b20efe60ff4601508a3bdb85f4ec10883a02e2ede1feff483901c4edfaa72375"

URI_x86_64_v2_rust-gix-validate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-validate+default-devel-0.10.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-validate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-validate+default-devel}"
SRC_URI[x86_64_v2_rust-gix-validate+default-devel.sha256sum] = "d2838dcd3cb7aa5779565f5a903e810d297568ac6cd9f1657c914bb8f43a9b1f"

URI_x86_64_v2_rust-gix-validate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-validate-devel-0.10.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-validate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-validate-devel}"
SRC_URI[x86_64_v2_rust-gix-validate-devel.sha256sum] = "5fe5ad3437e1394441f48ec30f60ada9e0c2a2781076ddb0dbf0d7caec2232aa"

URI_aarch64_rust-gix-validate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-validate+default-devel-0.10.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-validate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-validate+default-devel}"
SRC_URI[aarch64_rust-gix-validate+default-devel.sha256sum] = "ef47be1fc1c4d9bb3c61858658f9d0c9447d999c8f6b7bb38de1ddb6e271d49d"

URI_aarch64_rust-gix-validate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-validate-devel-0.10.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-validate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-validate-devel}"
SRC_URI[aarch64_rust-gix-validate-devel.sha256sum] = "0913ae92d2797331cc5b14db1130678792d18c60c4ad11424ac7057b3bea48de"

RDEPENDS:rust-gix-validate+default-devel = " \
 cargo \
 rust-gix-validate-devel \
 "
RDEPENDS:rust-gix-validate-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-thiserror+default-devel \
 "
