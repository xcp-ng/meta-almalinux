# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-platform-info"
PV = "2.0.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-platform-info+default-devel \
 rust-platform-info-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-platform-info-2.0.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "397f3f565b943f956353f04e388d64c276a5301e191add6409eb55a2a1b4d6a1"

URI_x86_64_v2_rust-platform-info+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-platform-info+default-devel-2.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-platform-info+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-platform-info+default-devel}"
SRC_URI[x86_64_v2_rust-platform-info+default-devel.sha256sum] = "a9ba8febfbc2c1ad70cc8fc6ddcf759f49015dd39eab1b6d4dd5455c7485e9cb"

URI_x86_64_v2_rust-platform-info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-platform-info-devel-2.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-platform-info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-platform-info-devel}"
SRC_URI[x86_64_v2_rust-platform-info-devel.sha256sum] = "e63750f58b66c38a06f76e5f5b94ac6f54a8038f18a4c8ad97fb50d194dd758d"

URI_aarch64_rust-platform-info+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-platform-info+default-devel-2.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-platform-info+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-platform-info+default-devel}"
SRC_URI[aarch64_rust-platform-info+default-devel.sha256sum] = "0441532176248496928f94c408ae8c732499d4ce6259b4f053a752b96cab24fb"

URI_aarch64_rust-platform-info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-platform-info-devel-2.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-platform-info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-platform-info-devel}"
SRC_URI[aarch64_rust-platform-info-devel.sha256sum] = "868db6b335f387d427a3a0b967cabf331cb11d969d2e5af1e77004ab042b37dd"

RDEPENDS:rust-platform-info+default-devel = " \
 cargo \
 rust-platform-info-devel \
 "
RDEPENDS:rust-platform-info-devel = " \
 cargo \
 rust-libc+default-devel \
 "
