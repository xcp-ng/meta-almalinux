# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-utils"
PV = "0.3.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-utils+bstr-devel \
 rust-gix-utils+default-devel \
 rust-gix-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-utils-0.3.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "238e71a9fe0b37d11110fc5b38cd0e3756a18307b54bb8371dc2f002a54bb3df"

URI_x86_64_v2_rust-gix-utils+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-utils+bstr-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-utils+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-utils+bstr-devel}"
SRC_URI[x86_64_v2_rust-gix-utils+bstr-devel.sha256sum] = "35826db83279635a175185ecff0a4434596498432a83fe3e212ba1e36f0e99b4"

URI_x86_64_v2_rust-gix-utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-utils+default-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-utils+default-devel}"
SRC_URI[x86_64_v2_rust-gix-utils+default-devel.sha256sum] = "61acb5f55f5b52bfed8cd749dfc987dcfca64165c7bed43151a2ef2286ec25dd"

URI_x86_64_v2_rust-gix-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-utils-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-utils-devel}"
SRC_URI[x86_64_v2_rust-gix-utils-devel.sha256sum] = "6714f45de6ffee27c91cca050407c94419ab11779f5ac883bc3ec94aa170efd1"

URI_aarch64_rust-gix-utils+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-utils+bstr-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-utils+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-utils+bstr-devel}"
SRC_URI[aarch64_rust-gix-utils+bstr-devel.sha256sum] = "891692af0c14bb55d0e930f8a0f9e7141c377a2c6220dbd96f5bd6128f73aed8"

URI_aarch64_rust-gix-utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-utils+default-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-utils+default-devel}"
SRC_URI[aarch64_rust-gix-utils+default-devel.sha256sum] = "29e2a8f8769498ee3ecaeb6f47abf31669bfa205a6eafa6ca85a999808ab140d"

URI_aarch64_rust-gix-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-utils-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-utils-devel}"
SRC_URI[aarch64_rust-gix-utils-devel.sha256sum] = "7a6501940cd4b76444e1f66ecfdac4cd296be9fb5163f67800a62ca0c85092e6"

RDEPENDS:rust-gix-utils+bstr-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-utils-devel \
 "
RDEPENDS:rust-gix-utils+default-devel = " \
 cargo \
 rust-gix-utils-devel \
 "
RDEPENDS:rust-gix-utils-devel = " \
 cargo \
 rust \
 rust-fastrand+default-devel \
 rust-unicode-normalization-devel \
 "
