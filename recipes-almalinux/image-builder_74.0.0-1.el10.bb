# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "image-builder"
PV = "74.0.0"
PR = "1.el10"
PACKAGES = " \
 image-builder \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/image-builder-74.0.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a30a9a4ae8ed8061884ea75647ba33535c3f2a5873e75e9960accd33c79f249"

URI_x86_64_v2_image-builder = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/image-builder-74.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_image-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_image-builder}"
SRC_URI[x86_64_v2_image-builder.sha256sum] = "012842e3d264a5d19fb250ece0f563006df65f187338c3e32b8547e2e01ec3bc"

URI_aarch64_image-builder = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/image-builder-74.0.0-1.el10.aarch64.rpm;name=aarch64_image-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_image-builder}"
SRC_URI[aarch64_image-builder.sha256sum] = "c70fdc089244eae4d01057be082a6843afb45c71732bd3eff0f6a3c769311597"

RDEPENDS:image-builder = " \
 glibc \
 gpgme \
 libvirt-libs \
 libxcrypt \
 osbuild \
 osbuild-depsolve-dnf \
 osbuild-luks2 \
 osbuild-lvm2 \
 osbuild-ostree \
 "
