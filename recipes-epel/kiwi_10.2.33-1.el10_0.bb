# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi"
PV = "10.2.33"
PR = "1.el10_0"
PACKAGES:x86_64_v2 = " \
 dracut-kiwi-lib \
 dracut-kiwi-live \
 dracut-kiwi-oem-dump \
 dracut-kiwi-oem-repart \
 dracut-kiwi-overlay \
 dracut-kiwi-verity \
 kiwi-cli \
 kiwi-pxeboot \
 kiwi-systemdeps \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-image-validation \
 kiwi-systemdeps-iso-media \
 python3-kiwi \
"
PACKAGES:aarch64 = " \
 dracut-kiwi-lib \
 dracut-kiwi-live \
 dracut-kiwi-oem-dump \
 dracut-kiwi-oem-repart \
 dracut-kiwi-overlay \
 dracut-kiwi-verity \
 kiwi-cli \
 kiwi-systemdeps \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-image-validation \
 kiwi-systemdeps-iso-media \
 python3-kiwi \
"

URI_src = "${EPELSRC_MIRROR}/Packages/k/kiwi-10.2.33-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2282841e6ede9045ed865362206f633f82e2672e3eae897359a1e52f82ba3caa"

URI_x86_64_v2_dracut-kiwi-lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-lib-10.2.33-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-lib}"
SRC_URI[x86_64_v2_dracut-kiwi-lib.sha256sum] = "5776b01278d1661210ef36f43db53e9aee292bd2bdbe679bb64e83a42dd07c25"

URI_x86_64_v2_dracut-kiwi-live = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-live-10.2.33-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-live;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-live}"
SRC_URI[x86_64_v2_dracut-kiwi-live.sha256sum] = "bf430f966a482f1091849b95812d6b6619c81d18b58ed9bc884af72f42b75896"

URI_x86_64_v2_dracut-kiwi-oem-dump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-oem-dump-10.2.33-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-oem-dump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-oem-dump}"
SRC_URI[x86_64_v2_dracut-kiwi-oem-dump.sha256sum] = "86c318c89c0f5058ff9cd4badce44ff973443112dfbcef3da3181dd1d328c320"

URI_x86_64_v2_dracut-kiwi-oem-repart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-oem-repart-10.2.33-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-oem-repart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-oem-repart}"
SRC_URI[x86_64_v2_dracut-kiwi-oem-repart.sha256sum] = "8c5d70fc7f03724b7fcc13f54ab8c3468e5f1154ed66c9bd7fff75c62e765703"

URI_x86_64_v2_dracut-kiwi-overlay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-overlay-10.2.33-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-overlay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-overlay}"
SRC_URI[x86_64_v2_dracut-kiwi-overlay.sha256sum] = "191f47a7ce86b6987c17478aae20011e95f0b4ecd8a3376c37fcc62beecf816f"

URI_x86_64_v2_dracut-kiwi-verity = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-verity-10.2.33-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dracut-kiwi-verity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-verity}"
SRC_URI[x86_64_v2_dracut-kiwi-verity.sha256sum] = "ffc3e5af0c4ec0ee3e41eb4bce4a0d9cb7f818728bee55244cc3a8c9c7af26e2"

URI_x86_64_v2_kiwi-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-cli-10.2.33-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-cli}"
SRC_URI[x86_64_v2_kiwi-cli.sha256sum] = "bdb35b754dab322f6f8b48d9c21e21c04e06c863338270ac6302b07370804264"

URI_x86_64_v2_kiwi-pxeboot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-pxeboot-10.2.33-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-pxeboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-pxeboot}"
SRC_URI[x86_64_v2_kiwi-pxeboot.sha256sum] = "908325c91641da1187fd44e63a108baf01ccf3861d6cc906b7b56c2592a70101"

URI_x86_64_v2_kiwi-systemdeps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-10.2.33-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps}"
SRC_URI[x86_64_v2_kiwi-systemdeps.sha256sum] = "05e2022e67059f6b7baa418ce6959a6202cc5326ea779a817035e1bde0858ea8"

URI_x86_64_v2_kiwi-systemdeps-bootloaders = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-bootloaders-10.2.33-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-bootloaders;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-bootloaders}"
SRC_URI[x86_64_v2_kiwi-systemdeps-bootloaders.sha256sum] = "270fbbbb445180e1f2dd012578cbf119272b501963f0766b77121176dd757ca7"

URI_x86_64_v2_kiwi-systemdeps-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-containers-10.2.33-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-containers}"
SRC_URI[x86_64_v2_kiwi-systemdeps-containers.sha256sum] = "fb8188f28d40537c9363668917c989becc695f7db6d8be7ff436fe60dbbb2859"

URI_x86_64_v2_kiwi-systemdeps-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-core-10.2.33-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-core}"
SRC_URI[x86_64_v2_kiwi-systemdeps-core.sha256sum] = "cbaadedddea6673c361a8baa008f862f72609d82f202da027b1102961524c18c"

URI_x86_64_v2_kiwi-systemdeps-disk-images = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-disk-images-10.2.33-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-disk-images;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-disk-images}"
SRC_URI[x86_64_v2_kiwi-systemdeps-disk-images.sha256sum] = "3081197f697e05b63e40eca1e3d06816718b4724a319c6b049cc2e089170f71a"

URI_x86_64_v2_kiwi-systemdeps-filesystems = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-filesystems-10.2.33-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-filesystems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-filesystems}"
SRC_URI[x86_64_v2_kiwi-systemdeps-filesystems.sha256sum] = "700724801e9e3b0d25a81a8cfe2b00343d77f8504ae1ea6217d6f480c09d700a"

URI_x86_64_v2_kiwi-systemdeps-image-validation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-image-validation-10.2.33-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-image-validation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-image-validation}"
SRC_URI[x86_64_v2_kiwi-systemdeps-image-validation.sha256sum] = "1537078defff62e9bf77d9d12eafd028640de898a20e15fc1d7eb15de092a129"

URI_x86_64_v2_kiwi-systemdeps-iso-media = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-iso-media-10.2.33-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-iso-media;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-iso-media}"
SRC_URI[x86_64_v2_kiwi-systemdeps-iso-media.sha256sum] = "25e286b587651e7d69d1529ff7d6bbf85d2f8aa2c3e31d287964d71d8d0e65c0"

URI_x86_64_v2_python3-kiwi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-10.2.33-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kiwi}"
SRC_URI[x86_64_v2_python3-kiwi.sha256sum] = "880b9a8e723be3baa2ad0b1bdaefa12722d04add8fe7935d44230a488d64821a"

URI_aarch64_dracut-kiwi-lib = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-lib-10.2.33-1.el10_0.noarch.rpm;name=aarch64_dracut-kiwi-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-lib}"
SRC_URI[aarch64_dracut-kiwi-lib.sha256sum] = "0294076a493f8208249759a45c78b5417386794de182b2d7b9984e51c7937cc3"

URI_aarch64_dracut-kiwi-live = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-live-10.2.33-1.el10_0.noarch.rpm;name=aarch64_dracut-kiwi-live;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-live}"
SRC_URI[aarch64_dracut-kiwi-live.sha256sum] = "c0e49d3714bfccc2d8c67565c68ca57386f14b078de9a16702f89ed4d6be573f"

URI_aarch64_dracut-kiwi-oem-dump = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-oem-dump-10.2.33-1.el10_0.noarch.rpm;name=aarch64_dracut-kiwi-oem-dump;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-oem-dump}"
SRC_URI[aarch64_dracut-kiwi-oem-dump.sha256sum] = "38980c4ef702b2ed37d59427318e525ea806f4770b999e0594120c1f512071c9"

URI_aarch64_dracut-kiwi-oem-repart = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-oem-repart-10.2.33-1.el10_0.noarch.rpm;name=aarch64_dracut-kiwi-oem-repart;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-oem-repart}"
SRC_URI[aarch64_dracut-kiwi-oem-repart.sha256sum] = "bed7cfee96e795b17dc59f1b8799e1e917e17367644e82d16d35cd51309c05a1"

URI_aarch64_dracut-kiwi-overlay = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-overlay-10.2.33-1.el10_0.noarch.rpm;name=aarch64_dracut-kiwi-overlay;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-overlay}"
SRC_URI[aarch64_dracut-kiwi-overlay.sha256sum] = "64894e53e1d0d21e10fcc195f56d9c47b560e37e59878d864c6f6b3067bcdb85"

URI_aarch64_dracut-kiwi-verity = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-verity-10.2.33-1.el10_0.aarch64.rpm;name=aarch64_dracut-kiwi-verity;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-verity}"
SRC_URI[aarch64_dracut-kiwi-verity.sha256sum] = "66b1796a89f87b330218afff7dff34981e271c54dde75d2bcfa22ba0584082d2"

URI_aarch64_kiwi-cli = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-cli-10.2.33-1.el10_0.noarch.rpm;name=aarch64_kiwi-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-cli}"
SRC_URI[aarch64_kiwi-cli.sha256sum] = "ef9c933460b9daf5923cf2094adcb45641c3f9fe7ff7a32b99df5d6eb9d5194c"

URI_aarch64_kiwi-systemdeps = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-10.2.33-1.el10_0.aarch64.rpm;name=aarch64_kiwi-systemdeps;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps}"
SRC_URI[aarch64_kiwi-systemdeps.sha256sum] = "27aadafcd0c87d448a67a409d3f155d76326cc7c43eaae80dc84edfaba771bfd"

URI_aarch64_kiwi-systemdeps-bootloaders = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-bootloaders-10.2.33-1.el10_0.aarch64.rpm;name=aarch64_kiwi-systemdeps-bootloaders;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-bootloaders}"
SRC_URI[aarch64_kiwi-systemdeps-bootloaders.sha256sum] = "893e6b24744ca502a1816f5b7837b11f38382f0019b983d939b7b8da7e84deef"

URI_aarch64_kiwi-systemdeps-containers = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-containers-10.2.33-1.el10_0.aarch64.rpm;name=aarch64_kiwi-systemdeps-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-containers}"
SRC_URI[aarch64_kiwi-systemdeps-containers.sha256sum] = "ef55bdf80f3484590d1915d008f6f7a6a0e14558455d69cfcf071d593c318eed"

URI_aarch64_kiwi-systemdeps-core = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-core-10.2.33-1.el10_0.aarch64.rpm;name=aarch64_kiwi-systemdeps-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-core}"
SRC_URI[aarch64_kiwi-systemdeps-core.sha256sum] = "c4cc4749f7a44e51118ddc376758b31e570bb933e963c1d686c86c2d32e32987"

URI_aarch64_kiwi-systemdeps-disk-images = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-disk-images-10.2.33-1.el10_0.aarch64.rpm;name=aarch64_kiwi-systemdeps-disk-images;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-disk-images}"
SRC_URI[aarch64_kiwi-systemdeps-disk-images.sha256sum] = "540d6a3e7b89129f750d0abeeea21537baf9162d532987c6a9b43421b62a7235"

URI_aarch64_kiwi-systemdeps-filesystems = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-filesystems-10.2.33-1.el10_0.aarch64.rpm;name=aarch64_kiwi-systemdeps-filesystems;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-filesystems}"
SRC_URI[aarch64_kiwi-systemdeps-filesystems.sha256sum] = "5da9896c94d1483a104b191d362412a601d96f21bca52d5f9531ae245579b57b"

URI_aarch64_kiwi-systemdeps-image-validation = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-image-validation-10.2.33-1.el10_0.aarch64.rpm;name=aarch64_kiwi-systemdeps-image-validation;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-image-validation}"
SRC_URI[aarch64_kiwi-systemdeps-image-validation.sha256sum] = "e5b66d9af89c78c9661a94e5e78037ed778942da592ca03952b7ade4dde327ac"

URI_aarch64_kiwi-systemdeps-iso-media = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-iso-media-10.2.33-1.el10_0.aarch64.rpm;name=aarch64_kiwi-systemdeps-iso-media;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-iso-media}"
SRC_URI[aarch64_kiwi-systemdeps-iso-media.sha256sum] = "492ea3249f2f7776adc380c0c8ad0113a61a7cb997800c20cd2b80e5655a581d"

URI_aarch64_python3-kiwi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-10.2.33-1.el10_0.noarch.rpm;name=aarch64_python3-kiwi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kiwi}"
SRC_URI[aarch64_python3-kiwi.sha256sum] = "4837ab904100b64f9e501511ea602f432da970eaef869f7d9082922044eb459b"

RDEPENDS:dracut-kiwi-lib = " \
 bash \
 bc \
 cryptsetup \
 curl \
 device-mapper \
 dialog \
 dracut \
 e2fsprogs \
 gdisk \
 grep \
 kpartx \
 lvm2 \
 mdadm \
 parted \
 pv \
 util-linux \
 virtual/coreutils \
 xfsprogs \
 xz \
 "
RDEPENDS:dracut-kiwi-live = " \
 bash \
 device-mapper \
 dialog \
 dracut \
 dracut-kiwi-lib \
 dracut-network \
 e2fsprogs \
 parted \
 util-linux \
 xfsprogs \
 "
RDEPENDS:dracut-kiwi-oem-dump = " \
 bash \
 dracut-kiwi-lib \
 gawk \
 kexec-tools \
 "
RDEPENDS:dracut-kiwi-oem-repart = " \
 bash \
 dracut-kiwi-lib \
 "
RDEPENDS:dracut-kiwi-overlay = " \
 bash \
 dracut \
 dracut-kiwi-lib \
 util-linux \
 "
RDEPENDS:dracut-kiwi-verity = " \
 bash \
 dracut \
 dracut-kiwi-lib \
 glibc \
 "
RDEPENDS:kiwi-cli = " \
 bash \
 bash-completion \
 python3-kiwi \
 "
RDEPENDS:kiwi-pxeboot = " \
 syslinux \
 tftp-server \
 "
RDEPENDS:kiwi-systemdeps = " \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-iso-media \
 "
RDEPENDS:kiwi-systemdeps-bootloaders:x86_64_v2 = " \
 grub2-efi-x64 \
 grub2-efi-x64-modules \
 grub2-pc \
 grub2-pc-modules \
 grub2-tools \
 grub2-tools-efi \
 grub2-tools-extra \
 grub2-tools-minimal \
 kiwi-systemdeps-core \
"
RDEPENDS:kiwi-systemdeps-bootloaders:aarch64 = " \
 grub2-efi-aa64-modules \
 grub2-tools \
 grub2-tools-extra \
 grub2-tools-minimal \
 kiwi-systemdeps-core \
"
RDEPENDS:kiwi-systemdeps-containers = " \
 appx-util \
 buildah \
 skopeo \
 "
RDEPENDS:kiwi-systemdeps-core = " \
 dnf \
 file \
 lsof \
 microdnf \
 mtools \
 openssl \
 rsync \
 screen \
 sed \
 tar \
 xz \
 "
RDEPENDS:kiwi-systemdeps-disk-images = " \
 cryptsetup \
 gdisk \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-iso-media \
 kpartx \
 lvm2 \
 mdadm \
 parted \
 util-linux \
 "
RDEPENDS:kiwi-systemdeps-filesystems = " \
 dosfstools \
 e2fsprogs \
 erofs-utils \
 kiwi-systemdeps-core \
 qemu-img \
 squashfs-tools \
 xfsprogs \
 "
RDEPENDS:kiwi-systemdeps-image-validation = " \
 python3-solv \
 "
RDEPENDS:kiwi-systemdeps-iso-media:x86_64_v2 = " \
 grub2-efi-x64-cdboot \
 isomd5sum \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-core \
 kiwi-systemdeps-filesystems \
 syslinux \
 syslinux-nonlinux \
 xorriso \
"
RDEPENDS:kiwi-systemdeps-iso-media:aarch64 = " \
 grub2-efi-aa64-cdboot \
 isomd5sum \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-core \
 kiwi-systemdeps-filesystems \
 xorriso \
"
RDEPENDS:python3-kiwi = " \
 kiwi-systemdeps-core \
 python3 \
 python3-docopt-ng \
 python3-lxml \
 python3-pyyaml \
 python3-requests \
 python3-simplejson \
 "
