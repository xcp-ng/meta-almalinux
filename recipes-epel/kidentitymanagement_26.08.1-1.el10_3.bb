# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kidentitymanagement"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kidentitymanagement \
 kidentitymanagement-devel \
 kidentitymanagement-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kidentitymanagement-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ebc3073d7c83dfb6fd4309baf90f8b59fbc7f25cbe030127944cf96b440cb4b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kidentitymanagement-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kidentitymanagement;unpack=0"
SRC_URI[x86_64_v2_kidentitymanagement.sha256sum] = "c2898e2960f49739a9c03e880125546140ead70b043add706903e3717e5addb7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kidentitymanagement-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kidentitymanagement-devel;unpack=0"
SRC_URI[x86_64_v2_kidentitymanagement-devel.sha256sum] = "013a87bdb31cfe563360a49c8fb316ee1047114631accebbe0d8dc2122082e10"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kidentitymanagement-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kidentitymanagement-doc;unpack=0"
SRC_URI[x86_64_v2_kidentitymanagement-doc.sha256sum] = "27be68523dc0f8333d590ce17f523674763d9458e2bb88170dc7c3e1975eb576"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kidentitymanagement-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kidentitymanagement;unpack=0"
SRC_URI[aarch64_kidentitymanagement.sha256sum] = "4c8fab31e8f2038b57e9ebcbf2af4dc5757e0c100b2c3f68d7294188cd3670f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kidentitymanagement-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kidentitymanagement-devel;unpack=0"
SRC_URI[aarch64_kidentitymanagement-devel.sha256sum] = "015833979360b40b2a2dc3f01224abd07bd9ccdc229296d7e100871ccaaf55eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kidentitymanagement-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kidentitymanagement-doc;unpack=0"
SRC_URI[aarch64_kidentitymanagement-doc.sha256sum] = "1fb3f5da0aad5699e273457de9762eb5fe8c2a0428758de7684335b054faeca2"

RDEPENDS:kidentitymanagement = " \
 glibc \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kpimtextedit \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kidentitymanagement-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kidentitymanagement \
 kpimtextedit-devel \
 "
RDEPENDS:kidentitymanagement-doc = " \
 "
