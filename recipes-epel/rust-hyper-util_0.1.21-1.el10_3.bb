# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hyper-util"
PV = "0.1.21"
PR = "1.el10_3"
PACKAGES = " \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+client-pool-devel \
 rust-hyper-util+client-proxy-devel \
 rust-hyper-util+client-proxy-system-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+full-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+rt-tracing-exec-force-devel \
 rust-hyper-util+server-auto-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+server-graceful-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util+tracing-devel \
 rust-hyper-util-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-hyper-util-0.1.21-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "517dddb8193ecf59e897f81598174725c88a7a83c5126989edf24a45706b179a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+client-devel.sha256sum] = "5bef84010feb4cfa228d3339a5b1668e7073c4f0c45d13d01b09827f9c107202"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-legacy-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-legacy-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+client-legacy-devel.sha256sum] = "b703d427b4cb3982d0ac9b04a3e25ef62dace4db6e2f72977d12b09dbd1c6263"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-pool-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-pool-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+client-pool-devel.sha256sum] = "7dd846e322391043469ec42b3bfb6ec4b6fa9d0618420592ca286e5d1bf4d44a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-proxy-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-proxy-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+client-proxy-devel.sha256sum] = "3ede28d71d9841a4f9108a0fed838eef2068fe1137451f5bf98edf54af37f19b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-proxy-system-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-proxy-system-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+client-proxy-system-devel.sha256sum] = "6704a4fdaf8f31ce5a1de92ef750ee0efa374d41f3309663d5092a9589fb7a8c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+default-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+default-devel.sha256sum] = "c0255b21e96377c60ebe95336fa731aea62a29e5dba626697b7422446fa8ad35"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+full-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+full-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+full-devel.sha256sum] = "797095a985aac90b631b770bb3897005c72f42a329cdaaa73bf782a4b44d596f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+http1-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+http1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+http1-devel.sha256sum] = "59e4937a5701df6b47e51adb44b0a2a48e2b368cde278c2d7855c906d31d0f51"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+http2-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+http2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+http2-devel.sha256sum] = "ec66f48b9be33f89fc8473af4fe2af1620b796f02ce29ce59124d556e7b8b2b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+rt-tracing-exec-force-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+rt-tracing-exec-force-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+rt-tracing-exec-force-devel.sha256sum] = "1ca2b32e0eb05b8dcdf8cc043daa12c5e0829bafd6e353c9b588a7fe85702900"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+server-auto-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+server-auto-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+server-auto-devel.sha256sum] = "0c18c4943365544fbb9687fed18f72baf9a7f945d7e682c2157093872ae98b40"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+server-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+server-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+server-devel.sha256sum] = "42d9bf7a47bad9522f15815479c1e19165b1135c601ffbf9e16ce5735f278985"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+server-graceful-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+server-graceful-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+server-graceful-devel.sha256sum] = "1a89ac2ac379dd36906d453e03d51f0c969a83fa5207b63723db3ffca10a6448"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+service-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+service-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+service-devel.sha256sum] = "eec55e117462238d7b88c3c34939461f8300aef8f41d41b8e28324d1bbc07fcf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+tokio-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+tokio-devel.sha256sum] = "62fa883f496b3664540ceea7c852fff8c1b59eb7d36e74bf063967741d758368"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+tracing-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+tracing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util+tracing-devel.sha256sum] = "d5f5e9cd7715c6204925e3ce99d36db536d5648bf940fbce8818ffc004ce4590"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-util-devel.sha256sum] = "879c7f3382d0b700cb6b4b094c2cf5d98f85cb6ae0cc2036fdcaf470eb7e466d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+client-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+client-devel.sha256sum] = "955900933a2fa39ff221b8e58a8d2fc6cc04597697d7a7158a39d150eba8ab16"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-legacy-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+client-legacy-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+client-legacy-devel.sha256sum] = "eecf4f49b1a65a5b0474ddfafad3f6286be6cc4d3c59b403e24d2316422f2154"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-pool-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+client-pool-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+client-pool-devel.sha256sum] = "511d584f2493ac0204827da8ef89e74330260d3d3d6dcc71efcbd7473d941080"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-proxy-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+client-proxy-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+client-proxy-devel.sha256sum] = "6eef07b34d886c2fb577c135f71a31a28de86ccb9c2e9780ca8bdf66ca08286a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-proxy-system-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+client-proxy-system-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+client-proxy-system-devel.sha256sum] = "ff7614a5d67edbc8d8786fd2736dd9ca8ceb275fde5ba352b57b0d1c220af9bb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+default-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+default-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+default-devel.sha256sum] = "3f0c4dcde97e6e35b9812c847f6bd93410f1abc0e7e57d9d84e68aad32a5a514"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+full-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+full-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+full-devel.sha256sum] = "dd27eafd2612a58a789c8a63a2892e3c1fff2edd382213dca7354e30cb1e2c6a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+http1-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+http1-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+http1-devel.sha256sum] = "b2b136948f740316e502f248cfab9361e485e71c32aab73db773e7bdb7569c21"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+http2-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+http2-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+http2-devel.sha256sum] = "cd4d1093ce23f8634ec4f40fedd47091aa43f4f9ef84db6580a32650d8d344aa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+rt-tracing-exec-force-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+rt-tracing-exec-force-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+rt-tracing-exec-force-devel.sha256sum] = "de76d72d101a7acaf21acc2a05765dd5bc8335a08f5be1e367f49c0bf22d5a68"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+server-auto-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+server-auto-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+server-auto-devel.sha256sum] = "936be83b16d79d097a4b44befa3ae400b0092a27ebb3253a31769ba4749349be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+server-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+server-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+server-devel.sha256sum] = "729d8d873b23402b603b7bb60efead9c849225a2c8242c3ff4cd1b3d4f4b275f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+server-graceful-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+server-graceful-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+server-graceful-devel.sha256sum] = "cf603c0b03e6c3c087f107bfb0653fc881a916e8372467902d87febcf38ee060"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+service-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+service-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+service-devel.sha256sum] = "709539ae13be9e7fdce1bbb6a127f96d4ea66cd1944b150e783d028b6e3f1933"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+tokio-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+tokio-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+tokio-devel.sha256sum] = "bc35989d1137e678de67c1689bf36de5f3e1bac8acf63f1eb2a34c225ce3cc31"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+tracing-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+tracing-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util+tracing-devel.sha256sum] = "99a065ec382cf026203bb87449201d4a27f3702f162694a76b9d756bf6721bc8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-util-devel.sha256sum] = "ed67d1471dfe774cd4e3b8f6ac25c2f66af9a5ddc000b0acc737c55cffae03f5"

RDEPENDS:rust-hyper-util+client-devel = " \
 cargo \
 rust-futures-channel+default-devel \
 rust-hyper+client-devel \
 rust-hyper-util-devel \
 rust-tower-service+default-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-hyper-util+client-legacy-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-httparse+default-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util-devel \
 rust-libc+default-devel \
 rust-socket2+all-devel \
 rust-socket2+default-devel \
 rust-tokio+net-devel \
 rust-tokio+sync-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-hyper-util+client-pool-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util-devel \
 rust-tokio+sync-devel \
 rust-tokio-devel \
 rust-tower-layer+default-devel \
 "
RDEPENDS:rust-hyper-util+client-proxy-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util-devel \
 rust-ipnet+default-devel \
 rust-percent-encoding+default-devel \
 "
RDEPENDS:rust-hyper-util+client-proxy-system-devel = " \
 cargo \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+default-devel = " \
 cargo \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+full-devel = " \
 cargo \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+client-pool-devel \
 rust-hyper-util+client-proxy-devel \
 rust-hyper-util+client-proxy-system-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-auto-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+server-graceful-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util+tracing-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+http1-devel = " \
 cargo \
 rust-hyper+http1-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+http2-devel = " \
 cargo \
 rust-hyper+http2-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+rt-tracing-exec-force-devel = " \
 cargo \
 rust-hyper-util+tokio-devel \
 rust-hyper-util+tracing-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+server-auto-devel = " \
 cargo \
 rust-hyper-util+http1-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+server-devel = " \
 cargo \
 rust-hyper+server-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+server-graceful-devel = " \
 cargo \
 rust-hyper-util+server-devel \
 rust-hyper-util-devel \
 rust-tokio+sync-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-hyper-util+service-devel = " \
 cargo \
 rust-hyper-util-devel \
 rust-tower-service+default-devel \
 "
RDEPENDS:rust-hyper-util+tokio-devel = " \
 cargo \
 rust-hyper-util-devel \
 rust-tokio+rt-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-hyper-util+tracing-devel = " \
 cargo \
 rust-hyper-util-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-hyper-util-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-hyper+default-devel \
 rust-pin-project-lite+default-devel \
 "
