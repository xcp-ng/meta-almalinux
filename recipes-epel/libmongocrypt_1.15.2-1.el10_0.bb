# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmongocrypt"
PV = "1.15.2"
PR = "1.el10_0"
PACKAGES = " \
 libmongocrypt \
 libmongocrypt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmongocrypt-1.15.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef072cc526fc9319a1d591c46467b91e38e68be21a4f0e6040e3a939adc612c5"

URI_x86_64_v2_libmongocrypt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmongocrypt-1.15.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmongocrypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmongocrypt}"
SRC_URI[x86_64_v2_libmongocrypt.sha256sum] = "464e874c25dade57150a4a051b5aad6ddd6f588d910e87870b164e368c722623"

URI_x86_64_v2_libmongocrypt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmongocrypt-devel-1.15.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmongocrypt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmongocrypt-devel}"
SRC_URI[x86_64_v2_libmongocrypt-devel.sha256sum] = "95d5dfb4989f788ac89513e144649a3885b52f5cac739184f89a8dc8ca4ce130"

URI_aarch64_libmongocrypt = "${EPEL_MIRROR}/aarch64/Packages/l/libmongocrypt-1.15.2-1.el10_0.aarch64.rpm;name=aarch64_libmongocrypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmongocrypt}"
SRC_URI[aarch64_libmongocrypt.sha256sum] = "b3b93679f07a6e67cea6439a8d08487417585adb322b80b4518787a468dc9926"

URI_aarch64_libmongocrypt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmongocrypt-devel-1.15.2-1.el10_0.aarch64.rpm;name=aarch64_libmongocrypt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmongocrypt-devel}"
SRC_URI[aarch64_libmongocrypt-devel.sha256sum] = "f4f5ecc4a4c1b9a81964130f8d54a3ed43308dde2203343f8599b7d61ff1db01"

RDEPENDS:libmongocrypt = " \
 glibc \
 libbson \
 openssl-libs \
 "
RDEPENDS:libmongocrypt-devel = " \
 cmake-filesystem \
 libbson-devel \
 libmongocrypt \
 pkgconf-pkg-config \
 "
