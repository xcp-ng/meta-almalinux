# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lddtree"
PV = "0.5.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-lddtree+default-devel \
 rust-lddtree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lddtree-0.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff998ca9e0c7a7b59924cfc1ab20bdbb5f67b6b88886bd25ba2d260f3547770c"

URI_x86_64_v2_rust-lddtree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lddtree+default-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lddtree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lddtree+default-devel}"
SRC_URI[x86_64_v2_rust-lddtree+default-devel.sha256sum] = "14110d39d7ddce6c7e52bed1aac33df2b084a87b40d7a8b931b665ba3eda0115"

URI_x86_64_v2_rust-lddtree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lddtree-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lddtree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lddtree-devel}"
SRC_URI[x86_64_v2_rust-lddtree-devel.sha256sum] = "e57cbdc87a8ff16b18ba999ed39f56f0f5bf602baa464ec9b7cbb82c95ec5af8"

URI_aarch64_rust-lddtree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lddtree+default-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-lddtree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lddtree+default-devel}"
SRC_URI[aarch64_rust-lddtree+default-devel.sha256sum] = "965e1b16ff17623c1c1abd635943d36c80d1273c52820fc0b19a9b2a2fa5c17b"

URI_aarch64_rust-lddtree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lddtree-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-lddtree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lddtree-devel}"
SRC_URI[aarch64_rust-lddtree-devel.sha256sum] = "3f832883abf68ad70c1e7d4880c309bd392f7206c6e2f01662d0c28e2103f7ea"

RDEPENDS:rust-lddtree+default-devel = " \
 cargo \
 rust-lddtree-devel \
 "
RDEPENDS:rust-lddtree-devel = " \
 cargo \
 rust \
 rust-fs-err+default-devel \
 rust-glob+default-devel \
 rust-goblin+default-devel \
 rust-memmap2+default-devel \
 "
