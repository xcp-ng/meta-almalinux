# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_builder"
PV = "4.6.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-clap_builder+cargo-devel \
 rust-clap_builder+color-devel \
 rust-clap_builder+debug-devel \
 rust-clap_builder+default-devel \
 rust-clap_builder+deprecated-devel \
 rust-clap_builder+env-devel \
 rust-clap_builder+error-context-devel \
 rust-clap_builder+help-devel \
 rust-clap_builder+std-devel \
 rust-clap_builder+string-devel \
 rust-clap_builder+suggestions-devel \
 rust-clap_builder+unicode-devel \
 rust-clap_builder+unstable-doc-devel \
 rust-clap_builder+unstable-ext-devel \
 rust-clap_builder+unstable-styles-devel \
 rust-clap_builder+unstable-v5-devel \
 rust-clap_builder+usage-devel \
 rust-clap_builder+wrap_help-devel \
 rust-clap_builder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_builder-4.6.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a67d77da7464bf0546fa07e4f06c1a7006b5fd621522fdd450eb4d97bb91b4b6"

URI_x86_64_v2_rust-clap_builder+cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+cargo-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+cargo-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+cargo-devel.sha256sum] = "6ea85fd6e99846bb685cdbac58c2806c8ecddbdde8299a261f7b2cb15e8a84d0"

URI_x86_64_v2_rust-clap_builder+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+color-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+color-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+color-devel.sha256sum] = "c92f6e67b2b6946560ce95e8e2456b3f7b16808610e39c3979987b6ed5c9f8c2"

URI_x86_64_v2_rust-clap_builder+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+debug-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+debug-devel.sha256sum] = "7061f0c3d8182f40a38f65bb7f40b594d87355be72ce8d9dbdd0e4cca3fcbaf6"

URI_x86_64_v2_rust-clap_builder+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+default-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+default-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+default-devel.sha256sum] = "7a0d462e76d7b03be4dbcf32814b1cab4905b41ecdebc3580e357c21a929ee82"

URI_x86_64_v2_rust-clap_builder+deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+deprecated-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+deprecated-devel.sha256sum] = "a6c3ac275300e1b7292de5043d5ad802d664643fcd7133801d176fd407cc035a"

URI_x86_64_v2_rust-clap_builder+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+env-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+env-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+env-devel.sha256sum] = "7142c2ed73c0f4bd0cc71050fb0c54b14b0c607db6f071108223e7ce7216d2a8"

URI_x86_64_v2_rust-clap_builder+error-context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+error-context-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+error-context-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+error-context-devel.sha256sum] = "e2567f0e792ebd6f60833438d2b166050b13a64b1b7b1dfc087d651b92475e49"

URI_x86_64_v2_rust-clap_builder+help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+help-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+help-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+help-devel.sha256sum] = "28dcf10c07fc0d5df852cdb53188d0534459373708bcabd9343c190bd1e46f4e"

URI_x86_64_v2_rust-clap_builder+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+std-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+std-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+std-devel.sha256sum] = "7f506cbb73bb2b4d1bdd1d2fcc30f76b051a080faad6d6404c711e9e81299aaf"

URI_x86_64_v2_rust-clap_builder+string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+string-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+string-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+string-devel.sha256sum] = "7e501dabbac92d47732f087a93880f859f028e860a06d639d9ff4bf905fbab02"

URI_x86_64_v2_rust-clap_builder+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+suggestions-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+suggestions-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+suggestions-devel.sha256sum] = "c925e75c7803ab9667a3c412dddb905a2c7696994249912759631579c97adee4"

URI_x86_64_v2_rust-clap_builder+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unicode-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unicode-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unicode-devel.sha256sum] = "dc791b3e492d7292d37b1bc7900e3841331e9bd21b87742fe3b9063eff01b9eb"

URI_x86_64_v2_rust-clap_builder+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-doc-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-doc-devel.sha256sum] = "9835c01486f7f09d2b9981b2fea6217e282b0e54ba55281ef25837fb4272b0be"

URI_x86_64_v2_rust-clap_builder+unstable-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-ext-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-ext-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-ext-devel.sha256sum] = "f09bb2727b3b5dcc44b34550a8a85523826306fbc81851a31a44984cea4c80a6"

URI_x86_64_v2_rust-clap_builder+unstable-styles-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-styles-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-styles-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-styles-devel.sha256sum] = "c47a739b10a3a5602e34c12919d4ec0748b6302601ecd9bce44e3e5bb8a443fe"

URI_x86_64_v2_rust-clap_builder+unstable-v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-v5-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-v5-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-v5-devel.sha256sum] = "11afd7e55de905f0a805eee11c4b965a43611584d772e229c6b04d7f975a1dd4"

URI_x86_64_v2_rust-clap_builder+usage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+usage-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+usage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+usage-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+usage-devel.sha256sum] = "3f866bc75247fb367e9b4539e18a743b2f442a36ff937293c178322db148518f"

URI_x86_64_v2_rust-clap_builder+wrap_help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+wrap_help-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+wrap_help-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+wrap_help-devel.sha256sum] = "a77fb5dc4088aa9f06968273c4827f7bd904f8a718b10b00d5a828e59bdda99a"

URI_x86_64_v2_rust-clap_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder-devel-4.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder-devel}"
SRC_URI[x86_64_v2_rust-clap_builder-devel.sha256sum] = "3ba33acaa7eedaa76b1e9c717d3f04319192097373efdfff549a961211fb2b80"

URI_aarch64_rust-clap_builder+cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+cargo-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+cargo-devel}"
SRC_URI[aarch64_rust-clap_builder+cargo-devel.sha256sum] = "5f9ff4a2a715796a2ac4b926b16e7f79a314b175113241eaa34573155e99ce20"

URI_aarch64_rust-clap_builder+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+color-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+color-devel}"
SRC_URI[aarch64_rust-clap_builder+color-devel.sha256sum] = "6b37ec52ba5d88ded29ea4f0952a076ad65ba6d4ab9a57e08ed89c530ea879f6"

URI_aarch64_rust-clap_builder+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+debug-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+debug-devel}"
SRC_URI[aarch64_rust-clap_builder+debug-devel.sha256sum] = "5b9bbebc13425a8e78c38479b78d37a2002d94923238b33b85b81c61e6f9fce7"

URI_aarch64_rust-clap_builder+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+default-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+default-devel}"
SRC_URI[aarch64_rust-clap_builder+default-devel.sha256sum] = "f0d777bad364fa1337180dcca47d1addcc056c6f66ec6bd224e449acc53e4851"

URI_aarch64_rust-clap_builder+deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+deprecated-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+deprecated-devel}"
SRC_URI[aarch64_rust-clap_builder+deprecated-devel.sha256sum] = "9595ed77e30b1910072867c1549cad7db1429f8ef289ea146d777dc1e323e841"

URI_aarch64_rust-clap_builder+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+env-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+env-devel}"
SRC_URI[aarch64_rust-clap_builder+env-devel.sha256sum] = "518053eb60540da1a8e1af1dd9cd2c9869fa859d3822053a37df0f81cbaaeae6"

URI_aarch64_rust-clap_builder+error-context-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+error-context-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+error-context-devel}"
SRC_URI[aarch64_rust-clap_builder+error-context-devel.sha256sum] = "ac86648520b98c2744870dea99e6b303769b52bc1f156b654c9cbffe24be7d7b"

URI_aarch64_rust-clap_builder+help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+help-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+help-devel}"
SRC_URI[aarch64_rust-clap_builder+help-devel.sha256sum] = "e8353b57b6e941976c2309a60ff20c46add14b309e0166826b74d67844205c1d"

URI_aarch64_rust-clap_builder+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+std-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+std-devel}"
SRC_URI[aarch64_rust-clap_builder+std-devel.sha256sum] = "f54321f1231e52884cb710624f52a24fd11fbcb1cce6604e206c3d27409ba493"

URI_aarch64_rust-clap_builder+string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+string-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+string-devel}"
SRC_URI[aarch64_rust-clap_builder+string-devel.sha256sum] = "dc19d12bba96d768c3b4c88c37efb0dc8d7775a3a1084368e1df9c3d9e9dc282"

URI_aarch64_rust-clap_builder+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+suggestions-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+suggestions-devel}"
SRC_URI[aarch64_rust-clap_builder+suggestions-devel.sha256sum] = "4b25efde8f49144bd4f0f43eccb56c1abe32481187c438cffb646b65ed903b33"

URI_aarch64_rust-clap_builder+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unicode-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unicode-devel}"
SRC_URI[aarch64_rust-clap_builder+unicode-devel.sha256sum] = "863ea5e671b928c6de404f664c74622d7c7171b33e71dbc29f0f002f4bf56420"

URI_aarch64_rust-clap_builder+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-doc-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-doc-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-doc-devel.sha256sum] = "7ffa99a5b238687c61553b7815a008db45d07094bf1bd626bb5fa15f9f2e6666"

URI_aarch64_rust-clap_builder+unstable-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-ext-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-ext-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-ext-devel.sha256sum] = "51911dd58b725c77cd1b9d5ca5ccb82f2f08cd9293f41fd2f1ab69378788d85a"

URI_aarch64_rust-clap_builder+unstable-styles-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-styles-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-styles-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-styles-devel.sha256sum] = "d4371a1e650e03a239eb13035856dd6ed5861fb937deed29ea6ce97432cee45f"

URI_aarch64_rust-clap_builder+unstable-v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-v5-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-v5-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-v5-devel.sha256sum] = "31da50ffe848a6eac76c154f591b25b2b30065b2633f26432d9130c133afa4c0"

URI_aarch64_rust-clap_builder+usage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+usage-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+usage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+usage-devel}"
SRC_URI[aarch64_rust-clap_builder+usage-devel.sha256sum] = "abae1e9c1ab788d1ec561da47d8ee94ff813ca5a5867c493bb33f0c963634e04"

URI_aarch64_rust-clap_builder+wrap_help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+wrap_help-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+wrap_help-devel}"
SRC_URI[aarch64_rust-clap_builder+wrap_help-devel.sha256sum] = "a26182e790b05c0d134b9abc2e47ba0737a3843af9af2ea361a9fa57491f2fc8"

URI_aarch64_rust-clap_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder-devel-4.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder-devel}"
SRC_URI[aarch64_rust-clap_builder-devel.sha256sum] = "c7d5780d3ba369d84e35276b74fd493c81a62027bd585d5ff516a07dfdf3994a"

RDEPENDS:rust-clap_builder+cargo-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+debug-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+default-devel = " \
 cargo \
 rust-clap_builder+color-devel \
 rust-clap_builder+error-context-devel \
 rust-clap_builder+help-devel \
 rust-clap_builder+std-devel \
 rust-clap_builder+suggestions-devel \
 rust-clap_builder+usage-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+deprecated-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+env-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+error-context-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+help-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+std-devel = " \
 cargo \
 rust-anstyle+std-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+string-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+suggestions-devel = " \
 cargo \
 rust-clap_builder+error-context-devel \
 rust-clap_builder-devel \
 rust-strsim+default-devel \
 "
RDEPENDS:rust-clap_builder+unicode-devel = " \
 cargo \
 rust-clap_builder-devel \
 rust-unicase+default-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-clap_builder+unstable-doc-devel = " \
 cargo \
 rust-clap_builder+cargo-devel \
 rust-clap_builder+env-devel \
 rust-clap_builder+string-devel \
 rust-clap_builder+unicode-devel \
 rust-clap_builder+unstable-ext-devel \
 rust-clap_builder+wrap_help-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+unstable-ext-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+unstable-styles-devel = " \
 cargo \
 rust-clap_builder+color-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+unstable-v5-devel = " \
 cargo \
 rust-clap_builder+deprecated-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+usage-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+wrap_help-devel = " \
 cargo \
 rust-clap_builder+help-devel \
 rust-clap_builder-devel \
 rust-terminal_size+default-devel \
 "
RDEPENDS:rust-clap_builder-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-clap_lex+default-devel \
 "
