# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtwebchannel"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtwebchannel \
 qt6-qtwebchannel-devel \
 qt6-qtwebchannel-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtwebchannel-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e24696c4c2ac010d11af314d0cab398896469a3cce20414c3126eb7cf129aee0"

URI_x86_64_v2_qt6-qtwebchannel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwebchannel-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebchannel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebchannel}"
SRC_URI[x86_64_v2_qt6-qtwebchannel.sha256sum] = "eb9ae4d42ce36e1df389e5783f4fbcebc2d791ee7d9a38433496f3725f5c32ad"

URI_x86_64_v2_qt6-qtwebchannel-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwebchannel-devel-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebchannel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebchannel-devel}"
SRC_URI[x86_64_v2_qt6-qtwebchannel-devel.sha256sum] = "12891af67b54ccb0267c620ade836fe0def2fb9f6d8e364acc6dcae81cf7dd06"

URI_x86_64_v2_qt6-qtwebchannel-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtwebchannel-examples-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebchannel-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebchannel-examples}"
SRC_URI[x86_64_v2_qt6-qtwebchannel-examples.sha256sum] = "e30b27fb18500e4240257d5a8195fa4a501cd9093ca5ffaf0a48fcf991d3eb94"

URI_aarch64_qt6-qtwebchannel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwebchannel-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtwebchannel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebchannel}"
SRC_URI[aarch64_qt6-qtwebchannel.sha256sum] = "61a1cf99819c06a7227a24d900653bdbc83ecfe487366276a0ed02f785c139bd"

URI_aarch64_qt6-qtwebchannel-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwebchannel-devel-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtwebchannel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebchannel-devel}"
SRC_URI[aarch64_qt6-qtwebchannel-devel.sha256sum] = "b3815f08386aed66aa378302b5426c790e1c0c95f432ba99b3f3d5b86d8eaa86"

URI_aarch64_qt6-qtwebchannel-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtwebchannel-examples-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtwebchannel-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebchannel-examples}"
SRC_URI[aarch64_qt6-qtwebchannel-examples.sha256sum] = "16cf4b19318ed32ee93c15af31d6540bc4321b6b6dab522b256761c136426cb0"

RDEPENDS:qt6-qtwebchannel = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtwebchannel-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtwebchannel \
 "
RDEPENDS:qt6-qtwebchannel-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtwebchannel \
 qt6-qtwebsockets \
 "
