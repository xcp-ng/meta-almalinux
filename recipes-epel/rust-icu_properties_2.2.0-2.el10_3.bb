# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_properties"
PV = "2.2.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-icu_properties+alloc-devel \
 rust-icu_properties+compiled_data-devel \
 rust-icu_properties+datagen-devel \
 rust-icu_properties+default-devel \
 rust-icu_properties+harfbuzz_traits-devel \
 rust-icu_properties+serde-devel \
 rust-icu_properties+unicode_bidi-devel \
 rust-icu_properties-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_properties-2.2.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68dafa3b2bfa0c83cd770c9bce03b8fe12acb70b63faf2b7663044078d0e039e"

URI_x86_64_v2_rust-icu_properties+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+alloc-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+alloc-devel.sha256sum] = "ab7f121cfea139432283e44155be596c90f6afae481e813507ced6eb552c0e89"

URI_x86_64_v2_rust-icu_properties+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+compiled_data-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+compiled_data-devel.sha256sum] = "3d4688b3df24e5196d516d4196782ea6917b537b9a1ed844724a3f773ef6dd19"

URI_x86_64_v2_rust-icu_properties+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+datagen-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+datagen-devel.sha256sum] = "01f5f02bad933e17a3dd3e522db536777f0685120dae2df95af84f407149cad8"

URI_x86_64_v2_rust-icu_properties+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+default-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+default-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+default-devel.sha256sum] = "e41f04266a840e9b1f5a4357469eecb68d255a8d6317329fc0dd4d5d46dec9bf"

URI_x86_64_v2_rust-icu_properties+harfbuzz_traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+harfbuzz_traits-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+harfbuzz_traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+harfbuzz_traits-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+harfbuzz_traits-devel.sha256sum] = "5b2764fa4c2f947472aa1c12ca8f4743693688ab3b1d288d7614610ac107b74f"

URI_x86_64_v2_rust-icu_properties+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+serde-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+serde-devel.sha256sum] = "68cf112bdc7af9b9e252cfafad4a78f3dfc708828f558ccc495811335bced3ed"

URI_x86_64_v2_rust-icu_properties+unicode_bidi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+unicode_bidi-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+unicode_bidi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+unicode_bidi-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+unicode_bidi-devel.sha256sum] = "640738b30bc16ae769c26b701fe75bd2499014fa2570f98eac666a3132f11c2a"

URI_x86_64_v2_rust-icu_properties-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties-devel}"
SRC_URI[x86_64_v2_rust-icu_properties-devel.sha256sum] = "40ef904bc9958c35d5adb2ae4f7bed1d38c855564ebc0050afc832bc0718a2b3"

URI_aarch64_rust-icu_properties+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+alloc-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_properties+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+alloc-devel}"
SRC_URI[aarch64_rust-icu_properties+alloc-devel.sha256sum] = "84a1217dba1141ae7917799d319f19d25ed7a0d3fc94c546bfe3d9c76d6f4248"

URI_aarch64_rust-icu_properties+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+compiled_data-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_properties+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_properties+compiled_data-devel.sha256sum] = "303f87946ca7bdc7d09d6be48467b606c6f2c247f9d22681badc5d552357fd5e"

URI_aarch64_rust-icu_properties+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+datagen-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_properties+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+datagen-devel}"
SRC_URI[aarch64_rust-icu_properties+datagen-devel.sha256sum] = "f8e10f988dfc648aee56191596e4705f007a83af9cb69b8faddb51c1c07a9d75"

URI_aarch64_rust-icu_properties+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+default-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_properties+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+default-devel}"
SRC_URI[aarch64_rust-icu_properties+default-devel.sha256sum] = "76cb9343a323e86ba3fba33bbd1fbeeb435b846614cd243135adb18fb6a35f36"

URI_aarch64_rust-icu_properties+harfbuzz_traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+harfbuzz_traits-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_properties+harfbuzz_traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+harfbuzz_traits-devel}"
SRC_URI[aarch64_rust-icu_properties+harfbuzz_traits-devel.sha256sum] = "765a4acb002ba25ffc6154bdf1804ff5be4e3ddd8abae3a9610c4910ace4b353"

URI_aarch64_rust-icu_properties+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+serde-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_properties+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+serde-devel}"
SRC_URI[aarch64_rust-icu_properties+serde-devel.sha256sum] = "59561e1e8d92be64adbfc87328bdac8eba72e24eab36b1f7c72d3fe02eb50d50"

URI_aarch64_rust-icu_properties+unicode_bidi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+unicode_bidi-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_properties+unicode_bidi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+unicode_bidi-devel}"
SRC_URI[aarch64_rust-icu_properties+unicode_bidi-devel.sha256sum] = "0c4839134ba226e5d5a616b78b14a0dcae7ddd49b3ddc36f8c8629bed05e52de"

URI_aarch64_rust-icu_properties-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_properties-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties-devel}"
SRC_URI[aarch64_rust-icu_properties-devel.sha256sum] = "61f30569a40d1cab600cb1dc28d6c080df54714c0a76b4bf0b520f27b785a7e2"

RDEPENDS:rust-icu_properties+alloc-devel = " \
 cargo \
 rust-icu_collections+alloc-devel \
 rust-icu_properties-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+alloc-devel \
 "
RDEPENDS:rust-icu_properties+compiled_data-devel = " \
 cargo \
 rust-icu_properties-devel \
 rust-icu_properties_data-devel \
 rust-icu_provider+baked-devel \
 "
RDEPENDS:rust-icu_properties+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collections+databake-devel \
 rust-icu_locale_core+databake-devel \
 rust-icu_properties+serde-devel \
 rust-icu_properties-devel \
 rust-icu_provider+export-devel \
 rust-zerotrie+databake-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_properties+default-devel = " \
 cargo \
 rust-icu_properties+compiled_data-devel \
 rust-icu_properties-devel \
 "
RDEPENDS:rust-icu_properties+harfbuzz_traits-devel = " \
 cargo \
 rust-harfbuzz-traits-devel \
 rust-icu_properties-devel \
 "
RDEPENDS:rust-icu_properties+serde-devel = " \
 cargo \
 rust-icu_collections+serde-devel \
 rust-icu_locale_core+serde-devel \
 rust-icu_properties-devel \
 rust-icu_provider+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerotrie+serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_properties+unicode_bidi-devel = " \
 cargo \
 rust-icu_properties-devel \
 rust-unicode-bidi-devel \
 "
RDEPENDS:rust-icu_properties-devel = " \
 cargo \
 rust \
 rust-icu_collections-devel \
 rust-icu_locale_core+zerovec-devel \
 rust-icu_locale_core-devel \
 rust-icu_provider-devel \
 rust-zerotrie+yoke-devel \
 rust-zerotrie+zerofrom-devel \
 rust-zerotrie-devel \
 rust-zerovec+derive-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
