# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tokodon"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 tokodon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tokodon-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bd8f005e6814c60e0ff4df4e4c360e9f6212668440d2e70ce4aee422f8e5b2b"

URI_x86_64_v2_tokodon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tokodon-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tokodon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tokodon}"
SRC_URI[x86_64_v2_tokodon.sha256sum] = "2f5c356218f507a5feb98e91ba5de165421e30e33536ee5318715196829096e2"

URI_aarch64_tokodon = "${EPEL_MIRROR}/aarch64/Packages/t/tokodon-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_tokodon;unpack=0"
SRC_URI:append = " ${URI_aarch64_tokodon}"
SRC_URI[aarch64_tokodon.sha256sum] = "7bac083013486d697c491cb0d0366a4a83a1da3441f0893250cdb7fdfbfaaca4"

RDEPENDS:tokodon = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-purpose \
 kf6-sonnet \
 kunifiedpush \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 qt6-qtwebview \
 qtkeychain-qt6 \
 "
