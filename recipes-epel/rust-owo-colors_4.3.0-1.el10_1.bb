# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-owo-colors"
PV = "4.3.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-owo-colors+alloc-devel \
 rust-owo-colors+default-devel \
 rust-owo-colors+supports-color-devel \
 rust-owo-colors+supports-colors-devel \
 rust-owo-colors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-owo-colors-4.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e869b446b4cea1fdde0f0b2b0a2a4e16ce0b66e07e10f1908c26ffcad1617397"

URI_x86_64_v2_rust-owo-colors+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+alloc-devel-4.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+alloc-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+alloc-devel.sha256sum] = "e38d7469c80b96f7e5e79d65ac1e87a4bd306b3b0a51cceb3f1c82b06b3576cb"

URI_x86_64_v2_rust-owo-colors+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+default-devel-4.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+default-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+default-devel.sha256sum] = "f6307c73edaf12a184d8c7338a8b4ebbaec5b60e613eb6d96eae5db55216d6b5"

URI_x86_64_v2_rust-owo-colors+supports-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+supports-color-devel-4.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+supports-color-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+supports-color-devel.sha256sum] = "136c48f66e6eb587a7765bfaac835a641f8fd2598d18aa749bfd88e1b05ac741"

URI_x86_64_v2_rust-owo-colors+supports-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+supports-colors-devel-4.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+supports-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+supports-colors-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+supports-colors-devel.sha256sum] = "8dc218bc995b5253e6a7b7a651af72f923df608c21f8e41f2a68e69f090eb6b5"

URI_x86_64_v2_rust-owo-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors-devel-4.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors-devel}"
SRC_URI[x86_64_v2_rust-owo-colors-devel.sha256sum] = "65441392928c302e2ce9f5dc9487ccd2cca342b37bf43dc506f1d095133e2a6f"
RPROVIDES:rust-owo-colors-devel:x86_64_v2 = "virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

URI_aarch64_rust-owo-colors+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+alloc-devel-4.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-owo-colors+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+alloc-devel}"
SRC_URI[aarch64_rust-owo-colors+alloc-devel.sha256sum] = "c1690434401f8801c91d1cf032929da4b9192808c1a6727b929be27e1d3e7d83"

URI_aarch64_rust-owo-colors+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+default-devel-4.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-owo-colors+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+default-devel}"
SRC_URI[aarch64_rust-owo-colors+default-devel.sha256sum] = "83b0dc5d70febedba4a72c4b40d3f67f2e81d4fceaad267b08a56d8058fdf279"

URI_aarch64_rust-owo-colors+supports-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+supports-color-devel-4.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-owo-colors+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+supports-color-devel}"
SRC_URI[aarch64_rust-owo-colors+supports-color-devel.sha256sum] = "f1e7292f50da13758d86b190f57d78399882f75d4cdaa8a22d2566f851614f80"

URI_aarch64_rust-owo-colors+supports-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+supports-colors-devel-4.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-owo-colors+supports-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+supports-colors-devel}"
SRC_URI[aarch64_rust-owo-colors+supports-colors-devel.sha256sum] = "f43284df078b529fe1eb264e0e2e4f8c60e3216333889110d13249d8f2cc7ecd"

URI_aarch64_rust-owo-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors-devel-4.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors-devel}"
SRC_URI[aarch64_rust-owo-colors-devel.sha256sum] = "066e9686adc81fbe952e971bfe53282eef12d262ee24049c2699b4e9d902ff9e"
RPROVIDES:rust-owo-colors-devel:aarch64 = "virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

RDEPENDS:rust-owo-colors+alloc-devel = " \
 cargo \
 rust-owo-colors-devel \
 "
RDEPENDS:rust-owo-colors+default-devel = " \
 cargo \
 rust-owo-colors-devel \
 "
RDEPENDS:rust-owo-colors+supports-color-devel = " \
 cargo \
 rust-owo-colors-devel \
 rust-supports-color+default-devel \
 "
RDEPENDS:rust-owo-colors+supports-colors-devel = " \
 cargo \
 rust-owo-colors+supports-color-devel \
 rust-owo-colors-devel \
 rust-supports-color2+default-devel \
 "
RDEPENDS:rust-owo-colors-devel = " \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"
