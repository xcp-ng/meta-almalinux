# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtxmlpatterns"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtxmlpatterns \
 qt5-qtxmlpatterns-devel \
 qt5-qtxmlpatterns-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtxmlpatterns-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d5247d90b23762502eeab5b797f957e1a9fcd25b5cefd59717a73f3b28e26fd"

URI_x86_64_v2_qt5-qtxmlpatterns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtxmlpatterns-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtxmlpatterns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtxmlpatterns}"
SRC_URI[x86_64_v2_qt5-qtxmlpatterns.sha256sum] = "f5f893c748962c0b45d973113a2168159bedcb75321d1997ca17cd0ebbfb7e3c"

URI_x86_64_v2_qt5-qtxmlpatterns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtxmlpatterns-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtxmlpatterns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtxmlpatterns-devel}"
SRC_URI[x86_64_v2_qt5-qtxmlpatterns-devel.sha256sum] = "0db92ce9f28c811595545ea2bfc5469d8fb0992da3d004872f61618dc3a911ca"

URI_x86_64_v2_qt5-qtxmlpatterns-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtxmlpatterns-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtxmlpatterns-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtxmlpatterns-examples}"
SRC_URI[x86_64_v2_qt5-qtxmlpatterns-examples.sha256sum] = "198403c0a3f1e302efff25c41e8efe3615ae4ca17783b8d29d8185f970628389"

URI_aarch64_qt5-qtxmlpatterns = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtxmlpatterns-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtxmlpatterns;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtxmlpatterns}"
SRC_URI[aarch64_qt5-qtxmlpatterns.sha256sum] = "05eef12f6ad151e49559cd7f5aa3c6d687364bbd636a7a8b0c6b12c2182b6ef1"

URI_aarch64_qt5-qtxmlpatterns-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtxmlpatterns-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtxmlpatterns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtxmlpatterns-devel}"
SRC_URI[aarch64_qt5-qtxmlpatterns-devel.sha256sum] = "7638e531fd8613ff8d9aa0520075585435da1ec21ca0d22fdb3f4408170a6f27"

URI_aarch64_qt5-qtxmlpatterns-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtxmlpatterns-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtxmlpatterns-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtxmlpatterns-examples}"
SRC_URI[aarch64_qt5-qtxmlpatterns-examples.sha256sum] = "495da3e69780fb5b6ff894005378ff22acd133804bd342721cf257b5bd02d7dc"

RDEPENDS:qt5-qtxmlpatterns = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtxmlpatterns-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtxmlpatterns \
 "
RDEPENDS:qt5-qtxmlpatterns-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtxmlpatterns \
 "
