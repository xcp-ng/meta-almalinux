# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yakuake"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 yakuake \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yakuake-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d1ef04c2d08fe388e8958b6aba9bb44046735f754615b79b56333cbcbcf1395"

URI_x86_64_v2_yakuake = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yakuake-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yakuake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yakuake}"
SRC_URI[x86_64_v2_yakuake.sha256sum] = "06524cac80aaa78e9f359660d712c63326c744c40f5af23c154918bffe479b9c"

URI_aarch64_yakuake = "${EPEL_MIRROR}/aarch64/Packages/y/yakuake-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_yakuake;unpack=0"
SRC_URI:append = " ${URI_aarch64_yakuake}"
SRC_URI[aarch64_yakuake.sha256sum] = "a0a01e57b1d084904f24afde66a0e13829e3ff34c095f2353395469325f713db"

RDEPENDS:yakuake = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 konsole-part \
 kwayland \
 libX11 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
