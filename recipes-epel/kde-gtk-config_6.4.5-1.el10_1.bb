# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-gtk-config"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 kde-gtk-config \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-gtk-config-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ed8000f911bfce4e56d50e4e35a5b2cff1c79dcea0e279cac19ad0ad5cd2a73"

URI_x86_64_v2_kde-gtk-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-gtk-config-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-gtk-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-gtk-config}"
SRC_URI[x86_64_v2_kde-gtk-config.sha256sum] = "e380de55ba8f20cc5f5ba92c27c576e9164eb391a9d61b80bd7a48eb191db7d3"

URI_aarch64_kde-gtk-config = "${EPEL_MIRROR}/aarch64/Packages/k/kde-gtk-config-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_kde-gtk-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-gtk-config}"
SRC_URI[aarch64_kde-gtk-config.sha256sum] = "901ae1b4ca5c45cda61b09085efb55d4e5197846aaef6672a69903467e8a55e9"

RDEPENDS:kde-gtk-config = " \
 bash \
 breeze-gtk-common \
 glib2 \
 glibc \
 gtk3 \
 kde-cli-tools \
 kdecoration \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
