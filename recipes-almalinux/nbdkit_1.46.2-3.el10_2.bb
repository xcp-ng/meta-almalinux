# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nbdkit"
PV = "1.46.2"
PR = "3.el10_2"
PACKAGES:x86_64_v2 = " \
 nbdkit \
 nbdkit-bash-completion \
 nbdkit-basic-filters \
 nbdkit-basic-plugins \
 nbdkit-curl-plugin \
 nbdkit-devel \
 nbdkit-example-plugins \
 nbdkit-linuxdisk-plugin \
 nbdkit-nbd-plugin \
 nbdkit-python-plugin \
 nbdkit-selinux \
 nbdkit-server \
 nbdkit-srpm-macros \
 nbdkit-ssh-plugin \
 nbdkit-tar-filter \
 nbdkit-tmpdisk-plugin \
 nbdkit-vddk-plugin \
 nbdkit-xz-filter \
"
PACKAGES:aarch64 = " \
 nbdkit \
 nbdkit-bash-completion \
 nbdkit-basic-filters \
 nbdkit-basic-plugins \
 nbdkit-curl-plugin \
 nbdkit-devel \
 nbdkit-example-plugins \
 nbdkit-linuxdisk-plugin \
 nbdkit-nbd-plugin \
 nbdkit-python-plugin \
 nbdkit-selinux \
 nbdkit-server \
 nbdkit-srpm-macros \
 nbdkit-ssh-plugin \
 nbdkit-tar-filter \
 nbdkit-tmpdisk-plugin \
 nbdkit-xz-filter \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nbdkit-1.46.2-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e26334d9d59a1130e8235c0fef02446c4dfb4b079820fa9d473eb670895c1401"

URI_x86_64_v2_nbdkit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-1.46.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nbdkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit}"
SRC_URI[x86_64_v2_nbdkit.sha256sum] = "42863b4abbc4ae299f7c9448fb2d9daf5e1754dfb4bb579ff9d4de1815a22808"

URI_x86_64_v2_nbdkit-bash-completion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-bash-completion-1.46.2-3.el10_2.noarch.rpm;name=x86_64_v2_nbdkit-bash-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-bash-completion}"
SRC_URI[x86_64_v2_nbdkit-bash-completion.sha256sum] = "fa3837f7da192742102eb8562b28f76206e1f012b021395bd73acf21de0910c8"

URI_x86_64_v2_nbdkit-basic-filters = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-basic-filters-1.46.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nbdkit-basic-filters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-basic-filters}"
SRC_URI[x86_64_v2_nbdkit-basic-filters.sha256sum] = "586f0e07a692a62c694eb2345a1f01b0c90e969b910713cce7b6f4994f0628a7"

URI_x86_64_v2_nbdkit-basic-plugins = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-basic-plugins-1.46.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nbdkit-basic-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-basic-plugins}"
SRC_URI[x86_64_v2_nbdkit-basic-plugins.sha256sum] = "61545b222bda26f2bda2bb2995db1d10fb98523000465fea697857be85942633"

URI_x86_64_v2_nbdkit-curl-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-curl-plugin-1.46.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nbdkit-curl-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-curl-plugin}"
SRC_URI[x86_64_v2_nbdkit-curl-plugin.sha256sum] = "e59583d92ca30c2949924d7080c527968ec418370643d26ad0a5714ece754411"

URI_x86_64_v2_nbdkit-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nbdkit-devel-1.46.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nbdkit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-devel}"
SRC_URI[x86_64_v2_nbdkit-devel.sha256sum] = "7c45ea18e8c7668674a69dfe821a73a68d9f8b3fb557731290f3021a34ce595e"

URI_x86_64_v2_nbdkit-example-plugins = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nbdkit-example-plugins-1.46.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nbdkit-example-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-example-plugins}"
SRC_URI[x86_64_v2_nbdkit-example-plugins.sha256sum] = "9813596dc350bafcc7ea56e6280c01b870cac882652065c68f53f496122e23bc"

URI_x86_64_v2_nbdkit-linuxdisk-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-linuxdisk-plugin-1.46.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nbdkit-linuxdisk-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-linuxdisk-plugin}"
SRC_URI[x86_64_v2_nbdkit-linuxdisk-plugin.sha256sum] = "bdfcb8a8b7b3202b5163d095a7398802260cb095ee68a6ed113d6317cc46e706"

URI_x86_64_v2_nbdkit-nbd-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-nbd-plugin-1.46.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nbdkit-nbd-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-nbd-plugin}"
SRC_URI[x86_64_v2_nbdkit-nbd-plugin.sha256sum] = "0b221a7979158108e620eb0e615ebe8707e0ee1e42f7ae7c1ca80eb58b8fe9ce"

URI_x86_64_v2_nbdkit-python-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-python-plugin-1.46.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nbdkit-python-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-python-plugin}"
SRC_URI[x86_64_v2_nbdkit-python-plugin.sha256sum] = "9cb70052e41702ffdc122acd89bea3c615764a82a551c50f6643ea0b2add0b1c"

URI_x86_64_v2_nbdkit-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-selinux-1.46.2-3.el10_2.noarch.rpm;name=x86_64_v2_nbdkit-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-selinux}"
SRC_URI[x86_64_v2_nbdkit-selinux.sha256sum] = "2ed0b8c18a11103a5d3fb8655158241e341dd56848b1d063371a649264ee116a"

URI_x86_64_v2_nbdkit-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-server-1.46.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nbdkit-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-server}"
SRC_URI[x86_64_v2_nbdkit-server.sha256sum] = "e75580560c5af35a95cb8d6ee8e6cd3c693eded28423ec28690257728cd2586a"

URI_x86_64_v2_nbdkit-srpm-macros = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nbdkit-srpm-macros-1.46.2-3.el10_2.noarch.rpm;name=x86_64_v2_nbdkit-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-srpm-macros}"
SRC_URI[x86_64_v2_nbdkit-srpm-macros.sha256sum] = "4d1ffdf20d9608e1180d08d1c89e9f0b0ed191af77ee38444353194b8c6c680d"

URI_x86_64_v2_nbdkit-ssh-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-ssh-plugin-1.46.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nbdkit-ssh-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-ssh-plugin}"
SRC_URI[x86_64_v2_nbdkit-ssh-plugin.sha256sum] = "e4013a900cf26e332b10bc89d00ce545eefdb17541f856a0be0ed54a0049561d"

URI_x86_64_v2_nbdkit-tar-filter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-tar-filter-1.46.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nbdkit-tar-filter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-tar-filter}"
SRC_URI[x86_64_v2_nbdkit-tar-filter.sha256sum] = "f47a1c31a9a30690045984b46f8a399475d6eb23236cdfaffbe13b0bc6d915c7"

URI_x86_64_v2_nbdkit-tmpdisk-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-tmpdisk-plugin-1.46.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nbdkit-tmpdisk-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-tmpdisk-plugin}"
SRC_URI[x86_64_v2_nbdkit-tmpdisk-plugin.sha256sum] = "38682a0bb92a522366df498297f0bfe4317e5177acafb0eb1f39db13560f8a39"

URI_x86_64_v2_nbdkit-vddk-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-vddk-plugin-1.46.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nbdkit-vddk-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-vddk-plugin}"
SRC_URI[x86_64_v2_nbdkit-vddk-plugin.sha256sum] = "944b03e340238ebe7f5bfbf1cf1304d3044946a7cf33681fca0ce5d95b8499d1"

URI_x86_64_v2_nbdkit-xz-filter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-xz-filter-1.46.2-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_nbdkit-xz-filter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-xz-filter}"
SRC_URI[x86_64_v2_nbdkit-xz-filter.sha256sum] = "93d93f96a7adecc8855dc71fdd53aaa23cd890f53fb56b4a5113d95528d31bf0"

URI_aarch64_nbdkit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-1.46.2-3.el10_2.aarch64.rpm;name=aarch64_nbdkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit}"
SRC_URI[aarch64_nbdkit.sha256sum] = "d8682e195ae23ad21c37f3991539ff1ec3f5aabaf2d1ee12141df846f0e53d25"

URI_aarch64_nbdkit-bash-completion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-bash-completion-1.46.2-3.el10_2.noarch.rpm;name=aarch64_nbdkit-bash-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-bash-completion}"
SRC_URI[aarch64_nbdkit-bash-completion.sha256sum] = "fa3837f7da192742102eb8562b28f76206e1f012b021395bd73acf21de0910c8"

URI_aarch64_nbdkit-basic-filters = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-basic-filters-1.46.2-3.el10_2.aarch64.rpm;name=aarch64_nbdkit-basic-filters;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-basic-filters}"
SRC_URI[aarch64_nbdkit-basic-filters.sha256sum] = "6f2ca74ff44f9632b9c1ff48f48695a1a7795a5a9a96afd7d41e0236d4a55211"

URI_aarch64_nbdkit-basic-plugins = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-basic-plugins-1.46.2-3.el10_2.aarch64.rpm;name=aarch64_nbdkit-basic-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-basic-plugins}"
SRC_URI[aarch64_nbdkit-basic-plugins.sha256sum] = "f0030d7de3b7caab42cf41003c4a8a93324f7700b04d966231a53e43fe2deabc"

URI_aarch64_nbdkit-curl-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-curl-plugin-1.46.2-3.el10_2.aarch64.rpm;name=aarch64_nbdkit-curl-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-curl-plugin}"
SRC_URI[aarch64_nbdkit-curl-plugin.sha256sum] = "6c138c8b2a58beb44c3295fab8a27bbca03caf73c710851e60b2ad6f393c7794"

URI_aarch64_nbdkit-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nbdkit-devel-1.46.2-3.el10_2.aarch64.rpm;name=aarch64_nbdkit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-devel}"
SRC_URI[aarch64_nbdkit-devel.sha256sum] = "d5782a4deb513990c4e8eeddb812600b27c44de9f76dd253f95355dbe39b89d0"

URI_aarch64_nbdkit-example-plugins = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nbdkit-example-plugins-1.46.2-3.el10_2.aarch64.rpm;name=aarch64_nbdkit-example-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-example-plugins}"
SRC_URI[aarch64_nbdkit-example-plugins.sha256sum] = "030b5ccdaa62df5331a09beee916622675533a0262135c1248c59fdc5018796d"

URI_aarch64_nbdkit-linuxdisk-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-linuxdisk-plugin-1.46.2-3.el10_2.aarch64.rpm;name=aarch64_nbdkit-linuxdisk-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-linuxdisk-plugin}"
SRC_URI[aarch64_nbdkit-linuxdisk-plugin.sha256sum] = "b96b6a2bacdef1f006f602f931e020d3ca49e2919f8be035023c362c4e881712"

URI_aarch64_nbdkit-nbd-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-nbd-plugin-1.46.2-3.el10_2.aarch64.rpm;name=aarch64_nbdkit-nbd-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-nbd-plugin}"
SRC_URI[aarch64_nbdkit-nbd-plugin.sha256sum] = "eb629e34e5090b16adf84e92171d0980d28f0a23612c45b6c8d45ab39c89b572"

URI_aarch64_nbdkit-python-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-python-plugin-1.46.2-3.el10_2.aarch64.rpm;name=aarch64_nbdkit-python-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-python-plugin}"
SRC_URI[aarch64_nbdkit-python-plugin.sha256sum] = "cf4d49cf2c001d72857f7c034b7ff56627fdaef41ebf07b961ccf6295becaaa3"

URI_aarch64_nbdkit-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-selinux-1.46.2-3.el10_2.noarch.rpm;name=aarch64_nbdkit-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-selinux}"
SRC_URI[aarch64_nbdkit-selinux.sha256sum] = "2ed0b8c18a11103a5d3fb8655158241e341dd56848b1d063371a649264ee116a"

URI_aarch64_nbdkit-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-server-1.46.2-3.el10_2.aarch64.rpm;name=aarch64_nbdkit-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-server}"
SRC_URI[aarch64_nbdkit-server.sha256sum] = "09f1ba8119522de416360590e93a7fac4b36b96e6cf990715b1e758268a224ce"

URI_aarch64_nbdkit-srpm-macros = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nbdkit-srpm-macros-1.46.2-3.el10_2.noarch.rpm;name=aarch64_nbdkit-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-srpm-macros}"
SRC_URI[aarch64_nbdkit-srpm-macros.sha256sum] = "4d1ffdf20d9608e1180d08d1c89e9f0b0ed191af77ee38444353194b8c6c680d"

URI_aarch64_nbdkit-ssh-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-ssh-plugin-1.46.2-3.el10_2.aarch64.rpm;name=aarch64_nbdkit-ssh-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-ssh-plugin}"
SRC_URI[aarch64_nbdkit-ssh-plugin.sha256sum] = "02cd2a55f3de921f3c621c2b1f45a736c7de5546f2f25e08999236a1aec0149a"

URI_aarch64_nbdkit-tar-filter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-tar-filter-1.46.2-3.el10_2.aarch64.rpm;name=aarch64_nbdkit-tar-filter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-tar-filter}"
SRC_URI[aarch64_nbdkit-tar-filter.sha256sum] = "af79dec90a48214dd3580f996d12c29e5ec1dc46217a867898cb12324c4af65a"

URI_aarch64_nbdkit-tmpdisk-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-tmpdisk-plugin-1.46.2-3.el10_2.aarch64.rpm;name=aarch64_nbdkit-tmpdisk-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-tmpdisk-plugin}"
SRC_URI[aarch64_nbdkit-tmpdisk-plugin.sha256sum] = "57821f199e59e287deb1efaf69f639802784d45d0ccbe690ba23fbc000e81e8e"

URI_aarch64_nbdkit-xz-filter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-xz-filter-1.46.2-3.el10_2.aarch64.rpm;name=aarch64_nbdkit-xz-filter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-xz-filter}"
SRC_URI[aarch64_nbdkit-xz-filter.sha256sum] = "226acc917a02d4f5111e79633b1e0e7a2fd99ab31943bc69e32f8a1ad4f2bd92"

RDEPENDS:nbdkit = " \
 nbdkit-basic-filters \
 nbdkit-basic-plugins \
 nbdkit-selinux \
 nbdkit-server \
 "
RDEPENDS:nbdkit-bash-completion = " \
 bash-completion \
 nbdkit-server \
 "
RDEPENDS:nbdkit-basic-filters = " \
 glibc \
 gnutls \
 libgcc \
 nbdkit-server \
 zlib-ng-compat \
 "
RDEPENDS:nbdkit-basic-plugins = " \
 glibc \
 gnutls \
 libgcc \
 libzstd \
 nbdkit-server \
 zlib-ng-compat \
 "
RDEPENDS:nbdkit-curl-plugin = " \
 glibc \
 libgcc \
 nbdkit-server \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:nbdkit-devel = " \
 nbdkit-server \
 pkgconf-pkg-config \
 "
RDEPENDS:nbdkit-example-plugins = " \
 glibc \
 nbdkit-server \
 "
RDEPENDS:nbdkit-linuxdisk-plugin = " \
 e2fsprogs \
 glibc \
 libgcc \
 nbdkit-server \
 zlib-ng-compat \
 "
RDEPENDS:nbdkit-nbd-plugin = " \
 glibc \
 libgcc \
 libnbd \
 nbdkit-server \
 zlib-ng-compat \
 "
RDEPENDS:nbdkit-python-plugin = " \
 glibc \
 libgcc \
 nbdkit-server \
 python3-libs \
 zlib-ng-compat \
 "
RDEPENDS:nbdkit-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:nbdkit-server = " \
 glibc \
 gnutls \
 libgcc \
 libselinux \
 "
RDEPENDS:nbdkit-srpm-macros = " \
 bash \
 "
RDEPENDS:nbdkit-ssh-plugin = " \
 glibc \
 libgcc \
 libssh \
 nbdkit-server \
 zlib-ng-compat \
 "
RDEPENDS:nbdkit-tar-filter = " \
 glibc \
 libgcc \
 nbdkit-server \
 tar \
 zlib-ng-compat \
 "
RDEPENDS:nbdkit-tmpdisk-plugin = " \
 e2fsprogs \
 glibc \
 libgcc \
 nbdkit-server \
 util-linux \
 zlib-ng-compat \
 "
RDEPENDS:nbdkit-vddk-plugin = " \
 glibc \
 libgcc \
 libxcrypt-compat \
 nbdkit-server \
 zlib-ng-compat \
 "
RDEPENDS:nbdkit-xz-filter = " \
 glibc \
 libgcc \
 nbdkit-server \
 xz-libs \
 zlib-ng-compat \
 "
