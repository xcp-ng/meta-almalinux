# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jwcrypto"
PV = "1.5.8"
PR = "1.el10"
PACKAGES = " \
 python3-jwcrypto \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-jwcrypto-1.5.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36885d670f4fbdc8a0eb6a9c116a52dc5d8dc34f4040bec91cfe5cbab8c17e4b"

URI_x86_64_v2_python3-jwcrypto = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-jwcrypto-1.5.8-1.el10.noarch.rpm;name=x86_64_v2_python3-jwcrypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jwcrypto}"
SRC_URI[x86_64_v2_python3-jwcrypto.sha256sum] = "a66f0b58e7dfbcfcf0593ba459b91a5f4167c2da4370eaef4a3d48354a8142ca"

URI_aarch64_python3-jwcrypto = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-jwcrypto-1.5.8-1.el10.noarch.rpm;name=aarch64_python3-jwcrypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jwcrypto}"
SRC_URI[aarch64_python3-jwcrypto.sha256sum] = "a66f0b58e7dfbcfcf0593ba459b91a5f4167c2da4370eaef4a3d48354a8142ca"

RDEPENDS:python3-jwcrypto = " \
 python3 \
 python3-cryptography \
 python3-typing-extensions \
 "
