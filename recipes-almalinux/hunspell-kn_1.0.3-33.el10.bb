# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-kn"
PV = "1.0.3"
PR = "33.el10"
PACKAGES = " \
 hunspell-kn \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-kn-1.0.3-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8eeaca26cc88c4494124740b50ee00841fffcecfc6cd822c1f80ef7f026c008f"

URI_x86_64_v2_hunspell-kn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-kn-1.0.3-33.el10.noarch.rpm;name=x86_64_v2_hunspell-kn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-kn}"
SRC_URI[x86_64_v2_hunspell-kn.sha256sum] = "d03b40f8b05c81f53ede38d39171e0724f8422d36aaf6ce150c09983eeec3bbe"

URI_aarch64_hunspell-kn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-kn-1.0.3-33.el10.noarch.rpm;name=aarch64_hunspell-kn;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-kn}"
SRC_URI[aarch64_hunspell-kn.sha256sum] = "d03b40f8b05c81f53ede38d39171e0724f8422d36aaf6ce150c09983eeec3bbe"

RDEPENDS:hunspell-kn = " \
 hunspell-filesystem \
 "
