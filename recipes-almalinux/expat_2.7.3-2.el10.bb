# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "expat"
PV = "2.7.3"
PR = "2.el10"
PACKAGES = " \
 expat \
 expat-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/expat-2.7.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d453c1de988d9af7551003271cc83dc8c6ddb88372081d176b8545390176f752"

URI_x86_64_v2_expat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/expat-2.7.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_expat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_expat}"
SRC_URI[x86_64_v2_expat.sha256sum] = "234d1defc4489ae4398f158aab239a606f3abb0b71bae3856ec909c13b3b8a5a"

URI_x86_64_v2_expat-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/expat-devel-2.7.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_expat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_expat-devel}"
SRC_URI[x86_64_v2_expat-devel.sha256sum] = "ac9c557fcc8edc06e1f4a9c76e04760c019c9dab69a24ffaf885050b807e3210"

URI_aarch64_expat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/expat-2.7.3-2.el10.aarch64.rpm;name=aarch64_expat;unpack=0"
SRC_URI:append = " ${URI_aarch64_expat}"
SRC_URI[aarch64_expat.sha256sum] = "000c766b52a9da33a90220afd2be408cd7297d00f151b4065539968c112f7158"

URI_aarch64_expat-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/expat-devel-2.7.3-2.el10.aarch64.rpm;name=aarch64_expat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_expat-devel}"
SRC_URI[aarch64_expat-devel.sha256sum] = "df66ced34a1a0fe22f60cdfe67b89bb929d2275d36922e312295237ef001514a"

RDEPENDS:expat = " \
 glibc \
 "
RDEPENDS:expat-devel = " \
 expat \
 pkgconf-pkg-config \
 "
