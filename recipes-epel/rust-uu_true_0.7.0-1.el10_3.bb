# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_true"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_true+default-devel \
 rust-uu_true-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_true-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2ee2435e3f6016190dde5ab916038f9a2bf78fcbb1c05a57282eb942457718b"

URI_x86_64_v2_rust-uu_true+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_true+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_true+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_true+default-devel}"
SRC_URI[x86_64_v2_rust-uu_true+default-devel.sha256sum] = "180c185bee0fc5af93ae8b86df29f1ded64fa041b1d1fb68b5c8a4d17a662fca"

URI_x86_64_v2_rust-uu_true-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_true-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_true-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_true-devel}"
SRC_URI[x86_64_v2_rust-uu_true-devel.sha256sum] = "841c66597b9cd59f197111f6ee1e11f51725a636745a90b83943ec7fe90d63a1"

URI_aarch64_rust-uu_true+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_true+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_true+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_true+default-devel}"
SRC_URI[aarch64_rust-uu_true+default-devel.sha256sum] = "b50ae76c82a4ebdda96774fd47c6274c8cf64535a8610b8c5939ee8de9edc59d"

URI_aarch64_rust-uu_true-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_true-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_true-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_true-devel}"
SRC_URI[aarch64_rust-uu_true-devel.sha256sum] = "723aa6d08df4caee37d75d052d16121586dc3d39212e1dd50ce6e9c24b989785"

RDEPENDS:rust-uu_true+default-devel = " \
 cargo \
 rust-uu_true-devel \
 "
RDEPENDS:rust-uu_true-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 "
