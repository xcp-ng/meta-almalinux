# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kiconthemes"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kiconthemes \
 kf6-kiconthemes-devel \
 kf6-kiconthemes-doc \
 kf6-kiconthemes-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kiconthemes-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aa94f941321165a735f05929ca98c069362b862a920dc040880c7efc4ce69bb2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kiconthemes;unpack=0"
SRC_URI[x86_64_v2_kf6-kiconthemes.sha256sum] = "89ebb5d895bf67b70fdee2c1dfdede36ac25751eaeb4e15fa579bcb45e21905d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kiconthemes-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kiconthemes-devel.sha256sum] = "2d2996bc3b6a69c1c160c11bb495e5405f4844773c7a1aaabecb7b0d267a37e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kiconthemes-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kiconthemes-doc.sha256sum] = "9f1604f1952141db052d0e4ed7f38605a3d18d2ea5ff8b74c6c540ab0e416120"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kiconthemes-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kiconthemes-html.sha256sum] = "78372c85f972545860f5a165469c67e20080d13e517bb1306383b17aadae5d34"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kiconthemes;unpack=0"
SRC_URI[aarch64_kf6-kiconthemes.sha256sum] = "e7bbbe55f3bb38a8b6d9a49bb619fb917452061f3de8535bee197b3dfc932ffd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kiconthemes-devel;unpack=0"
SRC_URI[aarch64_kf6-kiconthemes-devel.sha256sum] = "e40f55904979a71bda3f0e9cc787ab9d141aa9a1342067c3827b2d0bfef3ac00"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kiconthemes-doc;unpack=0"
SRC_URI[aarch64_kf6-kiconthemes-doc.sha256sum] = "6699bb7110a17afd0b32da56d5b97b041b15f664759623402248929c86891f68"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kiconthemes-html;unpack=0"
SRC_URI[aarch64_kf6-kiconthemes-html.sha256sum] = "c005aa20ec0742bfe4d8d94b323c1061fb03097570b932e620cf388d843b11de"

RDEPENDS:kf6-kiconthemes = " \
 glibc \
 hicolor-icon-theme \
 kf6-breeze-icons \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kiconthemes-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kiconthemes \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kiconthemes-doc = " \
 "
RDEPENDS:kf6-kiconthemes-html = " \
 "
