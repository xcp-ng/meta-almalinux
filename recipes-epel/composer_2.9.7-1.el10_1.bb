# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "composer"
PV = "2.9.7"
PR = "1.el10_1"
PACKAGES = " \
 composer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/composer-2.9.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a23620fd18c29205305df8d70ac54120b6f3394642b5fde5a480a97f4783e616"

URI_x86_64_v2_composer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/composer-2.9.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_composer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_composer}"
SRC_URI[x86_64_v2_composer.sha256sum] = "7dc9065a74a833639a54399037a4bbefa1c756a0c61d2baa50207b71a28b0731"

URI_aarch64_composer = "${EPEL_MIRROR}/aarch64/Packages/c/composer-2.9.7-1.el10_1.noarch.rpm;name=aarch64_composer;unpack=0"
SRC_URI:append = " ${URI_aarch64_composer}"
SRC_URI[aarch64_composer.sha256sum] = "cb235149c388ffec9b522cef539ef5ffd2277540719405e4838c4cb255069e84"

RDEPENDS:composer = " \
 bash \
 ca-certificates \
 php-cli \
 php-common \
 php-intl \
 php-mbstring \
 php-pecl-zip \
 php-process \
 php-xml \
 "
