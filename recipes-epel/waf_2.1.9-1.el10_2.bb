# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "waf"
PV = "2.1.9"
PR = "1.el10_2"
PACKAGES = " \
 waf \
 waf-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/waf-2.1.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8db46810e23931712a7fb256874954b1cb293c47c510c2e3ae3a09f9f92fa741"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/waf-2.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_waf;unpack=0"
SRC_URI[x86_64_v2_waf.sha256sum] = "6b701598b736aa2e1f61b0bf268b589c50ce41458132199bfe0498a057353f34"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/waf-doc-2.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_waf-doc;unpack=0"
SRC_URI[x86_64_v2_waf-doc.sha256sum] = "e82e8977e272497b134ef7d2a6c2626c7bd76a79eed36474749db0c3dcb09f9e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/waf-2.1.9-1.el10_2.noarch.rpm;name=aarch64_waf;unpack=0"
SRC_URI[aarch64_waf.sha256sum] = "967e0b13caeccabca2ede43313ce3610c14a866450a2305034bfe9dc1b785fa8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/waf-doc-2.1.9-1.el10_2.noarch.rpm;name=aarch64_waf-doc;unpack=0"
SRC_URI[aarch64_waf-doc.sha256sum] = "89826dbfafbef3d3ddb4c638c8a2c795f98390040c443f7891ab5c76954eb291"

RDEPENDS:waf = " \
 python3 \
 "
RDEPENDS:waf-doc = " \
 waf \
 "
