# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MIME-Lite"
PV = "3.033"
PR = "13.el10_0"
PACKAGES = " \
 perl-MIME-Lite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MIME-Lite-3.033-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "578f4e04b9a7637d71ee83bee063cba0631da34add452abb40dc7b6f933b0887"

URI_x86_64_v2_perl-MIME-Lite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MIME-Lite-3.033-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MIME-Lite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MIME-Lite}"
SRC_URI[x86_64_v2_perl-MIME-Lite.sha256sum] = "b97bca220537aa98c8a4526e7101362479891694785a5cb12a151fdc8ee666c9"

URI_aarch64_perl-MIME-Lite = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MIME-Lite-3.033-13.el10_0.noarch.rpm;name=aarch64_perl-MIME-Lite;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MIME-Lite}"
SRC_URI[aarch64_perl-MIME-Lite.sha256sum] = "4ca333ee08015cd72d8316793381704c50933fd13b02a86a14db1fe424b993cf"

RDEPENDS:perl-MIME-Lite = " \
 perl-Carp \
 perl-Email-Date-Format \
 perl-FileHandle \
 perl-MIME-Types \
 perl-libs \
 perl-vars \
 "
