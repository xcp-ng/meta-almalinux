# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tty-copy"
PV = "0.2.2"
PR = "6.el10_0"
PACKAGES = " \
 tty-copy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tty-copy-0.2.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d1d4bbec4ca0fccb5208f775dcc60c2a1f0c25415ccdba4edca636aa6ee07ed"

URI_x86_64_v2_tty-copy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tty-copy-0.2.2-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tty-copy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tty-copy}"
SRC_URI[x86_64_v2_tty-copy.sha256sum] = "7b19ccc2ef177710ff983ad5c60e09c708b517dcae8cd954fd2497e903e84170"

URI_aarch64_tty-copy = "${EPEL_MIRROR}/aarch64/Packages/t/tty-copy-0.2.2-6.el10_0.aarch64.rpm;name=aarch64_tty-copy;unpack=0"
SRC_URI:append = " ${URI_aarch64_tty-copy}"
SRC_URI[aarch64_tty-copy.sha256sum] = "8db7a71046ef2f0f12b470c66448946f7a04a5d92cb7d9b4485e34248ac399cb"

RDEPENDS:tty-copy = " \
 glibc \
 "
