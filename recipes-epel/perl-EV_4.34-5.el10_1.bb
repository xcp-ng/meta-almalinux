# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-EV"
PV = "4.34"
PR = "5.el10_1"
PACKAGES = " \
 perl-EV \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-EV-4.34-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6672dd593355b6d32ac87a16e2fd3db84d728288c3d9556c7ddc67fd98dd023d"

URI_x86_64_v2_perl-EV = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-EV-4.34-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-EV;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-EV}"
SRC_URI[x86_64_v2_perl-EV.sha256sum] = "a2b6ceffc8db19a76691ff4c4cdfd635f431aa0a4c33113079f87d1de27752d2"

URI_aarch64_perl-EV = "${EPEL_MIRROR}/aarch64/Packages/p/perl-EV-4.34-5.el10_1.aarch64.rpm;name=aarch64_perl-EV;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-EV}"
SRC_URI[aarch64_perl-EV.sha256sum] = "bc54dc7b7a9bb9cd492fed5ad78ebe05f1afc1a56417377c55cda8baf7307471"

RDEPENDS:perl-EV = " \
 glibc \
 perl-Exporter \
 perl-base \
 perl-common-sense \
 perl-libs \
 "
