# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-utils"
PV = "0.1.14"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-utils+bstr-devel \
 rust-gix-utils+default-devel \
 rust-gix-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-utils-0.1.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d932223aafa45f815ad71ee350753f0df6a6f7f727e3f497763b92889ef606c"

URI_x86_64_v2_rust-gix-utils+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-utils+bstr-devel-0.1.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-utils+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-utils+bstr-devel}"
SRC_URI[x86_64_v2_rust-gix-utils+bstr-devel.sha256sum] = "1ae032d30c8e0f7ea2e4d628da8b14e52dbb2f958aaf09e34115ff86417aff87"

URI_x86_64_v2_rust-gix-utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-utils+default-devel-0.1.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-utils+default-devel}"
SRC_URI[x86_64_v2_rust-gix-utils+default-devel.sha256sum] = "c5f10ec95c630f7860f2d67cc675a933ee97b40b13454e29dc1a2af44c82c76d"

URI_x86_64_v2_rust-gix-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-utils-devel-0.1.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-utils-devel}"
SRC_URI[x86_64_v2_rust-gix-utils-devel.sha256sum] = "62534edf1f7d90e6d0b29e5fbbdb152fcdfa9b8b5b77ade810557533a151e605"

URI_aarch64_rust-gix-utils+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-utils+bstr-devel-0.1.14-1.el10_0.noarch.rpm;name=aarch64_rust-gix-utils+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-utils+bstr-devel}"
SRC_URI[aarch64_rust-gix-utils+bstr-devel.sha256sum] = "75f351c9c529a8486fd42e45943495112f65f7b0d558d28448dc00959887e243"

URI_aarch64_rust-gix-utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-utils+default-devel-0.1.14-1.el10_0.noarch.rpm;name=aarch64_rust-gix-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-utils+default-devel}"
SRC_URI[aarch64_rust-gix-utils+default-devel.sha256sum] = "9f562ab23b02ef52f49dd9e140c120069884be2930896bb207c13f69633ff5e0"

URI_aarch64_rust-gix-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-utils-devel-0.1.14-1.el10_0.noarch.rpm;name=aarch64_rust-gix-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-utils-devel}"
SRC_URI[aarch64_rust-gix-utils-devel.sha256sum] = "b6e70a76dce69a7e5b84784fe1dbcdfe8c3c295b8e15a635241c0cf9751a4988"

RDEPENDS:rust-gix-utils+bstr-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-utils-devel \
 "
RDEPENDS:rust-gix-utils+default-devel = " \
 cargo \
 rust-gix-utils-devel \
 "
RDEPENDS:rust-gix-utils-devel = " \
 cargo \
 rust \
 rust-fastrand+default-devel \
 rust-unicode-normalization-devel \
 "
