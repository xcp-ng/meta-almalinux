# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-normalize-line-endings"
PV = "0.3.0"
PR = "15.el10_0"
PACKAGES = " \
 rust-normalize-line-endings+default-devel \
 rust-normalize-line-endings-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-normalize-line-endings-0.3.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f62b88fa511d983ede4c88db013c5a2f84315b32894a87c11b762c6c1cf4b42"

URI_x86_64_v2_rust-normalize-line-endings+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normalize-line-endings+default-devel-0.3.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normalize-line-endings+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-normalize-line-endings+default-devel}"
SRC_URI[x86_64_v2_rust-normalize-line-endings+default-devel.sha256sum] = "10247aaab6ef73ae6f851ae69054093ca32ba68e9f652e2a6fda7a1ea8439442"

URI_x86_64_v2_rust-normalize-line-endings-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normalize-line-endings-devel-0.3.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normalize-line-endings-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-normalize-line-endings-devel}"
SRC_URI[x86_64_v2_rust-normalize-line-endings-devel.sha256sum] = "b41330e12fb8c6dc6befcc272c6622f16e55f5b1630e6f45029367340a3f8cf6"

URI_aarch64_rust-normalize-line-endings+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-normalize-line-endings+default-devel-0.3.0-15.el10_0.noarch.rpm;name=aarch64_rust-normalize-line-endings+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-normalize-line-endings+default-devel}"
SRC_URI[aarch64_rust-normalize-line-endings+default-devel.sha256sum] = "3490cad5eab0727651b1b74b353d1801e64c351fd49c02b705312155f418622b"

URI_aarch64_rust-normalize-line-endings-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-normalize-line-endings-devel-0.3.0-15.el10_0.noarch.rpm;name=aarch64_rust-normalize-line-endings-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-normalize-line-endings-devel}"
SRC_URI[aarch64_rust-normalize-line-endings-devel.sha256sum] = "3dfddb4bd39df94e3cb09386fe74fad9df7b02b4eb38c895b4faef1031a1951e"

RDEPENDS:rust-normalize-line-endings+default-devel = " \
 cargo \
 rust-normalize-line-endings-devel \
 "
RDEPENDS:rust-normalize-line-endings-devel = " \
 cargo \
 "
