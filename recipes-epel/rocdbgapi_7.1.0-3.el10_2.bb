# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocdbgapi"
PV = "7.1.0"
PR = "3.el10_2"
PACKAGES:x86_64_v2 = " \
 rocdbgapi \
 rocdbgapi-devel \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rocdbgapi-7.1.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7909e0097c6794d896db8c14dd8bda98df2f74175a4736a1827d7631258ef555"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocdbgapi-7.1.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocdbgapi;unpack=0"
SRC_URI[x86_64_v2_rocdbgapi.sha256sum] = "a505313f82fe747b0fae29353571e434d5902592ae9e81ca6331c192135b700a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocdbgapi-devel-7.1.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocdbgapi-devel;unpack=0"
SRC_URI[x86_64_v2_rocdbgapi-devel.sha256sum] = "64fb7de9997c19aadcfd61f6b5591259c97e9bc3530c12126d077ea7303a86b0"

RDEPENDS:rocdbgapi = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-comgr \
 "
RDEPENDS:rocdbgapi-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 rocdbgapi \
 "
