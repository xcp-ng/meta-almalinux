# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spatialindex"
PV = "2.1.0"
PR = "4.el10_1"
PACKAGES = " \
 spatialindex \
 spatialindex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spatialindex-2.1.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "954286ea97dbd9ca78e6b450336acc53adcaae38a724f00eefd2b6b29f9ed46e"

URI_x86_64_v2_spatialindex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spatialindex-2.1.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spatialindex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spatialindex}"
SRC_URI[x86_64_v2_spatialindex.sha256sum] = "91b79f22abe67be1709f9f28204137eb62d90ed4b16ca49df860b43a55096bfa"

URI_x86_64_v2_spatialindex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spatialindex-devel-2.1.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spatialindex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spatialindex-devel}"
SRC_URI[x86_64_v2_spatialindex-devel.sha256sum] = "78ce494e058a630a04a552eb6f56f4711b9cb0a3dde54314fb500debe2db3c4a"

URI_aarch64_spatialindex = "${EPEL_MIRROR}/aarch64/Packages/s/spatialindex-2.1.0-4.el10_1.aarch64.rpm;name=aarch64_spatialindex;unpack=0"
SRC_URI:append = " ${URI_aarch64_spatialindex}"
SRC_URI[aarch64_spatialindex.sha256sum] = "79ddb502d8fd65b7d0e60a6a6a2522bf6a8a84421fa327f20b2f65f131ef4fb7"

URI_aarch64_spatialindex-devel = "${EPEL_MIRROR}/aarch64/Packages/s/spatialindex-devel-2.1.0-4.el10_1.aarch64.rpm;name=aarch64_spatialindex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_spatialindex-devel}"
SRC_URI[aarch64_spatialindex-devel.sha256sum] = "b3b768ea2ca94db60aa70a132633ba0dbad669bd9d068bb8510582d6e7c00bcd"

RDEPENDS:spatialindex = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:spatialindex-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 spatialindex \
 "
