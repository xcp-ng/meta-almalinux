# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chrono"
PV = "0.4.44"
PR = "1.el10_3"
PACKAGES = " \
 rust-chrono+alloc-devel \
 rust-chrono+arbitrary-devel \
 rust-chrono+clock-devel \
 rust-chrono+core-error-devel \
 rust-chrono+default-devel \
 rust-chrono+iana-time-zone-devel \
 rust-chrono+libc-devel \
 rust-chrono+now-devel \
 rust-chrono+oldtime-devel \
 rust-chrono+pure-rust-locales-devel \
 rust-chrono+rkyv-16-devel \
 rust-chrono+rkyv-32-devel \
 rust-chrono+rkyv-64-devel \
 rust-chrono+rkyv-devel \
 rust-chrono+rkyv-validation-devel \
 rust-chrono+serde-devel \
 rust-chrono+std-devel \
 rust-chrono+unstable-locales-devel \
 rust-chrono-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chrono-0.4.44-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a051093e60a53eea959b88e198891081470d17d2a7de13806dfa91468d18c103"

URI_x86_64_v2_rust-chrono+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+alloc-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+alloc-devel}"
SRC_URI[x86_64_v2_rust-chrono+alloc-devel.sha256sum] = "f4f5f663110c0d0fcee20bdaf13ecb9d3c8018bd9a3f5dce42bd9f48833085b6"

URI_x86_64_v2_rust-chrono+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+arbitrary-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-chrono+arbitrary-devel.sha256sum] = "50afd55c86cb18bcfd09f48559316b71900764d03fd2d3ca8c5aa5247716d640"

URI_x86_64_v2_rust-chrono+clock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+clock-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+clock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+clock-devel}"
SRC_URI[x86_64_v2_rust-chrono+clock-devel.sha256sum] = "7338d73def205b0f16afcaed35140b92153388d71733f18cc5f97740e83946e1"

URI_x86_64_v2_rust-chrono+core-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+core-error-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+core-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+core-error-devel}"
SRC_URI[x86_64_v2_rust-chrono+core-error-devel.sha256sum] = "e9eedcd5c3962d725b55607360538a1a68c7b1328a73e433c214b6a7b4263f40"

URI_x86_64_v2_rust-chrono+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+default-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+default-devel}"
SRC_URI[x86_64_v2_rust-chrono+default-devel.sha256sum] = "ed549f78dc88da155afd907fa0f1979a8feec841220d30f6608f5c24cf4a186b"

URI_x86_64_v2_rust-chrono+iana-time-zone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+iana-time-zone-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+iana-time-zone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+iana-time-zone-devel}"
SRC_URI[x86_64_v2_rust-chrono+iana-time-zone-devel.sha256sum] = "fe2278de67c151871cf73cceee1a97993b48ee0fe0ab18e54caeba71d96d6a7c"

URI_x86_64_v2_rust-chrono+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+libc-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+libc-devel}"
SRC_URI[x86_64_v2_rust-chrono+libc-devel.sha256sum] = "a2734bf6bfdccea2776ea40b9cc12d22f6190ccce5439e17779f20daced3cb94"

URI_x86_64_v2_rust-chrono+now-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+now-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+now-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+now-devel}"
SRC_URI[x86_64_v2_rust-chrono+now-devel.sha256sum] = "be43450d037728124e67bbfa0fe85b64e8d61c0cb414a0ce13ce70acae45c181"

URI_x86_64_v2_rust-chrono+oldtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+oldtime-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+oldtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+oldtime-devel}"
SRC_URI[x86_64_v2_rust-chrono+oldtime-devel.sha256sum] = "3d1441396c02c2a1fae195fcdaa0ac9547b9755e8b5a0e2b667ee39919510d0a"

URI_x86_64_v2_rust-chrono+pure-rust-locales-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+pure-rust-locales-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+pure-rust-locales-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+pure-rust-locales-devel}"
SRC_URI[x86_64_v2_rust-chrono+pure-rust-locales-devel.sha256sum] = "9d08d83fc21d136142716c9bd0d2f0b1b37f855134ea2971022e23966a8e711a"

URI_x86_64_v2_rust-chrono+rkyv-16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-16-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+rkyv-16-devel}"
SRC_URI[x86_64_v2_rust-chrono+rkyv-16-devel.sha256sum] = "85ba1898f44f32b64bd8ca7538b799aa43a1b98614c4e409cf14605dc8b849e3"

URI_x86_64_v2_rust-chrono+rkyv-32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-32-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+rkyv-32-devel}"
SRC_URI[x86_64_v2_rust-chrono+rkyv-32-devel.sha256sum] = "3e624f81ccfaec8c6ecdda1564358bb9bdfb2771ca2b19ca696431146bd9f34f"

URI_x86_64_v2_rust-chrono+rkyv-64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-64-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+rkyv-64-devel}"
SRC_URI[x86_64_v2_rust-chrono+rkyv-64-devel.sha256sum] = "d270b3d72a2d4f2d75abfcab85bdf1cc53f7abeb58052fd36bfee229b0334376"

URI_x86_64_v2_rust-chrono+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+rkyv-devel}"
SRC_URI[x86_64_v2_rust-chrono+rkyv-devel.sha256sum] = "021aca9cc54a51736b7ce939dfa9c28bb7b19760f689f7622ecc3856a5d950b9"

URI_x86_64_v2_rust-chrono+rkyv-validation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-validation-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-validation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+rkyv-validation-devel}"
SRC_URI[x86_64_v2_rust-chrono+rkyv-validation-devel.sha256sum] = "86991df77f7e887a743788a74f3e3a99e6663e6c421e38095517baea74dd51dc"

URI_x86_64_v2_rust-chrono+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+serde-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+serde-devel}"
SRC_URI[x86_64_v2_rust-chrono+serde-devel.sha256sum] = "783454cfbc480635bd818a3c2c5ea9fc2d1fcc0560a56368c2a3e9a305e224cc"

URI_x86_64_v2_rust-chrono+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+std-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+std-devel}"
SRC_URI[x86_64_v2_rust-chrono+std-devel.sha256sum] = "6c2daabc833a5e11ba246d8e48b25ec8eeb232e57f12630a2530ab252184204b"

URI_x86_64_v2_rust-chrono+unstable-locales-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+unstable-locales-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+unstable-locales-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+unstable-locales-devel}"
SRC_URI[x86_64_v2_rust-chrono+unstable-locales-devel.sha256sum] = "8efb8cc955d864de995babb2ca427f514e0bffc834e0a06893a1593ae2c73fee"

URI_x86_64_v2_rust-chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-devel-0.4.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-devel}"
SRC_URI[x86_64_v2_rust-chrono-devel.sha256sum] = "4107d58a03cecce84748a8e50c4a0c4e045298730c015c884cc37e8e54109b2b"

URI_aarch64_rust-chrono+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+alloc-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+alloc-devel}"
SRC_URI[aarch64_rust-chrono+alloc-devel.sha256sum] = "d4a23e89412b70e29245f873fef8588c01db8d63ad3235946cad2f84a3658c4a"

URI_aarch64_rust-chrono+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+arbitrary-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+arbitrary-devel}"
SRC_URI[aarch64_rust-chrono+arbitrary-devel.sha256sum] = "4a61cc390d0d87e2d7f93c043bc89f994048181575e2e899ddb5750c66fd0ca4"

URI_aarch64_rust-chrono+clock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+clock-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+clock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+clock-devel}"
SRC_URI[aarch64_rust-chrono+clock-devel.sha256sum] = "54c327b1f2ab45d03e5673f6a6fe63b81db4c3bcd5205cd2a4eabdc171f1c835"

URI_aarch64_rust-chrono+core-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+core-error-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+core-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+core-error-devel}"
SRC_URI[aarch64_rust-chrono+core-error-devel.sha256sum] = "c733ecf143c87c20ca35622553a5b49965a0c76bbe799e7499f1712cab00e2b7"

URI_aarch64_rust-chrono+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+default-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+default-devel}"
SRC_URI[aarch64_rust-chrono+default-devel.sha256sum] = "1fdd703d140c36efe5fa9bb20621aa56726ae4ada02054f1bf7a6f44491e67ce"

URI_aarch64_rust-chrono+iana-time-zone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+iana-time-zone-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+iana-time-zone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+iana-time-zone-devel}"
SRC_URI[aarch64_rust-chrono+iana-time-zone-devel.sha256sum] = "d276ee36bcfdbd14a92f9389c84ac2fe49262890b1be5a2284189c71d4417006"

URI_aarch64_rust-chrono+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+libc-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+libc-devel}"
SRC_URI[aarch64_rust-chrono+libc-devel.sha256sum] = "8f9abc85576e329e39757091ab705357bb99e6b39493237994c6552efaa1506e"

URI_aarch64_rust-chrono+now-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+now-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+now-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+now-devel}"
SRC_URI[aarch64_rust-chrono+now-devel.sha256sum] = "a09f564e061a9a5df322246ef3f6f772827b2a24626c6c0df59da81d92f74be0"

URI_aarch64_rust-chrono+oldtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+oldtime-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+oldtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+oldtime-devel}"
SRC_URI[aarch64_rust-chrono+oldtime-devel.sha256sum] = "7079806c05cd3df3e3f491481ab23f8e28acd4ef0509e046a7c0a7481f3a5a41"

URI_aarch64_rust-chrono+pure-rust-locales-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+pure-rust-locales-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+pure-rust-locales-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+pure-rust-locales-devel}"
SRC_URI[aarch64_rust-chrono+pure-rust-locales-devel.sha256sum] = "5000937fdcf4f4f0cb5f8334718aeefceac6d6109bcf2f4c6eaaab49c1e20873"

URI_aarch64_rust-chrono+rkyv-16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-16-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+rkyv-16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+rkyv-16-devel}"
SRC_URI[aarch64_rust-chrono+rkyv-16-devel.sha256sum] = "b306887f445c3f80c25436d8c3ea0d2f92bda2bd108b0ea5891efcf259a468ae"

URI_aarch64_rust-chrono+rkyv-32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-32-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+rkyv-32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+rkyv-32-devel}"
SRC_URI[aarch64_rust-chrono+rkyv-32-devel.sha256sum] = "969282b33562e84497ca2bebc2af7787a54f6ebda2cdef3d012d1b50c5c3f702"

URI_aarch64_rust-chrono+rkyv-64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-64-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+rkyv-64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+rkyv-64-devel}"
SRC_URI[aarch64_rust-chrono+rkyv-64-devel.sha256sum] = "12eb132fd2281c88cbbe92aad2c6499dc6d7fb5f56e681973b496cd16ff1092c"

URI_aarch64_rust-chrono+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+rkyv-devel}"
SRC_URI[aarch64_rust-chrono+rkyv-devel.sha256sum] = "080a0f90504799a2cb6a4fb51cb2c96ccc86e157bd09368d3eab5f4492a6026f"

URI_aarch64_rust-chrono+rkyv-validation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-validation-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+rkyv-validation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+rkyv-validation-devel}"
SRC_URI[aarch64_rust-chrono+rkyv-validation-devel.sha256sum] = "8bbedf4a9815425dfe4807b09709528a00e4f50aa2c96c9d268855ce5946be2a"

URI_aarch64_rust-chrono+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+serde-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+serde-devel}"
SRC_URI[aarch64_rust-chrono+serde-devel.sha256sum] = "bfa4a651aededcb876924170d4dde6a8cec171a07c47cc353d2e2cd902854fca"

URI_aarch64_rust-chrono+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+std-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+std-devel}"
SRC_URI[aarch64_rust-chrono+std-devel.sha256sum] = "f6a1b0f288b4abba9ad62c94eb89253c6492c930a943566300aa61270cd9f441"

URI_aarch64_rust-chrono+unstable-locales-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+unstable-locales-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono+unstable-locales-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+unstable-locales-devel}"
SRC_URI[aarch64_rust-chrono+unstable-locales-devel.sha256sum] = "141587b814b4f13f2d35563ba345710055110068eb70ed100c0622c8a1ce55ba"

URI_aarch64_rust-chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-devel-0.4.44-1.el10_3.noarch.rpm;name=aarch64_rust-chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-devel}"
SRC_URI[aarch64_rust-chrono-devel.sha256sum] = "139eb831c19c85cdb570551399a2dc3a8abfecd38f7388808895c1b95328e790"

RDEPENDS:rust-chrono+alloc-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+clock-devel = " \
 cargo \
 rust-chrono+iana-time-zone-devel \
 rust-chrono+now-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+core-error-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+default-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+oldtime-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+iana-time-zone-devel = " \
 cargo \
 rust-chrono-devel \
 rust-iana-time-zone+default-devel \
 rust-iana-time-zone+fallback-devel \
 "
RDEPENDS:rust-chrono+libc-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+now-devel = " \
 cargo \
 rust-chrono+std-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+oldtime-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+pure-rust-locales-devel = " \
 cargo \
 rust-chrono-devel \
 rust-pure-rust-locales+default-devel \
 "
RDEPENDS:rust-chrono+rkyv-16-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_16-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-32-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-64-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_64-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-validation-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+validation-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+serde-devel = " \
 cargo \
 rust-chrono-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-chrono+std-devel = " \
 cargo \
 rust-chrono+alloc-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+unstable-locales-devel = " \
 cargo \
 rust-chrono+pure-rust-locales-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono-devel = " \
 cargo \
 rust \
 rust-num-traits-devel \
 "
