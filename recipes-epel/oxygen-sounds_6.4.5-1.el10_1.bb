# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oxygen-sounds"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 oxygen-sounds \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/oxygen-sounds-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "78a3adf33ead512b36aef4c296c29077e4f51a66781e1c53a87da45f7b98dc51"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxygen-sounds-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_oxygen-sounds;unpack=0"
SRC_URI[x86_64_v2_oxygen-sounds.sha256sum] = "fefb0d3d3e3351c4a49a8148fdd047189e055b77e02b548ee26398b4173922fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/oxygen-sounds-6.4.5-1.el10_1.noarch.rpm;name=aarch64_oxygen-sounds;unpack=0"
SRC_URI[aarch64_oxygen-sounds.sha256sum] = "edae53703a2e5ee477ab8a6e60382b07259ee26465ef5f74c57b237218a6033c"

RDEPENDS:oxygen-sounds = " \
 "
