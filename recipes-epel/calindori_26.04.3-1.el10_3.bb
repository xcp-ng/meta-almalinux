# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "calindori"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 calindori \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/calindori-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b50d810263f4ea9b65e61750b5cdba01edc27f8cac9445d109ce3fd0dc899a6"

URI_x86_64_v2_calindori = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calindori-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calindori;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calindori}"
SRC_URI[x86_64_v2_calindori.sha256sum] = "ad1bf8d549f382ae85da5d3048361f8b2c8402d44d8eb14e84c1f91f40fc242b"

URI_aarch64_calindori = "${EPEL_MIRROR}/aarch64/Packages/c/calindori-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_calindori;unpack=0"
SRC_URI:append = " ${URI_aarch64_calindori}"
SRC_URI[aarch64_calindori.sha256sum] = "57fa6578c7029fb4146645f91275f8979fe0bcdb20cfb8f2a92d869edf4bb5ca"

RDEPENDS:calindori = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-knotifications \
 kf6-kpeople \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 "
