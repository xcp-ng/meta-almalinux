# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lhapdf"
PV = "6.5.6"
PR = "3.el10_3"
PACKAGES = " \
 lhapdf \
 lhapdf-devel \
 lhapdf-doc \
 python3-lhapdf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lhapdf-6.5.6-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "116d68e4abfd15f92635e3ace0f8907bfc0401bc67f89d65369c4b1734e09eb2"

URI_x86_64_v2_lhapdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lhapdf-6.5.6-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lhapdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lhapdf}"
SRC_URI[x86_64_v2_lhapdf.sha256sum] = "4f614d8f2d8e21fccd71b94e4b8e3455ed235f87edf4bd329641d323da461652"

URI_x86_64_v2_lhapdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lhapdf-devel-6.5.6-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lhapdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lhapdf-devel}"
SRC_URI[x86_64_v2_lhapdf-devel.sha256sum] = "8af49f03a2af4eef4a9bc0e02316ecb45bf0fb5bb7448183ebe41221b3ea8549"

URI_x86_64_v2_lhapdf-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lhapdf-doc-6.5.6-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lhapdf-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lhapdf-doc}"
SRC_URI[x86_64_v2_lhapdf-doc.sha256sum] = "d5362f421b73cc4fad4cd911d46da0cd959f40e55671488f7122f0f523ee51d6"

URI_x86_64_v2_python3-lhapdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lhapdf-6.5.6-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lhapdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lhapdf}"
SRC_URI[x86_64_v2_python3-lhapdf.sha256sum] = "d7558725b523e7805576afcdd24695f702d810c70f33e77ad14f566c4f360f2f"

URI_aarch64_lhapdf = "${EPEL_MIRROR}/aarch64/Packages/l/lhapdf-6.5.6-3.el10_3.aarch64.rpm;name=aarch64_lhapdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_lhapdf}"
SRC_URI[aarch64_lhapdf.sha256sum] = "f6c27faf5aaa3794cc29840b37e7644f6283b68f71d4a36c2b6300cc2ef815dd"

URI_aarch64_lhapdf-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lhapdf-devel-6.5.6-3.el10_3.aarch64.rpm;name=aarch64_lhapdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lhapdf-devel}"
SRC_URI[aarch64_lhapdf-devel.sha256sum] = "f0b68a14f59be273fb1339c9cdf3a8274ebb2904b02104db2cdeb242f390d85d"

URI_aarch64_lhapdf-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lhapdf-doc-6.5.6-3.el10_3.noarch.rpm;name=aarch64_lhapdf-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lhapdf-doc}"
SRC_URI[aarch64_lhapdf-doc.sha256sum] = "97a123e3f701f4740a14c0f432717090c3dd6bb7cde7a38b049e87df4c2fbaf8"

URI_aarch64_python3-lhapdf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lhapdf-6.5.6-3.el10_3.aarch64.rpm;name=aarch64_python3-lhapdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lhapdf}"
SRC_URI[aarch64_python3-lhapdf.sha256sum] = "72502019aa930c44e70c03f7de36e1ffa8df4ab942314eeef602906917e0bcfe"

RDEPENDS:lhapdf = " \
 glibc \
 libgcc \
 libstdc++ \
 yaml-cpp \
 "
RDEPENDS:lhapdf-devel = " \
 bash \
 lhapdf \
 pkgconf-pkg-config \
 yaml-cpp-devel \
 "
RDEPENDS:lhapdf-doc = " \
 "
RDEPENDS:python3-lhapdf = " \
 glibc \
 lhapdf \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 "
