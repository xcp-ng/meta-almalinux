# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-crypt"
PV = "0.7.0"
PR = "2.el10_0"
PACKAGES = " \
 git-crypt \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/git-crypt-0.7.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c61606521507c473c66fa3d0021a0619ddaa0a20491859d3296e51cc93e128e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-crypt-0.7.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_git-crypt;unpack=0"
SRC_URI[x86_64_v2_git-crypt.sha256sum] = "438cbc9027f9f9065ef74b1339012f5a7e9d53d8f44c4eb88a47b6169992b322"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/git-crypt-0.7.0-2.el10_0.aarch64.rpm;name=aarch64_git-crypt;unpack=0"
SRC_URI[aarch64_git-crypt.sha256sum] = "21ae1d45ab3319bd37600d02f8596dc5aab29f140809563331bfd07724cf75f2"

RDEPENDS:git-crypt = " \
 git \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 "
