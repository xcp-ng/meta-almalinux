# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openexr"
PV = "3.1.10"
PR = "8.el10_2.3"
PACKAGES = " \
 openexr \
 openexr-devel \
 openexr-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openexr-3.1.10-8.el10_2.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed7c4aceae122a1c52b73528aa0b072c9c9f2c06f871dee65300ede4f2c37e5d"

URI_x86_64_v2_openexr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openexr-3.1.10-8.el10_2.3.x86_64_v2.rpm;name=x86_64_v2_openexr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openexr}"
SRC_URI[x86_64_v2_openexr.sha256sum] = "422a266407251cc04240c86fd5f7b3dee937f8c8ca75b65213907068dcee7f87"

URI_x86_64_v2_openexr-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openexr-devel-3.1.10-8.el10_2.3.x86_64_v2.rpm;name=x86_64_v2_openexr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openexr-devel}"
SRC_URI[x86_64_v2_openexr-devel.sha256sum] = "91018c018c6c85306d92f0f5539e43c0edace708f0969b3185b71595c29e3478"

URI_x86_64_v2_openexr-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openexr-libs-3.1.10-8.el10_2.3.x86_64_v2.rpm;name=x86_64_v2_openexr-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openexr-libs}"
SRC_URI[x86_64_v2_openexr-libs.sha256sum] = "ed9b3c64de669c6b9ab6ce83043f40e4798d692eff95eb75360cc09a95961b86"

URI_aarch64_openexr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openexr-3.1.10-8.el10_2.3.aarch64.rpm;name=aarch64_openexr;unpack=0"
SRC_URI:append = " ${URI_aarch64_openexr}"
SRC_URI[aarch64_openexr.sha256sum] = "ec0c70315ee9f49040f681483c97564a0245807be5c74a501f870b08906d2e11"

URI_aarch64_openexr-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openexr-devel-3.1.10-8.el10_2.3.aarch64.rpm;name=aarch64_openexr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openexr-devel}"
SRC_URI[aarch64_openexr-devel.sha256sum] = "e9c051555c4d1016b9decd509b6d25dc4aa1ee8fdac211717a9f6d763ef6390b"

URI_aarch64_openexr-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openexr-libs-3.1.10-8.el10_2.3.aarch64.rpm;name=aarch64_openexr-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_openexr-libs}"
SRC_URI[aarch64_openexr-libs.sha256sum] = "12d30931de62ed26cbc852d0e4300a55f06140c64dcf5de40df2ced399cdde24"

RDEPENDS:openexr = " \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 openexr-libs \
 "
RDEPENDS:openexr-devel = " \
 cmake-filesystem \
 imath-devel \
 openexr-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openexr-libs = " \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
