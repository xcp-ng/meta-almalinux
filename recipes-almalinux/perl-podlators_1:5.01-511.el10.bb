# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-podlators"
PE = "1"
PV = "5.01"
PR = "511.el10"
PACKAGES = " \
 perl-podlators \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-podlators-5.01-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65f6bb339c84b44dbd492e3d2639c703b71dbb1df23b5f44c6e795f755f47f87"

URI_x86_64_v2_perl-podlators = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-podlators-5.01-511.el10.noarch.rpm;name=x86_64_v2_perl-podlators;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-podlators}"
SRC_URI[x86_64_v2_perl-podlators.sha256sum] = "0a91f03c8a56457bb7d9a11eebc0a6cbe714d2ba3db9a5c7b38e8895d59934a0"

URI_aarch64_perl-podlators = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-podlators-5.01-511.el10.noarch.rpm;name=aarch64_perl-podlators;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-podlators}"
SRC_URI[aarch64_perl-podlators.sha256sum] = "0a91f03c8a56457bb7d9a11eebc0a6cbe714d2ba3db9a5c7b38e8895d59934a0"

RDEPENDS:perl-podlators = " \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Simple \
 perl-Pod-Usage \
 perl-Term-ANSIColor \
 perl-Term-Cap \
 perl-interpreter \
 perl-libs \
 perl-podlators \
 "
