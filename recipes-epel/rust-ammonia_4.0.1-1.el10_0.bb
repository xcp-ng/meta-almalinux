# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ammonia"
PV = "4.0.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-ammonia+default-devel \
 rust-ammonia-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ammonia-4.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2965eb335ec51e4e5b3dbdfb8d08a1e817deeaf89a755ab856145d4537df8035"

URI_x86_64_v2_rust-ammonia+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ammonia+default-devel-4.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ammonia+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ammonia+default-devel}"
SRC_URI[x86_64_v2_rust-ammonia+default-devel.sha256sum] = "85305fec1f6a5b314d9a01584cb33a41bb5ac0574d13194dee611d5daa145845"

URI_x86_64_v2_rust-ammonia-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ammonia-devel-4.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ammonia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ammonia-devel}"
SRC_URI[x86_64_v2_rust-ammonia-devel.sha256sum] = "c8031a7e093948ddfbafcb2a79c6253454c58763f17dda6b5e5aa33ba75c8e99"

URI_aarch64_rust-ammonia+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ammonia+default-devel-4.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-ammonia+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ammonia+default-devel}"
SRC_URI[aarch64_rust-ammonia+default-devel.sha256sum] = "740449b472ab101486b6a11ee7f90806852ae3f5e8191dc7ddf5c7b50c3a45eb"

URI_aarch64_rust-ammonia-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ammonia-devel-4.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-ammonia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ammonia-devel}"
SRC_URI[aarch64_rust-ammonia-devel.sha256sum] = "88b9968ddfc9310df4cd3d1ec1da2696ca08e9754f65b3416525208bf1faebeb"

RDEPENDS:rust-ammonia+default-devel = " \
 cargo \
 rust-ammonia-devel \
 "
RDEPENDS:rust-ammonia-devel = " \
 cargo \
 rust \
 rust-html5ever+default-devel \
 rust-maplit+default-devel \
 rust-once_cell+default-devel \
 rust-tendril+default-devel \
 rust-url+default-devel \
 "
