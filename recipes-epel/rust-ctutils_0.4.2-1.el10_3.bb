# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ctutils"
PV = "0.4.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-ctutils+alloc-devel \
 rust-ctutils+default-devel \
 rust-ctutils+subtle-devel \
 rust-ctutils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ctutils-0.4.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49cc6530c89eee2ea5d5f0ece73b3568af6bb021168592d95cf86f80624c5485"

URI_x86_64_v2_rust-ctutils+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctutils+alloc-devel-0.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctutils+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctutils+alloc-devel}"
SRC_URI[x86_64_v2_rust-ctutils+alloc-devel.sha256sum] = "c8936e14674e6bb0b7f747053f26ff438b8c86883aa5167c661585d8115bdf38"

URI_x86_64_v2_rust-ctutils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctutils+default-devel-0.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctutils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctutils+default-devel}"
SRC_URI[x86_64_v2_rust-ctutils+default-devel.sha256sum] = "d24076e1e68d97dc2411438f9d4fe5b9448b07bc90fa4e016cfe09ede789f44a"

URI_x86_64_v2_rust-ctutils+subtle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctutils+subtle-devel-0.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctutils+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctutils+subtle-devel}"
SRC_URI[x86_64_v2_rust-ctutils+subtle-devel.sha256sum] = "6fd9aee247cecc06f0240ad1fe4a9545b1f76cd4f4b77115ca139e45e678e825"

URI_x86_64_v2_rust-ctutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctutils-devel-0.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctutils-devel}"
SRC_URI[x86_64_v2_rust-ctutils-devel.sha256sum] = "289bfff4e516c264995838d4f8bb0a84e68f056429fe708ff6c33418405fadb7"

URI_aarch64_rust-ctutils+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctutils+alloc-devel-0.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-ctutils+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctutils+alloc-devel}"
SRC_URI[aarch64_rust-ctutils+alloc-devel.sha256sum] = "bd308e27ff3bfa73579717f23e0828adc1ee9c4f611b7c5c622ab24d58444178"

URI_aarch64_rust-ctutils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctutils+default-devel-0.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-ctutils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctutils+default-devel}"
SRC_URI[aarch64_rust-ctutils+default-devel.sha256sum] = "a47f2487cea0e775df058042bbed7c492a6d212acf4547e1c8782d40115c907d"

URI_aarch64_rust-ctutils+subtle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctutils+subtle-devel-0.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-ctutils+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctutils+subtle-devel}"
SRC_URI[aarch64_rust-ctutils+subtle-devel.sha256sum] = "59832eef54beee8f55c9731c02a95a0485b1e53d2f11d13cd421705fa435fc02"

URI_aarch64_rust-ctutils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctutils-devel-0.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-ctutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctutils-devel}"
SRC_URI[aarch64_rust-ctutils-devel.sha256sum] = "12108f187359193af782115a3f7eb72e1ca15dbd84668cb5e538b161327b8919"

RDEPENDS:rust-ctutils+alloc-devel = " \
 cargo \
 rust-ctutils-devel \
 "
RDEPENDS:rust-ctutils+default-devel = " \
 cargo \
 rust-ctutils-devel \
 "
RDEPENDS:rust-ctutils+subtle-devel = " \
 cargo \
 rust-ctutils-devel \
 rust-subtle-devel \
 "
RDEPENDS:rust-ctutils-devel = " \
 cargo \
 rust \
 rust-cmov+default-devel \
 "
