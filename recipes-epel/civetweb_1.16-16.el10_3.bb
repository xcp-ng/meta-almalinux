# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "civetweb"
PV = "1.16"
PR = "16.el10_3"
PACKAGES = " \
 civetweb \
 civetweb-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/civetweb-1.16-16.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d63b9938e1eb121be74fb1b22a7be77936f9ab00e04966ff9cb03eb59e604cf5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/civetweb-1.16-16.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_civetweb;unpack=0"
SRC_URI[x86_64_v2_civetweb.sha256sum] = "13453403e3e32e521aa066a266abd8c1c56c8830ac174b5a05eeab6ca70232f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/civetweb-devel-1.16-16.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_civetweb-devel;unpack=0"
SRC_URI[x86_64_v2_civetweb-devel.sha256sum] = "a8df775c458dfa9b43e22e8e00011c073261606a939c146aaa8491d5f4ca45f2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/civetweb-1.16-16.el10_3.aarch64.rpm;name=aarch64_civetweb;unpack=0"
SRC_URI[aarch64_civetweb.sha256sum] = "eaee150499c41e1345c91f3930c9de511fc437d403bf737223b0c0b229b0d866"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/civetweb-devel-1.16-16.el10_3.aarch64.rpm;name=aarch64_civetweb-devel;unpack=0"
SRC_URI[aarch64_civetweb-devel.sha256sum] = "f70a2a02dd814d5cdb3effc3161cc2b98cebcf3cf88c170bd68d2e4ddb4701f8"

RDEPENDS:civetweb = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:civetweb-devel = " \
 civetweb \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
