# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-numpy"
PV = "2.3.4"
PR = "1.el10"
PACKAGES = " \
 python3.14-numpy \
 python3.14-numpy-f2py \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-numpy-2.3.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "758bc8424f02a95f748920311dbdbc874b6b3fca9788b2f6f4737d5f667fb1f2"

URI_x86_64_v2_python3.14-numpy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-numpy-2.3.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-numpy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-numpy}"
SRC_URI[x86_64_v2_python3.14-numpy.sha256sum] = "310dd8604d7bed0656647fa8efd86c5ab2adbb576c0a3fd8e06f982b0196bdef"

URI_x86_64_v2_python3.14-numpy-f2py = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-numpy-f2py-2.3.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-numpy-f2py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-numpy-f2py}"
SRC_URI[x86_64_v2_python3.14-numpy-f2py.sha256sum] = "53848a09724f980b86919a48d7f482a03ad07a17075a74e216c0837c8317635f"

URI_aarch64_python3.14-numpy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-numpy-2.3.4-1.el10.aarch64.rpm;name=aarch64_python3.14-numpy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-numpy}"
SRC_URI[aarch64_python3.14-numpy.sha256sum] = "1a669c6f044a522df823fb8d3c17a193836ed2855968301d40fdb8600e153031"

URI_aarch64_python3.14-numpy-f2py = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-numpy-f2py-2.3.4-1.el10.aarch64.rpm;name=aarch64_python3.14-numpy-f2py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-numpy-f2py}"
SRC_URI[aarch64_python3.14-numpy-f2py.sha256sum] = "69e87f9bc593852c229c8c6d182853efa8729acfd2bc11e62838d90cc88b83c3"

RDEPENDS:python3.14-numpy = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3.14 \
 python3.14-numpy-f2py \
 "
RDEPENDS:python3.14-numpy-f2py = " \
 python3.14 \
 python3.14-devel \
 python3.14-numpy \
 "
