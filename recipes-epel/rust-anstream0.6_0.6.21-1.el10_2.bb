# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstream0.6"
PV = "0.6.21"
PR = "1.el10_2"
PACKAGES = " \
 rust-anstream0.6+auto-devel \
 rust-anstream0.6+default-devel \
 rust-anstream0.6+test-devel \
 rust-anstream0.6+wincon-devel \
 rust-anstream0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstream0.6-0.6.21-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d83b0fb95e410f2f0768b038116446eb2f08b741f3eb4cb21eea9b472bfa1f63"

URI_x86_64_v2_rust-anstream0.6+auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream0.6+auto-devel-0.6.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream0.6+auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream0.6+auto-devel}"
SRC_URI[x86_64_v2_rust-anstream0.6+auto-devel.sha256sum] = "d2dbdecfa801b26e3c52049e577d4c804e79728839e6d414cd07f33e53cac1b0"

URI_x86_64_v2_rust-anstream0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream0.6+default-devel-0.6.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream0.6+default-devel}"
SRC_URI[x86_64_v2_rust-anstream0.6+default-devel.sha256sum] = "0d74b2688f33af3256a6112ff29586755d29710945ae25d2f9bd304091ee5451"

URI_x86_64_v2_rust-anstream0.6+test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream0.6+test-devel-0.6.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream0.6+test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream0.6+test-devel}"
SRC_URI[x86_64_v2_rust-anstream0.6+test-devel.sha256sum] = "5e5dc873d1adc50aaff325817418b4914dcc513988b5c4755fdc8d7a410a443a"

URI_x86_64_v2_rust-anstream0.6+wincon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream0.6+wincon-devel-0.6.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream0.6+wincon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream0.6+wincon-devel}"
SRC_URI[x86_64_v2_rust-anstream0.6+wincon-devel.sha256sum] = "5f6e14e2b2f0d2ec59fae1e4881fab7ccf0c63c80d4f4345a701002251cc9daf"

URI_x86_64_v2_rust-anstream0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream0.6-devel-0.6.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream0.6-devel}"
SRC_URI[x86_64_v2_rust-anstream0.6-devel.sha256sum] = "c573afebe59a97fb4fb64bc9252d264f0693f7d50ee163599d2c1a430175e6c4"

URI_aarch64_rust-anstream0.6+auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream0.6+auto-devel-0.6.21-1.el10_2.noarch.rpm;name=aarch64_rust-anstream0.6+auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream0.6+auto-devel}"
SRC_URI[aarch64_rust-anstream0.6+auto-devel.sha256sum] = "f2b2199ecd9b6e69ad3234d8430dfa4066a6fefc09a54ca50e461c5575e65d2f"

URI_aarch64_rust-anstream0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream0.6+default-devel-0.6.21-1.el10_2.noarch.rpm;name=aarch64_rust-anstream0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream0.6+default-devel}"
SRC_URI[aarch64_rust-anstream0.6+default-devel.sha256sum] = "8925571372429a7a6fd0944a3016ecd4e803981d7c17b0a2d703b25dd2e0b28a"

URI_aarch64_rust-anstream0.6+test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream0.6+test-devel-0.6.21-1.el10_2.noarch.rpm;name=aarch64_rust-anstream0.6+test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream0.6+test-devel}"
SRC_URI[aarch64_rust-anstream0.6+test-devel.sha256sum] = "ba1465efd8b35e1a75c2255dc7fc0ececb0509982990bca7b52131be5a9d17c0"

URI_aarch64_rust-anstream0.6+wincon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream0.6+wincon-devel-0.6.21-1.el10_2.noarch.rpm;name=aarch64_rust-anstream0.6+wincon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream0.6+wincon-devel}"
SRC_URI[aarch64_rust-anstream0.6+wincon-devel.sha256sum] = "c339625d6690fb1ea1b4772aef50bef2be7585ab4f1b6a616e4c66a95de82221"

URI_aarch64_rust-anstream0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream0.6-devel-0.6.21-1.el10_2.noarch.rpm;name=aarch64_rust-anstream0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream0.6-devel}"
SRC_URI[aarch64_rust-anstream0.6-devel.sha256sum] = "b2fe2d7df4af5a408fe17c07b8350056835bd3a0a1f5bb2e69cd8d8dd876818e"

RDEPENDS:rust-anstream0.6+auto-devel = " \
 cargo \
 rust-anstream0.6-devel \
 rust-anstyle-query+default-devel \
 "
RDEPENDS:rust-anstream0.6+default-devel = " \
 cargo \
 rust-anstream0.6+auto-devel \
 rust-anstream0.6+wincon-devel \
 rust-anstream0.6-devel \
 "
RDEPENDS:rust-anstream0.6+test-devel = " \
 cargo \
 rust-anstream0.6-devel \
 "
RDEPENDS:rust-anstream0.6+wincon-devel = " \
 cargo \
 rust-anstream0.6-devel \
 "
RDEPENDS:rust-anstream0.6-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-anstyle-parse0.2+default-devel \
 rust-colorchoice+default-devel \
 rust-utf8parse+default-devel \
 "
