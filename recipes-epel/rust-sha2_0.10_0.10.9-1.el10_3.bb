# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sha2_0.10"
PV = "0.10.9"
PR = "1.el10_3"
PACKAGES = " \
 rust-sha2_0.10+asm-aarch64-devel \
 rust-sha2_0.10+asm-devel \
 rust-sha2_0.10+compress-devel \
 rust-sha2_0.10+default-devel \
 rust-sha2_0.10+force-soft-compact-devel \
 rust-sha2_0.10+force-soft-devel \
 rust-sha2_0.10+loongarch64_asm-devel \
 rust-sha2_0.10+oid-devel \
 rust-sha2_0.10+sha2-asm-devel \
 rust-sha2_0.10+std-devel \
 rust-sha2_0.10-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sha2_0.10-0.10.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4231cbdfa791a5a028b90f18d5b035684ed185e7af91d19d050dd82d7a24a8c9"

URI_x86_64_v2_rust-sha2_0.10+asm-aarch64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2_0.10+asm-aarch64-devel-0.10.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2_0.10+asm-aarch64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2_0.10+asm-aarch64-devel}"
SRC_URI[x86_64_v2_rust-sha2_0.10+asm-aarch64-devel.sha256sum] = "98b0712402c66b04f4e7190520682b53b91c10057e23b39a4b0c00346a1d205c"

URI_x86_64_v2_rust-sha2_0.10+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2_0.10+asm-devel-0.10.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2_0.10+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2_0.10+asm-devel}"
SRC_URI[x86_64_v2_rust-sha2_0.10+asm-devel.sha256sum] = "7d5b3262e319cd6b599ca08cff1a908f3ff4b082a1c1ca48cae242fe106035f1"

URI_x86_64_v2_rust-sha2_0.10+compress-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2_0.10+compress-devel-0.10.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2_0.10+compress-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2_0.10+compress-devel}"
SRC_URI[x86_64_v2_rust-sha2_0.10+compress-devel.sha256sum] = "e034eb830737eea91127e2f3cec5cb89e79dba7d6b58310b1d9d1541cbce3332"

URI_x86_64_v2_rust-sha2_0.10+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2_0.10+default-devel-0.10.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2_0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2_0.10+default-devel}"
SRC_URI[x86_64_v2_rust-sha2_0.10+default-devel.sha256sum] = "bf68916595440f0aa6a4196390814013ff6765938f522ad11d263ec79625d02c"

URI_x86_64_v2_rust-sha2_0.10+force-soft-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2_0.10+force-soft-compact-devel-0.10.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2_0.10+force-soft-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2_0.10+force-soft-compact-devel}"
SRC_URI[x86_64_v2_rust-sha2_0.10+force-soft-compact-devel.sha256sum] = "588f574f653ea9d1034c1ba0d4f3443cf6f55d5f4d331baa29ca70a7e01f1823"

URI_x86_64_v2_rust-sha2_0.10+force-soft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2_0.10+force-soft-devel-0.10.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2_0.10+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2_0.10+force-soft-devel}"
SRC_URI[x86_64_v2_rust-sha2_0.10+force-soft-devel.sha256sum] = "efb749769d0ba66a8a7d899dde9b53c84599492d294e06395e4f011325459e41"

URI_x86_64_v2_rust-sha2_0.10+loongarch64_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2_0.10+loongarch64_asm-devel-0.10.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2_0.10+loongarch64_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2_0.10+loongarch64_asm-devel}"
SRC_URI[x86_64_v2_rust-sha2_0.10+loongarch64_asm-devel.sha256sum] = "361c85a236b8a9879826dc7470ff740343f7e65952fb2de4c79394dae261d62f"

URI_x86_64_v2_rust-sha2_0.10+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2_0.10+oid-devel-0.10.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2_0.10+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2_0.10+oid-devel}"
SRC_URI[x86_64_v2_rust-sha2_0.10+oid-devel.sha256sum] = "e380b2623ff51927c68d2805906577f78fc10b43753bf0be11517f463bbbe8b5"

URI_x86_64_v2_rust-sha2_0.10+sha2-asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2_0.10+sha2-asm-devel-0.10.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2_0.10+sha2-asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2_0.10+sha2-asm-devel}"
SRC_URI[x86_64_v2_rust-sha2_0.10+sha2-asm-devel.sha256sum] = "abf94a91653ea12dc7c2a104d388b43a397e36584579bbaf6e33be25c06c293c"

URI_x86_64_v2_rust-sha2_0.10+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2_0.10+std-devel-0.10.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2_0.10+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2_0.10+std-devel}"
SRC_URI[x86_64_v2_rust-sha2_0.10+std-devel.sha256sum] = "a7afec3e85371b44ec5888eaa3cc5f2654d9ccd4808253b8e6927f8c535ae5df"

URI_x86_64_v2_rust-sha2_0.10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2_0.10-devel-0.10.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2_0.10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2_0.10-devel}"
SRC_URI[x86_64_v2_rust-sha2_0.10-devel.sha256sum] = "40a75d9fe3d0abf2fb7a7ec1d84e2dff8ce56a6e21483fd36c03a6bb69809f2f"

URI_aarch64_rust-sha2_0.10+asm-aarch64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2_0.10+asm-aarch64-devel-0.10.9-1.el10_3.noarch.rpm;name=aarch64_rust-sha2_0.10+asm-aarch64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2_0.10+asm-aarch64-devel}"
SRC_URI[aarch64_rust-sha2_0.10+asm-aarch64-devel.sha256sum] = "c41e748bc58b530834d0cf9ff5226a9ec60ab3b1fd958d49343041c652644ca0"

URI_aarch64_rust-sha2_0.10+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2_0.10+asm-devel-0.10.9-1.el10_3.noarch.rpm;name=aarch64_rust-sha2_0.10+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2_0.10+asm-devel}"
SRC_URI[aarch64_rust-sha2_0.10+asm-devel.sha256sum] = "c74da00b4b85a9130d6892f239fa33c823ab52f7f1efc38e3b66d8e8caf0643f"

URI_aarch64_rust-sha2_0.10+compress-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2_0.10+compress-devel-0.10.9-1.el10_3.noarch.rpm;name=aarch64_rust-sha2_0.10+compress-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2_0.10+compress-devel}"
SRC_URI[aarch64_rust-sha2_0.10+compress-devel.sha256sum] = "42a827f1362289dd92ea27909218bfbf68da58d1cc616d757b8cff128eb5c9bd"

URI_aarch64_rust-sha2_0.10+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2_0.10+default-devel-0.10.9-1.el10_3.noarch.rpm;name=aarch64_rust-sha2_0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2_0.10+default-devel}"
SRC_URI[aarch64_rust-sha2_0.10+default-devel.sha256sum] = "302763c455bcf54ba44577256906e6464d3aa8d2f61cfc00511f1736214b44cf"

URI_aarch64_rust-sha2_0.10+force-soft-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2_0.10+force-soft-compact-devel-0.10.9-1.el10_3.noarch.rpm;name=aarch64_rust-sha2_0.10+force-soft-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2_0.10+force-soft-compact-devel}"
SRC_URI[aarch64_rust-sha2_0.10+force-soft-compact-devel.sha256sum] = "466d8e6511b5740f4a405387a1ba23ff0a5ccea80139e9846442fc37f887bf4e"

URI_aarch64_rust-sha2_0.10+force-soft-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2_0.10+force-soft-devel-0.10.9-1.el10_3.noarch.rpm;name=aarch64_rust-sha2_0.10+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2_0.10+force-soft-devel}"
SRC_URI[aarch64_rust-sha2_0.10+force-soft-devel.sha256sum] = "9d36b1ce9c6a10e17a67dce3b8897da37b41914555121692c9624d37b5442ab1"

URI_aarch64_rust-sha2_0.10+loongarch64_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2_0.10+loongarch64_asm-devel-0.10.9-1.el10_3.noarch.rpm;name=aarch64_rust-sha2_0.10+loongarch64_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2_0.10+loongarch64_asm-devel}"
SRC_URI[aarch64_rust-sha2_0.10+loongarch64_asm-devel.sha256sum] = "fa0b1a672a39f82456a572c9b255f8200f98dc0c616b279237c83c1e16552909"

URI_aarch64_rust-sha2_0.10+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2_0.10+oid-devel-0.10.9-1.el10_3.noarch.rpm;name=aarch64_rust-sha2_0.10+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2_0.10+oid-devel}"
SRC_URI[aarch64_rust-sha2_0.10+oid-devel.sha256sum] = "fc0209b731e09f42822840c3f2aef119ff78afc85f681d55a305160c98660b7a"

URI_aarch64_rust-sha2_0.10+sha2-asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2_0.10+sha2-asm-devel-0.10.9-1.el10_3.noarch.rpm;name=aarch64_rust-sha2_0.10+sha2-asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2_0.10+sha2-asm-devel}"
SRC_URI[aarch64_rust-sha2_0.10+sha2-asm-devel.sha256sum] = "fd2b4c36fe8d6ca6838e277629a4333c6103ab03b52c781e0304ec12480dfd32"

URI_aarch64_rust-sha2_0.10+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2_0.10+std-devel-0.10.9-1.el10_3.noarch.rpm;name=aarch64_rust-sha2_0.10+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2_0.10+std-devel}"
SRC_URI[aarch64_rust-sha2_0.10+std-devel.sha256sum] = "bee09ae9b5aaff678d7371aff2fd74698e5e6ff1d13788fdfcac3d3b004a6dc1"

URI_aarch64_rust-sha2_0.10-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2_0.10-devel-0.10.9-1.el10_3.noarch.rpm;name=aarch64_rust-sha2_0.10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2_0.10-devel}"
SRC_URI[aarch64_rust-sha2_0.10-devel.sha256sum] = "22373ed7882eca949a496568bad038ce6b59b6b02360d4a825203d48614fd7a1"

RDEPENDS:rust-sha2_0.10+asm-aarch64-devel = " \
 cargo \
 rust-sha2_0.10+asm-devel \
 rust-sha2_0.10-devel \
 "
RDEPENDS:rust-sha2_0.10+asm-devel = " \
 cargo \
 rust-sha2_0.10+sha2-asm-devel \
 rust-sha2_0.10-devel \
 "
RDEPENDS:rust-sha2_0.10+compress-devel = " \
 cargo \
 rust-sha2_0.10-devel \
 "
RDEPENDS:rust-sha2_0.10+default-devel = " \
 cargo \
 rust-sha2_0.10+std-devel \
 rust-sha2_0.10-devel \
 "
RDEPENDS:rust-sha2_0.10+force-soft-compact-devel = " \
 cargo \
 rust-sha2_0.10-devel \
 "
RDEPENDS:rust-sha2_0.10+force-soft-devel = " \
 cargo \
 rust-sha2_0.10-devel \
 "
RDEPENDS:rust-sha2_0.10+loongarch64_asm-devel = " \
 cargo \
 rust-sha2_0.10-devel \
 "
RDEPENDS:rust-sha2_0.10+oid-devel = " \
 cargo \
 rust-digest0.10+oid-devel \
 rust-sha2_0.10-devel \
 "
RDEPENDS:rust-sha2_0.10+sha2-asm-devel = " \
 cargo \
 rust-sha2-asm+default-devel \
 rust-sha2_0.10-devel \
 "
RDEPENDS:rust-sha2_0.10+std-devel = " \
 cargo \
 rust-digest0.10+std-devel \
 rust-sha2_0.10-devel \
 "
RDEPENDS:rust-sha2_0.10-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-cpufeatures0.2+default-devel \
 rust-digest0.10+default-devel \
 "
