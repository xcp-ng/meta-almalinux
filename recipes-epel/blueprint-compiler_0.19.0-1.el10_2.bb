# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "blueprint-compiler"
PV = "0.19.0"
PR = "1.el10_2"
PACKAGES = " \
 blueprint-compiler \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/blueprint-compiler-0.19.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "295f439ccb8e1a3f843ca133b42539cae78d3c5c6444db0e9ff9089654fc480b"

URI_x86_64_v2_blueprint-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blueprint-compiler-0.19.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_blueprint-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blueprint-compiler}"
SRC_URI[x86_64_v2_blueprint-compiler.sha256sum] = "c3bc6516d0901dcafdc37a0b77873333082bf8381bdd4dcd6ddbf901653ba1aa"

URI_aarch64_blueprint-compiler = "${EPEL_MIRROR}/aarch64/Packages/b/blueprint-compiler-0.19.0-1.el10_2.noarch.rpm;name=aarch64_blueprint-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_blueprint-compiler}"
SRC_URI[aarch64_blueprint-compiler.sha256sum] = "cf3b739f2bebc803fc4b7404823019ed38e5a24b0afce04bf99f722b1b378f1f"

RDEPENDS:blueprint-compiler = " \
 pkgconf-pkg-config \
 python3 \
 python3-gobject-devel \
 "
