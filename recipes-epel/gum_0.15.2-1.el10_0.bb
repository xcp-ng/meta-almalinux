# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gum"
PV = "0.15.2"
PR = "1.el10_0"
PACKAGES = " \
 gum \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gum-0.15.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6b060a94dcc50186521e29da0f6a646e87e8def54c0639cbb318572ff64447e"

URI_x86_64_v2_gum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gum-0.15.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gum}"
SRC_URI[x86_64_v2_gum.sha256sum] = "30e09f22ffd496021566bb01e376a6b176450b5ec6453e03a52e2e2e51cf745e"

URI_aarch64_gum = "${EPEL_MIRROR}/aarch64/Packages/g/gum-0.15.2-1.el10_0.aarch64.rpm;name=aarch64_gum;unpack=0"
SRC_URI:append = " ${URI_aarch64_gum}"
SRC_URI[aarch64_gum.sha256sum] = "2cabf9d92220434e7f1e8ba79489d91af8d41e3bb05efeee71a09b5e3ad17a99"

RDEPENDS:gum = " \
 glibc \
 "
