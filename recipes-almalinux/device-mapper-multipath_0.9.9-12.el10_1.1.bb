# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "device-mapper-multipath"
PV = "0.9.9"
PR = "12.el10_1.1"
PACKAGES = " \
 device-mapper-multipath \
 device-mapper-multipath-devel \
 device-mapper-multipath-libs \
 kpartx \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/device-mapper-multipath-0.9.9-12.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00137bf467368cfc2bce7cbc6061402e838e4c865f25882b0a24c568be010a82"

URI_x86_64_v2_device-mapper-multipath = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-multipath-0.9.9-12.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_device-mapper-multipath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-multipath}"
SRC_URI[x86_64_v2_device-mapper-multipath.sha256sum] = "93ac36a608bdc9dbec1436d5a14a32995e3c34ce046e605ca84ff8e18b77d13e"

URI_x86_64_v2_device-mapper-multipath-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/device-mapper-multipath-devel-0.9.9-12.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_device-mapper-multipath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-multipath-devel}"
SRC_URI[x86_64_v2_device-mapper-multipath-devel.sha256sum] = "34de1f49bff757a29fb2dd4f663d3c40b8e5cb7e911490571450e2b0957315f5"

URI_x86_64_v2_device-mapper-multipath-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-multipath-libs-0.9.9-12.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_device-mapper-multipath-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-multipath-libs}"
SRC_URI[x86_64_v2_device-mapper-multipath-libs.sha256sum] = "77a43f7364bd0f6bcff901f6b2e2efa7e9781c19a2173e4408e6db5446658743"

URI_x86_64_v2_kpartx = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kpartx-0.9.9-12.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_kpartx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpartx}"
SRC_URI[x86_64_v2_kpartx.sha256sum] = "110322b3626ccef970fe6a0bc45da8f116a161df8a551936bf582bdef533626c"

URI_aarch64_device-mapper-multipath = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-multipath-0.9.9-12.el10_1.1.aarch64.rpm;name=aarch64_device-mapper-multipath;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-multipath}"
SRC_URI[aarch64_device-mapper-multipath.sha256sum] = "cf7f390764fb79fec6eb7c83b30c2cc2ea866ca84ddf054af79beb9eeb3af897"

URI_aarch64_device-mapper-multipath-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/device-mapper-multipath-devel-0.9.9-12.el10_1.1.aarch64.rpm;name=aarch64_device-mapper-multipath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-multipath-devel}"
SRC_URI[aarch64_device-mapper-multipath-devel.sha256sum] = "a8dae9aeb7fc72c13c950f1ba40008b6247d50477611b2531f965909276088d2"

URI_aarch64_device-mapper-multipath-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-multipath-libs-0.9.9-12.el10_1.1.aarch64.rpm;name=aarch64_device-mapper-multipath-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-multipath-libs}"
SRC_URI[aarch64_device-mapper-multipath-libs.sha256sum] = "3db0d9eaf40777dae60cf5f77924f212431fdd3db1e5b719a1bb033bbf9df6f6"

URI_aarch64_kpartx = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kpartx-0.9.9-12.el10_1.1.aarch64.rpm;name=aarch64_kpartx;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpartx}"
SRC_URI[aarch64_kpartx.sha256sum] = "b25f3eea0eb0f11b7d23441e556a9d40373e894d3cd362a3b70dd67d170e9e93"

RDEPENDS:device-mapper-multipath = " \
 bash \
 device-mapper \
 device-mapper-libs \
 device-mapper-multipath-libs \
 glibc \
 kpartx \
 libgcc \
 libmount \
 readline \
 systemd \
 systemd-libs \
 userspace-rcu \
 "
RDEPENDS:device-mapper-multipath-devel = " \
 device-mapper-multipath \
 device-mapper-multipath-libs \
 "
RDEPENDS:device-mapper-multipath-libs = " \
 device-mapper-libs \
 glibc \
 libaio \
 libgcc \
 libmount \
 systemd-libs \
 userspace-rcu \
 "
RDEPENDS:kpartx = " \
 bash \
 device-mapper-libs \
 glibc \
 "
