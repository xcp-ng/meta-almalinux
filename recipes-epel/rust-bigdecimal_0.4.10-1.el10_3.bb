# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bigdecimal"
PV = "0.4.10"
PR = "1.el10_3"
PACKAGES = " \
 rust-bigdecimal+default-devel \
 rust-bigdecimal+serde-devel \
 rust-bigdecimal+serde-json-devel \
 rust-bigdecimal+serde_json-devel \
 rust-bigdecimal+std-devel \
 rust-bigdecimal+string-only-devel \
 rust-bigdecimal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bigdecimal-0.4.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa4e0a50db73bab7e9b6bd69f23f5289edb50ab61952510861d1017a2a6e6eb2"

URI_x86_64_v2_rust-bigdecimal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+default-devel-0.4.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+default-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+default-devel.sha256sum] = "27e67a108ec24a2b72b6f391f5ddb0ccf483634468481862d11cd74efa1409b7"

URI_x86_64_v2_rust-bigdecimal+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+serde-devel-0.4.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+serde-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+serde-devel.sha256sum] = "47e1f1e61ef8013dd3ddd6a957982dae8bc0bfce54f6e20d46a61d817190a330"

URI_x86_64_v2_rust-bigdecimal+serde-json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+serde-json-devel-0.4.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+serde-json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+serde-json-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+serde-json-devel.sha256sum] = "a333b0150182659710819bdc8448d08c0046928e3b928c672e1d3e36305e613e"

URI_x86_64_v2_rust-bigdecimal+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+serde_json-devel-0.4.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+serde_json-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+serde_json-devel.sha256sum] = "f2b1517c453e8dde05c0addb38b99851098d5e25bcfe973672d129af3b0c7644"

URI_x86_64_v2_rust-bigdecimal+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+std-devel-0.4.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+std-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+std-devel.sha256sum] = "f1836cb8125f959adead6a1746c278b42a593985ff3d9766fd25f1625446b68b"

URI_x86_64_v2_rust-bigdecimal+string-only-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+string-only-devel-0.4.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+string-only-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+string-only-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+string-only-devel.sha256sum] = "8c60447cf62b5be845686a94f91775f3786934d6fb462edf8d25cefbfde25d7b"

URI_x86_64_v2_rust-bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal-devel-0.4.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal-devel.sha256sum] = "9d5b225bf89e511ff983f6e0c893e9fa6cb3ce58a3397cd98f81c7024823d6b3"

URI_aarch64_rust-bigdecimal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+default-devel-0.4.10-1.el10_3.noarch.rpm;name=aarch64_rust-bigdecimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+default-devel}"
SRC_URI[aarch64_rust-bigdecimal+default-devel.sha256sum] = "95f8e4b72724e3f2ac7e71f29d44fe45d81a890414872db8481142601176916c"

URI_aarch64_rust-bigdecimal+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+serde-devel-0.4.10-1.el10_3.noarch.rpm;name=aarch64_rust-bigdecimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+serde-devel}"
SRC_URI[aarch64_rust-bigdecimal+serde-devel.sha256sum] = "21b3687c89c1ca820a8270778c0b0d3a1e0d3cccbad704f50c77aafb3869bdd2"

URI_aarch64_rust-bigdecimal+serde-json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+serde-json-devel-0.4.10-1.el10_3.noarch.rpm;name=aarch64_rust-bigdecimal+serde-json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+serde-json-devel}"
SRC_URI[aarch64_rust-bigdecimal+serde-json-devel.sha256sum] = "0e14beafa7b5cd0cd513354e9ea92add5a5ea841525542779acaf01168ddd77d"

URI_aarch64_rust-bigdecimal+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+serde_json-devel-0.4.10-1.el10_3.noarch.rpm;name=aarch64_rust-bigdecimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+serde_json-devel}"
SRC_URI[aarch64_rust-bigdecimal+serde_json-devel.sha256sum] = "51e29174d57e1aed2cd099f2520b33aeff011e213c2760332ae482452d2926a4"

URI_aarch64_rust-bigdecimal+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+std-devel-0.4.10-1.el10_3.noarch.rpm;name=aarch64_rust-bigdecimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+std-devel}"
SRC_URI[aarch64_rust-bigdecimal+std-devel.sha256sum] = "b2defc41eebb8e849ba350e5ac68ff2c983628c610378b01a0b7f9f00af221fd"

URI_aarch64_rust-bigdecimal+string-only-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+string-only-devel-0.4.10-1.el10_3.noarch.rpm;name=aarch64_rust-bigdecimal+string-only-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+string-only-devel}"
SRC_URI[aarch64_rust-bigdecimal+string-only-devel.sha256sum] = "de98f6e808ac1f483ef8b2c7cc00622978f1181f344b432ed5d6b539492eb554"

URI_aarch64_rust-bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal-devel-0.4.10-1.el10_3.noarch.rpm;name=aarch64_rust-bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal-devel}"
SRC_URI[aarch64_rust-bigdecimal-devel.sha256sum] = "5c27c6cecdc4f6e5985e9883f988a9f6f06119dd283f43145feabd3485933a79"

RDEPENDS:rust-bigdecimal+default-devel = " \
 cargo \
 rust-bigdecimal+std-devel \
 rust-bigdecimal-devel \
 "
RDEPENDS:rust-bigdecimal+serde-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bigdecimal+serde-json-devel = " \
 cargo \
 rust-bigdecimal+serde_json-devel \
 rust-bigdecimal-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bigdecimal+serde_json-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-serde_json+alloc-devel \
 rust-serde_json+arbitrary_precision-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-bigdecimal+std-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-num-bigint+std-devel \
 rust-num-integer+std-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-bigdecimal+string-only-devel = " \
 cargo \
 rust-bigdecimal-devel \
 "
RDEPENDS:rust-bigdecimal-devel = " \
 cargo \
 rust-autocfg+default-devel \
 rust-libm+default-devel \
 rust-num-bigint-devel \
 rust-num-integer-devel \
 rust-num-traits-devel \
 "
