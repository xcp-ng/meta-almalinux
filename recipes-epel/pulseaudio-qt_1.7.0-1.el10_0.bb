# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pulseaudio-qt"
PV = "1.7.0"
PR = "1.el10_0"
PACKAGES = " \
 pulseaudio-qt-qt6 \
 pulseaudio-qt-qt6-devel \
 pulseaudio-qt-qt6-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pulseaudio-qt-1.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "497661c4ea9fec97ef64f98413e99ae4fd3dcf12f2fe81beaff4a0d04c4329cc"

URI_x86_64_v2_pulseaudio-qt-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulseaudio-qt-qt6-1.7.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-qt-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-qt-qt6}"
SRC_URI[x86_64_v2_pulseaudio-qt-qt6.sha256sum] = "d8f3b2fb540eb4c93d0af859ea4a01829497820ee303c36b86f05388de18a576"

URI_x86_64_v2_pulseaudio-qt-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulseaudio-qt-qt6-devel-1.7.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-qt-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-qt-qt6-devel}"
SRC_URI[x86_64_v2_pulseaudio-qt-qt6-devel.sha256sum] = "0e101e7b88302270bc8efe32f9717b116c38eeeeb072390a02477b5696f4f15d"

URI_x86_64_v2_pulseaudio-qt-qt6-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulseaudio-qt-qt6-doc-1.7.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-qt-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-qt-qt6-doc}"
SRC_URI[x86_64_v2_pulseaudio-qt-qt6-doc.sha256sum] = "45f9a6e65dd29ac6786ddff3ea76f38b2db3f21c9a630a9066bad8c58ebcf1dc"

URI_aarch64_pulseaudio-qt-qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/pulseaudio-qt-qt6-1.7.0-1.el10_0.aarch64.rpm;name=aarch64_pulseaudio-qt-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-qt-qt6}"
SRC_URI[aarch64_pulseaudio-qt-qt6.sha256sum] = "d5b9d88d1b12bdc8f11a06867a5b5f4a3899f64bd54cc5df5171da509d746b20"

URI_aarch64_pulseaudio-qt-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pulseaudio-qt-qt6-devel-1.7.0-1.el10_0.aarch64.rpm;name=aarch64_pulseaudio-qt-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-qt-qt6-devel}"
SRC_URI[aarch64_pulseaudio-qt-qt6-devel.sha256sum] = "700def6298d417ce220228ec90b8fed68d9868dd24b995b3f71e1282aeed088f"

URI_aarch64_pulseaudio-qt-qt6-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pulseaudio-qt-qt6-doc-1.7.0-1.el10_0.aarch64.rpm;name=aarch64_pulseaudio-qt-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-qt-qt6-doc}"
SRC_URI[aarch64_pulseaudio-qt-qt6-doc.sha256sum] = "544e7a814929781e00837704649616d467665574e938c5c8075ceeeb3693aa67"

RDEPENDS:pulseaudio-qt-qt6 = " \
 glibc \
 libstdc++ \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pulseaudio-qt-qt6-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 pulseaudio-qt-qt6 \
 qt6-qtbase-devel \
 "
RDEPENDS:pulseaudio-qt-qt6-doc = " \
 "
