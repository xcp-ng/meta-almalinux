# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plymouth-theme-breeze"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plymouth-theme-breeze \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plymouth-theme-breeze-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69b89829236b979ed903b2c51002591a7182440a4c48630ef631f3bcafcb839f"

URI_x86_64_v2_plymouth-theme-breeze = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plymouth-theme-breeze-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plymouth-theme-breeze;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-breeze}"
SRC_URI[x86_64_v2_plymouth-theme-breeze.sha256sum] = "0fe35ac88099afbc6165ed6534d8b3fcd7bbbd22921aed0098757ed381152ff6"

URI_aarch64_plymouth-theme-breeze = "${EPEL_MIRROR}/aarch64/Packages/p/plymouth-theme-breeze-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plymouth-theme-breeze;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-breeze}"
SRC_URI[aarch64_plymouth-theme-breeze.sha256sum] = "b03b7af0a346f0b6f608db4aeaf11290d091ad2b05e19ad3ec283b5cd830fb6a"

RDEPENDS:plymouth-theme-breeze = " \
 glibc \
 plymouth \
 plymouth-core-libs \
 plymouth-plugin-script \
 "
