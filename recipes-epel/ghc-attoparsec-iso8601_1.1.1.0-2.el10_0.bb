# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-attoparsec-iso8601"
PV = "1.1.1.0"
PR = "2.el10_0"
PACKAGES = " \
 ghc-attoparsec-iso8601 \
 ghc-attoparsec-iso8601-devel \
 ghc-attoparsec-iso8601-doc \
 ghc-attoparsec-iso8601-prof \
 ghc-integer-conversion \
 ghc-integer-conversion-devel \
 ghc-integer-conversion-doc \
 ghc-integer-conversion-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-attoparsec-iso8601-1.1.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84aee0e1a8071f603674af61060b5cc2db077fc7dcc157776448a328244fd357"

URI_x86_64_v2_ghc-attoparsec-iso8601 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-attoparsec-iso8601-1.1.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-attoparsec-iso8601;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-attoparsec-iso8601}"
SRC_URI[x86_64_v2_ghc-attoparsec-iso8601.sha256sum] = "4790eb57392e34f925033e65fe77f46998dba79aee6321a06c396d827e67a825"

URI_x86_64_v2_ghc-attoparsec-iso8601-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-attoparsec-iso8601-devel-1.1.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-attoparsec-iso8601-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-attoparsec-iso8601-devel}"
SRC_URI[x86_64_v2_ghc-attoparsec-iso8601-devel.sha256sum] = "d3745e4d750b6a3c67ff0b37e63e92837ed9e0613c1d00d5ddfa9deed7b01ede"

URI_x86_64_v2_ghc-attoparsec-iso8601-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-attoparsec-iso8601-doc-1.1.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-attoparsec-iso8601-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-attoparsec-iso8601-doc}"
SRC_URI[x86_64_v2_ghc-attoparsec-iso8601-doc.sha256sum] = "96d78da4ed66b0a1e87276c5033075d04e74c2cd55f471f1464f41a9d437e3e8"

URI_x86_64_v2_ghc-attoparsec-iso8601-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-attoparsec-iso8601-prof-1.1.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-attoparsec-iso8601-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-attoparsec-iso8601-prof}"
SRC_URI[x86_64_v2_ghc-attoparsec-iso8601-prof.sha256sum] = "ee5dcc32c29191b5021911db39c54ac0edf11f8292e197aa157ba114fab52194"

URI_x86_64_v2_ghc-integer-conversion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-integer-conversion-0.1.0.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-integer-conversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-integer-conversion}"
SRC_URI[x86_64_v2_ghc-integer-conversion.sha256sum] = "0d1dfb6b5bed5d6b1f2a68f4842d34b4e74525e7f2382f919643810b66a31aa8"

URI_x86_64_v2_ghc-integer-conversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-integer-conversion-devel-0.1.0.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-integer-conversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-integer-conversion-devel}"
SRC_URI[x86_64_v2_ghc-integer-conversion-devel.sha256sum] = "b8123ce97b3bb852550f0ac824d2cf069b255ea326bdcb4e8958e8e3fa4110da"

URI_x86_64_v2_ghc-integer-conversion-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-integer-conversion-doc-0.1.0.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-integer-conversion-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-integer-conversion-doc}"
SRC_URI[x86_64_v2_ghc-integer-conversion-doc.sha256sum] = "f74c8e264d8a32a7fc7a572762493625f449da554f7fc309e1eb34050d5808f1"

URI_x86_64_v2_ghc-integer-conversion-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-integer-conversion-prof-0.1.0.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-integer-conversion-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-integer-conversion-prof}"
SRC_URI[x86_64_v2_ghc-integer-conversion-prof.sha256sum] = "041fa8110772cd2c7ec71ffbb54998423afe6d1435114322c114c2716c6ddae2"

URI_aarch64_ghc-attoparsec-iso8601 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-attoparsec-iso8601-1.1.1.0-2.el10_0.aarch64.rpm;name=aarch64_ghc-attoparsec-iso8601;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-attoparsec-iso8601}"
SRC_URI[aarch64_ghc-attoparsec-iso8601.sha256sum] = "33a2e72960bc229fe6896bd9ad8b989ade55e71c776768324126b545ed65bb87"

URI_aarch64_ghc-attoparsec-iso8601-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-attoparsec-iso8601-devel-1.1.1.0-2.el10_0.aarch64.rpm;name=aarch64_ghc-attoparsec-iso8601-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-attoparsec-iso8601-devel}"
SRC_URI[aarch64_ghc-attoparsec-iso8601-devel.sha256sum] = "7a8dfb767a3c59ea3106baa2177c2e3dca68559fdfaa8c2d65fe1fc4371874f6"

URI_aarch64_ghc-attoparsec-iso8601-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-attoparsec-iso8601-doc-1.1.1.0-2.el10_0.noarch.rpm;name=aarch64_ghc-attoparsec-iso8601-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-attoparsec-iso8601-doc}"
SRC_URI[aarch64_ghc-attoparsec-iso8601-doc.sha256sum] = "c4213005e304103b803bc7d74055aedd035f9f10bb7944db555ebdf252e4453f"

URI_aarch64_ghc-attoparsec-iso8601-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-attoparsec-iso8601-prof-1.1.1.0-2.el10_0.aarch64.rpm;name=aarch64_ghc-attoparsec-iso8601-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-attoparsec-iso8601-prof}"
SRC_URI[aarch64_ghc-attoparsec-iso8601-prof.sha256sum] = "8f5b64a80525b7de4bc75211f990b65eb5c2b4aa5ad285b683746a13bfab8fbf"

URI_aarch64_ghc-integer-conversion = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-integer-conversion-0.1.0.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-integer-conversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-integer-conversion}"
SRC_URI[aarch64_ghc-integer-conversion.sha256sum] = "87e2e8fd2dabf76bceca125fa717bd96f484686174e4ce15b256a907288a7e65"

URI_aarch64_ghc-integer-conversion-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-integer-conversion-devel-0.1.0.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-integer-conversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-integer-conversion-devel}"
SRC_URI[aarch64_ghc-integer-conversion-devel.sha256sum] = "3feead420082712692e26c9345671468885f76f150040c5258c0e711576e9768"

URI_aarch64_ghc-integer-conversion-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-integer-conversion-doc-0.1.0.1-2.el10_0.noarch.rpm;name=aarch64_ghc-integer-conversion-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-integer-conversion-doc}"
SRC_URI[aarch64_ghc-integer-conversion-doc.sha256sum] = "133548f17ed2a8643cc2fa45c5dd99a052d9206030a5eb1ae7b4be84096927ba"

URI_aarch64_ghc-integer-conversion-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-integer-conversion-prof-0.1.0.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-integer-conversion-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-integer-conversion-prof}"
SRC_URI[aarch64_ghc-integer-conversion-prof.sha256sum] = "8095db1089e62e78822fad3d4a9e3055129ebc6df9f60a1a005014c448d7d6ad"

RDEPENDS:ghc-attoparsec-iso8601 = " \
 ghc-array \
 ghc-attoparsec \
 ghc-base \
 ghc-base-orphans \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-conversion \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-scientific \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-attoparsec-iso8601-devel = " \
 ghc-attoparsec-devel \
 ghc-attoparsec-iso8601 \
 ghc-base-devel \
 ghc-compiler \
 ghc-integer-conversion-devel \
 ghc-text-devel \
 ghc-time-compat-devel \
 ghc-time-devel \
 "
RDEPENDS:ghc-attoparsec-iso8601-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-attoparsec-iso8601-prof = " \
 ghc-attoparsec-iso8601-devel \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-integer-conversion-prof \
 ghc-text-prof \
 ghc-time-compat-prof \
 ghc-time-prof \
 "
RDEPENDS:ghc-integer-conversion = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-primitive \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-integer-conversion-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-integer-conversion \
 ghc-primitive-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-integer-conversion-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-integer-conversion-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-integer-conversion-devel \
 ghc-primitive-prof \
 ghc-text-prof \
 "
