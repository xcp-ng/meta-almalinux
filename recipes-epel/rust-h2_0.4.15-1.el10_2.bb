# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-h2"
PV = "0.4.15"
PR = "1.el10_2"
PACKAGES = " \
 rust-h2+default-devel \
 rust-h2+stream-devel \
 rust-h2+unstable-devel \
 rust-h2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-h2-0.4.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffaf724558badf1fdd5772717654a3dfec7e34ee09399d63a2e3679554fdf37e"

URI_x86_64_v2_rust-h2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+default-devel-0.4.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2+default-devel}"
SRC_URI[x86_64_v2_rust-h2+default-devel.sha256sum] = "7e6805fa7f0d0d5908600b99b37ce039e63835cc58e863e947ff738af0b9a6cd"

URI_x86_64_v2_rust-h2+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+stream-devel-0.4.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2+stream-devel}"
SRC_URI[x86_64_v2_rust-h2+stream-devel.sha256sum] = "408bff31869d881b2222ac96fe5348904252bea9d15a664c77551d7b0db43563"

URI_x86_64_v2_rust-h2+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+unstable-devel-0.4.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2+unstable-devel}"
SRC_URI[x86_64_v2_rust-h2+unstable-devel.sha256sum] = "074cb522b448d662f36aaa5a6b3bd2e0dbcecbc74a6fb1a379076fb8e088eed2"

URI_x86_64_v2_rust-h2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2-devel-0.4.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2-devel}"
SRC_URI[x86_64_v2_rust-h2-devel.sha256sum] = "0319f9cc331ebe2ab927a929e0e6b3e846d7f76af79f8a847a106ced650da121"

URI_aarch64_rust-h2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+default-devel-0.4.15-1.el10_2.noarch.rpm;name=aarch64_rust-h2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2+default-devel}"
SRC_URI[aarch64_rust-h2+default-devel.sha256sum] = "7c474cd733802aaf83adcf67fdf2b95f3989c0311006f6a31dffb995de58b914"

URI_aarch64_rust-h2+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+stream-devel-0.4.15-1.el10_2.noarch.rpm;name=aarch64_rust-h2+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2+stream-devel}"
SRC_URI[aarch64_rust-h2+stream-devel.sha256sum] = "8ab6b21098186fbeaabfd05a2a804bdc4d78ef6d1e490b90ecc13aaf667acebf"

URI_aarch64_rust-h2+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+unstable-devel-0.4.15-1.el10_2.noarch.rpm;name=aarch64_rust-h2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2+unstable-devel}"
SRC_URI[aarch64_rust-h2+unstable-devel.sha256sum] = "4a457de789b43d94a2bd79c0c2cf52715ac822504897e58275dcb995622f031e"

URI_aarch64_rust-h2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2-devel-0.4.15-1.el10_2.noarch.rpm;name=aarch64_rust-h2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2-devel}"
SRC_URI[aarch64_rust-h2-devel.sha256sum] = "7d717c80714e2370c8d243bc6d2c56cc73c8eb2109c852429c5230f35e697cba"

RDEPENDS:rust-h2+default-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2+stream-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2+unstable-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2-devel = " \
 cargo \
 rust \
 rust-atomic-waker+default-devel \
 rust-bytes+default-devel \
 rust-fnv+default-devel \
 rust-futures-core-devel \
 rust-futures-sink-devel \
 rust-http+default-devel \
 rust-indexmap+default-devel \
 rust-indexmap+std-devel \
 rust-slab+default-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio-util+codec-devel \
 rust-tokio-util+default-devel \
 rust-tokio-util+io-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
