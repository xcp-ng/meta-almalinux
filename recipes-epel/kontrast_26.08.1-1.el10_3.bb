# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kontrast"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kontrast \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kontrast-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1f8ab45c8f00090d3e79c2d810fa089f3776f2e46c6b0d774314e1a70759c1c1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontrast-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontrast;unpack=0"
SRC_URI[x86_64_v2_kontrast.sha256sum] = "4a7038a3139f715449d69296cf8ad2f51b14451f915ad370374c5d0e4a526d5e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kontrast-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kontrast;unpack=0"
SRC_URI[aarch64_kontrast.sha256sum] = "277b3a15ced389f187be6f9f13c7d911458bc7bb1d94319b98d138934fb7f41c"

RDEPENDS:kontrast = " \
 futuresql-qt6 \
 glibc \
 hicolor-icon-theme \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
