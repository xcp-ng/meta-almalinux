# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "containers-common"
PE = "5"
PV = "0.62.0"
PR = "1.el10"
PACKAGES = " \
 containers-common \
 containers-common-extra \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/containers-common-0.62.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b74a393b91e612757ad5bf425a1b708914d9fd6635ad78c3e3762302ff77920e"

URI_x86_64_v2_containers-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/containers-common-0.62.0-1.el10.noarch.rpm;name=x86_64_v2_containers-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_containers-common}"
SRC_URI[x86_64_v2_containers-common.sha256sum] = "66d92377bf8287ab24f05dfd3981a4e21cba5dfe8689ce9aecfb2524b74570a2"

URI_x86_64_v2_containers-common-extra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/containers-common-extra-0.62.0-1.el10.noarch.rpm;name=x86_64_v2_containers-common-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_containers-common-extra}"
SRC_URI[x86_64_v2_containers-common-extra.sha256sum] = "3292ccfb82baafc3472f47b90617438b3680e1a298ace75b152dd8c99dc97be2"

URI_aarch64_containers-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/containers-common-0.62.0-1.el10.noarch.rpm;name=aarch64_containers-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_containers-common}"
SRC_URI[aarch64_containers-common.sha256sum] = "66d92377bf8287ab24f05dfd3981a4e21cba5dfe8689ce9aecfb2524b74570a2"

URI_aarch64_containers-common-extra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/containers-common-extra-0.62.0-1.el10.noarch.rpm;name=aarch64_containers-common-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_containers-common-extra}"
SRC_URI[aarch64_containers-common-extra.sha256sum] = "3292ccfb82baafc3472f47b90617438b3680e1a298ace75b152dd8c99dc97be2"

RDEPENDS:containers-common = " \
 container-selinux \
 netavark \
 "
RDEPENDS:containers-common-extra = " \
 containers-common \
 crun \
 netavark \
 nftables \
 passt \
 "
