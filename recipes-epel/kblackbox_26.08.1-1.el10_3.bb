# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kblackbox"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kblackbox \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kblackbox-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fce9497f92c546f6e14df78e20f23f42e4812b104867c75707afcb3a0db056f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kblackbox-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kblackbox;unpack=0"
SRC_URI[x86_64_v2_kblackbox.sha256sum] = "5469bee7652c4bd376ee1bc1ab1b37fc7421adfe20126ff420419592f290e0ac"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kblackbox-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kblackbox;unpack=0"
SRC_URI[aarch64_kblackbox.sha256sum] = "0c2e9b2260ee2aa81b0efa0080f0ecc8f7721ce42799c142d402f6851f88b60a"

RDEPENDS:kblackbox = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
