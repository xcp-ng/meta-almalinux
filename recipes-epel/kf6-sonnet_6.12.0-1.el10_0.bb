# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-sonnet"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-sonnet \
 kf6-sonnet-aspell \
 kf6-sonnet-devel \
 kf6-sonnet-doc \
 kf6-sonnet-hspell \
 kf6-sonnet-hunspell \
 kf6-sonnet-voikko \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-sonnet-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2493e1ae8120bca8b91f622240dc3ae3d69f7887a3f96b3e710af95ca7d9d62e"

URI_x86_64_v2_kf6-sonnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet}"
SRC_URI[x86_64_v2_kf6-sonnet.sha256sum] = "f315399484c03bd536d529e1486d69d8c564a0bf91c30576f5fda1440593b765"

URI_x86_64_v2_kf6-sonnet-aspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-aspell-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-aspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-aspell}"
SRC_URI[x86_64_v2_kf6-sonnet-aspell.sha256sum] = "2e89b26f35ac65399fac7918c6236559b878f27eb059dde35c544700a9581722"

URI_x86_64_v2_kf6-sonnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-devel}"
SRC_URI[x86_64_v2_kf6-sonnet-devel.sha256sum] = "d946082b3772c5a8b0f731e71ff68f76d7ba3c196d1a5c4c753550f1e6fb58de"

URI_x86_64_v2_kf6-sonnet-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-sonnet-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-doc}"
SRC_URI[x86_64_v2_kf6-sonnet-doc.sha256sum] = "7ac3e3735fea03fc315a3108d8c0144d18b14ba0019cfe2184de2ac208048ef3"

URI_x86_64_v2_kf6-sonnet-hspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-hspell-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-hspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-hspell}"
SRC_URI[x86_64_v2_kf6-sonnet-hspell.sha256sum] = "40a37cfb9359ba98631eaa3ce5f424575e02581c4d9fa5a36d4262ab7c5cb5f8"

URI_x86_64_v2_kf6-sonnet-hunspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-hunspell-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-hunspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-hunspell}"
SRC_URI[x86_64_v2_kf6-sonnet-hunspell.sha256sum] = "10d3da12b3379acad66cdeecab91a6913e67bbbf805f6ea21acee7c6532535af"

URI_x86_64_v2_kf6-sonnet-voikko = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-voikko-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-voikko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-voikko}"
SRC_URI[x86_64_v2_kf6-sonnet-voikko.sha256sum] = "ed9c00d366c3223de69676d02510f638ebda3c2dbae420ed35ed44ce4fdb607d"

URI_aarch64_kf6-sonnet = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-sonnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet}"
SRC_URI[aarch64_kf6-sonnet.sha256sum] = "915c880bded4844cd11c2c5cbb6a1229be050fa12780e2ba969d7e48a030e25f"

URI_aarch64_kf6-sonnet-aspell = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-aspell-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-sonnet-aspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-aspell}"
SRC_URI[aarch64_kf6-sonnet-aspell.sha256sum] = "bafdc99dabfceee1ce16e95f9b566cc19883f863b96933a4a91d2bf0e77e2e49"

URI_aarch64_kf6-sonnet-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-sonnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-devel}"
SRC_URI[aarch64_kf6-sonnet-devel.sha256sum] = "581782c168ac858915ea2fefd812df3c0c780735e81a5c8b70544b8d3ee9df22"

URI_aarch64_kf6-sonnet-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-sonnet-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-doc}"
SRC_URI[aarch64_kf6-sonnet-doc.sha256sum] = "e97bd69b6dfd9eb96410bce08670b7d6d1a9ca254b7b193bc6adbbcd8b618df6"

URI_aarch64_kf6-sonnet-hspell = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-hspell-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-sonnet-hspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-hspell}"
SRC_URI[aarch64_kf6-sonnet-hspell.sha256sum] = "b25666a279f228a6b996be7410089633a4f28aa26608ec0a14542370d00ab722"

URI_aarch64_kf6-sonnet-hunspell = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-hunspell-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-sonnet-hunspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-hunspell}"
SRC_URI[aarch64_kf6-sonnet-hunspell.sha256sum] = "19b1a6cf70717f801e23760e1b45ef66cf98bd1faac4e8ea7c42e3cb95a744f8"

URI_aarch64_kf6-sonnet-voikko = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-voikko-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-sonnet-voikko;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-voikko}"
SRC_URI[aarch64_kf6-sonnet-voikko.sha256sum] = "8fc4513a38b74672c5da96438ffbcd208ef5d2cb4f6712653f1579f87d7c799a"

RDEPENDS:kf6-sonnet = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-sonnet-aspell = " \
 aspell \
 glibc \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-sonnet-devel = " \
 cmake-filesystem \
 glibc \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-sonnet-doc = " \
 "
RDEPENDS:kf6-sonnet-hspell = " \
 glibc \
 hspell \
 hunspell-he \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-sonnet-hunspell = " \
 glibc \
 hunspell \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-sonnet-voikko = " \
 glibc \
 kf6-sonnet \
 libstdc++ \
 libvoikko \
 qt6-qtbase \
 "
