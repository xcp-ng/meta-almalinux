# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tokodon"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 tokodon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tokodon-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a41497295f402e1712a5ea34dad976dd291efbe6fe4d9fc92d206eedf263fd58"

URI_x86_64_v2_tokodon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tokodon-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tokodon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tokodon}"
SRC_URI[x86_64_v2_tokodon.sha256sum] = "5cafacc5a96a336fb8a4d20846eeacccbd35e4f237f31d0a0398511e432838f4"

URI_aarch64_tokodon = "${EPEL_MIRROR}/aarch64/Packages/t/tokodon-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_tokodon;unpack=0"
SRC_URI:append = " ${URI_aarch64_tokodon}"
SRC_URI[aarch64_tokodon.sha256sum] = "aa5a35ae0dac6dd9f7b0b98b91fb283044d91d8985878ffdb2c14d084c4fd80c"

RDEPENDS:tokodon = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-purpose \
 kf6-sonnet \
 kunifiedpush \
 libgcc \
 libstdc++ \
 mpvqt \
 openssl-libs \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 qt6-qtwebview \
 qtkeychain-qt6 \
 "
