# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "appstream-data"
PE = "1"
PV = "10"
PR = "20250213.1.el10"
PACKAGES = " \
 appstream-data \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/appstream-data-10-20250213.1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6fc17cd98e84f90faf701176515b53082f399bfbd602c0d5017dfc605c8dd1cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/appstream-data-10-20250213.1.el10.noarch.rpm;name=x86_64_v2_appstream-data;unpack=0"
SRC_URI[x86_64_v2_appstream-data.sha256sum] = "a1cafb674550d9d3939c542ef54865e0ec5ce75c3bc7ece58d1ed7c87dde0cd0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/appstream-data-10-20250213.1.el10.noarch.rpm;name=aarch64_appstream-data;unpack=0"
SRC_URI[aarch64_appstream-data.sha256sum] = "a1cafb674550d9d3939c542ef54865e0ec5ce75c3bc7ece58d1ed7c87dde0cd0"

RDEPENDS:appstream-data = " \
 "
