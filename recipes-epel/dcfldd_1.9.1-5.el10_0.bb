# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dcfldd"
PV = "1.9.1"
PR = "5.el10_0"
PACKAGES = " \
 dcfldd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dcfldd-1.9.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1974c1f212a4b0363d85ce90d3f87dc47e982feb1dd30e8083c88f7dd808ccd8"

URI_x86_64_v2_dcfldd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dcfldd-1.9.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dcfldd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dcfldd}"
SRC_URI[x86_64_v2_dcfldd.sha256sum] = "b36fb47eec1157877d8b04379bd44a9a01106c8821811676ce02a71c30b4f9e3"

URI_aarch64_dcfldd = "${EPEL_MIRROR}/aarch64/Packages/d/dcfldd-1.9.1-5.el10_0.aarch64.rpm;name=aarch64_dcfldd;unpack=0"
SRC_URI:append = " ${URI_aarch64_dcfldd}"
SRC_URI[aarch64_dcfldd.sha256sum] = "aba284951b47f91c12d4ab573ab8f653a2c68d7446e179bff60d632dc19e9b4f"

RDEPENDS:dcfldd = " \
 glibc \
 "
