# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-Format-W3CDTF"
PV = "0.08"
PR = "12.el10_0"
PACKAGES = " \
 perl-DateTime-Format-W3CDTF \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-Format-W3CDTF-0.08-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "debdb5bd6a15190c2843258cd23f90c38fa70cd826625559e81c112cbe9a7520"

URI_x86_64_v2_perl-DateTime-Format-W3CDTF = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-Format-W3CDTF-0.08-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-Format-W3CDTF;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-Format-W3CDTF}"
SRC_URI[x86_64_v2_perl-DateTime-Format-W3CDTF.sha256sum] = "eda6f0e0da67d67f18615c2889b79ae5b51306152072ef706c8e03b1332f0df3"

URI_aarch64_perl-DateTime-Format-W3CDTF = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-Format-W3CDTF-0.08-12.el10_0.noarch.rpm;name=aarch64_perl-DateTime-Format-W3CDTF;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-Format-W3CDTF}"
SRC_URI[aarch64_perl-DateTime-Format-W3CDTF.sha256sum] = "dfc3f9b5b33e17146fee28f8fe2c2fa3eb5d0ed799d27a675408f4fa4cee0229"

RDEPENDS:perl-DateTime-Format-W3CDTF = " \
 perl-DateTime \
 perl-DateTime-TimeZone \
 perl-libs \
 perl-vars \
 "
