# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpanel"
PV = "1.8.1"
PR = "1.el10"
PACKAGES = " \
 libpanel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libpanel-1.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e7e3c1d9bf144389813ed762e4fbf3e782a5b73c518ed261bbcc50307dadfa1"

URI_x86_64_v2_libpanel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpanel-1.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libpanel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpanel}"
SRC_URI[x86_64_v2_libpanel.sha256sum] = "03b89e849f1f648185af689ee95f784382ece958d99bf8aef2e778cd33d1c93a"

URI_aarch64_libpanel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpanel-1.8.1-1.el10.aarch64.rpm;name=aarch64_libpanel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpanel}"
SRC_URI[aarch64_libpanel.sha256sum] = "9a0c9aa0a049e33e446f75b85e4fff2b6730ed8c6611c18b3be32020538e9c48"

RDEPENDS:libpanel = " \
 cairo \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 hicolor-icon-theme \
 libadwaita \
 "
