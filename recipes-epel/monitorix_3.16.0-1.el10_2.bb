# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "monitorix"
PV = "3.16.0"
PR = "1.el10_2"
PACKAGES = " \
 monitorix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/monitorix-3.16.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0f70e29ee1feab2d8ef5df32cddfefc68ff44c114e1234fd2ece9981e5a9767"

URI_x86_64_v2_monitorix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/monitorix-3.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_monitorix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_monitorix}"
SRC_URI[x86_64_v2_monitorix.sha256sum] = "7b4449385d6b45d2191d0bf3592af4370e8812779c67bb24d20b591fdd8a5a62"

URI_aarch64_monitorix = "${EPEL_MIRROR}/aarch64/Packages/m/monitorix-3.16.0-1.el10_2.noarch.rpm;name=aarch64_monitorix;unpack=0"
SRC_URI:append = " ${URI_aarch64_monitorix}"
SRC_URI[aarch64_monitorix.sha256sum] = "4756fe48fea96df92cfdebb699e6475645dd02031b0a2e56f2dfd4c2b0057f8d"

RDEPENDS:monitorix = " \
 bash \
 logrotate \
 perl-DBD-MySQL \
 perl-DBD-Pg \
 perl-IO-Socket-SSL \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 systemd \
 "
