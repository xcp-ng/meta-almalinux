# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bind"
PE = "32"
PV = "9.18.33"
PR = "4.el10_0.2"
PACKAGES = " \
 bind \
 bind-chroot \
 bind-devel \
 bind-dnssec-utils \
 bind-doc \
 bind-libs \
 bind-license \
 bind-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bind-9.18.33-4.el10_0.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e94685c38b51872a58126deb9a7c01880dbbebf21d520b6b156dc8254c89057"

URI_x86_64_v2_bind = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-9.18.33-4.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_bind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind}"
SRC_URI[x86_64_v2_bind.sha256sum] = "474ed71742cff44f0f31dd5594e2a7e82c2992de458b0e2921b39f17eaeba359"

URI_x86_64_v2_bind-chroot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-chroot-9.18.33-4.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_bind-chroot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-chroot}"
SRC_URI[x86_64_v2_bind-chroot.sha256sum] = "10c1313c4ba4f608af59deb7698e2aa117ecbc5fb1437bb9670354f3f286c9a0"

URI_x86_64_v2_bind-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bind-devel-9.18.33-4.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_bind-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-devel}"
SRC_URI[x86_64_v2_bind-devel.sha256sum] = "b623e50406412d0a1f812c1f33befc23c5115e84a1c11b49d22bbbf27cd11658"

URI_x86_64_v2_bind-dnssec-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-dnssec-utils-9.18.33-4.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_bind-dnssec-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-dnssec-utils}"
SRC_URI[x86_64_v2_bind-dnssec-utils.sha256sum] = "f92b92df6e5f8fae4eeb4b2e3fbdf8eb94b7654cdd25aefa52af73a375a3793f"

URI_x86_64_v2_bind-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bind-doc-9.18.33-4.el10_0.2.noarch.rpm;name=x86_64_v2_bind-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-doc}"
SRC_URI[x86_64_v2_bind-doc.sha256sum] = "f3b77d17c084a53a89188b9e49368a24d1a2220f32e1750e2a2311568c4f9b2a"

URI_x86_64_v2_bind-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-libs-9.18.33-4.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_bind-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-libs}"
SRC_URI[x86_64_v2_bind-libs.sha256sum] = "d5565376d637ec4af5b63735a6b0db29cd734622867ce7329c079b668e481fb7"

URI_x86_64_v2_bind-license = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-license-9.18.33-4.el10_0.2.noarch.rpm;name=x86_64_v2_bind-license;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-license}"
SRC_URI[x86_64_v2_bind-license.sha256sum] = "bb81e250595f5da9b569c3ac03115910f28d9faa14c99e5296e260b6950a565f"

URI_x86_64_v2_bind-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-utils-9.18.33-4.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_bind-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-utils}"
SRC_URI[x86_64_v2_bind-utils.sha256sum] = "b78c628b4b84815f2b7b2f924a5df68dc3739aa0d89d025a02b7b7e8ab192d70"

URI_aarch64_bind = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-9.18.33-4.el10_0.2.aarch64.rpm;name=aarch64_bind;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind}"
SRC_URI[aarch64_bind.sha256sum] = "df891e2337d4f4fb2abd521dac78359e7716ff0225fae8729437d9a9f83d01c1"

URI_aarch64_bind-chroot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-chroot-9.18.33-4.el10_0.2.aarch64.rpm;name=aarch64_bind-chroot;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-chroot}"
SRC_URI[aarch64_bind-chroot.sha256sum] = "893ebbaa1bddd7651340770cc8f569fb7473bc0597200003c02888738c8401cc"

URI_aarch64_bind-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bind-devel-9.18.33-4.el10_0.2.aarch64.rpm;name=aarch64_bind-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-devel}"
SRC_URI[aarch64_bind-devel.sha256sum] = "ec2b28c911f7de99b873ba2bfeb9cfe68f068b5266bb3fe21f2b134609ae3fe8"

URI_aarch64_bind-dnssec-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-dnssec-utils-9.18.33-4.el10_0.2.aarch64.rpm;name=aarch64_bind-dnssec-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-dnssec-utils}"
SRC_URI[aarch64_bind-dnssec-utils.sha256sum] = "c17e07c03f6c4610a62e1d18f60334933f4efe2ad4231e1f831a4e54f426eaa7"

URI_aarch64_bind-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bind-doc-9.18.33-4.el10_0.2.noarch.rpm;name=aarch64_bind-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-doc}"
SRC_URI[aarch64_bind-doc.sha256sum] = "f3b77d17c084a53a89188b9e49368a24d1a2220f32e1750e2a2311568c4f9b2a"

URI_aarch64_bind-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-libs-9.18.33-4.el10_0.2.aarch64.rpm;name=aarch64_bind-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-libs}"
SRC_URI[aarch64_bind-libs.sha256sum] = "43760a757ba34b9f2d9f7b38587a8e898a70ae114ecd4781b90898d60d58e7ff"

URI_aarch64_bind-license = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-license-9.18.33-4.el10_0.2.noarch.rpm;name=aarch64_bind-license;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-license}"
SRC_URI[aarch64_bind-license.sha256sum] = "bb81e250595f5da9b569c3ac03115910f28d9faa14c99e5296e260b6950a565f"

URI_aarch64_bind-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-utils-9.18.33-4.el10_0.2.aarch64.rpm;name=aarch64_bind-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-utils}"
SRC_URI[aarch64_bind-utils.sha256sum] = "d2cf4be981145776a70f56d92645b46ab89b700fec4d2b2534e9866deca3535a"

RDEPENDS:bind = " \
 bash \
 bind-libs \
 fstrm \
 glibc \
 glibc-common \
 grep \
 json-c \
 libcap \
 libmaxminddb \
 libnghttp2 \
 libuv \
 libxml2 \
 lmdb-libs \
 openssl-libs \
 protobuf-c \
 shadow-utils \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:bind-chroot = " \
 bash \
 bind \
 grep \
 "
RDEPENDS:bind-devel = " \
 bind-libs \
 fstrm-devel \
 json-c-devel \
 krb5-devel \
 libcap-devel \
 libmaxminddb-devel \
 libxml2-devel \
 lmdb-devel \
 openssl-devel \
 protobuf-c-devel \
 "
RDEPENDS:bind-dnssec-utils = " \
 bind-libs \
 glibc \
 "
RDEPENDS:bind-doc = " \
 bind-license \
 python3-sphinx_rtd_theme \
 "
RDEPENDS:bind-libs = " \
 bind-license \
 fstrm \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libmaxminddb \
 libnghttp2 \
 libuv \
 libxml2 \
 lmdb-libs \
 openssl-libs \
 protobuf-c \
 zlib-ng-compat \
 "
RDEPENDS:bind-license = " \
 "
RDEPENDS:bind-utils = " \
 bind-libs \
 glibc \
 krb5-libs \
 libidn2 \
 lmdb-libs \
 protobuf-c \
 "
