# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libetpan"
PV = "1.9.4"
PR = "19.el10_3"
PACKAGES = " \
 libetpan \
 libetpan-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libetpan-1.9.4-19.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d371615fe20b956848016e7e168379b6df7c9f04572b5add01461a08ee39a19"

URI_x86_64_v2_libetpan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libetpan-1.9.4-19.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libetpan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libetpan}"
SRC_URI[x86_64_v2_libetpan.sha256sum] = "0a9340561b01127732df5ad3121474877bd2e52e07700479fb3de2423acc6377"

URI_x86_64_v2_libetpan-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libetpan-devel-1.9.4-19.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libetpan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libetpan-devel}"
SRC_URI[x86_64_v2_libetpan-devel.sha256sum] = "fe22ead6a3bfa59297786ddeda9fc3682abfc6578923c9cbc529e0bae8097d4e"

URI_aarch64_libetpan = "${EPEL_MIRROR}/aarch64/Packages/l/libetpan-1.9.4-19.el10_3.aarch64.rpm;name=aarch64_libetpan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libetpan}"
SRC_URI[aarch64_libetpan.sha256sum] = "c82fd23d0e0e6b442af6849f6e2a3f62b635912b017068f3cc7bd9edb3ddae63"

URI_aarch64_libetpan-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libetpan-devel-1.9.4-19.el10_3.aarch64.rpm;name=aarch64_libetpan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libetpan-devel}"
SRC_URI[aarch64_libetpan-devel.sha256sum] = "10868890a5d274315e9a3ecdd7e409c9911c457fa4c046d2d920489e15926cb5"

RDEPENDS:libetpan = " \
 cyrus-sasl-lib \
 glibc \
 gnutls \
 libdb \
 libgcc \
 liblockfile \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:libetpan-devel = " \
 libetpan \
 pkgconf-pkg-config \
 "
