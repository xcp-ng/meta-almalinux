# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_vdir"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_vdir+default-devel \
 rust-uu_vdir-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-uu_vdir-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fd08958f19856907a3199fdfb91fd2d098a666d6d22f40821b8657b4b9074afd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_vdir+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_vdir+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uu_vdir+default-devel.sha256sum] = "38a02f7cc51b89da333497356513e6dfa48b9a29aaf4f8d6a2771483bebaad54"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_vdir-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_vdir-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uu_vdir-devel.sha256sum] = "7c318deb5ccfbd493e1581514789f684547aa50d98f2c9fb5104051c05909d0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_vdir+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_vdir+default-devel;unpack=0"
SRC_URI[aarch64_rust-uu_vdir+default-devel.sha256sum] = "f48092aa72cbf00e9c9d0a92d768c29fbd1263b4c8b5fb55fa4e1cfba4fdd1fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_vdir-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_vdir-devel;unpack=0"
SRC_URI[aarch64_rust-uu_vdir-devel.sha256sum] = "4598a46396e0a3d46e18d75c086924e7cafb2d79166a5c0cdd3dfc6e539ea5d5"

RDEPENDS:rust-uu_vdir+default-devel = " \
 cargo \
 rust-uu_vdir-devel \
 "
RDEPENDS:rust-uu_vdir-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+env-devel \
 rust-clap+wrap_help-devel \
 rust-uu_ls+default-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+fs-devel \
 rust-uucore+quoting-style-devel \
 "
