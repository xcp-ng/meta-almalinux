# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-siguldry"
PV = "0.9.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-siguldry+cli-devel \
 rust-siguldry+default-devel \
 rust-siguldry+server-devel \
 rust-siguldry+sigul-client-devel \
 rust-siguldry-devel \
 siguldry \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-siguldry-0.9.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a6760c81cef5fe84a86ed1406e84fa9390dc912d11b26b856e8a1a8416626d36"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siguldry+cli-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siguldry+cli-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siguldry+cli-devel.sha256sum] = "7404c081db9596dbdcff28188a96b773bb7d0149e6e752fc67985d604be0e579"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siguldry+default-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siguldry+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siguldry+default-devel.sha256sum] = "c1bb9f429bdd77cf0fac723e53db6ebe4e8b1a4ccd29aafd00a2ea651587a7ab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siguldry+server-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siguldry+server-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siguldry+server-devel.sha256sum] = "48b7c1d794aa9f956903c986a231de40819525b0af59d06bfef81bf128f84c9c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siguldry+sigul-client-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siguldry+sigul-client-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siguldry+sigul-client-devel.sha256sum] = "f43cea2d48b594be376b28f3467ff210de611f90c0ebac00bb86927dfd77f8bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siguldry-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siguldry-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siguldry-devel.sha256sum] = "2708daa534fbbc83d31579e85a6fa343a0d89e7da9fe01b5a966432be4a41e65"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/siguldry-0.9.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_siguldry;unpack=0"
SRC_URI[x86_64_v2_siguldry.sha256sum] = "5b052a8b97a0f94903fd23ab694c1e28e815d86ec32504c37a8b745eb3525ec3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siguldry+cli-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-siguldry+cli-devel;unpack=0"
SRC_URI[aarch64_rust-siguldry+cli-devel.sha256sum] = "d719208cc82fda2ad907f9a9468a23994a55eb8442a47afe0e22aceef2ee52d5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siguldry+default-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-siguldry+default-devel;unpack=0"
SRC_URI[aarch64_rust-siguldry+default-devel.sha256sum] = "ee339eb6fcd5731ab432b80172100500efb5b5ba428d75c092928532ee961b35"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siguldry+server-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-siguldry+server-devel;unpack=0"
SRC_URI[aarch64_rust-siguldry+server-devel.sha256sum] = "bf81bca41005668f7ee363fa3800803b4f5e9b0290f076ba5fe8ee665dad8bcd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siguldry+sigul-client-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-siguldry+sigul-client-devel;unpack=0"
SRC_URI[aarch64_rust-siguldry+sigul-client-devel.sha256sum] = "89090bbfcd98abb4f41438971c5757fd5ba37d4395c12f29fa6e6fc21af28c26"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siguldry-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-siguldry-devel;unpack=0"
SRC_URI[aarch64_rust-siguldry-devel.sha256sum] = "5127898e4186ca7ef5b249c090074b139c3f26a219017d443ac4e9b66d365863"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/siguldry-0.9.0-1.el10_3.aarch64.rpm;name=aarch64_siguldry;unpack=0"
SRC_URI[aarch64_siguldry.sha256sum] = "9a76121bcbbead660e8d11fb59b582e3ff3e786bd83032170f62fa6f10914701"

RDEPENDS:rust-siguldry+cli-devel = " \
 cargo \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+error-context-devel \
 rust-clap+help-devel \
 rust-clap+std-devel \
 rust-clap+usage-devel \
 rust-clap-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+process-devel \
 rust-rustix+stdio-devel \
 rust-rustix+termios-devel \
 rust-siguldry-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+registry-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-siguldry+default-devel = " \
 cargo \
 rust-siguldry+cli-devel \
 rust-siguldry+server-devel \
 rust-siguldry-devel \
 "
RDEPENDS:rust-siguldry+server-devel = " \
 cargo \
 rust-cryptoki+default-devel \
 rust-rustix+default-devel \
 rust-rustix+stdio-devel \
 rust-rustix+termios-devel \
 rust-siguldry-devel \
 rust-sqlx+default-devel \
 rust-sqlx+macros-devel \
 rust-sqlx+migrate-devel \
 rust-sqlx+runtime-tokio-devel \
 rust-sqlx+sqlite-unbundled-devel \
 "
RDEPENDS:rust-siguldry+sigul-client-devel = " \
 cargo \
 rust-siguldry-devel \
 "
RDEPENDS:rust-siguldry-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-asn1+default-devel \
 rust-bytes+default-devel \
 rust-foreign-types0.3+default-devel \
 rust-hex+default-devel \
 rust-libc+default-devel \
 rust-openssl+default-devel \
 rust-openssl-sys-devel \
 rust-sequoia-openpgp+crypto-openssl-devel \
 rust-sequoia-openpgp-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 rust-tokio+default-devel \
 rust-tokio+io-std-devel \
 rust-tokio+io-util-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+signal-devel \
 rust-tokio+time-devel \
 rust-tokio-openssl+default-devel \
 rust-tokio-util+default-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util+rt-devel \
 rust-toml+default-devel \
 rust-tracing+default-devel \
 rust-uuid+default-devel \
 rust-uuid+serde-devel \
 rust-uuid+v7-devel \
 rust-zerocopy+default-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+std-devel \
 "
RDEPENDS:siguldry = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 sqlite-libs \
 "
