# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyliblo3"
PV = "0.16.3"
PR = "1.el10_1"
PACKAGES = " \
 python-pyliblo3-doc \
 python3-pyliblo3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyliblo3-0.16.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54b0a15a9c826659097e4fec60134343793d1cbc797d3fda899607c157cdd80a"

URI_x86_64_v2_python-pyliblo3-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pyliblo3-doc-0.16.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-pyliblo3-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pyliblo3-doc}"
SRC_URI[x86_64_v2_python-pyliblo3-doc.sha256sum] = "09932cf7677e34b94ad040085b4a56bc3e635064674590241adbda9efa5ca619"

URI_x86_64_v2_python3-pyliblo3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyliblo3-0.16.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyliblo3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyliblo3}"
SRC_URI[x86_64_v2_python3-pyliblo3.sha256sum] = "edb2b2b30f1547fbd7fed7e4733524f844fadcaee30abca3a2c97a4844be70f8"

URI_aarch64_python-pyliblo3-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-pyliblo3-doc-0.16.3-1.el10_1.noarch.rpm;name=aarch64_python-pyliblo3-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pyliblo3-doc}"
SRC_URI[aarch64_python-pyliblo3-doc.sha256sum] = "e12e557b9261fc8df7b93638cb1ed5b4a1cd9beff6771a598c7eb1d5b2bc949e"

URI_aarch64_python3-pyliblo3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyliblo3-0.16.3-1.el10_1.aarch64.rpm;name=aarch64_python3-pyliblo3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyliblo3}"
SRC_URI[aarch64_python3-pyliblo3.sha256sum] = "89692069ebfea34e2a9b4969f126040515b0d19600b74e2408e444f2dd0bfb73"

RDEPENDS:python-pyliblo3-doc = " \
 "
RDEPENDS:python3-pyliblo3 = " \
 glibc \
 liblo \
 python3 \
 "
