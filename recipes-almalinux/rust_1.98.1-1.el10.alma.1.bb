# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust"
PV = "1.98.1"
PR = "1.el10.alma.1"
PACKAGES = " \
 cargo \
 clippy \
 rust \
 rust-analyzer \
 rust-debugger-common \
 rust-doc \
 rust-gdb \
 rust-lldb \
 rust-src \
 rust-std-static \
 rust-std-static-aarch64-unknown-none-softfloat \
 rust-std-static-wasm32-unknown-unknown \
 rust-std-static-wasm32-wasip1 \
 rust-std-static-x86_64-unknown-none \
 rust-toolset \
 rust-toolset-srpm-macros \
 rustfmt \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-1.98.1-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d2a8f46edefa2315d84a0b3b12855234a27b0339abc8a61c29f93e7bf1dfb664"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cargo-1.98.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_cargo;unpack=0"
SRC_URI[x86_64_v2_cargo.sha256sum] = "9c5ccf265e80f532c68dfda57d0f71e2fa87d9d311f2743736dc1c5fee34ac08"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clippy-1.98.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clippy;unpack=0"
SRC_URI[x86_64_v2_clippy.sha256sum] = "b960ef6836f3824bdd078f8b279d63e96309de78140625a17c42cf3ce6f639eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-1.98.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust;unpack=0"
SRC_URI[x86_64_v2_rust.sha256sum] = "e0ca0355db97ebb314e27c285483bc343ee42cf0e8ffcc2221d47668f5293c70"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-analyzer-1.98.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-analyzer;unpack=0"
SRC_URI[x86_64_v2_rust-analyzer.sha256sum] = "778b50e7cdc8e17391e4a5a6c58314fb5cc73e65c9cc1dd0aa04a190cf801651"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-debugger-common-1.98.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-debugger-common;unpack=0"
SRC_URI[x86_64_v2_rust-debugger-common.sha256sum] = "4c540fe1c3325a92e7a308e1c43bb61126968d59d1afd4dc68ca4a1efb2a3b4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-doc-1.98.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-doc;unpack=0"
SRC_URI[x86_64_v2_rust-doc.sha256sum] = "09e7b2c6fbf2a41c1866993b7481ea62346a08ef045a97fbf42091e686fce5a0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-gdb-1.98.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-gdb;unpack=0"
SRC_URI[x86_64_v2_rust-gdb.sha256sum] = "02fd1a36902e7a7302547b528d2a87a29294bd3b8a79384c9c4308a3bdb06da0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-lldb-1.98.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-lldb;unpack=0"
SRC_URI[x86_64_v2_rust-lldb.sha256sum] = "20ac5f1e57d9a3eda622b5f9ea6a6b7afc05284ea1088dc1942ec696fdc50e91"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-src-1.98.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-src;unpack=0"
SRC_URI[x86_64_v2_rust-src.sha256sum] = "c60ae5b053454f43a18fc8fd70f39d758fe58baa6ce19ff460d843ebdd2fa2e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-1.98.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-std-static;unpack=0"
SRC_URI[x86_64_v2_rust-std-static.sha256sum] = "37065599bc07cbedc1501c178fe7e366681b95a4137db7f4cb61011ce6e53358"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rust-std-static-aarch64-unknown-none-softfloat-1.98.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-std-static-aarch64-unknown-none-softfloat;unpack=0"
SRC_URI[x86_64_v2_rust-std-static-aarch64-unknown-none-softfloat.sha256sum] = "c66a28aac95e3f164fa75e4b8dcff3857e928e48ae356f5260b82c91fd147f85"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-wasm32-unknown-unknown-1.98.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-std-static-wasm32-unknown-unknown;unpack=0"
SRC_URI[x86_64_v2_rust-std-static-wasm32-unknown-unknown.sha256sum] = "c35949e72528a5f000ad6ab39891c4bacd2d7106d15b2186dadbc179847bd379"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-wasm32-wasip1-1.98.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-std-static-wasm32-wasip1;unpack=0"
SRC_URI[x86_64_v2_rust-std-static-wasm32-wasip1.sha256sum] = "6203415f418394bbd181e10a56c60fc0870a88be4347820f9ed8824d93896e9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rust-std-static-x86_64-unknown-none-1.98.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-std-static-x86_64-unknown-none;unpack=0"
SRC_URI[x86_64_v2_rust-std-static-x86_64-unknown-none.sha256sum] = "7cf0abf1e278170eabd6c97e893c4a1c4822044e86af90203dcc0160f95bd05a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-toolset-1.98.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-toolset;unpack=0"
SRC_URI[x86_64_v2_rust-toolset.sha256sum] = "3f07fcd7982de0287be750be1b5f0d370a572a5669fff77b27f5b08814cd3896"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-toolset-srpm-macros-1.98.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-toolset-srpm-macros;unpack=0"
SRC_URI[x86_64_v2_rust-toolset-srpm-macros.sha256sum] = "72d255c45bb564111891d34eff395591eace54548e53bbf24aa028b0e1f8d8c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rustfmt-1.98.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rustfmt;unpack=0"
SRC_URI[x86_64_v2_rustfmt.sha256sum] = "a19610f3e7a978e3fdc2b8bc425137b5f9061215a16d0f8f81b15d7683e97866"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cargo-1.98.1-1.el10.alma.1.aarch64.rpm;name=aarch64_cargo;unpack=0"
SRC_URI[aarch64_cargo.sha256sum] = "442f5344723cc72700bd67acfebbd9bbdc370a46557bca650d336df72b4d8494"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clippy-1.98.1-1.el10.alma.1.aarch64.rpm;name=aarch64_clippy;unpack=0"
SRC_URI[aarch64_clippy.sha256sum] = "d6df3f18162b693a8a7d1fb2f6b0e66a67f4f8872bb46aa969d70147c15f6af1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-1.98.1-1.el10.alma.1.aarch64.rpm;name=aarch64_rust;unpack=0"
SRC_URI[aarch64_rust.sha256sum] = "f371883338b6fda956e2a6604bb30a87db6876542c47bd2d8dbcb8d59970da84"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-analyzer-1.98.1-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-analyzer;unpack=0"
SRC_URI[aarch64_rust-analyzer.sha256sum] = "4dea6078976570af575be861a79488c0fe0cb38f6fd632d023591a9ef0967db4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-debugger-common-1.98.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-debugger-common;unpack=0"
SRC_URI[aarch64_rust-debugger-common.sha256sum] = "4c540fe1c3325a92e7a308e1c43bb61126968d59d1afd4dc68ca4a1efb2a3b4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-doc-1.98.1-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-doc;unpack=0"
SRC_URI[aarch64_rust-doc.sha256sum] = "8d9c2c8e0df9abca1d2b28e6cd0858caae879b3f8cfa26aef9eadecdac4ff838"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-gdb-1.98.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-gdb;unpack=0"
SRC_URI[aarch64_rust-gdb.sha256sum] = "02fd1a36902e7a7302547b528d2a87a29294bd3b8a79384c9c4308a3bdb06da0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-lldb-1.98.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-lldb;unpack=0"
SRC_URI[aarch64_rust-lldb.sha256sum] = "20ac5f1e57d9a3eda622b5f9ea6a6b7afc05284ea1088dc1942ec696fdc50e91"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-src-1.98.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-src;unpack=0"
SRC_URI[aarch64_rust-src.sha256sum] = "c60ae5b053454f43a18fc8fd70f39d758fe58baa6ce19ff460d843ebdd2fa2e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-1.98.1-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-std-static;unpack=0"
SRC_URI[aarch64_rust-std-static.sha256sum] = "6782bc9cbbdddc010c2d76617f86de52d7e5fd04209f6c9aeafa250010166bae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rust-std-static-aarch64-unknown-none-softfloat-1.98.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-std-static-aarch64-unknown-none-softfloat;unpack=0"
SRC_URI[aarch64_rust-std-static-aarch64-unknown-none-softfloat.sha256sum] = "c66a28aac95e3f164fa75e4b8dcff3857e928e48ae356f5260b82c91fd147f85"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-wasm32-unknown-unknown-1.98.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-std-static-wasm32-unknown-unknown;unpack=0"
SRC_URI[aarch64_rust-std-static-wasm32-unknown-unknown.sha256sum] = "c35949e72528a5f000ad6ab39891c4bacd2d7106d15b2186dadbc179847bd379"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-wasm32-wasip1-1.98.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-std-static-wasm32-wasip1;unpack=0"
SRC_URI[aarch64_rust-std-static-wasm32-wasip1.sha256sum] = "6203415f418394bbd181e10a56c60fc0870a88be4347820f9ed8824d93896e9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rust-std-static-x86_64-unknown-none-1.98.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-std-static-x86_64-unknown-none;unpack=0"
SRC_URI[aarch64_rust-std-static-x86_64-unknown-none.sha256sum] = "7cf0abf1e278170eabd6c97e893c4a1c4822044e86af90203dcc0160f95bd05a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-toolset-1.98.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-toolset;unpack=0"
SRC_URI[aarch64_rust-toolset.sha256sum] = "3f07fcd7982de0287be750be1b5f0d370a572a5669fff77b27f5b08814cd3896"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-toolset-srpm-macros-1.98.1-1.el10.alma.1.noarch.rpm;name=aarch64_rust-toolset-srpm-macros;unpack=0"
SRC_URI[aarch64_rust-toolset-srpm-macros.sha256sum] = "72d255c45bb564111891d34eff395591eace54548e53bbf24aa028b0e1f8d8c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rustfmt-1.98.1-1.el10.alma.1.aarch64.rpm;name=aarch64_rustfmt;unpack=0"
SRC_URI[aarch64_rustfmt.sha256sum] = "05578547a4e5eaacb573d6868e359f834b4736a41e7683a2d9423c0a5f3c4216"

RDEPENDS:cargo = " \
 glibc \
 libgcc \
 openssl-libs \
 rust \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clippy = " \
 cargo \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust = " \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 rust-std-static \
 "
RDEPENDS:rust-analyzer = " \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust-debugger-common = " \
 "
RDEPENDS:rust-doc = " \
 "
RDEPENDS:rust-gdb = " \
 bash \
 gdb \
 rust \
 rust-debugger-common \
 "
RDEPENDS:rust-lldb = " \
 bash \
 lldb \
 python3-lldb \
 rust \
 rust-debugger-common \
 "
RDEPENDS:rust-src = " \
 "
RDEPENDS:rust-std-static = " \
 glibc \
 glibc-devel \
 libgcc \
 rust \
 "
RDEPENDS:rust-std-static-aarch64-unknown-none-softfloat = " \
 lld \
 rust \
 "
RDEPENDS:rust-std-static-wasm32-unknown-unknown = " \
 lld \
 rust \
 "
RDEPENDS:rust-std-static-wasm32-wasip1 = " \
 lld \
 rust \
 "
RDEPENDS:rust-std-static-x86_64-unknown-none = " \
 lld \
 rust \
 "
RDEPENDS:rust-toolset = " \
 cargo \
 python3 \
 rust \
 rust-toolset-srpm-macros \
 "
RDEPENDS:rust-toolset-srpm-macros = " \
 "
RDEPENDS:rustfmt = " \
 cargo \
 glibc \
 libgcc \
 rust \
 "
