# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libfontenc"
PV = "1.1.7"
PR = "5.el10"
PACKAGES = " \
 libfontenc \
 libfontenc-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libfontenc-1.1.7-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a849fcc0f4e7e4df3fbab2dffcea8366ada4dba26b11a50c620bc4f825ce028"

URI_x86_64_v2_libfontenc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libfontenc-1.1.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_libfontenc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfontenc}"
SRC_URI[x86_64_v2_libfontenc.sha256sum] = "e0632c28ecd0a3adbcbd33338980bb488c1e4008d3d28ed76d3ea3602c5b1823"

URI_x86_64_v2_libfontenc-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libfontenc-devel-1.1.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_libfontenc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfontenc-devel}"
SRC_URI[x86_64_v2_libfontenc-devel.sha256sum] = "7721e4309d2e40e4af5e8944ba7f783268d05b40ca5c4aa6b3dbecddcfc38733"

URI_aarch64_libfontenc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libfontenc-1.1.7-5.el10.aarch64.rpm;name=aarch64_libfontenc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfontenc}"
SRC_URI[aarch64_libfontenc.sha256sum] = "5f692040f380137190590e02f3c840a058ce7549034512a53cdbe2f9dd578dce"

URI_aarch64_libfontenc-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libfontenc-devel-1.1.7-5.el10.aarch64.rpm;name=aarch64_libfontenc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfontenc-devel}"
SRC_URI[aarch64_libfontenc-devel.sha256sum] = "efcfe34e83bc772a4c0b73e0c3271d232c23ffa89c65c2efc9878a6e7f05a37b"

RDEPENDS:libfontenc = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:libfontenc-devel = " \
 libfontenc \
 pkgconf-pkg-config \
 "
