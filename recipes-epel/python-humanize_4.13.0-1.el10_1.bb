# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-humanize"
PV = "4.13.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-humanize \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-humanize-4.13.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34cd4240ef9b441cf8cdf38e502ad4f056cf727350db6567f3ef0ad1946641ab"

URI_x86_64_v2_python3-humanize = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-humanize-4.13.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-humanize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-humanize}"
SRC_URI[x86_64_v2_python3-humanize.sha256sum] = "28e8e31d31339bb46f7cca9056c1cf6675ada7154b93f65da205067a19dbb3ac"

URI_aarch64_python3-humanize = "${EPEL_MIRROR}/aarch64/Packages/p/python3-humanize-4.13.0-1.el10_1.noarch.rpm;name=aarch64_python3-humanize;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-humanize}"
SRC_URI[aarch64_python3-humanize.sha256sum] = "9e87376e2ebff1224248b4ec0861effe00a2094f8ebd0c196d01956c0a68656c"

RDEPENDS:python3-humanize = " \
 python3 \
 "
