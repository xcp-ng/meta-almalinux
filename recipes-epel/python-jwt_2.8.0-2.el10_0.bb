# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jwt"
PV = "2.8.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-jwt \
 python3-jwt+crypto \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jwt-2.8.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83a37a74b7bec67f84fcebd69b3b5b5b503978f4e995a01f742e6a50a3af1e4b"

URI_x86_64_v2_python3-jwt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jwt-2.8.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jwt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jwt}"
SRC_URI[x86_64_v2_python3-jwt.sha256sum] = "05ca2b52fa7d68809c51009dd3411277ba9da9bc6167ca2446576c8dca8a187d"

URI_x86_64_v2_python3-jwt+crypto = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jwt+crypto-2.8.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jwt+crypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jwt+crypto}"
SRC_URI[x86_64_v2_python3-jwt+crypto.sha256sum] = "f46925d1e87586ce9c7964f18716b6902e6a420ff7b011b19661e65a60d5143f"

URI_aarch64_python3-jwt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jwt-2.8.0-2.el10_0.noarch.rpm;name=aarch64_python3-jwt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jwt}"
SRC_URI[aarch64_python3-jwt.sha256sum] = "616ad316bfb633b62735528daed83e51b0e778a597aacab028d59f2cfe7a8a33"

URI_aarch64_python3-jwt+crypto = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jwt+crypto-2.8.0-2.el10_0.noarch.rpm;name=aarch64_python3-jwt+crypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jwt+crypto}"
SRC_URI[aarch64_python3-jwt+crypto.sha256sum] = "1a671a36b2708f794539ccf5add089f7220543e90788be4efd68b020c70f2582"

RDEPENDS:python3-jwt = " \
 python3 \
 "
RDEPENDS:python3-jwt+crypto = " \
 python3 \
 python3-cryptography \
 python3-jwt \
 "
