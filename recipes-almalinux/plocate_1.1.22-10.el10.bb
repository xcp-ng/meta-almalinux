# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plocate"
PV = "1.1.22"
PR = "10.el10"
PACKAGES = " \
 plocate \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/plocate-1.1.22-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c5dcfe4d2d3bde50626267c8eeca6e8fa71049fcad8a422dc53bb6c6eec2166"

URI_x86_64_v2_plocate = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/plocate-1.1.22-10.el10.x86_64_v2.rpm;name=x86_64_v2_plocate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plocate}"
SRC_URI[x86_64_v2_plocate.sha256sum] = "b8f2152d9515263fd2f3e77e532f31cb4b0dfe50a8400a120104860059a82c44"

URI_aarch64_plocate = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/plocate-1.1.22-10.el10.aarch64.rpm;name=aarch64_plocate;unpack=0"
SRC_URI:append = " ${URI_aarch64_plocate}"
SRC_URI[aarch64_plocate.sha256sum] = "162c650ead7a3c3fdfec3b779233e247814bd3d1de0c626ee4ad5e74010f8db4"

RDEPENDS:plocate = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 liburing \
 libzstd \
 "
