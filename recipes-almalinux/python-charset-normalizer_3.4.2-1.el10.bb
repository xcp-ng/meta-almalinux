# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-charset-normalizer"
PV = "3.4.2"
PR = "1.el10"
PACKAGES = " \
 python3-charset-normalizer \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-charset-normalizer-3.4.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9770f7201608fd6f386caac8df3315e343666d6650c9a24c4b6316dda15e2d0c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-charset-normalizer-3.4.2-1.el10.noarch.rpm;name=x86_64_v2_python3-charset-normalizer;unpack=0"
SRC_URI[x86_64_v2_python3-charset-normalizer.sha256sum] = "b84531608508ff1f8acc646e47aebace24ef8e463803a5623d684224603eb50c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-charset-normalizer-3.4.2-1.el10.noarch.rpm;name=aarch64_python3-charset-normalizer;unpack=0"
SRC_URI[aarch64_python3-charset-normalizer.sha256sum] = "b84531608508ff1f8acc646e47aebace24ef8e463803a5623d684224603eb50c"

RDEPENDS:python3-charset-normalizer = " \
 python3 \
 "
