# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-websockets"
PV = "14.2"
PR = "2.el10_0"
PACKAGES = " \
 python3-websockets \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-websockets-14.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d246d3c2cb1b36b4e9354c69b73f63176f113dc2814c4ab1c84abdfaae70cea2"

URI_x86_64_v2_python3-websockets = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-websockets-14.2-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-websockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-websockets}"
SRC_URI[x86_64_v2_python3-websockets.sha256sum] = "c5ed93a3bc385581d2d741fd63913b04e83515e457c8e3780765c7b64cfc3343"

URI_aarch64_python3-websockets = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-websockets-14.2-2.el10_0.aarch64.rpm;name=aarch64_python3-websockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-websockets}"
SRC_URI[aarch64_python3-websockets.sha256sum] = "a5b4551c0b3678a7ac6455c06b2c7d8561a3bb1541b56a08529c3acd8e5cee47"

RDEPENDS:python3-websockets = " \
 glibc \
 python3 \
 "
