# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpmconf"
PV = "1.1.11"
PR = "3.el10_0"
PACKAGES = " \
 python3-rpmconf \
 python3-rpmconf-doc \
 rpmconf \
 rpmconf-base \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rpmconf-1.1.11-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bee9bdfffe6a7d9ed9fc51cb3fff0a5e9352e6d0a6d7cf7c9d4f998186fd1c9"

URI_x86_64_v2_python3-rpmconf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpmconf-1.1.11-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpmconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpmconf}"
SRC_URI[x86_64_v2_python3-rpmconf.sha256sum] = "37b6249b48baf653c23aad62e86703ded77dce1b855d9d5723bc4c449e33234d"

URI_x86_64_v2_python3-rpmconf-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpmconf-doc-1.1.11-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpmconf-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpmconf-doc}"
SRC_URI[x86_64_v2_python3-rpmconf-doc.sha256sum] = "fcf1cb3b321250634ae05edade60f43bf32c3cecaab509d49b098458d4d6f081"

URI_x86_64_v2_rpmconf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmconf-1.1.11-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rpmconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmconf}"
SRC_URI[x86_64_v2_rpmconf.sha256sum] = "80dc4b29ba240854ab2ed8304a5e860d7ac5f23fa5f44fa8074981647ac9c283"

URI_x86_64_v2_rpmconf-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmconf-base-1.1.11-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rpmconf-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmconf-base}"
SRC_URI[x86_64_v2_rpmconf-base.sha256sum] = "39c18b80d62e43095083d2d702e8a588d64daa5c9626dcaf0d1393ec64a2dabf"

URI_aarch64_python3-rpmconf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpmconf-1.1.11-3.el10_0.noarch.rpm;name=aarch64_python3-rpmconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpmconf}"
SRC_URI[aarch64_python3-rpmconf.sha256sum] = "58e45bde3999717bda6eea6a18f2b66fc033c175713b3f47ca5570fc962f953e"

URI_aarch64_python3-rpmconf-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpmconf-doc-1.1.11-3.el10_0.noarch.rpm;name=aarch64_python3-rpmconf-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpmconf-doc}"
SRC_URI[aarch64_python3-rpmconf-doc.sha256sum] = "c4824506ccd8fe8613ba5ab9d20c5a6868e6b68a9a8a4dc40cb8e34861d361a1"

URI_aarch64_rpmconf = "${EPEL_MIRROR}/aarch64/Packages/r/rpmconf-1.1.11-3.el10_0.noarch.rpm;name=aarch64_rpmconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmconf}"
SRC_URI[aarch64_rpmconf.sha256sum] = "088e1471ed2da5b21fe074877bc1526bef21af5f874ae45a8c75b6376c1ba6f4"

URI_aarch64_rpmconf-base = "${EPEL_MIRROR}/aarch64/Packages/r/rpmconf-base-1.1.11-3.el10_0.noarch.rpm;name=aarch64_rpmconf-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmconf-base}"
SRC_URI[aarch64_rpmconf-base.sha256sum] = "324d3194e85ae0f3e849e8ca264c2875f96e97eedde3788f173b811eae5e2dcb"

RDEPENDS:python3-rpmconf = " \
 python3 \
 "
RDEPENDS:python3-rpmconf-doc = " \
 "
RDEPENDS:rpmconf = " \
 python3 \
 python3-rpm \
 python3-rpmconf \
 rpmconf-base \
 "
RDEPENDS:rpmconf-base = " \
 "
