# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "travelccm"
PV = "1.00.11"
PR = "1.el10_2"
PACKAGES = " \
 travelccm \
 travelccm-devel \
 travelccm-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/travelccm-1.00.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c534cc08a423cf220b07b4229e79b8f9bac7001ed3619ec23448754cdab7ec1"

URI_x86_64_v2_travelccm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/travelccm-1.00.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_travelccm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_travelccm}"
SRC_URI[x86_64_v2_travelccm.sha256sum] = "9c30a898914be98eacea996900677cb7caf8c43b5c18c221e4e5a37e92bfd7cb"

URI_x86_64_v2_travelccm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/travelccm-devel-1.00.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_travelccm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_travelccm-devel}"
SRC_URI[x86_64_v2_travelccm-devel.sha256sum] = "a0b19816a338f41e316425459534077b54ca361c397be117f4e8c24ad23f0aea"

URI_x86_64_v2_travelccm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/travelccm-doc-1.00.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_travelccm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_travelccm-doc}"
SRC_URI[x86_64_v2_travelccm-doc.sha256sum] = "2b89ea48733368745a096c564572a3bcc9b336b35c53a5f226216b72a8218c7e"

URI_aarch64_travelccm = "${EPEL_MIRROR}/aarch64/Packages/t/travelccm-1.00.11-1.el10_2.aarch64.rpm;name=aarch64_travelccm;unpack=0"
SRC_URI:append = " ${URI_aarch64_travelccm}"
SRC_URI[aarch64_travelccm.sha256sum] = "5c17b83182a8a63bdf3c56b34bb6e56c1ad804ba992795807c6499559b54a067"

URI_aarch64_travelccm-devel = "${EPEL_MIRROR}/aarch64/Packages/t/travelccm-devel-1.00.11-1.el10_2.aarch64.rpm;name=aarch64_travelccm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_travelccm-devel}"
SRC_URI[aarch64_travelccm-devel.sha256sum] = "80ca02617789ecb72c3527c0e25bdd37f51c9bdd9fc5883b44cf3ab706b9341d"

URI_aarch64_travelccm-doc = "${EPEL_MIRROR}/aarch64/Packages/t/travelccm-doc-1.00.11-1.el10_2.noarch.rpm;name=aarch64_travelccm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_travelccm-doc}"
SRC_URI[aarch64_travelccm-doc.sha256sum] = "e9cbbff745f3641e9c8203519d7b8fea10641c4b9601748dc6d5a4c76c033654"

RDEPENDS:travelccm = " \
 boost-program-options \
 glibc \
 libgcc \
 libstdc++ \
 stdair \
 "
RDEPENDS:travelccm-devel = " \
 bash \
 cmake-filesystem \
 pkgconf-pkg-config \
 travelccm \
 "
RDEPENDS:travelccm-doc = " \
 "
