# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-protox-parse"
PV = "0.9.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-protox-parse+default-devel \
 rust-protox-parse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-protox-parse-0.9.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b53b31490ec8f8f0e47388fd6aa7a6212ec844a161ec370efbe40b999295043e"

URI_x86_64_v2_rust-protox-parse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-protox-parse+default-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-protox-parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-protox-parse+default-devel}"
SRC_URI[x86_64_v2_rust-protox-parse+default-devel.sha256sum] = "aca6e859a7dc72894dce3064fca814b067f92fc7df5bb50aa6d7ddcb57e62842"

URI_x86_64_v2_rust-protox-parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-protox-parse-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-protox-parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-protox-parse-devel}"
SRC_URI[x86_64_v2_rust-protox-parse-devel.sha256sum] = "37268910679cd671c5c888076627fa4ec42371c5cd15d77b00c3fd2ff4a55169"

URI_aarch64_rust-protox-parse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-protox-parse+default-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-protox-parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-protox-parse+default-devel}"
SRC_URI[aarch64_rust-protox-parse+default-devel.sha256sum] = "7dfab3f81e8f294b4db2501389f31f91566a4fa212ec89a628a5b3a590891cc6"

URI_aarch64_rust-protox-parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-protox-parse-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-protox-parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-protox-parse-devel}"
SRC_URI[aarch64_rust-protox-parse-devel.sha256sum] = "cb1617f790bee0ada82bc2e285f281ad1ec6a5d11edd4384c8e28034cf632244"

RDEPENDS:rust-protox-parse+default-devel = " \
 cargo \
 rust-protox-parse-devel \
 "
RDEPENDS:rust-protox-parse-devel = " \
 cargo \
 rust \
 rust-logos+default-devel \
 rust-miette+default-devel \
 rust-prost-types+default-devel \
 rust-thiserror+default-devel \
 "
