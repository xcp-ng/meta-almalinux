# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtasn1"
PV = "4.20.0"
PR = "1.el10"
PACKAGES = " \
 libtasn1 \
 libtasn1-devel \
 libtasn1-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libtasn1-4.20.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9030ab43374c0ce6a1da8e68138d4aea7fb64762b7a66f68a0f1f38d5d30df2d"

URI_x86_64_v2_libtasn1 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libtasn1-4.20.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libtasn1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtasn1}"
SRC_URI[x86_64_v2_libtasn1.sha256sum] = "87389257451e49f97c457124c68283ffbd020326e830ffe7f799f448dd6d3c1e"

URI_x86_64_v2_libtasn1-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtasn1-devel-4.20.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libtasn1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtasn1-devel}"
SRC_URI[x86_64_v2_libtasn1-devel.sha256sum] = "1e9f0b92c0ed1da730230df845a17645d2885065a9ff5784e7e8474bf08a54b6"

URI_x86_64_v2_libtasn1-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtasn1-tools-4.20.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libtasn1-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtasn1-tools}"
SRC_URI[x86_64_v2_libtasn1-tools.sha256sum] = "586be6af1af8911645dd5628bd3196447abab38c5e74aba58784ad76504b97ab"

URI_aarch64_libtasn1 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libtasn1-4.20.0-1.el10.aarch64.rpm;name=aarch64_libtasn1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtasn1}"
SRC_URI[aarch64_libtasn1.sha256sum] = "3ede15f956344d5d8d59648094868a08607868ab6522a9d1a992f8f39b1fa570"

URI_aarch64_libtasn1-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtasn1-devel-4.20.0-1.el10.aarch64.rpm;name=aarch64_libtasn1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtasn1-devel}"
SRC_URI[aarch64_libtasn1-devel.sha256sum] = "38865aecbf95081940d161bb702c9a2e9ccdb0ee23d376e58c2a087d9fad2fd5"

URI_aarch64_libtasn1-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtasn1-tools-4.20.0-1.el10.aarch64.rpm;name=aarch64_libtasn1-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtasn1-tools}"
SRC_URI[aarch64_libtasn1-tools.sha256sum] = "3e73e8e4e586c5c8e943c2261fbfa63399b44e7de52278aa9fe8d38019c1bcf2"

RDEPENDS:libtasn1 = " \
 glibc \
 "
RDEPENDS:libtasn1-devel = " \
 libtasn1 \
 libtasn1-tools \
 pkgconf-pkg-config \
 "
RDEPENDS:libtasn1-tools = " \
 glibc \
 libtasn1 \
 "
