# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-integration"
PV = "6.7.5"
PR = "1.1.el10_3"
PACKAGES = " \
 plasma-integration \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-integration-6.7.5-1.1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ffb4b510e5bcb4ec9f187b72db902eb6129adb1c1aa6d0c1a9e5583999b26977"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-integration-6.7.5-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-integration;unpack=0"
SRC_URI[x86_64_v2_plasma-integration.sha256sum] = "9d2984ce7d1524c4b43177d4b2cdda034b7d1746aeb88b0a5069895f50b1d904"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-integration-6.7.5-1.1.el10_3.aarch64.rpm;name=aarch64_plasma-integration;unpack=0"
SRC_URI[aarch64_plasma-integration.sha256sum] = "68e592e12913cbb2ae2f0a8688d265cbaba6f1b71861658cb93f768e5f800ffd"

RDEPENDS:plasma-integration = " \
 breeze-cursor-theme \
 breeze-icon-theme \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-qqc2-desktop-style \
 libXcursor \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-breeze \
 qqc2-breeze-style \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 virtual/font_notosans_ \
 "
