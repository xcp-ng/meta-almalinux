# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Pod-Checker"
PE = "4"
PV = "1.77"
PR = "511.el10"
PACKAGES = " \
 perl-Pod-Checker \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Pod-Checker-1.77-511.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6a7a1df18043c3b245591930f359a0994ca4d92dcc08a6dbc60c1310e2a5daa9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Pod-Checker-1.77-511.el10.noarch.rpm;name=x86_64_v2_perl-Pod-Checker;unpack=0"
SRC_URI[x86_64_v2_perl-Pod-Checker.sha256sum] = "a822d46b937093eba8b8f9b03d5ded24c66cee0d32b0534c0d6341d158618c23"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Pod-Checker-1.77-511.el10.noarch.rpm;name=aarch64_perl-Pod-Checker;unpack=0"
SRC_URI[aarch64_perl-Pod-Checker.sha256sum] = "a822d46b937093eba8b8f9b03d5ded24c66cee0d32b0534c0d6341d158618c23"

RDEPENDS:perl-Pod-Checker = " \
 perl-Carp \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Pod-Checker \
 perl-Pod-Simple \
 perl-Pod-Usage \
 perl-base \
 perl-interpreter \
 perl-libs \
 "
