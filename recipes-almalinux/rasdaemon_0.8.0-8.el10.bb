# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rasdaemon"
PV = "0.8.0"
PR = "8.el10"
PACKAGES = " \
 rasdaemon \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rasdaemon-0.8.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d84d596b3c66e4b5026425bd4b8f6df4f9c89ff01870f686d638501d0a3757ac"

URI_x86_64_v2_rasdaemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rasdaemon-0.8.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_rasdaemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rasdaemon}"
SRC_URI[x86_64_v2_rasdaemon.sha256sum] = "66edb902b86206319bc298ebbe64ff00315fe4822d5be9ed15732bd4abb9b4d0"

URI_aarch64_rasdaemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rasdaemon-0.8.0-8.el10.aarch64.rpm;name=aarch64_rasdaemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_rasdaemon}"
SRC_URI[aarch64_rasdaemon.sha256sum] = "a8b44904948376017e1a0d7a2ccec6c60bf25f7f46477981f12520b45281cf66"

RDEPENDS:rasdaemon:x86_64_v2 = " \
 dmidecode \
 glibc \
 hwdata \
 libtraceevent \
 perl-DBD-SQLite \
 perl-File-Basename \
 perl-File-Find \
 perl-Getopt-Long \
 perl-POSIX \
 perl-constant \
 perl-interpreter \
 perl-libs \
 sqlite-libs \
 systemd \
"
RDEPENDS:rasdaemon:aarch64 = " \
 glibc \
 hwdata \
 libtraceevent \
 perl-DBD-SQLite \
 perl-File-Basename \
 perl-File-Find \
 perl-Getopt-Long \
 perl-POSIX \
 perl-constant \
 perl-interpreter \
 perl-libs \
 sqlite-libs \
 systemd \
"
