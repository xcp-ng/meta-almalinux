# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-yac"
PV = "2.3.1"
PR = "14.el10_0"
PACKAGES = " \
 php-pecl-yac \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-yac-2.3.1-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b2b35ea3717fba24c079ec1c58658f31d2cf31c37f6901b9e647814493f657c"

URI_x86_64_v2_php-pecl-yac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-yac-2.3.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-yac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-yac}"
SRC_URI[x86_64_v2_php-pecl-yac.sha256sum] = "371b018b79aa780e89880a5933e28591a33e5c0c0c5fd4644fb77966fe81e39f"

URI_aarch64_php-pecl-yac = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-yac-2.3.1-14.el10_0.aarch64.rpm;name=aarch64_php-pecl-yac;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-yac}"
SRC_URI[aarch64_php-pecl-yac.sha256sum] = "b152062d8a8f4b3a5c8fd1207dfc46fda21e8dba8de036e63b51773a0358b2eb"

RDEPENDS:php-pecl-yac = " \
 fastlz \
 glibc \
 php-common \
 php-pecl-igbinary \
 php-pecl-msgpack \
 "
