# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kolourpaint"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kolourpaint \
 kolourpaint-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kolourpaint-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ece12593ebd8247548b04a8893ca9409c401b09fb2e1161c3274061840790ea"

URI_x86_64_v2_kolourpaint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kolourpaint-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kolourpaint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kolourpaint}"
SRC_URI[x86_64_v2_kolourpaint.sha256sum] = "c59d1827fe2cb2c980fc72c1c1eb602423d9f6b895c2d2d9cbfae018f049310f"

URI_x86_64_v2_kolourpaint-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kolourpaint-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kolourpaint-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kolourpaint-libs}"
SRC_URI[x86_64_v2_kolourpaint-libs.sha256sum] = "f34d5174229731e8426eba9873f60ed46248aa068d3e67761ea8b74335a2b93f"

URI_aarch64_kolourpaint = "${EPEL_MIRROR}/aarch64/Packages/k/kolourpaint-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kolourpaint;unpack=0"
SRC_URI:append = " ${URI_aarch64_kolourpaint}"
SRC_URI[aarch64_kolourpaint.sha256sum] = "9fa4df4a9e2da155b56894516f9ae193c6f85629e8071331d7dd359b41e616a4"

URI_aarch64_kolourpaint-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kolourpaint-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kolourpaint-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kolourpaint-libs}"
SRC_URI[aarch64_kolourpaint-libs.sha256sum] = "121c326738392b3456fa3b0730503d64583dc87fb71266fbf01a3561d9ba6889"

RDEPENDS:kolourpaint = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kolourpaint-libs \
 libksane \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kolourpaint-libs = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kolourpaint \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
