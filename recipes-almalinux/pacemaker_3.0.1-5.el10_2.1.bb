# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pacemaker"
PV = "3.0.1"
PR = "5.el10_2.1"
PACKAGES = " \
 pacemaker-cluster-libs \
 pacemaker-libs \
 pacemaker-schemas \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pacemaker-3.0.1-5.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4401f010001c502775b3e2488c64b13d4a38590e081d788d85e2a5df137d01c3"

URI_x86_64_v2_pacemaker-cluster-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pacemaker-cluster-libs-3.0.1-5.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pacemaker-cluster-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pacemaker-cluster-libs}"
SRC_URI[x86_64_v2_pacemaker-cluster-libs.sha256sum] = "6f8fb526df2f8e63e300214c5f4f26152156690de76d2f620ea977d8f3a2719e"

URI_x86_64_v2_pacemaker-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pacemaker-libs-3.0.1-5.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pacemaker-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pacemaker-libs}"
SRC_URI[x86_64_v2_pacemaker-libs.sha256sum] = "b040c830bf367a7a17ae8fe57970f036094a8dc81596da80b2b19887006e6001"

URI_x86_64_v2_pacemaker-schemas = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pacemaker-schemas-3.0.1-5.el10_2.1.noarch.rpm;name=x86_64_v2_pacemaker-schemas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pacemaker-schemas}"
SRC_URI[x86_64_v2_pacemaker-schemas.sha256sum] = "6e3da70c121af183095ce7a58c2b0a382194143758f71b5c897c62fa60a07c53"

URI_aarch64_pacemaker-cluster-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pacemaker-cluster-libs-3.0.1-5.el10_2.1.aarch64.rpm;name=aarch64_pacemaker-cluster-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pacemaker-cluster-libs}"
SRC_URI[aarch64_pacemaker-cluster-libs.sha256sum] = "f417c00b601a1e52fba0a1bd1ab032d2588c6919147be8935b8d9587bd2745ed"

URI_aarch64_pacemaker-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pacemaker-libs-3.0.1-5.el10_2.1.aarch64.rpm;name=aarch64_pacemaker-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pacemaker-libs}"
SRC_URI[aarch64_pacemaker-libs.sha256sum] = "d50c6ac0fbbccf8abba3dde620a69aeaf5837755dd3bf5c1a0e93f27ea9a7669"

URI_aarch64_pacemaker-schemas = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pacemaker-schemas-3.0.1-5.el10_2.1.noarch.rpm;name=aarch64_pacemaker-schemas;unpack=0"
SRC_URI:append = " ${URI_aarch64_pacemaker-schemas}"
SRC_URI[aarch64_pacemaker-schemas.sha256sum] = "6e3da70c121af183095ce7a58c2b0a382194143758f71b5c897c62fa60a07c53"

RDEPENDS:pacemaker-cluster-libs = " \
 bzip2-libs \
 corosynclib \
 dbus-libs \
 glib2 \
 glibc \
 gnutls \
 libqb \
 libuuid \
 libxml2 \
 libxslt \
 pacemaker-libs \
 "
RDEPENDS:pacemaker-libs = " \
 bash \
 bzip2-libs \
 dbus-libs \
 glib2 \
 glibc \
 gnutls \
 libqb \
 libuuid \
 libxml2 \
 libxslt \
 pacemaker-schemas \
 shadow-utils \
 "
RDEPENDS:pacemaker-schemas = " \
 pkgconf-pkg-config \
 "
