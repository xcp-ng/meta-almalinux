# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gengo-language"
PV = "0.14.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-gengo-language+default-devel \
 rust-gengo-language-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gengo-language-0.14.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68c4290f7afb856deb1f1005f63c0f23d00abbc96d5dbae739e6d914cc1b694b"

URI_x86_64_v2_rust-gengo-language+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo-language+default-devel-0.14.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo-language+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo-language+default-devel}"
SRC_URI[x86_64_v2_rust-gengo-language+default-devel.sha256sum] = "29c4f7bfd6a62f5be13610c36bca3a18bdecca94f78e3a53b86ec3308cc5584e"

URI_x86_64_v2_rust-gengo-language-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo-language-devel-0.14.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo-language-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo-language-devel}"
SRC_URI[x86_64_v2_rust-gengo-language-devel.sha256sum] = "b0c34f1f3dfc32c3a6e4f3995b134597d064293d0e5a1e0e9520f715cbaeab70"

URI_aarch64_rust-gengo-language+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo-language+default-devel-0.14.3-1.el10_3.noarch.rpm;name=aarch64_rust-gengo-language+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo-language+default-devel}"
SRC_URI[aarch64_rust-gengo-language+default-devel.sha256sum] = "cc371c3bcc8a61b76717ef1362a712cc7c8fd2c398117146ac0fbfe3ff391864"

URI_aarch64_rust-gengo-language-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo-language-devel-0.14.3-1.el10_3.noarch.rpm;name=aarch64_rust-gengo-language-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo-language-devel}"
SRC_URI[aarch64_rust-gengo-language-devel.sha256sum] = "7d63d2399adcac1e405b5aa9f4fc25e6b8e0152435b80e2cda2bb45c3b83fcbb"

RDEPENDS:rust-gengo-language+default-devel = " \
 cargo \
 rust-gengo-language-devel \
 "
RDEPENDS:rust-gengo-language-devel = " \
 cargo \
 rust \
 rust-glob+default-devel \
 rust-indexmap+default-devel \
 rust-indexmap+serde-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_yaml+default-devel \
 "
