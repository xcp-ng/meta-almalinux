# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fxdiv"
PV = "1.0^git20201208.63058ef"
PR = "7.el10_1"
PACKAGES = " \
 fxdiv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fxdiv-1.0^git20201208.63058ef-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2442ca60418ba382e625d8eea28cdb06a8aaec82009e8b6b7809c5295f713b7e"

URI_x86_64_v2_fxdiv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fxdiv-devel-1.0^git20201208.63058ef-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fxdiv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fxdiv-devel}"
SRC_URI[x86_64_v2_fxdiv-devel.sha256sum] = "fc3cf8791b7b7991ada6c02f2fb6de9dc84be90e12af6c349527fddaea0679a4"

URI_aarch64_fxdiv-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fxdiv-devel-1.0^git20201208.63058ef-7.el10_1.noarch.rpm;name=aarch64_fxdiv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fxdiv-devel}"
SRC_URI[aarch64_fxdiv-devel.sha256sum] = "074016db92ac3ca9f28c72dd27490631a136069e7ac6ff7a500359d5e7df65a6"

RDEPENDS:fxdiv-devel = " \
 "
