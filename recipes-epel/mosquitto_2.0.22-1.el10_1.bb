# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mosquitto"
PV = "2.0.22"
PR = "1.el10_1"
PACKAGES = " \
 mosquitto \
 mosquitto-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mosquitto-2.0.22-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbcebb19875dc2c5925b9a65d9aef71389380ce117afda265b63ce2ba478c143"

URI_x86_64_v2_mosquitto = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mosquitto-2.0.22-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mosquitto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mosquitto}"
SRC_URI[x86_64_v2_mosquitto.sha256sum] = "b6629eb6c0ac0bbb055b99ec35cc150a196b283ee09d5737550cd7446cc81add"

URI_x86_64_v2_mosquitto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mosquitto-devel-2.0.22-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mosquitto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mosquitto-devel}"
SRC_URI[x86_64_v2_mosquitto-devel.sha256sum] = "d678f1e2dc7b46cafc5937588139503281e25b8938a91c866b7a857889b18e37"

URI_aarch64_mosquitto = "${EPEL_MIRROR}/aarch64/Packages/m/mosquitto-2.0.22-1.el10_1.aarch64.rpm;name=aarch64_mosquitto;unpack=0"
SRC_URI:append = " ${URI_aarch64_mosquitto}"
SRC_URI[aarch64_mosquitto.sha256sum] = "f5093adf7008576abbff7dab29f9731f7e8adb806e276a249a506774f27fa958"

URI_aarch64_mosquitto-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mosquitto-devel-2.0.22-1.el10_1.aarch64.rpm;name=aarch64_mosquitto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mosquitto-devel}"
SRC_URI[aarch64_mosquitto-devel.sha256sum] = "dc16aa751b384ca05106382f9d337a43856577ce5ba49bbe6508c8f28d6eaf47"

RDEPENDS:mosquitto = " \
 c-ares \
 cjson \
 glibc \
 libstdc++ \
 libwebsockets \
 openssl-libs \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:mosquitto-devel = " \
 mosquitto \
 pkgconf-pkg-config \
 "
