# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-nm"
PV = "6.6.4"
PR = "1.1.el10_2"
PACKAGES = " \
 plasma-nm \
 plasma-nm-l2tp \
 plasma-nm-openconnect \
 plasma-nm-openswan \
 plasma-nm-openvpn \
 plasma-nm-pptp \
 plasma-nm-strongswan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-nm-6.6.4-1.1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "612896aaa48edbd123ad9268086a7b40b327d51b3a4a746852e06235b2de0063"

URI_x86_64_v2_plasma-nm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-6.6.4-1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm}"
SRC_URI[x86_64_v2_plasma-nm.sha256sum] = "c5b57b5d0a9bc2c80c2f4f40c85b3042db03d45561f028a0814adbd8c42f90f7"

URI_x86_64_v2_plasma-nm-l2tp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-l2tp-6.6.4-1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-l2tp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-l2tp}"
SRC_URI[x86_64_v2_plasma-nm-l2tp.sha256sum] = "687e80e3de315c28d391d4378a71692fc0622e4e05adf66c6621be9f865129b5"

URI_x86_64_v2_plasma-nm-openconnect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-openconnect-6.6.4-1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-openconnect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-openconnect}"
SRC_URI[x86_64_v2_plasma-nm-openconnect.sha256sum] = "6ed7375d2694dbdd22f19ef33081969bbb1f87abfa9558e0ca11b3ad17d2c865"

URI_x86_64_v2_plasma-nm-openswan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-openswan-6.6.4-1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-openswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-openswan}"
SRC_URI[x86_64_v2_plasma-nm-openswan.sha256sum] = "0e11bda5c4158599d9e0d7ca17841267ebe9a05f127aea5b41aba525eb458aca"

URI_x86_64_v2_plasma-nm-openvpn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-openvpn-6.6.4-1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-openvpn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-openvpn}"
SRC_URI[x86_64_v2_plasma-nm-openvpn.sha256sum] = "2105065a69df300278b4c7fd78d8a228862ebd4fabe932d1a6f0b56bf6604a1e"

URI_x86_64_v2_plasma-nm-pptp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-pptp-6.6.4-1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-pptp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-pptp}"
SRC_URI[x86_64_v2_plasma-nm-pptp.sha256sum] = "9d44ba2b48878353a519d1983f8203527315237bbc61cc75a3d216b29a511793"

URI_x86_64_v2_plasma-nm-strongswan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-strongswan-6.6.4-1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-strongswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-strongswan}"
SRC_URI[x86_64_v2_plasma-nm-strongswan.sha256sum] = "c157c10d1831daebb6913f79ef6cd900e7b3a592333eb7aa71eeeee29f6486b6"

URI_aarch64_plasma-nm = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-6.6.4-1.1.el10_2.aarch64.rpm;name=aarch64_plasma-nm;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm}"
SRC_URI[aarch64_plasma-nm.sha256sum] = "2fff5307bd63ac79f2421f0f7e08960ea93c8d57b02b9e378120d81b0a076e12"

URI_aarch64_plasma-nm-l2tp = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-l2tp-6.6.4-1.1.el10_2.aarch64.rpm;name=aarch64_plasma-nm-l2tp;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-l2tp}"
SRC_URI[aarch64_plasma-nm-l2tp.sha256sum] = "8b59e1b23fb1a19966790976612f9a3e224978c1d51bc93155b98428852d879a"

URI_aarch64_plasma-nm-openconnect = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-openconnect-6.6.4-1.1.el10_2.aarch64.rpm;name=aarch64_plasma-nm-openconnect;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-openconnect}"
SRC_URI[aarch64_plasma-nm-openconnect.sha256sum] = "26c52f0641656bb061cdde4745903ec72f7b0a76168d8ecf52eb734399fc206c"

URI_aarch64_plasma-nm-openswan = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-openswan-6.6.4-1.1.el10_2.aarch64.rpm;name=aarch64_plasma-nm-openswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-openswan}"
SRC_URI[aarch64_plasma-nm-openswan.sha256sum] = "9ca1bb4e51190d1be5e77d0e8d7d7d1e70a8c034aa07284e942ab6b53c403e6f"

URI_aarch64_plasma-nm-openvpn = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-openvpn-6.6.4-1.1.el10_2.aarch64.rpm;name=aarch64_plasma-nm-openvpn;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-openvpn}"
SRC_URI[aarch64_plasma-nm-openvpn.sha256sum] = "45246af7c67232975c3daf9743386edd456808b27e104dd84f08dbf2820098bc"

URI_aarch64_plasma-nm-pptp = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-pptp-6.6.4-1.1.el10_2.aarch64.rpm;name=aarch64_plasma-nm-pptp;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-pptp}"
SRC_URI[aarch64_plasma-nm-pptp.sha256sum] = "e3ef957793f4542f8c9ad88e8e0eb64d035639beadf33166d952ee2a40b2d6e6"

URI_aarch64_plasma-nm-strongswan = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-strongswan-6.6.4-1.1.el10_2.aarch64.rpm;name=aarch64_plasma-nm-strongswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-strongswan}"
SRC_URI[aarch64_plasma-nm-strongswan.sha256sum] = "3a00d5dbff7a16d52b061a1e326be5faec92565b495d33b5a1028cb0993f5523"

RDEPENDS:plasma-nm = " \
 NetworkManager \
 NetworkManager-libnm \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-modemmanager-qt \
 kf6-networkmanager-qt \
 kf6-prison \
 kf6-solid \
 libplasma \
 libstdc++ \
 qca-qt6 \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-nm-l2tp = " \
 NetworkManager-l2tp \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-openconnect = " \
 NetworkManager-openconnect \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 openconnect \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:plasma-nm-openswan = " \
 NetworkManager-libreswan \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-openvpn = " \
 NetworkManager-libnm \
 NetworkManager-openvpn \
 glib2 \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-pptp = " \
 NetworkManager-pptp \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-strongswan = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 strongswan \
 "
