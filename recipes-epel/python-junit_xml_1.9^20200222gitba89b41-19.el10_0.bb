# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-junit_xml"
PV = "1.9^20200222gitba89b41"
PR = "19.el10_0"
PACKAGES = " \
 python3-junit-xml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-junit_xml-1.9^20200222gitba89b41-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b44397f333f0619b4d04801f203ab4ae06184f2bf8b2c348e3f9f7b196fa568"

URI_x86_64_v2_python3-junit-xml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-junit-xml-1.9^20200222gitba89b41-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-junit-xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-junit-xml}"
SRC_URI[x86_64_v2_python3-junit-xml.sha256sum] = "06dba1af0783d5a2e304cefbb8ebd92d5b487ae4f557aa42b4cd0d0e63ca77f9"

URI_aarch64_python3-junit-xml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-junit-xml-1.9^20200222gitba89b41-19.el10_0.noarch.rpm;name=aarch64_python3-junit-xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-junit-xml}"
SRC_URI[aarch64_python3-junit-xml.sha256sum] = "e61592f6a7c011b3e399fe06ba84cf51a41276818064070d2689ce7299fac5b2"

RDEPENDS:python3-junit-xml = " \
 python3 \
 python3-six \
 "
