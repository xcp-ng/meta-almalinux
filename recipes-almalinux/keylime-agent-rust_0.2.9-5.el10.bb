# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keylime-agent-rust"
PV = "0.2.9"
PR = "5.el10"
PACKAGES = " \
 keylime-agent-rust \
 keylime-agent-rust-common \
 keylime-agent-rust-ima-emulator \
 keylime-agent-rust-push \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/keylime-agent-rust-0.2.9-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dccd2481e9cc244824023eaf17fe9485bdb90e7d6a73560fee5ba09f7b2afe1d"

URI_x86_64_v2_keylime-agent-rust = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-agent-rust-0.2.9-5.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-agent-rust;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-agent-rust}"
SRC_URI[x86_64_v2_keylime-agent-rust.sha256sum] = "ac0261930ae96fd81f56e58ba2d8dad88f34bc82dbbf40db976b96c72ab22e3e"
RPROVIDES:keylime-agent-rust:x86_64_v2 = "virtual/keylime-agent"

URI_x86_64_v2_keylime-agent-rust-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-agent-rust-common-0.2.9-5.el10.noarch.rpm;name=x86_64_v2_keylime-agent-rust-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-agent-rust-common}"
SRC_URI[x86_64_v2_keylime-agent-rust-common.sha256sum] = "cf35a58b91e20d128a6c0d7425ad4e23b90cd97a6d005ea67947232bd3f80214"

URI_x86_64_v2_keylime-agent-rust-ima-emulator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-agent-rust-ima-emulator-0.2.9-5.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-agent-rust-ima-emulator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-agent-rust-ima-emulator}"
SRC_URI[x86_64_v2_keylime-agent-rust-ima-emulator.sha256sum] = "42a09c7eebddaf5484efa880233bb2617ed894b690354224afb7bea59552d861"

URI_x86_64_v2_keylime-agent-rust-push = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-agent-rust-push-0.2.9-5.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-agent-rust-push;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-agent-rust-push}"
SRC_URI[x86_64_v2_keylime-agent-rust-push.sha256sum] = "4a266755600443d5a26f52482292c36ee876c04bda8a25902ad7b554052ed882"
RPROVIDES:keylime-agent-rust-push:x86_64_v2 = "virtual/keylime-agent"

URI_aarch64_keylime-agent-rust = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-agent-rust-0.2.9-5.el10.aarch64.rpm;name=aarch64_keylime-agent-rust;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-agent-rust}"
SRC_URI[aarch64_keylime-agent-rust.sha256sum] = "100af8cf8eeda6b7884bb520aa7e7c061d6f884654d8e63591767d2ae2391b5b"
RPROVIDES:keylime-agent-rust:aarch64 = "virtual/keylime-agent"

URI_aarch64_keylime-agent-rust-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-agent-rust-common-0.2.9-5.el10.noarch.rpm;name=aarch64_keylime-agent-rust-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-agent-rust-common}"
SRC_URI[aarch64_keylime-agent-rust-common.sha256sum] = "cf35a58b91e20d128a6c0d7425ad4e23b90cd97a6d005ea67947232bd3f80214"

URI_aarch64_keylime-agent-rust-ima-emulator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-agent-rust-ima-emulator-0.2.9-5.el10.aarch64.rpm;name=aarch64_keylime-agent-rust-ima-emulator;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-agent-rust-ima-emulator}"
SRC_URI[aarch64_keylime-agent-rust-ima-emulator.sha256sum] = "024cf84501caae40b9b40b868008aab136258350c87e23bac7a2e722e08a2c61"

URI_aarch64_keylime-agent-rust-push = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-agent-rust-push-0.2.9-5.el10.aarch64.rpm;name=aarch64_keylime-agent-rust-push;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-agent-rust-push}"
SRC_URI[aarch64_keylime-agent-rust-push.sha256sum] = "241e3d7aff97bc6e04d1ae8b13f6b54fa1043f6b9476b12388199a60f0f5232a"
RPROVIDES:keylime-agent-rust-push:aarch64 = "virtual/keylime-agent"

RDEPENDS:keylime-agent-rust = " \
 bash \
 glibc \
 keylime-agent-rust-common \
 keylime-agent-rust-ima-emulator \
 keylime-base \
 libgcc \
 openssl-libs \
 tpm2-tss \
 util-linux-core \
 "
RDEPENDS:keylime-agent-rust-common = " \
 "
RDEPENDS:keylime-agent-rust-ima-emulator = " \
 glibc \
 keylime-agent-rust-common \
 keylime-base \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
RDEPENDS:keylime-agent-rust-push = " \
 glibc \
 keylime-agent-rust-common \
 keylime-agent-rust-ima-emulator \
 keylime-base \
 libgcc \
 openssl-libs \
 tpm2-tss \
 util-linux-core \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/keylime-agent"

PROVIDES:append:aarch64 = " rpm/virtual/keylime-agent"
