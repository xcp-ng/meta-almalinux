# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls"
PV = "0.23.43"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustls+brotli-devel \
 rust-rustls+custom-provider-devel \
 rust-rustls+default-devel \
 rust-rustls+hashbrown-devel \
 rust-rustls+log-devel \
 rust-rustls+logging-devel \
 rust-rustls+read_buf-devel \
 rust-rustls+ring-devel \
 rust-rustls+rustversion-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls+zlib-devel \
 rust-rustls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-0.23.43-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32e345006874fdad55e5ab3a59b48758f58ba06c548ef001601acf86e6cba148"

URI_x86_64_v2_rust-rustls+brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+brotli-devel-0.23.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+brotli-devel}"
SRC_URI[x86_64_v2_rust-rustls+brotli-devel.sha256sum] = "003afcae2921333e7050ccb42c17bbaf4cdc5247a85ee32276ad11105f1070d8"

URI_x86_64_v2_rust-rustls+custom-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+custom-provider-devel-0.23.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+custom-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+custom-provider-devel}"
SRC_URI[x86_64_v2_rust-rustls+custom-provider-devel.sha256sum] = "08565500325d28de7bd3b4ce197c0984f2c2c08f5d82e617d95ab6d86d117bc9"

URI_x86_64_v2_rust-rustls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+default-devel-0.23.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+default-devel}"
SRC_URI[x86_64_v2_rust-rustls+default-devel.sha256sum] = "2faaf4e28321816bf8b52035179ce8d7fed311f3c3262e05675567a2e80a7807"

URI_x86_64_v2_rust-rustls+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+hashbrown-devel-0.23.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-rustls+hashbrown-devel.sha256sum] = "09500703b10ce9e7f945354553d456cfd927d11b71b878ea438a16a4013352b8"

URI_x86_64_v2_rust-rustls+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+log-devel-0.23.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+log-devel}"
SRC_URI[x86_64_v2_rust-rustls+log-devel.sha256sum] = "69d399bc395eaefe8eb27dc783d2af8dcc09906ce5944b75109da083f78df1cc"

URI_x86_64_v2_rust-rustls+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+logging-devel-0.23.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+logging-devel}"
SRC_URI[x86_64_v2_rust-rustls+logging-devel.sha256sum] = "43f160e23c5b7f17c44f9dc3d327c03328c00455e86f119e1555cb58fd2f83ab"

URI_x86_64_v2_rust-rustls+read_buf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+read_buf-devel-0.23.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+read_buf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+read_buf-devel}"
SRC_URI[x86_64_v2_rust-rustls+read_buf-devel.sha256sum] = "dd2c6334f77b0105b0529d55f08e463346c518e4550dcafcdf570061f8e8a9d2"

URI_x86_64_v2_rust-rustls+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+ring-devel-0.23.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+ring-devel}"
SRC_URI[x86_64_v2_rust-rustls+ring-devel.sha256sum] = "693978d5fcdf6af59ed5414609162927d3b39740913b1d298fc2a4f97a544ae3"

URI_x86_64_v2_rust-rustls+rustversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+rustversion-devel-0.23.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+rustversion-devel}"
SRC_URI[x86_64_v2_rust-rustls+rustversion-devel.sha256sum] = "aeb6369bad47d2407bfa5c37f6abf17c60ff47805ff3981d2b488562ee708811"

URI_x86_64_v2_rust-rustls+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+std-devel-0.23.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+std-devel}"
SRC_URI[x86_64_v2_rust-rustls+std-devel.sha256sum] = "3f375e06fc0f3217d17459877aae185ab1742b7e0e2b27a0fcdd0496b6ba2626"

URI_x86_64_v2_rust-rustls+tls12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+tls12-devel-0.23.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+tls12-devel}"
SRC_URI[x86_64_v2_rust-rustls+tls12-devel.sha256sum] = "79ebaf8287bedf6a82985deb68827e1b0afc911ba4964e8daaf7755284d924c8"

URI_x86_64_v2_rust-rustls+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+zlib-devel-0.23.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+zlib-devel}"
SRC_URI[x86_64_v2_rust-rustls+zlib-devel.sha256sum] = "3c41a0dc5145e6db60f7286f4bbf52f73b18e4b8e4b8641f73adbe1fdb31b9fa"

URI_x86_64_v2_rust-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-devel-0.23.43-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-devel}"
SRC_URI[x86_64_v2_rust-rustls-devel.sha256sum] = "fc0f637b35e62dede1581f773ea4f2300b250ce6d289f20b3acbb5de28c5f900"

URI_aarch64_rust-rustls+brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+brotli-devel-0.23.43-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+brotli-devel}"
SRC_URI[aarch64_rust-rustls+brotli-devel.sha256sum] = "ef5c3fdf902f4c785c3aa10251bdd9c71279a22c0d37fd2fae2d0c9f1e6587bc"

URI_aarch64_rust-rustls+custom-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+custom-provider-devel-0.23.43-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+custom-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+custom-provider-devel}"
SRC_URI[aarch64_rust-rustls+custom-provider-devel.sha256sum] = "aaa205d38e27f10cad4e8cb648a472e38c3d8563577afd57d4ffd4c948f6c0d1"

URI_aarch64_rust-rustls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+default-devel-0.23.43-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+default-devel}"
SRC_URI[aarch64_rust-rustls+default-devel.sha256sum] = "c14081cb473fd7921034e6c4afc2afa75dcc7cc81283a0a6f3bf06e44d94390a"

URI_aarch64_rust-rustls+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+hashbrown-devel-0.23.43-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+hashbrown-devel}"
SRC_URI[aarch64_rust-rustls+hashbrown-devel.sha256sum] = "de239fa40735ffde28ed4e026d720baf110314267aeeea59fe10cdc5cbac32ef"

URI_aarch64_rust-rustls+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+log-devel-0.23.43-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+log-devel}"
SRC_URI[aarch64_rust-rustls+log-devel.sha256sum] = "d27d166d7544a9d09c25ddabffd39cc26aca67bdeacd3d3595ceead6531e171e"

URI_aarch64_rust-rustls+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+logging-devel-0.23.43-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+logging-devel}"
SRC_URI[aarch64_rust-rustls+logging-devel.sha256sum] = "0052b99e6bf18b5accf3002931d118b2b81069cc3b48a8297227d0d8809e17ab"

URI_aarch64_rust-rustls+read_buf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+read_buf-devel-0.23.43-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+read_buf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+read_buf-devel}"
SRC_URI[aarch64_rust-rustls+read_buf-devel.sha256sum] = "cea469d0d9cd6d0e98fd0d94bc5866a4a63f1551a8cecb225d8a6aad1945277f"

URI_aarch64_rust-rustls+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+ring-devel-0.23.43-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+ring-devel}"
SRC_URI[aarch64_rust-rustls+ring-devel.sha256sum] = "79d092d79f9f25bc83adae2ecab5ed7a504c419625512e39a8692360c54a5336"

URI_aarch64_rust-rustls+rustversion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+rustversion-devel-0.23.43-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+rustversion-devel}"
SRC_URI[aarch64_rust-rustls+rustversion-devel.sha256sum] = "29e7b3cad860d5d268aebda79fc4a8adb5e73195da27eef80fdf219ed2922de9"

URI_aarch64_rust-rustls+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+std-devel-0.23.43-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+std-devel}"
SRC_URI[aarch64_rust-rustls+std-devel.sha256sum] = "0e74e34f8dc2b1a9d58913075bdf3ee807e74dc6425045aa935cd864f0fdece5"

URI_aarch64_rust-rustls+tls12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+tls12-devel-0.23.43-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+tls12-devel}"
SRC_URI[aarch64_rust-rustls+tls12-devel.sha256sum] = "1e843a34330ecfd7ca13dd3b39dbaa714f58d9086d850d811e1c344ac19fdd03"

URI_aarch64_rust-rustls+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+zlib-devel-0.23.43-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+zlib-devel}"
SRC_URI[aarch64_rust-rustls+zlib-devel.sha256sum] = "b4c3524873bcf0374fd90bf3ad7cf16b8ed3b993e542c0719041298fc4ad3853"

URI_aarch64_rust-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-devel-0.23.43-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-devel}"
SRC_URI[aarch64_rust-rustls-devel.sha256sum] = "b7add66ad200f8852e35c48b6d17bfaa00ed820fb46bb68ebd5714ea624c9e80"

RDEPENDS:rust-rustls+brotli-devel = " \
 cargo \
 rust-brotli+std-devel \
 rust-brotli-decompressor+default-devel \
 rust-brotli-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+custom-provider-devel = " \
 cargo \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+default-devel = " \
 cargo \
 rust-rustls+logging-devel \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+hashbrown-devel = " \
 cargo \
 rust-hashbrown0.15+default-hasher-devel \
 rust-hashbrown0.15+inline-more-devel \
 rust-hashbrown0.15-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+logging-devel = " \
 cargo \
 rust-rustls+log-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+read_buf-devel = " \
 cargo \
 rust-rustls+rustversion-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+ring-devel = " \
 cargo \
 rust-ring+default-devel \
 rust-rustls-devel \
 rust-rustls-webpki+ring-devel \
 "
RDEPENDS:rust-rustls+rustversion-devel = " \
 cargo \
 rust-rustls-devel \
 rust-rustversion+default-devel \
 "
RDEPENDS:rust-rustls+std-devel = " \
 cargo \
 rust-once_cell+std-devel \
 rust-rustls-devel \
 rust-rustls-pki-types+std-devel \
 rust-rustls-webpki+std-devel \
 "
RDEPENDS:rust-rustls+tls12-devel = " \
 cargo \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+zlib-devel = " \
 cargo \
 rust-rustls-devel \
 rust-zlib-rs+default-devel \
 "
RDEPENDS:rust-rustls-devel = " \
 cargo \
 rust \
 rust-once_cell+alloc-devel \
 rust-once_cell+race-devel \
 rust-once_cell-devel \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki-devel \
 rust-subtle-devel \
 rust-zeroize+default-devel \
 "
