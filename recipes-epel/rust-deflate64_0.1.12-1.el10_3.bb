# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deflate64"
PV = "0.1.12"
PR = "1.el10_3"
PACKAGES = " \
 rust-deflate64+checkpoint-devel \
 rust-deflate64+default-devel \
 rust-deflate64-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deflate64-0.1.12-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdbcccee72d700c160f0137081bde58e2a571c2c466c5dd3018058b5e5114f20"

URI_x86_64_v2_rust-deflate64+checkpoint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deflate64+checkpoint-devel-0.1.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deflate64+checkpoint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deflate64+checkpoint-devel}"
SRC_URI[x86_64_v2_rust-deflate64+checkpoint-devel.sha256sum] = "c6a6ed48a0bceac1c62bf708dbb061d46bc0dda06cb2a099624b316bc4073370"

URI_x86_64_v2_rust-deflate64+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deflate64+default-devel-0.1.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deflate64+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deflate64+default-devel}"
SRC_URI[x86_64_v2_rust-deflate64+default-devel.sha256sum] = "65db5d1138b27ef55964f977b31667883e65b08760484797540c2a7298484e82"

URI_x86_64_v2_rust-deflate64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deflate64-devel-0.1.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deflate64-devel}"
SRC_URI[x86_64_v2_rust-deflate64-devel.sha256sum] = "b4d11de8100b01dfe29ecd2d5afa49693bc19fac84caf23491f57c0266646ef2"

URI_aarch64_rust-deflate64+checkpoint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deflate64+checkpoint-devel-0.1.12-1.el10_3.noarch.rpm;name=aarch64_rust-deflate64+checkpoint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deflate64+checkpoint-devel}"
SRC_URI[aarch64_rust-deflate64+checkpoint-devel.sha256sum] = "94b77de7992fe353a416181d2528b1ff7d23b3c3153742b9aa5d72c3fa065faf"

URI_aarch64_rust-deflate64+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deflate64+default-devel-0.1.12-1.el10_3.noarch.rpm;name=aarch64_rust-deflate64+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deflate64+default-devel}"
SRC_URI[aarch64_rust-deflate64+default-devel.sha256sum] = "678876fec406df213967d0b911e7db0f1599049f128187dd8e613e7628eeb5bc"

URI_aarch64_rust-deflate64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deflate64-devel-0.1.12-1.el10_3.noarch.rpm;name=aarch64_rust-deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deflate64-devel}"
SRC_URI[aarch64_rust-deflate64-devel.sha256sum] = "6b7b3ade1b16195e181dec1a2b3f053304cb3e6f28059b7502d91f2b6c872109"

RDEPENDS:rust-deflate64+checkpoint-devel = " \
 cargo \
 rust-deflate64-devel \
 "
RDEPENDS:rust-deflate64+default-devel = " \
 cargo \
 rust-deflate64-devel \
 "
RDEPENDS:rust-deflate64-devel = " \
 cargo \
 "
