# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-platform"
PV = "0.1.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-cargo-platform+default-devel \
 rust-cargo-platform-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-platform-0.1.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7409bd197cb1d774f3077bc60bc31f57eebc88f087adba9c5920ada8f7ed4603"

URI_x86_64_v2_rust-cargo-platform+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-platform+default-devel-0.1.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-platform+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-platform+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-platform+default-devel.sha256sum] = "366aacda9fd57f86f7a4e42da8e5e1de15ebfb8024651dcecaadf4803e4f2f0f"

URI_x86_64_v2_rust-cargo-platform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-platform-devel-0.1.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-platform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-platform-devel}"
SRC_URI[x86_64_v2_rust-cargo-platform-devel.sha256sum] = "1c7444900ee6059b634898cb42b811ac5ca810a4c2966f3e64f7747d3af5cca4"

URI_aarch64_rust-cargo-platform+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-platform+default-devel-0.1.9-1.el10_0.noarch.rpm;name=aarch64_rust-cargo-platform+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-platform+default-devel}"
SRC_URI[aarch64_rust-cargo-platform+default-devel.sha256sum] = "d4fcc72e857af973613a8dc028f31aef0bc56ecc604272ea68bd1a7350a4d0c4"

URI_aarch64_rust-cargo-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-platform-devel-0.1.9-1.el10_0.noarch.rpm;name=aarch64_rust-cargo-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-platform-devel}"
SRC_URI[aarch64_rust-cargo-platform-devel.sha256sum] = "651e5de815cd837a8337c46dc3315c99f8da121e935fd2cb6a0d45f029e2dfad"

RDEPENDS:rust-cargo-platform+default-devel = " \
 cargo \
 rust-cargo-platform-devel \
 "
RDEPENDS:rust-cargo-platform-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 "
