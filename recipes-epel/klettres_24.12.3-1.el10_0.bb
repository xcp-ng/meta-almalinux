# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "klettres"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 klettres \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/klettres-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8cf114e66294cbb8fd7d6cbdb5a54eba1d02100058f081b9f17d38cae27bbac"

URI_x86_64_v2_klettres = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/klettres-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_klettres;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_klettres}"
SRC_URI[x86_64_v2_klettres.sha256sum] = "69fde003e9eb5864f6e4ae0fe8452882b3154a50ecc37c1f8ff7289a1d42264c"

URI_aarch64_klettres = "${EPEL_MIRROR}/aarch64/Packages/k/klettres-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_klettres;unpack=0"
SRC_URI:append = " ${URI_aarch64_klettres}"
SRC_URI[aarch64_klettres.sha256sum] = "0539e08395553243c8fd35d115cbbc1e817378291acbfa38ac742d5e3e11d06c"

RDEPENDS:klettres = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 phonon-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
