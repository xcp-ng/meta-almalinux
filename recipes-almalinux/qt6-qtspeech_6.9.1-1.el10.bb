# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtspeech"
PV = "6.9.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtspeech \
 qt6-qtspeech-devel \
 qt6-qtspeech-examples \
 qt6-qtspeech-speechd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtspeech-6.9.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "212596fdbe05c040f84dba88b476941a95328cfd697e0c5652388cf5e512844e"

URI_x86_64_v2_qt6-qtspeech = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtspeech-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtspeech;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtspeech}"
SRC_URI[x86_64_v2_qt6-qtspeech.sha256sum] = "1a6ce433fee7120e121a9918352d205889ff8a953ec486d1ab6b62226931501a"

URI_x86_64_v2_qt6-qtspeech-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtspeech-devel-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtspeech-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtspeech-devel}"
SRC_URI[x86_64_v2_qt6-qtspeech-devel.sha256sum] = "29d009c943c106158fe34e5a8ecf474da35a12f1d3ca33921b19df6b28fb6c55"

URI_x86_64_v2_qt6-qtspeech-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtspeech-examples-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtspeech-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtspeech-examples}"
SRC_URI[x86_64_v2_qt6-qtspeech-examples.sha256sum] = "4d16bdc93a5902fb045c420e505672c7625455881970b61ac82129015d8bfb32"

URI_x86_64_v2_qt6-qtspeech-speechd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtspeech-speechd-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtspeech-speechd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtspeech-speechd}"
SRC_URI[x86_64_v2_qt6-qtspeech-speechd.sha256sum] = "38696cbb5ddab1655a946c1cd6de4de069c61464ba6ee9794fe4c988654ff65a"

URI_aarch64_qt6-qtspeech = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtspeech-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtspeech;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtspeech}"
SRC_URI[aarch64_qt6-qtspeech.sha256sum] = "312ee406ab9391713d432d5fef45590d15527bc37ee5b11ab50aad800a9e2b21"

URI_aarch64_qt6-qtspeech-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtspeech-devel-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtspeech-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtspeech-devel}"
SRC_URI[aarch64_qt6-qtspeech-devel.sha256sum] = "531d1f9a98fc0f63e186bb7ff32bd02f570734aef95318b8c0e8b5e5bad3e2ff"

URI_aarch64_qt6-qtspeech-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtspeech-examples-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtspeech-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtspeech-examples}"
SRC_URI[aarch64_qt6-qtspeech-examples.sha256sum] = "3d78f140498d91a3e96decb93b09eab453c44f85c33c0448c4433769d2df3bb3"

URI_aarch64_qt6-qtspeech-speechd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtspeech-speechd-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtspeech-speechd;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtspeech-speechd}"
SRC_URI[aarch64_qt6-qtspeech-speechd.sha256sum] = "30d69f31f21e3e3568631f0343a9421eab5af0052e42d8f5c7a15d2bd6dc3e46"

RDEPENDS:qt6-qtspeech = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
RDEPENDS:qt6-qtspeech-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtmultimedia-devel \
 qt6-qtspeech \
 qt6-qtspeech-speechd \
 "
RDEPENDS:qt6-qtspeech-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtspeech \
 "
RDEPENDS:qt6-qtspeech-speechd = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtspeech \
 speech-dispatcher-libs \
 "
