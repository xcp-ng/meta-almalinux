# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Script"
PV = "1.29"
PR = "2.el10_0"
PACKAGES = " \
 perl-Test-Script \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-Script-1.29-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "525f071a4f80cb056d8e867857d278d6ad5fc3df839771ebe576d09a5bac212f"

URI_x86_64_v2_perl-Test-Script = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Script-1.29-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Script;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Script}"
SRC_URI[x86_64_v2_perl-Test-Script.sha256sum] = "7f31ad24b12e29149cf8b9f0dab0bbf0a95e62492371e57ddf20c154861c87a7"

URI_aarch64_perl-Test-Script = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Script-1.29-2.el10_0.noarch.rpm;name=aarch64_perl-Test-Script;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Script}"
SRC_URI[aarch64_perl-Test-Script.sha256sum] = "07b713b6a8853a12ed95e1a139405b68654dd48e4cd5381abbc5b3e269a55a00"

RDEPENDS:perl-Test-Script = " \
 perl-Capture-Tiny \
 perl-Carp \
 perl-Exporter \
 perl-File-Temp \
 perl-IO \
 perl-PathTools \
 perl-Probe-Perl \
 perl-Test-Simple \
 perl-Text-ParseWords \
 perl-libs \
 "
