# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openarc"
PV = "1.3.0"
PR = "2.el10_1"
PACKAGES = " \
 libopenarc \
 libopenarc-devel \
 openarc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openarc-1.3.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6943b7b8b1575992dd2a29e9b1f979c69a86c6a1292f782bdaa55b4d2025c6fd"

URI_x86_64_v2_libopenarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenarc-1.3.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenarc}"
SRC_URI[x86_64_v2_libopenarc.sha256sum] = "a7e79a37466e7da18b53711426824a4502e7ee0cccb706bea8d0ec0e9ab487c1"

URI_x86_64_v2_libopenarc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenarc-devel-1.3.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenarc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenarc-devel}"
SRC_URI[x86_64_v2_libopenarc-devel.sha256sum] = "3cd037af9d25aac0207873ef6511b3cc4519c356f4ffd841dfcf35143fb4a105"

URI_x86_64_v2_openarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openarc-1.3.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openarc}"
SRC_URI[x86_64_v2_openarc.sha256sum] = "0fc1daed524cc35c09e4f442b8efc65dd7782309d9506e416436ec1fc4783a4b"

URI_aarch64_libopenarc = "${EPEL_MIRROR}/aarch64/Packages/l/libopenarc-1.3.0-2.el10_1.aarch64.rpm;name=aarch64_libopenarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenarc}"
SRC_URI[aarch64_libopenarc.sha256sum] = "6dad5d2a7d3a0466c074fa2e22678036739232856eaded12782b42a2bb0b8311"

URI_aarch64_libopenarc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libopenarc-devel-1.3.0-2.el10_1.aarch64.rpm;name=aarch64_libopenarc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenarc-devel}"
SRC_URI[aarch64_libopenarc-devel.sha256sum] = "7e0b12edacf50ef0eb5c2cd1c0237439d6cbbd292a1eeeece517bf2eb8cd91d3"

URI_aarch64_openarc = "${EPEL_MIRROR}/aarch64/Packages/o/openarc-1.3.0-2.el10_1.aarch64.rpm;name=aarch64_openarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_openarc}"
SRC_URI[aarch64_openarc.sha256sum] = "5699405872e1113e6d5ca9ad37035840b456c45522cdcb294b0025ca304ae532"

RDEPENDS:libopenarc = " \
 glibc \
 libidn2 \
 openssl-libs \
 "
RDEPENDS:libopenarc-devel = " \
 libidn2-devel \
 libopenarc \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:openarc = " \
 bash \
 glibc \
 jansson \
 libopenarc \
 openssl-libs \
 python3 \
 sendmail-milter \
 setup \
 shadow-utils \
 systemd \
 "
