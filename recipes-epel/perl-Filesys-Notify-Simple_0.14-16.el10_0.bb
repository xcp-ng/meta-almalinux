# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Filesys-Notify-Simple"
PV = "0.14"
PR = "16.el10_0"
PACKAGES = " \
 perl-Filesys-Notify-Simple \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Filesys-Notify-Simple-0.14-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68dcb5fbc9dbd8d6e0e05c262d5c86b04283b069d5a2e2d47c4ebf665dcea9e2"

URI_x86_64_v2_perl-Filesys-Notify-Simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Filesys-Notify-Simple-0.14-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Filesys-Notify-Simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Filesys-Notify-Simple}"
SRC_URI[x86_64_v2_perl-Filesys-Notify-Simple.sha256sum] = "ae3bd47575f9a1dc2042f68ea2529aae7454c7a73a67b4b0da5332f031127f4c"

URI_aarch64_perl-Filesys-Notify-Simple = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Filesys-Notify-Simple-0.14-16.el10_0.noarch.rpm;name=aarch64_perl-Filesys-Notify-Simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Filesys-Notify-Simple}"
SRC_URI[aarch64_perl-Filesys-Notify-Simple.sha256sum] = "978753dbf9103cfac21b75e92967eda52409dc4d4ca23d08fe9b217a871b9279"

RDEPENDS:perl-Filesys-Notify-Simple = " \
 perl-Carp \
 perl-File-Find \
 perl-Linux-Inotify2 \
 perl-PathTools \
 perl-constant \
 perl-libs \
 "
