# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-similar"
PV = "2.7.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-similar+bstr-devel \
 rust-similar+bytes-devel \
 rust-similar+default-devel \
 rust-similar+inline-devel \
 rust-similar+serde-devel \
 rust-similar+text-devel \
 rust-similar+unicode-devel \
 rust-similar+unicode-segmentation-devel \
 rust-similar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-similar-2.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b48b6a3147eacc13458385041f4b27ab91b6365a1df644b3cd3eb1c8626987e3"

URI_x86_64_v2_rust-similar+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+bstr-devel-2.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+bstr-devel}"
SRC_URI[x86_64_v2_rust-similar+bstr-devel.sha256sum] = "01b8fc84979dd14b2e84f0aab778d96ae8626b8054b8d4aaee5978923363b2f9"

URI_x86_64_v2_rust-similar+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+bytes-devel-2.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+bytes-devel}"
SRC_URI[x86_64_v2_rust-similar+bytes-devel.sha256sum] = "611df20702aaa95af3989e9c26722214c9bd25a3960830d83ba9feb39700b2ae"

URI_x86_64_v2_rust-similar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+default-devel-2.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+default-devel}"
SRC_URI[x86_64_v2_rust-similar+default-devel.sha256sum] = "0e49264ea0095086ad4c1d0d7de5a8a32142450769773777b5202c6260ff1174"

URI_x86_64_v2_rust-similar+inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+inline-devel-2.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+inline-devel}"
SRC_URI[x86_64_v2_rust-similar+inline-devel.sha256sum] = "e9c2fa7b0b1fa500a2dc87cc3a0637203535f3c9ecec071d3e2086383aea7f30"

URI_x86_64_v2_rust-similar+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+serde-devel-2.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+serde-devel}"
SRC_URI[x86_64_v2_rust-similar+serde-devel.sha256sum] = "e478659979837fc4aa8f693e70124ee1e700ed0449088b01653bd0f38ad54097"

URI_x86_64_v2_rust-similar+text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+text-devel-2.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+text-devel}"
SRC_URI[x86_64_v2_rust-similar+text-devel.sha256sum] = "32957978dd8f0761310a2d25c3df113c957ef792d6e840c8c1481b3253a5bb9c"

URI_x86_64_v2_rust-similar+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+unicode-devel-2.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+unicode-devel}"
SRC_URI[x86_64_v2_rust-similar+unicode-devel.sha256sum] = "0be20502d1b6e2d80b8a8a900aa95bb2e9ad796f640ff7f408f147c967beeb3a"

URI_x86_64_v2_rust-similar+unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+unicode-segmentation-devel-2.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-similar+unicode-segmentation-devel.sha256sum] = "758f55fc3b66d8ae9d111a35c69f19f3003b05c16bdaa3008048a350c563f6c8"

URI_x86_64_v2_rust-similar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar-devel-2.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar-devel}"
SRC_URI[x86_64_v2_rust-similar-devel.sha256sum] = "e0fd87f696c5cdaa522b5e8ef0567c0c3b895698b9c6d326c7a368753060b00f"

URI_aarch64_rust-similar+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+bstr-devel-2.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-similar+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+bstr-devel}"
SRC_URI[aarch64_rust-similar+bstr-devel.sha256sum] = "d1847231fa1e52486622137e6e9147df063c33eef9f65b47bf116fa4b7b83ab3"

URI_aarch64_rust-similar+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+bytes-devel-2.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-similar+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+bytes-devel}"
SRC_URI[aarch64_rust-similar+bytes-devel.sha256sum] = "e5e01c5508d891a08c4e3239d1aa3ab42218044a1910c084eec2c6eb6e32279b"

URI_aarch64_rust-similar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+default-devel-2.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-similar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+default-devel}"
SRC_URI[aarch64_rust-similar+default-devel.sha256sum] = "645cbb9006af86eff75d170cf07e813b98f98da629f87cc0257fd1e5089dc982"

URI_aarch64_rust-similar+inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+inline-devel-2.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-similar+inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+inline-devel}"
SRC_URI[aarch64_rust-similar+inline-devel.sha256sum] = "d390b200db6938d32dc4e636bb3df112ad82e3d9e4fcb55aac8316cc43844a94"

URI_aarch64_rust-similar+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+serde-devel-2.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-similar+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+serde-devel}"
SRC_URI[aarch64_rust-similar+serde-devel.sha256sum] = "5a6663ffd4a6b4cf45893d0e99c55d02d47711671bdf5559cef52b792d93a9e2"

URI_aarch64_rust-similar+text-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+text-devel-2.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-similar+text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+text-devel}"
SRC_URI[aarch64_rust-similar+text-devel.sha256sum] = "a36bca50d40cb1550e3929db6cdf61997ec7d9ec3dcfaa8bc211990db2e49a83"

URI_aarch64_rust-similar+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+unicode-devel-2.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-similar+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+unicode-devel}"
SRC_URI[aarch64_rust-similar+unicode-devel.sha256sum] = "c44dfbb9d8a3c90ece71176495dd84772f4d394263bec2b5ac76a53496bd4388"

URI_aarch64_rust-similar+unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+unicode-segmentation-devel-2.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-similar+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+unicode-segmentation-devel}"
SRC_URI[aarch64_rust-similar+unicode-segmentation-devel.sha256sum] = "b842f53a3b298b61a468963f0cab47bc02277ae7c489c96229fec7c38d6d1db6"

URI_aarch64_rust-similar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar-devel-2.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-similar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar-devel}"
SRC_URI[aarch64_rust-similar-devel.sha256sum] = "3ee8e3fdd5052f896b0cf6f8d061c335752663b9421f5d57389ba07290d5fe96"

RDEPENDS:rust-similar+bstr-devel = " \
 cargo \
 rust-bstr-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+bytes-devel = " \
 cargo \
 rust-similar+bstr-devel \
 rust-similar+text-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+default-devel = " \
 cargo \
 rust-similar+text-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+inline-devel = " \
 cargo \
 rust-similar+text-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+text-devel = " \
 cargo \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+unicode-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-similar+text-devel \
 rust-similar+unicode-segmentation-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+unicode-segmentation-devel = " \
 cargo \
 rust-similar-devel \
 rust-unicode-segmentation+default-devel \
 "
RDEPENDS:rust-similar-devel = " \
 bash \
 cargo \
 rust \
 "
