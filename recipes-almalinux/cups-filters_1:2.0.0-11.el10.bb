# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cups-filters"
PE = "1"
PV = "2.0.0"
PR = "11.el10"
PACKAGES = " \
 cups-filters \
 cups-filters-driverless \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cups-filters-2.0.0-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d89ae1182367a15615b770445d844df88be3a7161eafe04d4a1501ba918a1c07"

URI_x86_64_v2_cups-filters = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-filters-2.0.0-11.el10.x86_64_v2.rpm;name=x86_64_v2_cups-filters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-filters}"
SRC_URI[x86_64_v2_cups-filters.sha256sum] = "f784ceffbed5895e4ed59cfafe680d86650f57abe3e78c51d289690a536d0e9b"

URI_x86_64_v2_cups-filters-driverless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-filters-driverless-2.0.0-11.el10.x86_64_v2.rpm;name=x86_64_v2_cups-filters-driverless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-filters-driverless}"
SRC_URI[x86_64_v2_cups-filters-driverless.sha256sum] = "8f818803a02e62f9d2350a44caba6e05a4ecce231c81724936d4cad98cdca18b"

URI_aarch64_cups-filters = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-filters-2.0.0-11.el10.aarch64.rpm;name=aarch64_cups-filters;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-filters}"
SRC_URI[aarch64_cups-filters.sha256sum] = "c4cc4c29acd28a7244af39ad83c28990293c2bf291adecd0981d5157c00618aa"

URI_aarch64_cups-filters-driverless = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-filters-driverless-2.0.0-11.el10.aarch64.rpm;name=aarch64_cups-filters-driverless;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-filters-driverless}"
SRC_URI[aarch64_cups-filters-driverless.sha256sum] = "1e8f47502433aea699472284c7e47dabc61b8977dfc9b261bf2ffb8d92919c50"

RDEPENDS:cups-filters = " \
 bash \
 cups-filesystem \
 cups-libs \
 glibc \
 libcupsfilters \
 libppd \
 "
RDEPENDS:cups-filters-driverless = " \
 avahi \
 bash \
 cups-filesystem \
 cups-ipptool \
 cups-libs \
 glibc \
 libcupsfilters \
 libppd \
 "
