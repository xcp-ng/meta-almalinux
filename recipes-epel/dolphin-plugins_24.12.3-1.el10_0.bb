# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dolphin-plugins"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 dolphin-plugins \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dolphin-plugins-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf6462e3f9965c893d59a1c5e7bb1bb9aec74ace3c60031b2a08770b53f68fe9"

URI_x86_64_v2_dolphin-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-plugins-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dolphin-plugins}"
SRC_URI[x86_64_v2_dolphin-plugins.sha256sum] = "1339fa30d47c2e5d59d0feaf6f8089760f549d272956b59d3251f2e2b8a483da"

URI_aarch64_dolphin-plugins = "${EPEL_MIRROR}/aarch64/Packages/d/dolphin-plugins-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_dolphin-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_dolphin-plugins}"
SRC_URI[aarch64_dolphin-plugins.sha256sum] = "d95d357fcc5a5d179c8b8454d9dec99c9739b570284db31bf645cb13c63d354f"

RDEPENDS:dolphin-plugins = " \
 dolphin \
 dolphin-libs \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
