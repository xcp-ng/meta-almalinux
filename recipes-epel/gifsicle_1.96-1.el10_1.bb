# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gifsicle"
PV = "1.96"
PR = "1.el10_1"
PACKAGES = " \
 gifsicle \
 gifview \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gifsicle-1.96-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "342f54df7c1229aac2d39aca12f8e2ca32921ee324e12c80e62d094bb2df5077"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gifsicle-1.96-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gifsicle;unpack=0"
SRC_URI[x86_64_v2_gifsicle.sha256sum] = "19bd51c10491cf7a5ebd99e8beec80606e3fa540c49c74552854f53d69c95538"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gifview-1.96-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gifview;unpack=0"
SRC_URI[x86_64_v2_gifview.sha256sum] = "71a22beb864149748befafb03040371e839d93d39fb42ed32ef673eab8327614"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gifsicle-1.96-1.el10_1.aarch64.rpm;name=aarch64_gifsicle;unpack=0"
SRC_URI[aarch64_gifsicle.sha256sum] = "5deeffdc6b5fe58ece53646a699879ecb9ef1f6909c5a6fa5898d0dcb0039852"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gifview-1.96-1.el10_1.aarch64.rpm;name=aarch64_gifview;unpack=0"
SRC_URI[aarch64_gifview.sha256sum] = "603e9a70ed4d428c73ca5baf342839f0696189e8756bdcef58eafaf51bfc1791"

RDEPENDS:gifsicle = " \
 glibc \
 "
RDEPENDS:gifview = " \
 glibc \
 libX11 \
 "
