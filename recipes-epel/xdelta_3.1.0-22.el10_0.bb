# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdelta"
PV = "3.1.0"
PR = "22.el10_0"
PACKAGES = " \
 xdelta \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xdelta-3.1.0-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdd66ba781bd8bd0f4c1ac1dbf1def59f641ddfe783125f64273f2883ddd419b"

URI_x86_64_v2_xdelta = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xdelta-3.1.0-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xdelta;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdelta}"
SRC_URI[x86_64_v2_xdelta.sha256sum] = "492e68c532d9ed5eedcd1b8259761aa26e816f691efe1b0d16b6d9704f3f932c"

URI_aarch64_xdelta = "${EPEL_MIRROR}/aarch64/Packages/x/xdelta-3.1.0-22.el10_0.aarch64.rpm;name=aarch64_xdelta;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdelta}"
SRC_URI[aarch64_xdelta.sha256sum] = "54a646701cb06f5910566de8a39d6304089b28dca3ea9bd11ca7803d5007673e"

RDEPENDS:xdelta = " \
 glibc \
 xz-libs \
 "
