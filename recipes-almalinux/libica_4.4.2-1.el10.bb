# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libica"
PV = "4.4.2"
PR = "1.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libica-4.4.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09aff709620681b1bd230bc0239a7b064eeae57c1c0f87507633fa650d407e65"

