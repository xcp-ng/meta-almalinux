# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-date"
PV = "0.11.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-date+default-devel \
 rust-gix-date+document-features-devel \
 rust-gix-date+serde-devel \
 rust-gix-date-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-date-0.11.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24a3da0aae137e4a085450ade1b64c17e736efff87e96278d5eb158712693de2"

URI_x86_64_v2_rust-gix-date+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date+default-devel-0.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date+default-devel}"
SRC_URI[x86_64_v2_rust-gix-date+default-devel.sha256sum] = "e71a8c6eb1ac81450081f6082f8b9d007adc8d08b706dfc3b7c057514d9771c5"

URI_x86_64_v2_rust-gix-date+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date+document-features-devel-0.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-date+document-features-devel.sha256sum] = "53b9e0a096559cb8ed74ccf3f78d5885dc233adcd4206e2a879e57454d0fe8f4"

URI_x86_64_v2_rust-gix-date+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date+serde-devel-0.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-date+serde-devel.sha256sum] = "bc67f36e66efab856b4e3944363bac8e036572349bd64530e2e0f81bc5e6aaef"

URI_x86_64_v2_rust-gix-date-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date-devel-0.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date-devel}"
SRC_URI[x86_64_v2_rust-gix-date-devel.sha256sum] = "e2f8ca7147824e532dc075a475e35c8e19e56c4497f8394ebba87e86756d74c7"

URI_aarch64_rust-gix-date+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date+default-devel-0.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-date+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date+default-devel}"
SRC_URI[aarch64_rust-gix-date+default-devel.sha256sum] = "d4e950e3896c07a1117d5f1bd283ea75f1f21a095ef94cd98009f9a9b417adaa"

URI_aarch64_rust-gix-date+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date+document-features-devel-0.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-date+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date+document-features-devel}"
SRC_URI[aarch64_rust-gix-date+document-features-devel.sha256sum] = "4a27c13ad707e8111b3839d415b13cb8ecb61b53c05659a33939dcc7f0721f06"

URI_aarch64_rust-gix-date+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date+serde-devel-0.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-date+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date+serde-devel}"
SRC_URI[aarch64_rust-gix-date+serde-devel.sha256sum] = "67bc572a1de40f7df06b4f2f03284a70ef79c717cfc4758f70cddd1506371c6d"

URI_aarch64_rust-gix-date-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date-devel-0.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-date-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date-devel}"
SRC_URI[aarch64_rust-gix-date-devel.sha256sum] = "662ccb5872e5684835da8e26fd9643ac5b95013d7113bca9f9603b93de83339f"

RDEPENDS:rust-gix-date+default-devel = " \
 cargo \
 rust-gix-date-devel \
 "
RDEPENDS:rust-gix-date+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-date-devel \
 "
RDEPENDS:rust-gix-date+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-date-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-date-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-itoa+default-devel \
 rust-jiff+default-devel \
 rust-smallvec+default-devel \
 rust-smallvec+write-devel \
 rust-thiserror+default-devel \
 "
