# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_dirname"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_dirname+default-devel \
 rust-uu_dirname-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_dirname-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b416ff0c2cff8e8c1f3f97bf78551938b24d42fedd80f622bc5a59f6671f76c9"

URI_x86_64_v2_rust-uu_dirname+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_dirname+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_dirname+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_dirname+default-devel}"
SRC_URI[x86_64_v2_rust-uu_dirname+default-devel.sha256sum] = "7d31d1cf0a3542f66444f440b0055492ae8ddf2a7d99ef812b4b4c4b794088bc"

URI_x86_64_v2_rust-uu_dirname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_dirname-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_dirname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_dirname-devel}"
SRC_URI[x86_64_v2_rust-uu_dirname-devel.sha256sum] = "d94792c41619fa2d130950efc1f34a8d3ff9f1c61d23c52fa76e72d9feebcc3b"

URI_aarch64_rust-uu_dirname+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_dirname+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_dirname+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_dirname+default-devel}"
SRC_URI[aarch64_rust-uu_dirname+default-devel.sha256sum] = "c116ec2aa6515aba3b84e998d512bccb82c7ec1bf2085fadd2fb73b3601d97b5"

URI_aarch64_rust-uu_dirname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_dirname-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_dirname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_dirname-devel}"
SRC_URI[aarch64_rust-uu_dirname-devel.sha256sum] = "f28484e88873a1240de8c43396814c2a9d4cce78814628632fc0f897581b9e21"

RDEPENDS:rust-uu_dirname+default-devel = " \
 cargo \
 rust-uu_dirname-devel \
 "
RDEPENDS:rust-uu_dirname-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 "
