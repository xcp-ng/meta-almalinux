# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mackup"
PV = "0.10.3"
PR = "1.el10_3"
PACKAGES = " \
 mackup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mackup-0.10.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ebf5c7e72a6e0ef54bc638ed63284bac146782a63290b1241205924d8803bff"

URI_x86_64_v2_mackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mackup-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mackup}"
SRC_URI[x86_64_v2_mackup.sha256sum] = "1af27ca0e35dbd13cbe400f633ddece2268f69ee0940ee61af1d6bc4c0eefcaa"

URI_aarch64_mackup = "${EPEL_MIRROR}/aarch64/Packages/m/mackup-0.10.3-1.el10_3.noarch.rpm;name=aarch64_mackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_mackup}"
SRC_URI[aarch64_mackup.sha256sum] = "9d30cc8ce4d2275c0475aa660532bc4d5ec6b25d79e03a31ff2d8f2049aa4eb9"

RDEPENDS:mackup = " \
 procps-ng \
 python3 \
 python3-docopt-ng \
 "
