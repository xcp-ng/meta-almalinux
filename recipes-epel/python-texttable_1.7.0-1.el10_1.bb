# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-texttable"
PV = "1.7.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-texttable \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-texttable-1.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fc1f0502444ddcf0ac603f8cfe6029581db91f854c2e515dd1cb3a424aa8957"

URI_x86_64_v2_python3-texttable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-texttable-1.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-texttable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-texttable}"
SRC_URI[x86_64_v2_python3-texttable.sha256sum] = "52dd497f97979c55f54b3edac12b1534ab2b49416f7322e7457ea51708f6ecaf"

URI_aarch64_python3-texttable = "${EPEL_MIRROR}/aarch64/Packages/p/python3-texttable-1.7.0-1.el10_1.noarch.rpm;name=aarch64_python3-texttable;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-texttable}"
SRC_URI[aarch64_python3-texttable.sha256sum] = "1568e6fb4d036bf7ac8a4dc40fd8100676da9f881dcf2004947d9574a17a6d8a"

RDEPENDS:python3-texttable = " \
 python3 \
 "
