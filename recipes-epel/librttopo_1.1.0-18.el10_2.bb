# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librttopo"
PV = "1.1.0"
PR = "18.el10_2"
PACKAGES = " \
 librttopo \
 librttopo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/librttopo-1.1.0-18.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3841157ad78720050733f2072d514a2c6346e81a8f81c5b21a87a9050afd90b0"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - librttopo: libgeos_c.so.1()(64bit)

URI_x86_64_v2_librttopo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librttopo-1.1.0-18.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librttopo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librttopo}"
SRC_URI[x86_64_v2_librttopo.sha256sum] = "1365471569857a0623f04b8b578c53bf15c0da29f6beca9591d4fd86bfef61e6"

URI_x86_64_v2_librttopo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librttopo-devel-1.1.0-18.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librttopo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librttopo-devel}"
SRC_URI[x86_64_v2_librttopo-devel.sha256sum] = "6e66ae09d771779c96d384603c0a2d84af5b6d2bbe9830581cc4487607ec0eec"

URI_aarch64_librttopo = "${EPEL_MIRROR}/aarch64/Packages/l/librttopo-1.1.0-18.el10_2.aarch64.rpm;name=aarch64_librttopo;unpack=0"
SRC_URI:append = " ${URI_aarch64_librttopo}"
SRC_URI[aarch64_librttopo.sha256sum] = "53f472d4c4a4be426f63a5d9497eaaffe41b5fb5853330807ea2a3499565d409"

URI_aarch64_librttopo-devel = "${EPEL_MIRROR}/aarch64/Packages/l/librttopo-devel-1.1.0-18.el10_2.aarch64.rpm;name=aarch64_librttopo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librttopo-devel}"
SRC_URI[aarch64_librttopo-devel.sha256sum] = "7ddad58ce4e6854d0e01d7d9fbe4916d40dd983c8510ed9e47f1e28d5c2a358f"

RDEPENDS:librttopo:x86_64_v2 = " \
 glibc \
"
RDEPENDS:librttopo:aarch64 = " \
 geos \
 glibc \
"
RDEPENDS:librttopo-devel = " \
 librttopo \
 pkgconf-pkg-config \
 "
