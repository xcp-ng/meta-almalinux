# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "log4cxx"
PV = "1.7.0"
PR = "3.el10_3"
PACKAGES = " \
 log4cxx \
 log4cxx-devel \
 log4cxx-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/log4cxx-1.7.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5176ce1fd0fecaaeafdcfbc2a10e3c9a12fe4c2dacad47875fa33af7a55c6d68"

URI_x86_64_v2_log4cxx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cxx-1.7.0-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cxx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cxx}"
SRC_URI[x86_64_v2_log4cxx.sha256sum] = "a791264835fa22238e3ef54b62e7b0d1a53c926cbce46ccf868ba2ceb9af96e7"

URI_x86_64_v2_log4cxx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cxx-devel-1.7.0-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cxx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cxx-devel}"
SRC_URI[x86_64_v2_log4cxx-devel.sha256sum] = "f71e4c535c6e5b5ce3dfc25228f2a68d09b6628b7d74f86f4e7375774e76da75"

URI_x86_64_v2_log4cxx-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cxx-doc-1.7.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_log4cxx-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cxx-doc}"
SRC_URI[x86_64_v2_log4cxx-doc.sha256sum] = "eaaa31e005b6b2bdc38ce7822fdf97d9f944933112a0ab0bedd9890da831d812"

URI_aarch64_log4cxx = "${EPEL_MIRROR}/aarch64/Packages/l/log4cxx-1.7.0-3.el10_3.aarch64.rpm;name=aarch64_log4cxx;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cxx}"
SRC_URI[aarch64_log4cxx.sha256sum] = "f8385acab0440c06b49acd8fd5ae6558258353cc68c23751f3dab481455838cc"

URI_aarch64_log4cxx-devel = "${EPEL_MIRROR}/aarch64/Packages/l/log4cxx-devel-1.7.0-3.el10_3.aarch64.rpm;name=aarch64_log4cxx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cxx-devel}"
SRC_URI[aarch64_log4cxx-devel.sha256sum] = "f64d8ac07c0fedf64d8822acbdb44d67f190eb872bd52b39987367f5bc648fc0"

URI_aarch64_log4cxx-doc = "${EPEL_MIRROR}/aarch64/Packages/l/log4cxx-doc-1.7.0-3.el10_3.noarch.rpm;name=aarch64_log4cxx-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cxx-doc}"
SRC_URI[aarch64_log4cxx-doc.sha256sum] = "6107dd85ab5ad7202119ba9bbbc6aaef8ebe94ad14f1a5e9d41a424c918f2e64"

RDEPENDS:log4cxx = " \
 apr \
 apr-util \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:log4cxx-devel = " \
 apr-devel \
 apr-util-devel \
 cmake-filesystem \
 log4cxx \
 pkgconf-pkg-config \
 "
RDEPENDS:log4cxx-doc = " \
 "
