# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "evolution-ews"
PV = "3.52.4"
PR = "1.el10_0"
PACKAGES = " \
 evolution-ews \
 evolution-ews-langpacks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/evolution-ews-3.52.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edc5116ed0aa42699dc8b9cb694e8fffa17884a1357844158c7465ce774755b6"

URI_x86_64_v2_evolution-ews = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-ews-3.52.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_evolution-ews;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-ews}"
SRC_URI[x86_64_v2_evolution-ews.sha256sum] = "08a63973978bff2b48be4fd1794fac5d3ff29b3e32d76ece315dcd553ccfd180"

URI_x86_64_v2_evolution-ews-langpacks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-ews-langpacks-3.52.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_evolution-ews-langpacks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-ews-langpacks}"
SRC_URI[x86_64_v2_evolution-ews-langpacks.sha256sum] = "05bba2547fea7ada6bad6af5d365ade430face10f8960668e842734c5cce666d"

URI_aarch64_evolution-ews = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-ews-3.52.4-1.el10_0.aarch64.rpm;name=aarch64_evolution-ews;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-ews}"
SRC_URI[aarch64_evolution-ews.sha256sum] = "aaf6a55ee0daf6a16370c5c653e50a43a005495dacc713bed81b2b8f5d2fb991"

URI_aarch64_evolution-ews-langpacks = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-ews-langpacks-3.52.4-1.el10_0.noarch.rpm;name=aarch64_evolution-ews-langpacks;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-ews-langpacks}"
SRC_URI[aarch64_evolution-ews-langpacks.sha256sum] = "0c5122d8652d9e65aa012752377045c2ae917e0e6578e7e6c1b854d406973cb1"

RDEPENDS:evolution-ews = " \
 evolution \
 evolution-data-server \
 evolution-ews-langpacks \
 glib2 \
 glibc \
 gtk3 \
 json-glib \
 libgcc \
 libical-glib \
 libmspack \
 libsoup3 \
 libxml2 \
 pango \
 "
RDEPENDS:evolution-ews-langpacks = " \
 evolution-ews \
 "
