# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dtor-proc-macro"
PV = "0.0.13"
PR = "1.el10_3"
PACKAGES = " \
 rust-dtor-proc-macro+default-devel \
 rust-dtor-proc-macro-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-dtor-proc-macro-0.0.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1b70523ce63a4fabea4d537d9ec697b5b6d7b782381d62ce90c9b21fcd8cecb4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dtor-proc-macro+default-devel-0.0.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dtor-proc-macro+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-dtor-proc-macro+default-devel.sha256sum] = "835dd39295ef763f18da6cd29977595cca46ab26134f08d82abbb66ae5a878e8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dtor-proc-macro-devel-0.0.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dtor-proc-macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-dtor-proc-macro-devel.sha256sum] = "36bbaeab54faba222b9b6da3cb1dc7d32d1b7d47a09dd76f4dfb664927e2e6c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-dtor-proc-macro+default-devel-0.0.13-1.el10_3.noarch.rpm;name=aarch64_rust-dtor-proc-macro+default-devel;unpack=0"
SRC_URI[aarch64_rust-dtor-proc-macro+default-devel.sha256sum] = "b2128071a86a94b1df5bae7218e0a6a2940e620d05b144ac95429436651be568"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-dtor-proc-macro-devel-0.0.13-1.el10_3.noarch.rpm;name=aarch64_rust-dtor-proc-macro-devel;unpack=0"
SRC_URI[aarch64_rust-dtor-proc-macro-devel.sha256sum] = "e14fa6393e7ef8fab2c68275b203272479fc472907e1196b023ea846a389a883"

RDEPENDS:rust-dtor-proc-macro+default-devel = " \
 cargo \
 rust-dtor-proc-macro-devel \
 "
RDEPENDS:rust-dtor-proc-macro-devel = " \
 cargo \
 "
