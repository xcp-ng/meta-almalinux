# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-bigint-dig"
PV = "0.9.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-num-bigint-dig+arbitrary-devel \
 rust-num-bigint-dig+default-devel \
 rust-num-bigint-dig+fuzz-devel \
 rust-num-bigint-dig+i128-devel \
 rust-num-bigint-dig+prime-devel \
 rust-num-bigint-dig+rand-devel \
 rust-num-bigint-dig+serde-devel \
 rust-num-bigint-dig+std-devel \
 rust-num-bigint-dig+u64_digit-devel \
 rust-num-bigint-dig+zeroize-devel \
 rust-num-bigint-dig-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-bigint-dig-0.9.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38c9560b78f62898d520bbae3912631283febd4465dd78cfc7f3cf9048ca5d88"

URI_x86_64_v2_rust-num-bigint-dig+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+arbitrary-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+arbitrary-devel.sha256sum] = "dd9b30469e7f96ccfb649e1475a4626b3c65e990cdf4b856963da10e5061bfe4"

URI_x86_64_v2_rust-num-bigint-dig+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+default-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+default-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+default-devel.sha256sum] = "14b0c0d44fcad3118f656e15dffad64fa4aecd619a45f68503c9d96e565cf420"

URI_x86_64_v2_rust-num-bigint-dig+fuzz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+fuzz-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+fuzz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+fuzz-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+fuzz-devel.sha256sum] = "2a1895ba09370656f5fd1fb1115a01811af8d97e68c1fb4ac1e560ad662abdf7"

URI_x86_64_v2_rust-num-bigint-dig+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+i128-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+i128-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+i128-devel.sha256sum] = "85f416a93b01dd5c0a380456fc40f02e34746e067aa934ae31283463288e1279"

URI_x86_64_v2_rust-num-bigint-dig+prime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+prime-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+prime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+prime-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+prime-devel.sha256sum] = "b02827bbe679487819b3a9da1a491fb41c922d437410cf3f783ae468336e10cf"

URI_x86_64_v2_rust-num-bigint-dig+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+rand-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+rand-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+rand-devel.sha256sum] = "5f409bcfa19ac425b1cea69bed16406445d4a81c84c17584706b34a40a5c5494"

URI_x86_64_v2_rust-num-bigint-dig+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+serde-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+serde-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+serde-devel.sha256sum] = "06dd6231e52dbd976c53a0218cbba85538712b6ca24357faa32ae57a64e51d07"

URI_x86_64_v2_rust-num-bigint-dig+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+std-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+std-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+std-devel.sha256sum] = "bd388f2b670b256ba25f6c2025cc0a2ef733b46749fa10ea177f9605b575158b"

URI_x86_64_v2_rust-num-bigint-dig+u64_digit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+u64_digit-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+u64_digit-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+u64_digit-devel.sha256sum] = "f818290824f1a6b945bb6b1683f61331b5f89d69747de152ad8ea69bd38a4a1d"

URI_x86_64_v2_rust-num-bigint-dig+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+zeroize-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+zeroize-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+zeroize-devel.sha256sum] = "46ed7553e8d430aad646a57970e0f26a8137171d14d306d2e57dd2f37a4088ff"

URI_x86_64_v2_rust-num-bigint-dig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig-devel.sha256sum] = "2f40ccc09b7507d8a4e6defa2fafcc251c58a9995d8e44172cb86f081e851a42"

URI_aarch64_rust-num-bigint-dig+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+arbitrary-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+arbitrary-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+arbitrary-devel.sha256sum] = "165cfc1053f5735885eddfd42ed13cc7e5a19577004e2fa7ffa9dfbe968e4e3b"

URI_aarch64_rust-num-bigint-dig+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+default-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+default-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+default-devel.sha256sum] = "646db2356a5c6518107f4c6fb9a1d1505ace44731ed64d367bb4d5ad11e6cb7a"

URI_aarch64_rust-num-bigint-dig+fuzz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+fuzz-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig+fuzz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+fuzz-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+fuzz-devel.sha256sum] = "5cb686843a0c2793bc5651d0f23c971aaeb57fbb338255180ef714741a07fc7b"

URI_aarch64_rust-num-bigint-dig+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+i128-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+i128-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+i128-devel.sha256sum] = "fe99ae1e6e7f81c8897a4e8e45f3ea05c18ac47bd17599c5d9c447683d7ffc0f"

URI_aarch64_rust-num-bigint-dig+prime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+prime-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig+prime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+prime-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+prime-devel.sha256sum] = "09567637c5a91abd8e607f034ab02427bef538108353bd3c838ad6038223a655"

URI_aarch64_rust-num-bigint-dig+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+rand-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+rand-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+rand-devel.sha256sum] = "d72e250ce188c69483318116e7bc486ed6f089a026bd5914401727c0bdb74e07"

URI_aarch64_rust-num-bigint-dig+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+serde-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+serde-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+serde-devel.sha256sum] = "9f31d0860e9648db73dfaf5cd36d1989666f9dceb3c9e275d457a292eb626d52"

URI_aarch64_rust-num-bigint-dig+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+std-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+std-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+std-devel.sha256sum] = "095a8bce038c68663a9d116b44141d2516da28932b00a6c26f756da0834dc723"

URI_aarch64_rust-num-bigint-dig+u64_digit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+u64_digit-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+u64_digit-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+u64_digit-devel.sha256sum] = "3633f7420e024099ee4fba4f68675ca16ed25cd5b31213289a574be055645405"

URI_aarch64_rust-num-bigint-dig+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+zeroize-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+zeroize-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+zeroize-devel.sha256sum] = "179cd3a98d0422f076f43c3be654d335802d6baff314c0271981c935128329b7"

URI_aarch64_rust-num-bigint-dig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig-devel}"
SRC_URI[aarch64_rust-num-bigint-dig-devel.sha256sum] = "e1cf1f2fdccce6ef23f37b1ee756a27d1ac8b2341b85bdb00199d3fe2d8865ab"

RDEPENDS:rust-num-bigint-dig+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+default-devel = " \
 cargo \
 rust-num-bigint-dig+std-devel \
 rust-num-bigint-dig+u64_digit-devel \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+fuzz-devel = " \
 cargo \
 rust-num-bigint-dig+arbitrary-devel \
 rust-num-bigint-dig-devel \
 rust-smallvec+arbitrary-devel \
 "
RDEPENDS:rust-num-bigint-dig+i128-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+prime-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-rand0.9+std_rng-devel \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-num-bigint-dig+rand-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-num-bigint-dig+serde-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-num-bigint-dig+std-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-num-integer+std-devel \
 rust-num-traits+std-devel \
 rust-rand0.9+std-devel \
 rust-rand0.9-devel \
 rust-serde+alloc-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-smallvec+write-devel \
 "
RDEPENDS:rust-num-bigint-dig+u64_digit-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+zeroize-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-num-bigint-dig-devel = " \
 bash \
 cargo \
 rust \
 rust-libm+default-devel \
 rust-num-integer+i128-devel \
 rust-num-integer-devel \
 rust-num-iter-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 rust-once_cell+default-devel \
 rust-smallvec-devel \
 "
