# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apt"
PV = "3.3.2"
PR = "1.el10_3"
PACKAGES = " \
 apt \
 apt-apidoc \
 apt-devel \
 apt-doc \
 apt-libs \
 apt-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/apt-3.3.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38eb5d148a4e6a38a467b09ba6edefd0bd643f8d2432db263589d65a6e167d69"

URI_x86_64_v2_apt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-3.3.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt}"
SRC_URI[x86_64_v2_apt.sha256sum] = "b1b9d5a3cde6bc8d3ea19695a29db289438625ddb9b39e35e756f6312236fe73"

URI_x86_64_v2_apt-apidoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-apidoc-3.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_apt-apidoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt-apidoc}"
SRC_URI[x86_64_v2_apt-apidoc.sha256sum] = "a9b29d0a1963be71a7ac57f5160777d02b9a21655e21671a56540edf21ea5f7d"

URI_x86_64_v2_apt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-devel-3.3.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt-devel}"
SRC_URI[x86_64_v2_apt-devel.sha256sum] = "e1dff51cda85e8e7fcf256b212a515a784a402d9585467fb2b3c2337b92e9b80"

URI_x86_64_v2_apt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-doc-3.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_apt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt-doc}"
SRC_URI[x86_64_v2_apt-doc.sha256sum] = "ce12c140c595ec08cce01cfdd9120ac842535eff6cc996ddebd5bc697a2ffc54"

URI_x86_64_v2_apt-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-libs-3.3.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt-libs}"
SRC_URI[x86_64_v2_apt-libs.sha256sum] = "0f7f342d63f28bee9418bf6bb32aa55b8b1d7860720c08d4cb02fa76b77a25fb"

URI_x86_64_v2_apt-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-utils-3.3.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt-utils}"
SRC_URI[x86_64_v2_apt-utils.sha256sum] = "b3fe5bc4ae73c522be2cae163e359aa326512e6e7485ada897f0a51287d42dea"

URI_aarch64_apt = "${EPEL_MIRROR}/aarch64/Packages/a/apt-3.3.2-1.el10_3.aarch64.rpm;name=aarch64_apt;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt}"
SRC_URI[aarch64_apt.sha256sum] = "0b81aaf418959e6ff0017012dd1b9747b177908d978243155bbd8519b7a5f938"

URI_aarch64_apt-apidoc = "${EPEL_MIRROR}/aarch64/Packages/a/apt-apidoc-3.3.2-1.el10_3.noarch.rpm;name=aarch64_apt-apidoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt-apidoc}"
SRC_URI[aarch64_apt-apidoc.sha256sum] = "68fa7de88a71cedee291b340aa4a2f882d01551595318d82bb5c52c083b7f09e"

URI_aarch64_apt-devel = "${EPEL_MIRROR}/aarch64/Packages/a/apt-devel-3.3.2-1.el10_3.aarch64.rpm;name=aarch64_apt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt-devel}"
SRC_URI[aarch64_apt-devel.sha256sum] = "1c50a3d8182acc78007bd777b916ad6e4b3b8a9f2abbb22f507bac0c49d62a23"

URI_aarch64_apt-doc = "${EPEL_MIRROR}/aarch64/Packages/a/apt-doc-3.3.2-1.el10_3.noarch.rpm;name=aarch64_apt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt-doc}"
SRC_URI[aarch64_apt-doc.sha256sum] = "c2ddeb76b3eb6d48b401c353ae6fd4f21f88cabafd5fd517e385620498ef7247"

URI_aarch64_apt-libs = "${EPEL_MIRROR}/aarch64/Packages/a/apt-libs-3.3.2-1.el10_3.aarch64.rpm;name=aarch64_apt-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt-libs}"
SRC_URI[aarch64_apt-libs.sha256sum] = "80e7553f687f544ed9b8e5e707af4d7aaa3701965d32fb9806b3c435a52034a4"

URI_aarch64_apt-utils = "${EPEL_MIRROR}/aarch64/Packages/a/apt-utils-3.3.2-1.el10_3.aarch64.rpm;name=aarch64_apt-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt-utils}"
SRC_URI[aarch64_apt-utils.sha256sum] = "f6e5af18b0e03b842fd41aac4ab399aa5009e2b4590be2a70da3d69d8ab4c1c0"

RDEPENDS:apt = " \
 apt-libs \
 bash \
 dpkg \
 glibc \
 libgcc \
 libseccomp \
 libstdc++ \
 openssl-libs \
 systemd-libs \
 "
RDEPENDS:apt-apidoc = " \
 "
RDEPENDS:apt-devel = " \
 apt-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:apt-doc = " \
 "
RDEPENDS:apt-libs = " \
 bzip2-libs \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 openssl-libs \
 systemd-libs \
 xxhash-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:apt-utils = " \
 apt \
 apt-libs \
 glibc \
 libdb \
 libgcc \
 libstdc++ \
 "
