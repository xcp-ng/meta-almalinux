# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnxz"
PV = "0.64"
PR = "8.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libnxz-0.64-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50879950a51e72f30833dcc2a5e7d7ba2df4de6665575c5c5dcd8a71f203266c"

