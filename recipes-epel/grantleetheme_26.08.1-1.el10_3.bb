# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grantleetheme"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 grantleetheme \
 grantleetheme-devel \
 grantleetheme-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/grantleetheme-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5ac6210f8b29121db0c325f8acb352ea312f2ef2ad94698ecec35056705fa8e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantleetheme-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantleetheme;unpack=0"
SRC_URI[x86_64_v2_grantleetheme.sha256sum] = "1d0491a2286af68e3e7644c1f9d77702d363077b2c7cc08c6550d9d09b40b1c1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantleetheme-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantleetheme-devel;unpack=0"
SRC_URI[x86_64_v2_grantleetheme-devel.sha256sum] = "fef42918866be247d481a499ba6955895f3253369576080c120654b937e0ba70"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantleetheme-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_grantleetheme-doc;unpack=0"
SRC_URI[x86_64_v2_grantleetheme-doc.sha256sum] = "e35d2e936cef55346947766f8f21c1023deed2a4b85f14aa3e7a07638702e016"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/grantleetheme-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_grantleetheme;unpack=0"
SRC_URI[aarch64_grantleetheme.sha256sum] = "957e5bbbcad9f9fe97a65c2b8b563cbb7bee3cff9c8245096431779035e8cbda"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/grantleetheme-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_grantleetheme-devel;unpack=0"
SRC_URI[aarch64_grantleetheme-devel.sha256sum] = "c487a3861f1f7f4141fdd10ec3cab5fc4e2701bf96296d04035de7dcab25d818"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/grantleetheme-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_grantleetheme-doc;unpack=0"
SRC_URI[aarch64_grantleetheme-doc.sha256sum] = "7dbdaed08192357e1baa58ec333fba75adea68562ec764083b07073212b6c666"

RDEPENDS:grantleetheme = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knewstuff \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:grantleetheme-devel = " \
 cmake-filesystem \
 grantleetheme \
 kf6-ktexttemplate-devel \
 "
RDEPENDS:grantleetheme-doc = " \
 "
