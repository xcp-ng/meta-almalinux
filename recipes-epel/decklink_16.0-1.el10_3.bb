# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "decklink"
PV = "16.0"
PR = "1.el10_3"
PACKAGES = " \
 decklink-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/decklink-16.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0b4ba0e4cee73a88522acce6e65a7e978b5a38909fc8522718a651f7809824ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/decklink-devel-16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_decklink-devel;unpack=0"
SRC_URI[x86_64_v2_decklink-devel.sha256sum] = "24014d6760b1fd42a409b7e28de5a6d645d181b6cb420268e12566e2d01c81ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/decklink-devel-16.0-1.el10_3.noarch.rpm;name=aarch64_decklink-devel;unpack=0"
SRC_URI[aarch64_decklink-devel.sha256sum] = "b0781103e15e126fc93fda6149b7cc9bd79ddcfab717f40f1626cf2f40a91cae"

RDEPENDS:decklink-devel = " \
 "
