# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qttranslations"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qttranslations \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qttranslations-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8eede26b6dc131781dd0ea870b7ccae7e733d19b3fd2b750718907e650369470"

URI_x86_64_v2_qt5-qttranslations = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttranslations-5.15.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qttranslations;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttranslations}"
SRC_URI[x86_64_v2_qt5-qttranslations.sha256sum] = "7c6b456e4a2419fcac652499a12b7805dbac61630b419ac6d5827efcd1a31334"

URI_aarch64_qt5-qttranslations = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttranslations-5.15.15-1.el10_0.noarch.rpm;name=aarch64_qt5-qttranslations;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttranslations}"
SRC_URI[aarch64_qt5-qttranslations.sha256sum] = "e2130fe4463388019a82d8f5514efdb19fe2255159dc33d6f74a6f95d121d5c0"

RDEPENDS:qt5-qttranslations = " \
 "
