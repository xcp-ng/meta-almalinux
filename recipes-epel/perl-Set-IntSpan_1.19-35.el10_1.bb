# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Set-IntSpan"
PV = "1.19"
PR = "35.el10_1"
PACKAGES = " \
 perl-Set-IntSpan \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Set-IntSpan-1.19-35.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "00915817bb3ac79872e6417e6c6b444ca094eaa5b92dfbbac74dd3ecf592d4ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Set-IntSpan-1.19-35.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Set-IntSpan;unpack=0"
SRC_URI[x86_64_v2_perl-Set-IntSpan.sha256sum] = "87ee231023334b41c2589a7b1f1b001a7a35bc269367fb382d4b60fd6075061a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Set-IntSpan-1.19-35.el10_1.noarch.rpm;name=aarch64_perl-Set-IntSpan;unpack=0"
SRC_URI[aarch64_perl-Set-IntSpan.sha256sum] = "e7aa40bfe19e49e0fda5b30b15c8c77c0acffc6a3050dbe31cc494c3981339bf"

RDEPENDS:perl-Set-IntSpan = " \
 perl-Carp \
 perl-Exporter \
 perl-base \
 perl-constant \
 perl-if \
 perl-libs \
 perl-overload \
 "
