# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtdeclarative"
PV = "6.9.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtdeclarative \
 qt6-qtdeclarative-devel \
 qt6-qtdeclarative-examples \
 qt6-qtdeclarative-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtdeclarative-6.9.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f4b0a6b85a74f4da84a97f99a2d51ca0e5a42cff3c6675213f522caa26d53c0"

URI_x86_64_v2_qt6-qtdeclarative = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtdeclarative-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdeclarative;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdeclarative}"
SRC_URI[x86_64_v2_qt6-qtdeclarative.sha256sum] = "bd229bac868429ed4769e7c906d85337e047512ae1ee801baf91efe213125739"

URI_x86_64_v2_qt6-qtdeclarative-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtdeclarative-devel-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdeclarative-devel}"
SRC_URI[x86_64_v2_qt6-qtdeclarative-devel.sha256sum] = "1c26ba83f8744ea28056eddc517c306b826cdf589e00682b615e26cb53ed5fa5"

URI_x86_64_v2_qt6-qtdeclarative-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtdeclarative-examples-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdeclarative-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdeclarative-examples}"
SRC_URI[x86_64_v2_qt6-qtdeclarative-examples.sha256sum] = "46724ac5ae8e9438eb02161b6d05f827670e09ea0d4815515d3e52667694ddf6"

URI_x86_64_v2_qt6-qtdeclarative-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtdeclarative-static-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdeclarative-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdeclarative-static}"
SRC_URI[x86_64_v2_qt6-qtdeclarative-static.sha256sum] = "7ce3cd43bc42dd74446d051c0443b104e1d4ae0da9ac59cf620caf03dfa284ff"

URI_aarch64_qt6-qtdeclarative = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtdeclarative-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtdeclarative;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdeclarative}"
SRC_URI[aarch64_qt6-qtdeclarative.sha256sum] = "41359b23f20883d09a1e021c020c75fe1b074ea809ec6f1d525cad32140c1ba0"

URI_aarch64_qt6-qtdeclarative-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtdeclarative-devel-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdeclarative-devel}"
SRC_URI[aarch64_qt6-qtdeclarative-devel.sha256sum] = "a3493afef2835b8539b122d0b12a3de4ef231571a99bcd84ffae7b5c3cd937fb"

URI_aarch64_qt6-qtdeclarative-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtdeclarative-examples-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtdeclarative-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdeclarative-examples}"
SRC_URI[aarch64_qt6-qtdeclarative-examples.sha256sum] = "ffb4162f10ec4068efe349e9fb01170f8e5de5c3b3dff4b533dca389e630c9b1"

URI_aarch64_qt6-qtdeclarative-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtdeclarative-static-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtdeclarative-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdeclarative-static}"
SRC_URI[aarch64_qt6-qtdeclarative-static.sha256sum] = "6fc58bcc8299e99308913286545337ede0336ea61a915b46355008214be28b3c"

RDEPENDS:qt6-qtdeclarative:x86_64_v2 = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
"
RDEPENDS:qt6-qtdeclarative:aarch64 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
"
RDEPENDS:qt6-qtdeclarative-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:qt6-qtdeclarative-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtdeclarative-static = " \
 cmake-filesystem \
 qt6-qtdeclarative-devel \
 "
