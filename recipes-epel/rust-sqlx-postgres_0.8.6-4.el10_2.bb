# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sqlx-postgres"
PV = "0.8.6"
PR = "4.el10_2"
PACKAGES = " \
 rust-sqlx-postgres+any-devel \
 rust-sqlx-postgres+bigdecimal-devel \
 rust-sqlx-postgres+bit-vec-devel \
 rust-sqlx-postgres+chrono-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+ipnet-devel \
 rust-sqlx-postgres+ipnetwork-devel \
 rust-sqlx-postgres+json-devel \
 rust-sqlx-postgres+mac_address-devel \
 rust-sqlx-postgres+migrate-devel \
 rust-sqlx-postgres+offline-devel \
 rust-sqlx-postgres+rust_decimal-devel \
 rust-sqlx-postgres+time-devel \
 rust-sqlx-postgres+uuid-devel \
 rust-sqlx-postgres-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sqlx-postgres-0.8.6-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e778ed367bdc8c71113f8dd5c002b1f477c59b7b388dbfa4fc554a834909add4"

URI_x86_64_v2_rust-sqlx-postgres+any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+any-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+any-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+any-devel.sha256sum] = "661dc03663027b6c965a21a2ca041e4fad4b786d28bc9161d3641e776aff7a26"

URI_x86_64_v2_rust-sqlx-postgres+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+bigdecimal-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+bigdecimal-devel.sha256sum] = "31f9579105d2d00125e1c7663e2f167cc418696a7874c2f8b252f5e3e7a9c81e"

URI_x86_64_v2_rust-sqlx-postgres+bit-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+bit-vec-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+bit-vec-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+bit-vec-devel.sha256sum] = "33762b4d430dcd2be3020eda3d4fce62e6d190b47766c0a1a06d3ecc78ef2ca7"

URI_x86_64_v2_rust-sqlx-postgres+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+chrono-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+chrono-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+chrono-devel.sha256sum] = "6a6bfa0ed8155afcccb1768af433237484e6f611481d704cdec3ae8af89e7c5a"

URI_x86_64_v2_rust-sqlx-postgres+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+default-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+default-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+default-devel.sha256sum] = "9d0f9b7a381b0c8035321cf42f153b6d3d0b7edd3af8f7816da39083bbcb3dd5"

URI_x86_64_v2_rust-sqlx-postgres+ipnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+ipnet-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+ipnet-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+ipnet-devel.sha256sum] = "47cc64dd9a1469b789495c3a4e6808fdc6eb029ef46e0d1b58fd7265048d8ae7"

URI_x86_64_v2_rust-sqlx-postgres+ipnetwork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+ipnetwork-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+ipnetwork-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+ipnetwork-devel.sha256sum] = "7a23ea052445486cf04adb6fd2fd37d76b0b67406ac9985e653637fd41eb368b"

URI_x86_64_v2_rust-sqlx-postgres+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+json-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+json-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+json-devel.sha256sum] = "6b611a8684af4f7940b3658b81efbcee776a0b7171ebfe6b77019d3a5b3d8f9c"

URI_x86_64_v2_rust-sqlx-postgres+mac_address-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+mac_address-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+mac_address-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+mac_address-devel.sha256sum] = "97920c38f0ffc6602acdbe6a51c6a0ebd7b25c47c64a7be310a4e3c17c350784"

URI_x86_64_v2_rust-sqlx-postgres+migrate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+migrate-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+migrate-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+migrate-devel.sha256sum] = "19e2228b4ec0c24392e495b42e1957a934add4952ebabbc54511ea9aa5a036c8"

URI_x86_64_v2_rust-sqlx-postgres+offline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+offline-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+offline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+offline-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+offline-devel.sha256sum] = "86fb13f752ad7f1e3741e2a900522fbe8e08cc816d8fe0c6399bf1a00fadf669"

URI_x86_64_v2_rust-sqlx-postgres+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+rust_decimal-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+rust_decimal-devel.sha256sum] = "1c700a8f4d1b200cd634f4aaf9501edc0cbc566fc134b3a1637dab9f613bedb5"

URI_x86_64_v2_rust-sqlx-postgres+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+time-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+time-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+time-devel.sha256sum] = "36326eb1b44e696c088eae56aa596bcbbea2a53088a83e3f73b7de22a5e281bd"

URI_x86_64_v2_rust-sqlx-postgres+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres+uuid-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres+uuid-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres+uuid-devel.sha256sum] = "5aac97f43126afad06087c2f058b89ddbb1c5082f38e5d13cf7764413db0563c"

URI_x86_64_v2_rust-sqlx-postgres-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-postgres-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-postgres-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-postgres-devel}"
SRC_URI[x86_64_v2_rust-sqlx-postgres-devel.sha256sum] = "75e195e8b6474fa4506b5e87026cd62852b02fc8e413ad1d07c679fe57a4e053"

URI_aarch64_rust-sqlx-postgres+any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+any-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-postgres+any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+any-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+any-devel.sha256sum] = "092e2d87c68049761af314d862b3daf00a6bf7d4967df8e09baaef45ca4d0f03"

URI_aarch64_rust-sqlx-postgres+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+bigdecimal-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-postgres+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+bigdecimal-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+bigdecimal-devel.sha256sum] = "93101b325890aecbfa488c8e2a5e7805e05bde29e60a3be9de67a55bac09fec9"

URI_aarch64_rust-sqlx-postgres+bit-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+bit-vec-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-postgres+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+bit-vec-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+bit-vec-devel.sha256sum] = "90356e26b7e3a344c1d5527489fcdf297f1870ff06b6c32a190ec0a59ee96ed8"

URI_aarch64_rust-sqlx-postgres+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+chrono-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-postgres+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+chrono-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+chrono-devel.sha256sum] = "765da3bbbf109ff72ab546f8a093dec6332e639abeb318b41326a01828196791"

URI_aarch64_rust-sqlx-postgres+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+default-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-postgres+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+default-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+default-devel.sha256sum] = "c20725562839fcad0509adf46457603a2c402f79f25fd584519fc11faeb9c68e"

URI_aarch64_rust-sqlx-postgres+ipnet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+ipnet-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-postgres+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+ipnet-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+ipnet-devel.sha256sum] = "04dc012a9d92d53e857c44141c1857cf9a729a13b9e8e53c5f3e289dabe41ea1"

URI_aarch64_rust-sqlx-postgres+ipnetwork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+ipnetwork-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-postgres+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+ipnetwork-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+ipnetwork-devel.sha256sum] = "e968fd5e976e2cfb3e2170321449ad65a788e57db4b6017b8ba8f44a7d23e3da"

URI_aarch64_rust-sqlx-postgres+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+json-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-postgres+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+json-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+json-devel.sha256sum] = "a09199b5e9f07f3ed04ceb6ccb601b168c43d35164cf7811258df95206b6d6f8"

URI_aarch64_rust-sqlx-postgres+mac_address-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+mac_address-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-postgres+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+mac_address-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+mac_address-devel.sha256sum] = "3d853199a99674061138c0e53f69d5e71922d255be9a31ca8f5cb8172f16e12f"

URI_aarch64_rust-sqlx-postgres+migrate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+migrate-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-postgres+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+migrate-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+migrate-devel.sha256sum] = "9eea1197f819705046639780610fe5a6fd9ea50461a4d87ca4b98cb79e87c0ef"

URI_aarch64_rust-sqlx-postgres+offline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+offline-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-postgres+offline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+offline-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+offline-devel.sha256sum] = "cbdebb0ff62c8df20d655c10b1369ee855a64fc535c22daddccebaebe87c50e2"

URI_aarch64_rust-sqlx-postgres+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+rust_decimal-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-postgres+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+rust_decimal-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+rust_decimal-devel.sha256sum] = "fccce9d25fff4db872a92063a801f34c6331b5ec3b0200e39a4d5f899dfc4e74"

URI_aarch64_rust-sqlx-postgres+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+time-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-postgres+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+time-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+time-devel.sha256sum] = "c6f38adcd1bb2335f806a166e955a10633a2a48e600578ddca9a457a26167d88"

URI_aarch64_rust-sqlx-postgres+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres+uuid-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-postgres+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres+uuid-devel}"
SRC_URI[aarch64_rust-sqlx-postgres+uuid-devel.sha256sum] = "fea56618751fd6d267b6b60c29bb9e99500588f8d5ec1702fa2544411e21b866"

URI_aarch64_rust-sqlx-postgres-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-postgres-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-postgres-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-postgres-devel}"
SRC_URI[aarch64_rust-sqlx-postgres-devel.sha256sum] = "c7667553b09373d8b922e1e42f298841572b56b795ba5e20706334217850b90e"

RDEPENDS:rust-sqlx-postgres+any-devel = " \
 cargo \
 rust-sqlx-core+any-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+bigdecimal-devel = " \
 cargo \
 rust-bigdecimal+default-devel \
 rust-num-bigint+default-devel \
 rust-sqlx-core+bigdecimal-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+bit-vec-devel = " \
 cargo \
 rust-bit-vec0.6+default-devel \
 rust-sqlx-core+bit-vec-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-sqlx-core+chrono-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+default-devel = " \
 cargo \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+ipnet-devel = " \
 cargo \
 rust-ipnet+default-devel \
 rust-sqlx-core+ipnet-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+ipnetwork-devel = " \
 cargo \
 rust-ipnetwork+default-devel \
 rust-sqlx-core+ipnetwork-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+json-devel = " \
 cargo \
 rust-sqlx-core+json-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+mac_address-devel = " \
 cargo \
 rust-mac_address+default-devel \
 rust-sqlx-core+mac_address-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+migrate-devel = " \
 cargo \
 rust-sqlx-core+migrate-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+offline-devel = " \
 cargo \
 rust-sqlx-core+offline-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+rust_decimal-devel = " \
 cargo \
 rust-rust_decimal+maths-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 rust-sqlx-core+rust_decimal-devel \
 rust-sqlx-postgres-devel \
 "
RDEPENDS:rust-sqlx-postgres+time-devel = " \
 cargo \
 rust-sqlx-core+time-devel \
 rust-sqlx-postgres-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-sqlx-postgres+uuid-devel = " \
 cargo \
 rust-sqlx-core+uuid-devel \
 rust-sqlx-postgres-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-sqlx-postgres-devel = " \
 cargo \
 rust-atoi+default-devel \
 rust-base64+std-devel \
 rust-base64-devel \
 rust-bitflags-devel \
 rust-byteorder+std-devel \
 rust-byteorder-devel \
 rust-crc+default-devel \
 rust-dotenvy-devel \
 rust-futures-channel+alloc-devel \
 rust-futures-channel+sink-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-core-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util+io-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 rust-hex+default-devel \
 rust-hkdf+default-devel \
 rust-hmac+reset-devel \
 rust-hmac-devel \
 rust-home+default-devel \
 rust-itoa+default-devel \
 rust-log+default-devel \
 rust-md-5-devel \
 rust-memchr-devel \
 rust-once_cell+default-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+raw_value-devel \
 rust-sha2-devel \
 rust-smallvec+default-devel \
 rust-smallvec+serde-devel \
 rust-sqlx-core+default-devel \
 rust-sqlx-core+json-devel \
 rust-stringprep+default-devel \
 rust-thiserror+default-devel \
 rust-tracing+default-devel \
 rust-tracing+log-devel \
 rust-whoami-devel \
 "
