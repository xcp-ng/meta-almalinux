# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-osc-placement"
PV = "4.8.0"
PR = "1.el10_3"
PACKAGES = " \
 python-osc-placement-docs \
 python3-osc-placement \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-osc-placement-4.8.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "479e67f2add330c18bc399d6bb4a49f6ee95c2f427dd13c8db1f5c95db8f9129"

URI_x86_64_v2_python-osc-placement-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-osc-placement-docs-4.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-osc-placement-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-osc-placement-docs}"
SRC_URI[x86_64_v2_python-osc-placement-docs.sha256sum] = "9df0df10ace0cba239649b8ba7f8997ca77cbd081cac65ed642960d4d024c6c5"

URI_x86_64_v2_python3-osc-placement = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-osc-placement-4.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-osc-placement;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-osc-placement}"
SRC_URI[x86_64_v2_python3-osc-placement.sha256sum] = "ae64de6b3ee18a3372162b9af017eea76d9fedbcead346a205fd2ebde6252ee1"

URI_aarch64_python-osc-placement-docs = "${EPEL_MIRROR}/aarch64/Packages/p/python-osc-placement-docs-4.8.0-1.el10_3.noarch.rpm;name=aarch64_python-osc-placement-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-osc-placement-docs}"
SRC_URI[aarch64_python-osc-placement-docs.sha256sum] = "95e6389a40091e10c500fcd35cacc32861969120984b2678f1f97fce44782e22"

URI_aarch64_python3-osc-placement = "${EPEL_MIRROR}/aarch64/Packages/p/python3-osc-placement-4.8.0-1.el10_3.noarch.rpm;name=aarch64_python3-osc-placement;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-osc-placement}"
SRC_URI[aarch64_python3-osc-placement.sha256sum] = "6085f95d8824559e52e06208eb85a8f4b5bb79fd14af023c8e9b418f16b7e85d"

RDEPENDS:python-osc-placement-docs = " \
 python3-osc-placement \
 "
RDEPENDS:python3-osc-placement = " \
 python3 \
 python3-keystoneauth1 \
 python3-osc-lib \
 python3-oslo-utils \
 python3-pbr \
 "
