# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liburing"
PV = "2.12"
PR = "1.el10"
PACKAGES = " \
 liburing \
 liburing-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/liburing-2.12-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7663a961f9747383540b2315d532a9b454f15d7f315726724674155f7a447524"

URI_x86_64_v2_liburing = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/liburing-2.12-1.el10.x86_64_v2.rpm;name=x86_64_v2_liburing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liburing}"
SRC_URI[x86_64_v2_liburing.sha256sum] = "e338655c9a3186a4eba1b28f9002f218a1e1d253401bf510d1fc685206654eb2"

URI_x86_64_v2_liburing-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/liburing-devel-2.12-1.el10.x86_64_v2.rpm;name=x86_64_v2_liburing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liburing-devel}"
SRC_URI[x86_64_v2_liburing-devel.sha256sum] = "c5bf6af13f39b0f578e186e9964976f7ae853d753bf59827d71cd1a460d53a5d"

URI_aarch64_liburing = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/liburing-2.12-1.el10.aarch64.rpm;name=aarch64_liburing;unpack=0"
SRC_URI:append = " ${URI_aarch64_liburing}"
SRC_URI[aarch64_liburing.sha256sum] = "22a11e758e6317acdbb1db9f6a61dbbe51fb8a76abafa8e7d1f0f29e0624d4a2"

URI_aarch64_liburing-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/liburing-devel-2.12-1.el10.aarch64.rpm;name=aarch64_liburing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liburing-devel}"
SRC_URI[aarch64_liburing-devel.sha256sum] = "ac442cd6c38bbd8ef0e730726d8dd8444b505048b9dab0317a9cdcfee620182f"

RDEPENDS:liburing = " \
 glibc \
 "
RDEPENDS:liburing-devel = " \
 liburing \
 pkgconf-pkg-config \
 "
