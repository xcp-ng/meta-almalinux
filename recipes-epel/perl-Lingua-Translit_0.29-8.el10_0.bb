# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Lingua-Translit"
PV = "0.29"
PR = "8.el10_0"
PACKAGES = " \
 perl-Lingua-Translit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Lingua-Translit-0.29-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2dff90c7d612cb88209e050659b373286dedf221feffecdf3f63015abe312a76"

URI_x86_64_v2_perl-Lingua-Translit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Lingua-Translit-0.29-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Lingua-Translit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Lingua-Translit}"
SRC_URI[x86_64_v2_perl-Lingua-Translit.sha256sum] = "94e1e30489e6bdc96a4a10693527b08cd5ad6d293d669c91afadae58bd993379"

URI_aarch64_perl-Lingua-Translit = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Lingua-Translit-0.29-8.el10_0.noarch.rpm;name=aarch64_perl-Lingua-Translit;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Lingua-Translit}"
SRC_URI[aarch64_perl-Lingua-Translit.sha256sum] = "0917b2941fbae5818ac95e5a78136d1cd6d7e976c3de7ec4cce8d9fe8233e601"

RDEPENDS:perl-Lingua-Translit = " \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Lingua-Translit \
 perl-interpreter \
 perl-libs \
 "
