# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-proto0.24"
PV = "0.24.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-hickory-proto0.24+backtrace-devel \
 rust-hickory-proto0.24+bytes-devel \
 rust-hickory-proto0.24+default-devel \
 rust-hickory-proto0.24+dns-over-native-tls-devel \
 rust-hickory-proto0.24+dns-over-openssl-devel \
 rust-hickory-proto0.24+dns-over-tls-devel \
 rust-hickory-proto0.24+dnssec-devel \
 rust-hickory-proto0.24+dnssec-openssl-devel \
 rust-hickory-proto0.24+mdns-devel \
 rust-hickory-proto0.24+native-tls-devel \
 rust-hickory-proto0.24+openssl-devel \
 rust-hickory-proto0.24+serde-config-devel \
 rust-hickory-proto0.24+serde-devel \
 rust-hickory-proto0.24+socket2-devel \
 rust-hickory-proto0.24+testing-devel \
 rust-hickory-proto0.24+text-parsing-devel \
 rust-hickory-proto0.24+tokio-devel \
 rust-hickory-proto0.24+tokio-native-tls-devel \
 rust-hickory-proto0.24+tokio-openssl-devel \
 rust-hickory-proto0.24+tokio-runtime-devel \
 rust-hickory-proto0.24-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-proto0.24-0.24.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2ce216cd76c8aa56a8835a3836d231dc65ba497211725f9f0ab64a39b34f1cc"

URI_x86_64_v2_rust-hickory-proto0.24+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+backtrace-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+backtrace-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+backtrace-devel.sha256sum] = "d1d32d54a3e56737e9d4e190f7202c7cf47a43b160a94db8da2d85fff8db0f37"

URI_x86_64_v2_rust-hickory-proto0.24+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+bytes-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+bytes-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+bytes-devel.sha256sum] = "773e0c4fdbae08983dd0ba8beb2e4edc845aeba8dbb159c73eedbe23f551ebc9"

URI_x86_64_v2_rust-hickory-proto0.24+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+default-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+default-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+default-devel.sha256sum] = "a3c45e41b79a8a78c69aee4e8adda661b21defffb53e7281b368ef1506dd8ece"

URI_x86_64_v2_rust-hickory-proto0.24+dns-over-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+dns-over-native-tls-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+dns-over-native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+dns-over-native-tls-devel.sha256sum] = "29ae344ce671c0cf080081c45039a3b5c1a754469169ce33a3264fe47572c001"

URI_x86_64_v2_rust-hickory-proto0.24+dns-over-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+dns-over-openssl-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+dns-over-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+dns-over-openssl-devel.sha256sum] = "10b696797faa5bf079501de512f611e3d6899ed964c1bf4853a4cdbaccc5e94c"

URI_x86_64_v2_rust-hickory-proto0.24+dns-over-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+dns-over-tls-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+dns-over-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+dns-over-tls-devel.sha256sum] = "5ec4b27638e2a3c385814fdd06a36a3fea73c81a699213f08dedb8eceff38b37"

URI_x86_64_v2_rust-hickory-proto0.24+dnssec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+dnssec-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+dnssec-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+dnssec-devel.sha256sum] = "fa4026d9e15aa0d4a026ef93c7617c08e99dad4b0ee207d7c1390b5f822c66fe"

URI_x86_64_v2_rust-hickory-proto0.24+dnssec-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+dnssec-openssl-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+dnssec-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+dnssec-openssl-devel.sha256sum] = "e92e64ae4382ce7fee06e3b81a43bc1be620352dbade57995c27e684bd1fabb2"

URI_x86_64_v2_rust-hickory-proto0.24+mdns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+mdns-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+mdns-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+mdns-devel.sha256sum] = "1eb5892f9b75eaee67b0ad36d6df27b60086597cf421462b973057141bc625da"

URI_x86_64_v2_rust-hickory-proto0.24+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+native-tls-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+native-tls-devel.sha256sum] = "0306d45b36d0ac9bcb399c81f8e2790bd72ffc0cd1b453a64fbfcb45f0eda094"

URI_x86_64_v2_rust-hickory-proto0.24+openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+openssl-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+openssl-devel.sha256sum] = "d4676b19ea4e818c1f8b69fb40cc630a711850e261d360efa763deededcf1914"

URI_x86_64_v2_rust-hickory-proto0.24+serde-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+serde-config-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+serde-config-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+serde-config-devel.sha256sum] = "2273cb1d89f42a374788c9153262814615a92c25c4da64476ba694671ad12cb9"

URI_x86_64_v2_rust-hickory-proto0.24+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+serde-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+serde-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+serde-devel.sha256sum] = "74d7b519281f0cafc3c4fcd7795c1e46c39b48793870603fb4f534c36f17e5c9"

URI_x86_64_v2_rust-hickory-proto0.24+socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+socket2-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+socket2-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+socket2-devel.sha256sum] = "9086b693b1ed976a9f232c713d0d0d597960cb6676aaefc53dce9b6085d016b5"

URI_x86_64_v2_rust-hickory-proto0.24+testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+testing-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+testing-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+testing-devel.sha256sum] = "88d32fa28397f328c6e23f843eae5681e2bb6aead701afa9027ed0bd64771e89"

URI_x86_64_v2_rust-hickory-proto0.24+text-parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+text-parsing-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+text-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+text-parsing-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+text-parsing-devel.sha256sum] = "e8a7dc3e7714a616f2088c91fd28fb6763dafea2f14075e71fc870f6d99834b3"

URI_x86_64_v2_rust-hickory-proto0.24+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+tokio-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+tokio-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+tokio-devel.sha256sum] = "f93b5c98c0ad0fa8381d3d5172cdeda3053e9639991b94bedb6af6e011770351"

URI_x86_64_v2_rust-hickory-proto0.24+tokio-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+tokio-native-tls-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+tokio-native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+tokio-native-tls-devel.sha256sum] = "073316b49b98e382916d4a3ece6c5f592dc5d1c8fe9bd8cf524be8abf7728022"

URI_x86_64_v2_rust-hickory-proto0.24+tokio-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+tokio-openssl-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+tokio-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+tokio-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+tokio-openssl-devel.sha256sum] = "365a406b2d26bb70364fb728c15e11f823c582cd346094122664872cabf9088b"

URI_x86_64_v2_rust-hickory-proto0.24+tokio-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24+tokio-runtime-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24+tokio-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24+tokio-runtime-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24+tokio-runtime-devel.sha256sum] = "d26cb380a0c01b62f6d4866ec7852c8464c4cdfc0528765a333dcab4ccd9f7b6"

URI_x86_64_v2_rust-hickory-proto0.24-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.24-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.24-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.24-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.24-devel.sha256sum] = "86a9ab2d118331b240ec3a7bed3599ee221f7762c7103ef1d108aeb1f7afcefb"

URI_aarch64_rust-hickory-proto0.24+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+backtrace-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+backtrace-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+backtrace-devel.sha256sum] = "61fbb2a3ced4bfdc4d97f0eb193521271223f7b175fb92d68258942101551617"

URI_aarch64_rust-hickory-proto0.24+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+bytes-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+bytes-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+bytes-devel.sha256sum] = "86b5986017746925c3eb243d82298e972e7e370ae1d1f2e11c4613d3b1fbb5fc"

URI_aarch64_rust-hickory-proto0.24+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+default-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+default-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+default-devel.sha256sum] = "352208a9ecb45b6f364a7c1da7a225986d451e5724604eda2ff99cf6c338b167"

URI_aarch64_rust-hickory-proto0.24+dns-over-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+dns-over-native-tls-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+dns-over-native-tls-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+dns-over-native-tls-devel.sha256sum] = "777b057a27a363371c3d8fd23ac039043b86549103e2b57fb45513aa5d6a8dba"

URI_aarch64_rust-hickory-proto0.24+dns-over-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+dns-over-openssl-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+dns-over-openssl-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+dns-over-openssl-devel.sha256sum] = "969c1ad58ff986c01af251374aeaab9d56f7aec2b481acb99fa2c9c7fb65f210"

URI_aarch64_rust-hickory-proto0.24+dns-over-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+dns-over-tls-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+dns-over-tls-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+dns-over-tls-devel.sha256sum] = "aaf04709ed5f71b86feee7e6ea3a8d42f18cc1b49215eed28d12c96ce0e3848c"

URI_aarch64_rust-hickory-proto0.24+dnssec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+dnssec-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+dnssec-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+dnssec-devel.sha256sum] = "731bd6e1e3348602c664c3f6a918b31316eb9381fcf486df84763d5c104abe08"

URI_aarch64_rust-hickory-proto0.24+dnssec-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+dnssec-openssl-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+dnssec-openssl-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+dnssec-openssl-devel.sha256sum] = "38d934d59d7d420e2c6b0b1f8518d79c90d17322e25e034814b8d49b56c2427d"

URI_aarch64_rust-hickory-proto0.24+mdns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+mdns-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+mdns-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+mdns-devel.sha256sum] = "de5b76a256b00ce55947a38418b68ff5ca97889ce0f756dbb604f27940e7cf1b"

URI_aarch64_rust-hickory-proto0.24+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+native-tls-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+native-tls-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+native-tls-devel.sha256sum] = "7fef71f6f717ad75a6d8f29671a651d34d63f0113d4b3da958f749f177b60e51"

URI_aarch64_rust-hickory-proto0.24+openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+openssl-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+openssl-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+openssl-devel.sha256sum] = "b33db19ecc2b3f45e1db6c93de70950bea5da3deb0c50ea2e58e3d041277d576"

URI_aarch64_rust-hickory-proto0.24+serde-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+serde-config-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+serde-config-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+serde-config-devel.sha256sum] = "6a9642adaaa5d5c155dde5a60cd6e2df6451f610691d96d4fee5f16e0a7345b6"

URI_aarch64_rust-hickory-proto0.24+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+serde-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+serde-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+serde-devel.sha256sum] = "8589b4ded55e86dfe5f28da5f8d499aeb02740ffe52bc686c3c9e7009941b163"

URI_aarch64_rust-hickory-proto0.24+socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+socket2-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+socket2-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+socket2-devel.sha256sum] = "cd4abd34cd8ee282259822caa66390e5c084d59e6bd3e788a9bb1a1dd08f76ba"

URI_aarch64_rust-hickory-proto0.24+testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+testing-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+testing-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+testing-devel.sha256sum] = "b17d376192b85b900e8c67e41cfc0bc356338e6c222285435a661569fa9fe68d"

URI_aarch64_rust-hickory-proto0.24+text-parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+text-parsing-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+text-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+text-parsing-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+text-parsing-devel.sha256sum] = "851d4ea0aadfe0cc0087a43f60dfcb4138bb9fd0031b1d57d81812405df6a7f2"

URI_aarch64_rust-hickory-proto0.24+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+tokio-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+tokio-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+tokio-devel.sha256sum] = "e1e27e790f0e3374a68c9dc3a11c38539c34113e9ee4a8feb3b94d680ab3b346"

URI_aarch64_rust-hickory-proto0.24+tokio-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+tokio-native-tls-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+tokio-native-tls-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+tokio-native-tls-devel.sha256sum] = "d3b239e6f61284192ddeaf50b0b0701ec4f1da2628f2482345063f51249257ed"

URI_aarch64_rust-hickory-proto0.24+tokio-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+tokio-openssl-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+tokio-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+tokio-openssl-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+tokio-openssl-devel.sha256sum] = "ba8b2826a6d458599e2336d58633a1cc362ad569af257433140290e23ab5d662"

URI_aarch64_rust-hickory-proto0.24+tokio-runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24+tokio-runtime-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24+tokio-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24+tokio-runtime-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24+tokio-runtime-devel.sha256sum] = "808492cd995d7d0f7f54f161fccce8381fcf49fe0006d4bff72bf0c28b928813"

URI_aarch64_rust-hickory-proto0.24-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.24-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-proto0.24-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.24-devel}"
SRC_URI[aarch64_rust-hickory-proto0.24-devel.sha256sum] = "5f3184e75b7f8d194bb37d8aab12337e544352fc8dc815557b15af90e234ed4a"

RDEPENDS:rust-hickory-proto0.24+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-hickory-proto0.24-devel \
 "
RDEPENDS:rust-hickory-proto0.24+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-hickory-proto0.24-devel \
 "
RDEPENDS:rust-hickory-proto0.24+default-devel = " \
 cargo \
 rust-hickory-proto0.24+tokio-runtime-devel \
 rust-hickory-proto0.24-devel \
 "
RDEPENDS:rust-hickory-proto0.24+dns-over-native-tls-devel = " \
 cargo \
 rust-hickory-proto0.24+dns-over-tls-devel \
 rust-hickory-proto0.24+native-tls-devel \
 rust-hickory-proto0.24+tokio-native-tls-devel \
 rust-hickory-proto0.24+tokio-runtime-devel \
 rust-hickory-proto0.24-devel \
 "
RDEPENDS:rust-hickory-proto0.24+dns-over-openssl-devel = " \
 cargo \
 rust-hickory-proto0.24+dns-over-tls-devel \
 rust-hickory-proto0.24+openssl-devel \
 rust-hickory-proto0.24+tokio-openssl-devel \
 rust-hickory-proto0.24+tokio-runtime-devel \
 rust-hickory-proto0.24-devel \
 "
RDEPENDS:rust-hickory-proto0.24+dns-over-tls-devel = " \
 cargo \
 rust-hickory-proto0.24-devel \
 "
RDEPENDS:rust-hickory-proto0.24+dnssec-devel = " \
 cargo \
 rust-hickory-proto0.24-devel \
 "
RDEPENDS:rust-hickory-proto0.24+dnssec-openssl-devel = " \
 cargo \
 rust-hickory-proto0.24+dnssec-devel \
 rust-hickory-proto0.24+openssl-devel \
 rust-hickory-proto0.24-devel \
 "
RDEPENDS:rust-hickory-proto0.24+mdns-devel = " \
 cargo \
 rust-hickory-proto0.24-devel \
 rust-socket2_0.5+all-devel \
 rust-socket2_0.5+default-devel \
 "
RDEPENDS:rust-hickory-proto0.24+native-tls-devel = " \
 cargo \
 rust-hickory-proto0.24-devel \
 rust-native-tls+default-devel \
 "
RDEPENDS:rust-hickory-proto0.24+openssl-devel = " \
 cargo \
 rust-hickory-proto0.24-devel \
 rust-openssl+default-devel \
 rust-openssl+v102-devel \
 rust-openssl+v110-devel \
 "
RDEPENDS:rust-hickory-proto0.24+serde-config-devel = " \
 cargo \
 rust-hickory-proto0.24+serde-devel \
 rust-hickory-proto0.24-devel \
 rust-url+serde-devel \
 "
RDEPENDS:rust-hickory-proto0.24+serde-devel = " \
 cargo \
 rust-hickory-proto0.24-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-hickory-proto0.24+socket2-devel = " \
 cargo \
 rust-hickory-proto0.24-devel \
 rust-socket2_0.5+default-devel \
 "
RDEPENDS:rust-hickory-proto0.24+testing-devel = " \
 cargo \
 rust-hickory-proto0.24-devel \
 "
RDEPENDS:rust-hickory-proto0.24+text-parsing-devel = " \
 cargo \
 rust-hickory-proto0.24-devel \
 "
RDEPENDS:rust-hickory-proto0.24+tokio-devel = " \
 cargo \
 rust-hickory-proto0.24-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 "
RDEPENDS:rust-hickory-proto0.24+tokio-native-tls-devel = " \
 cargo \
 rust-hickory-proto0.24-devel \
 rust-tokio-native-tls+default-devel \
 "
RDEPENDS:rust-hickory-proto0.24+tokio-openssl-devel = " \
 cargo \
 rust-hickory-proto0.24-devel \
 rust-tokio-openssl+default-devel \
 "
RDEPENDS:rust-hickory-proto0.24+tokio-runtime-devel = " \
 cargo \
 rust-hickory-proto0.24-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-hickory-proto0.24-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-cfg-if+default-devel \
 rust-data-encoding+default-devel \
 rust-enum-as-inner+default-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-idna+default-devel \
 rust-ipnet+default-devel \
 rust-once_cell+default-devel \
 rust-rand0.8+default-devel \
 rust-thiserror1+default-devel \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+default-devel \
 rust-tracing+default-devel \
 rust-url+default-devel \
 "
