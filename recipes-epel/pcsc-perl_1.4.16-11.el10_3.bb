# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcsc-perl"
PV = "1.4.16"
PR = "11.el10_3"
PACKAGES = " \
 pcsc-perl \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pcsc-perl-1.4.16-11.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7eb21e825c3ee250483ced2f20d25e6439b50788b363e3ad305e35d6c5113bf2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcsc-perl-1.4.16-11.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pcsc-perl;unpack=0"
SRC_URI[x86_64_v2_pcsc-perl.sha256sum] = "8087e147ec2bff7d36e43681e6efb7ca005e4856269c24a1e798612e474737ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pcsc-perl-1.4.16-11.el10_3.aarch64.rpm;name=aarch64_pcsc-perl;unpack=0"
SRC_URI[aarch64_pcsc-perl.sha256sum] = "1c0b120c2c5a968e3016f4d5140b432b4c845c1a0afea3ea5c47ab419b419a11"

RDEPENDS:pcsc-perl = " \
 glibc \
 pcsc-lite-libs \
 pcsc-perl \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
