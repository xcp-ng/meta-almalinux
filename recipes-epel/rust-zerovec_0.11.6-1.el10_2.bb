# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerovec"
PV = "0.11.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-zerovec+alloc-devel \
 rust-zerovec+databake-devel \
 rust-zerovec+default-devel \
 rust-zerovec+derive-devel \
 rust-zerovec+hashmap-devel \
 rust-zerovec+schemars-devel \
 rust-zerovec+serde-devel \
 rust-zerovec+std-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerovec-0.11.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ea76c6ae23a7431a3d4f903d77eaa9751ef4b3d876978ff33c68687db30f2d8"

URI_x86_64_v2_rust-zerovec+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+alloc-devel-0.11.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+alloc-devel}"
SRC_URI[x86_64_v2_rust-zerovec+alloc-devel.sha256sum] = "a72561f3e7c352440a35368467bae9d108cc32caf41acc09d1aaa4d28e399b5d"

URI_x86_64_v2_rust-zerovec+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+databake-devel-0.11.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+databake-devel}"
SRC_URI[x86_64_v2_rust-zerovec+databake-devel.sha256sum] = "f4766f4a997e10f40591f2f01522d3f599638d2ca59e1bc8df8160b7b3fafd21"

URI_x86_64_v2_rust-zerovec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+default-devel-0.11.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+default-devel}"
SRC_URI[x86_64_v2_rust-zerovec+default-devel.sha256sum] = "eb15dc51f574429dc9003c866aaf5a0895f02e9a2f5f7f4199159d772c195bb6"

URI_x86_64_v2_rust-zerovec+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+derive-devel-0.11.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+derive-devel}"
SRC_URI[x86_64_v2_rust-zerovec+derive-devel.sha256sum] = "03499c4749c9a0940d787bbf48ae849a8591775ca9607482c78f538ef91d18d4"

URI_x86_64_v2_rust-zerovec+hashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+hashmap-devel-0.11.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+hashmap-devel}"
SRC_URI[x86_64_v2_rust-zerovec+hashmap-devel.sha256sum] = "51f7face4a765e3e58e3d818fcdbe0754be9429d9c1014811a46f96806888cb5"

URI_x86_64_v2_rust-zerovec+schemars-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+schemars-devel-0.11.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+schemars-devel}"
SRC_URI[x86_64_v2_rust-zerovec+schemars-devel.sha256sum] = "53d8acd9cd585b6ade9ce8c602990d4d41bdd7de22ab28870e67ef36b1b5e30b"

URI_x86_64_v2_rust-zerovec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+serde-devel-0.11.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+serde-devel}"
SRC_URI[x86_64_v2_rust-zerovec+serde-devel.sha256sum] = "05b3b34edea176adcc3e009303984b0a6f19c246e70451279ba9f5f636360023"

URI_x86_64_v2_rust-zerovec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+std-devel-0.11.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+std-devel}"
SRC_URI[x86_64_v2_rust-zerovec+std-devel.sha256sum] = "98fd5e11de48af5d44c3f4a2becd1ccb572a2fbe4bd8210e6f4fa43aa65232a5"

URI_x86_64_v2_rust-zerovec+yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+yoke-devel-0.11.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+yoke-devel}"
SRC_URI[x86_64_v2_rust-zerovec+yoke-devel.sha256sum] = "bfa0b3339c9dfa5862dfaea40532e1fcd834247144e39c6f5bda6b651ef29692"

URI_x86_64_v2_rust-zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec-devel-0.11.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec-devel}"
SRC_URI[x86_64_v2_rust-zerovec-devel.sha256sum] = "862f29c58bafee2c3b0b4beda6b5c7570ce49eac674891181ae64224e538a45f"

URI_aarch64_rust-zerovec+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+alloc-devel-0.11.6-1.el10_2.noarch.rpm;name=aarch64_rust-zerovec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+alloc-devel}"
SRC_URI[aarch64_rust-zerovec+alloc-devel.sha256sum] = "321a36d94a90fca7a27b48f3ec06289eff1dac6696d723508213a982d48d4bd5"

URI_aarch64_rust-zerovec+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+databake-devel-0.11.6-1.el10_2.noarch.rpm;name=aarch64_rust-zerovec+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+databake-devel}"
SRC_URI[aarch64_rust-zerovec+databake-devel.sha256sum] = "a4b8654c4471c1a065984ec5e7472ef64af6f3414ce34ca91da275fb576fdfa6"

URI_aarch64_rust-zerovec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+default-devel-0.11.6-1.el10_2.noarch.rpm;name=aarch64_rust-zerovec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+default-devel}"
SRC_URI[aarch64_rust-zerovec+default-devel.sha256sum] = "6a1847bb74676e77953bc5c029cebb8e437164ffa59280d81f1a16340b5a02a3"

URI_aarch64_rust-zerovec+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+derive-devel-0.11.6-1.el10_2.noarch.rpm;name=aarch64_rust-zerovec+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+derive-devel}"
SRC_URI[aarch64_rust-zerovec+derive-devel.sha256sum] = "1fe27df7f8b8ef6bae77db799499efae0096b3f404b7380ae7c4146f6ec04ff9"

URI_aarch64_rust-zerovec+hashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+hashmap-devel-0.11.6-1.el10_2.noarch.rpm;name=aarch64_rust-zerovec+hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+hashmap-devel}"
SRC_URI[aarch64_rust-zerovec+hashmap-devel.sha256sum] = "cb247e42989d75e27da0b1dbb0376b92147a93293a0577f3bff6b93b2e908c02"

URI_aarch64_rust-zerovec+schemars-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+schemars-devel-0.11.6-1.el10_2.noarch.rpm;name=aarch64_rust-zerovec+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+schemars-devel}"
SRC_URI[aarch64_rust-zerovec+schemars-devel.sha256sum] = "74f83c670f05df11803c0b710967fa9f072a3e8ffb8be5cec22705c9907447f0"

URI_aarch64_rust-zerovec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+serde-devel-0.11.6-1.el10_2.noarch.rpm;name=aarch64_rust-zerovec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+serde-devel}"
SRC_URI[aarch64_rust-zerovec+serde-devel.sha256sum] = "f101e570c41697984d2b42cdc8f05757dc35b30af9dc1ec5a8f5ffb8622df2ba"

URI_aarch64_rust-zerovec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+std-devel-0.11.6-1.el10_2.noarch.rpm;name=aarch64_rust-zerovec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+std-devel}"
SRC_URI[aarch64_rust-zerovec+std-devel.sha256sum] = "0f75fe9d911ca1f417ec5d3a0b8cc73773f79e02b082a51c47b3807ac468c66c"

URI_aarch64_rust-zerovec+yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+yoke-devel-0.11.6-1.el10_2.noarch.rpm;name=aarch64_rust-zerovec+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+yoke-devel}"
SRC_URI[aarch64_rust-zerovec+yoke-devel.sha256sum] = "79baa5cf169745d33a2d3513c082a2e4f4657ec4b42e75a7e21a7c0131017bc5"

URI_aarch64_rust-zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec-devel-0.11.6-1.el10_2.noarch.rpm;name=aarch64_rust-zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec-devel}"
SRC_URI[aarch64_rust-zerovec-devel.sha256sum] = "c660ea87579f7a1eb8f5bda8b2d12781c158c2565f1876604cd1e2945e7d07c5"

RDEPENDS:rust-zerovec+alloc-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+default-devel = " \
 cargo \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+derive-devel = " \
 cargo \
 rust-zerovec-derive-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+hashmap-devel = " \
 cargo \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+schemars-devel = " \
 cargo \
 rust-schemars-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+serde-devel = " \
 cargo \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+std-devel = " \
 cargo \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+yoke-devel = " \
 cargo \
 rust-yoke-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec-devel = " \
 cargo \
 rust \
 rust-zerofrom-devel \
 "
