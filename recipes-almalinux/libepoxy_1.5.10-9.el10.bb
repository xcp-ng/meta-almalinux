# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libepoxy"
PV = "1.5.10"
PR = "9.el10"
PACKAGES = " \
 libepoxy \
 libepoxy-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libepoxy-1.5.10-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15d98821f5c4955dbd280ae05b527711a6ea963f5c0c77ca6c3acc26a13002df"

URI_x86_64_v2_libepoxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libepoxy-1.5.10-9.el10.x86_64_v2.rpm;name=x86_64_v2_libepoxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libepoxy}"
SRC_URI[x86_64_v2_libepoxy.sha256sum] = "329ded071a62f7526aaf08625ec726950b47fc712b68f63c7d6d353d82bfa425"

URI_x86_64_v2_libepoxy-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libepoxy-devel-1.5.10-9.el10.x86_64_v2.rpm;name=x86_64_v2_libepoxy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libepoxy-devel}"
SRC_URI[x86_64_v2_libepoxy-devel.sha256sum] = "6775e7d971e355a4eb914a77e9f545ec550e3bd2a906efd038a82eef51f7b09b"

URI_aarch64_libepoxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libepoxy-1.5.10-9.el10.aarch64.rpm;name=aarch64_libepoxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_libepoxy}"
SRC_URI[aarch64_libepoxy.sha256sum] = "867091143c244c1e907d2fc5f63502e6923e6d07c1c404c32d60fb7d17bee95c"

URI_aarch64_libepoxy-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libepoxy-devel-1.5.10-9.el10.aarch64.rpm;name=aarch64_libepoxy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libepoxy-devel}"
SRC_URI[aarch64_libepoxy-devel.sha256sum] = "d514d2bd673f1a19a05c821aaa8bc8ca5516807fbc914395d6850509eafd40d7"

RDEPENDS:libepoxy = " \
 glibc \
 "
RDEPENDS:libepoxy-devel = " \
 libX11-devel \
 libepoxy \
 libglvnd-devel \
 pkgconf-pkg-config \
 "
