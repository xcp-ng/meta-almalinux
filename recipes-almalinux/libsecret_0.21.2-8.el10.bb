# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsecret"
PV = "0.21.2"
PR = "8.el10"
PACKAGES = " \
 libsecret \
 libsecret-devel \
 libsecret-mock-service \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libsecret-0.21.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bff2a677cf88795bcfbbe45a1c65fb67e2bc522fb86f505f67ad665a05e85c5c"

URI_x86_64_v2_libsecret = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsecret-0.21.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_libsecret;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsecret}"
SRC_URI[x86_64_v2_libsecret.sha256sum] = "7e2091105ad6b987d2bc8e542f840e77165225be5714271b8d56ee9652a3d421"

URI_x86_64_v2_libsecret-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsecret-devel-0.21.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_libsecret-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsecret-devel}"
SRC_URI[x86_64_v2_libsecret-devel.sha256sum] = "29b4c72e85aba5813e3251ed2e96e663ec993984b9f947000a0270897185c908"

URI_x86_64_v2_libsecret-mock-service = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsecret-mock-service-0.21.2-8.el10.noarch.rpm;name=x86_64_v2_libsecret-mock-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsecret-mock-service}"
SRC_URI[x86_64_v2_libsecret-mock-service.sha256sum] = "ef6238467df22377dea56ff2a9f50a88b05015a88d2a2b8a6e175a80def89716"

URI_aarch64_libsecret = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsecret-0.21.2-8.el10.aarch64.rpm;name=aarch64_libsecret;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsecret}"
SRC_URI[aarch64_libsecret.sha256sum] = "7b611b6a7be0b81df1ec30e7e9bc075ae01108e87c5c09ed1d5c196fe8462804"

URI_aarch64_libsecret-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsecret-devel-0.21.2-8.el10.aarch64.rpm;name=aarch64_libsecret-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsecret-devel}"
SRC_URI[aarch64_libsecret-devel.sha256sum] = "610a622731afe32275826374e6fb7239d54d5895b457157f3cd406799f925153"

URI_aarch64_libsecret-mock-service = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsecret-mock-service-0.21.2-8.el10.noarch.rpm;name=aarch64_libsecret-mock-service;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsecret-mock-service}"
SRC_URI[aarch64_libsecret-mock-service.sha256sum] = "ef6238467df22377dea56ff2a9f50a88b05015a88d2a2b8a6e175a80def89716"

RDEPENDS:libsecret = " \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 "
RDEPENDS:libsecret-devel = " \
 glib2-devel \
 gnutls-devel \
 libsecret \
 libsecret-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libsecret-mock-service = " \
 libsecret \
 "
