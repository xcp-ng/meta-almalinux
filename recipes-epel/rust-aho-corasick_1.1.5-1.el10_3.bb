# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aho-corasick"
PV = "1.1.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-aho-corasick+default-devel \
 rust-aho-corasick+logging-devel \
 rust-aho-corasick+perf-literal-devel \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aho-corasick-1.1.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "156bbfe43c5b4fe7bde561f17d388c3e89f2b74d99246a11774b372bde684d0e"

URI_x86_64_v2_rust-aho-corasick+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+default-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+default-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+default-devel.sha256sum] = "8bc38f9fd16c827420c6c5fb241a0ade87a27e8dc8122984f5243809069b7637"

URI_x86_64_v2_rust-aho-corasick+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+logging-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+logging-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+logging-devel.sha256sum] = "5cf613777f7f3b7dc4f160e3b816b89ab1a150e7b7e3970090ede610e0c4e869"

URI_x86_64_v2_rust-aho-corasick+perf-literal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+perf-literal-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+perf-literal-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+perf-literal-devel.sha256sum] = "57e1a71d2625d86b3d83afd41e25ebdfb260d5de756eadad6e5d76155279ae89"

URI_x86_64_v2_rust-aho-corasick+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+std-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+std-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+std-devel.sha256sum] = "6fd45be34b48971cb5c866a52dd893b9d56dfd1ecf1e5d7eb32977860b56341c"

URI_x86_64_v2_rust-aho-corasick-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick-devel-1.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick-devel.sha256sum] = "8687c76c4857923bb36dc9cff0afa346a7e72d26e7c309800d6c4f08c51b952d"

URI_aarch64_rust-aho-corasick+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+default-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-aho-corasick+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+default-devel}"
SRC_URI[aarch64_rust-aho-corasick+default-devel.sha256sum] = "f54f5f3d2fb684e618de78991689ed0a445165ea144eabbba4a215069e16c0d4"

URI_aarch64_rust-aho-corasick+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+logging-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-aho-corasick+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+logging-devel}"
SRC_URI[aarch64_rust-aho-corasick+logging-devel.sha256sum] = "3b7efd068c71fd0b2ec05b17949059821e4295ab2ea388500062b05666e7cf3b"

URI_aarch64_rust-aho-corasick+perf-literal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+perf-literal-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-aho-corasick+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+perf-literal-devel}"
SRC_URI[aarch64_rust-aho-corasick+perf-literal-devel.sha256sum] = "11efbb24db8878dc8259a813b2120c1299399911a1ccfcfb2676cf68ea7ed116"

URI_aarch64_rust-aho-corasick+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+std-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-aho-corasick+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+std-devel}"
SRC_URI[aarch64_rust-aho-corasick+std-devel.sha256sum] = "0e36bdd0c794ad9469b6a3cf2266c522d9f6913cb629ada5101262df1cf23e92"

URI_aarch64_rust-aho-corasick-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick-devel-1.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-aho-corasick-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick-devel}"
SRC_URI[aarch64_rust-aho-corasick-devel.sha256sum] = "6f3748edb8a5dc41a00c685283e1423f90d7d14be205567bdc9c9a077be88360"

RDEPENDS:rust-aho-corasick+default-devel = " \
 cargo \
 rust-aho-corasick+perf-literal-devel \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 "
RDEPENDS:rust-aho-corasick+logging-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-aho-corasick+perf-literal-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-aho-corasick+std-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-aho-corasick-devel = " \
 cargo \
 rust \
 "
