# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-group"
PV = "0.14.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-group+alloc-devel \
 rust-group+default-devel \
 rust-group+rand-devel \
 rust-group+rand_xorshift-devel \
 rust-group+tests-devel \
 rust-group-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-group-0.14.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fef722b44badb668dbf1c017e012cee8c54c62288036ddfb3ca532fa3f84335"

URI_x86_64_v2_rust-group+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group+alloc-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group+alloc-devel}"
SRC_URI[x86_64_v2_rust-group+alloc-devel.sha256sum] = "b3f5c6ab8936b92589b386cf26b1151319591e49737ac5fdc63c5ca26a43e742"

URI_x86_64_v2_rust-group+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group+default-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group+default-devel}"
SRC_URI[x86_64_v2_rust-group+default-devel.sha256sum] = "2407875439a4959968b08e39c3ccd6c04ca2f7d63b08335ef65b3b04a327d38a"

URI_x86_64_v2_rust-group+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group+rand-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group+rand-devel}"
SRC_URI[x86_64_v2_rust-group+rand-devel.sha256sum] = "980e825e9f54871c224b89850abf82e84994b88320a017bdb3db422321136d38"

URI_x86_64_v2_rust-group+rand_xorshift-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group+rand_xorshift-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group+rand_xorshift-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group+rand_xorshift-devel}"
SRC_URI[x86_64_v2_rust-group+rand_xorshift-devel.sha256sum] = "241993441fcf8dc9b3119fa2dbc922d8a49f1c5d395eea57611448a50b05eb08"

URI_x86_64_v2_rust-group+tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group+tests-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group+tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group+tests-devel}"
SRC_URI[x86_64_v2_rust-group+tests-devel.sha256sum] = "489cd03a3be5e9771e2c7b1cbfc517f3185eb119dddbf50b38f5c4cfab6911c7"

URI_x86_64_v2_rust-group-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group-devel}"
SRC_URI[x86_64_v2_rust-group-devel.sha256sum] = "4818703db9c9f266b5944ffa4b75e6502df461f9c80dad4e606c63b2cbc95f45"

URI_aarch64_rust-group+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group+alloc-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-group+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group+alloc-devel}"
SRC_URI[aarch64_rust-group+alloc-devel.sha256sum] = "6a56a4c1aafadfb3143874f20c0b712314f0d693762e9ed0f071d5e0df63651c"

URI_aarch64_rust-group+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group+default-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-group+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group+default-devel}"
SRC_URI[aarch64_rust-group+default-devel.sha256sum] = "338f8ff12537199beaf3e0657cdf2e6b6829666689b4a3684a215936730cd852"

URI_aarch64_rust-group+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group+rand-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-group+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group+rand-devel}"
SRC_URI[aarch64_rust-group+rand-devel.sha256sum] = "d66065aa2320d7d3d4a85f0e8beda422c779c4948f65e5b9f9f8aa82f42368fe"

URI_aarch64_rust-group+rand_xorshift-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group+rand_xorshift-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-group+rand_xorshift-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group+rand_xorshift-devel}"
SRC_URI[aarch64_rust-group+rand_xorshift-devel.sha256sum] = "882d2803aac32dd56a89108678aafc9d68ac4f861b095e18fa40f4b060434dc3"

URI_aarch64_rust-group+tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group+tests-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-group+tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group+tests-devel}"
SRC_URI[aarch64_rust-group+tests-devel.sha256sum] = "ff0e848d479ac340016d91af53e6abbc7368377db148afd4d2bfe90afd938332"

URI_aarch64_rust-group-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-group-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group-devel}"
SRC_URI[aarch64_rust-group-devel.sha256sum] = "e1fc4a9cecaf73d51935752a70514c2beabd8afad7df5bd5002f1108b682ae0d"

RDEPENDS:rust-group+alloc-devel = " \
 cargo \
 rust-group-devel \
 "
RDEPENDS:rust-group+default-devel = " \
 cargo \
 rust-group+alloc-devel \
 rust-group-devel \
 "
RDEPENDS:rust-group+rand-devel = " \
 cargo \
 rust-group-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-group+rand_xorshift-devel = " \
 cargo \
 rust-group-devel \
 rust-rand_xorshift+default-devel \
 "
RDEPENDS:rust-group+tests-devel = " \
 cargo \
 rust-group+alloc-devel \
 rust-group+rand-devel \
 rust-group+rand_xorshift-devel \
 rust-group-devel \
 "
RDEPENDS:rust-group-devel = " \
 cargo \
 rust \
 rust-ff-devel \
 rust-rand_core-devel \
 rust-subtle-devel \
 "
