# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mp4parse"
PV = "0.17.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-mp4parse+3gpp-devel \
 rust-mp4parse+default-devel \
 rust-mp4parse+meta-xml-devel \
 rust-mp4parse+missing-pixi-permitted-devel \
 rust-mp4parse+mp4v-devel \
 rust-mp4parse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mp4parse-0.17.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d82142349aa8a82bd0fe820daf0fdd637fc174bf9f0cb5b2294ac3bbbdfb353c"

URI_x86_64_v2_rust-mp4parse+3gpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mp4parse+3gpp-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mp4parse+3gpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mp4parse+3gpp-devel}"
SRC_URI[x86_64_v2_rust-mp4parse+3gpp-devel.sha256sum] = "d3c3061ff8a7423eda644421678172c4846453ae6dfc0e1a8735b14668daa261"

URI_x86_64_v2_rust-mp4parse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mp4parse+default-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mp4parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mp4parse+default-devel}"
SRC_URI[x86_64_v2_rust-mp4parse+default-devel.sha256sum] = "8fc8e9dba212d6046f8eaae546f72048dc757b6674faad125f6a99b300a2de13"

URI_x86_64_v2_rust-mp4parse+meta-xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mp4parse+meta-xml-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mp4parse+meta-xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mp4parse+meta-xml-devel}"
SRC_URI[x86_64_v2_rust-mp4parse+meta-xml-devel.sha256sum] = "97a0914fafc5aa42e4cf14246200547e1ed416f4b7620d59fdd58f7d95c26b7e"

URI_x86_64_v2_rust-mp4parse+missing-pixi-permitted-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mp4parse+missing-pixi-permitted-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mp4parse+missing-pixi-permitted-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mp4parse+missing-pixi-permitted-devel}"
SRC_URI[x86_64_v2_rust-mp4parse+missing-pixi-permitted-devel.sha256sum] = "a191bd60e8520adbba8de39c477c5075676ca1c48af4ead4e159ee361b07969c"

URI_x86_64_v2_rust-mp4parse+mp4v-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mp4parse+mp4v-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mp4parse+mp4v-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mp4parse+mp4v-devel}"
SRC_URI[x86_64_v2_rust-mp4parse+mp4v-devel.sha256sum] = "fc5c621f30cb55a17d7aeba38c39b3f2e598d19fec240954ad48682b1822023c"

URI_x86_64_v2_rust-mp4parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mp4parse-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mp4parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mp4parse-devel}"
SRC_URI[x86_64_v2_rust-mp4parse-devel.sha256sum] = "fdfe4c9e338bf688786602bffd61aa380b576c86c1ae8558f041a72de41f2df8"

URI_aarch64_rust-mp4parse+3gpp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mp4parse+3gpp-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-mp4parse+3gpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mp4parse+3gpp-devel}"
SRC_URI[aarch64_rust-mp4parse+3gpp-devel.sha256sum] = "238688a8fc5c931fc0f6ba8e055eea3bdbc0f64c634d9b7b331e9c30890f7c33"

URI_aarch64_rust-mp4parse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mp4parse+default-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-mp4parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mp4parse+default-devel}"
SRC_URI[aarch64_rust-mp4parse+default-devel.sha256sum] = "d645209bb57d3adfe22b75bdbf5056fb6bcb934afe372878d752e0c26e56e39e"

URI_aarch64_rust-mp4parse+meta-xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mp4parse+meta-xml-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-mp4parse+meta-xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mp4parse+meta-xml-devel}"
SRC_URI[aarch64_rust-mp4parse+meta-xml-devel.sha256sum] = "3d03c6c097f31eaa170486b1aa70e7c30d600cc8e38f2b7afc3ebbecf45bb331"

URI_aarch64_rust-mp4parse+missing-pixi-permitted-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mp4parse+missing-pixi-permitted-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-mp4parse+missing-pixi-permitted-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mp4parse+missing-pixi-permitted-devel}"
SRC_URI[aarch64_rust-mp4parse+missing-pixi-permitted-devel.sha256sum] = "319255e1664656e862a7c5988edfff2365196d30ef8c80f1cb9809d51109bd0c"

URI_aarch64_rust-mp4parse+mp4v-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mp4parse+mp4v-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-mp4parse+mp4v-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mp4parse+mp4v-devel}"
SRC_URI[aarch64_rust-mp4parse+mp4v-devel.sha256sum] = "953bbbe0a36352d33c2ad30acb9bc289de81dcef8896667bc8b157a5397d2410"

URI_aarch64_rust-mp4parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mp4parse-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-mp4parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mp4parse-devel}"
SRC_URI[aarch64_rust-mp4parse-devel.sha256sum] = "57c96202dbd314247ab4f2b2cb8b0796af8bc121a9ff05586c90e8e35e66fcb2"

RDEPENDS:rust-mp4parse+3gpp-devel = " \
 cargo \
 rust-mp4parse-devel \
 "
RDEPENDS:rust-mp4parse+default-devel = " \
 cargo \
 rust-mp4parse-devel \
 "
RDEPENDS:rust-mp4parse+meta-xml-devel = " \
 cargo \
 rust-mp4parse-devel \
 "
RDEPENDS:rust-mp4parse+missing-pixi-permitted-devel = " \
 cargo \
 rust-mp4parse-devel \
 "
RDEPENDS:rust-mp4parse+mp4v-devel = " \
 cargo \
 rust-mp4parse-devel \
 "
RDEPENDS:rust-mp4parse-devel = " \
 cargo \
 rust-bitreader+default-devel \
 rust-byteorder+default-devel \
 rust-fallible_collections+default-devel \
 rust-fallible_collections+std_io-devel \
 rust-log+default-devel \
 rust-num-traits+default-devel \
 rust-static_assertions+default-devel \
 "
