# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-static_assertions"
PV = "1.1.0"
PR = "15.el10_0"
PACKAGES = " \
 rust-static_assertions+default-devel \
 rust-static_assertions+nightly-devel \
 rust-static_assertions-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-static_assertions-1.1.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a40c28f17a53e729c08929aa2ec27e6e0ee46f93698ae20067daafd84dcb096"

URI_x86_64_v2_rust-static_assertions+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-static_assertions+default-devel-1.1.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-static_assertions+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-static_assertions+default-devel}"
SRC_URI[x86_64_v2_rust-static_assertions+default-devel.sha256sum] = "1f974925fa6726137d111fcf481303ada37e55fecde7897a40e294613b581719"

URI_x86_64_v2_rust-static_assertions+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-static_assertions+nightly-devel-1.1.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-static_assertions+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-static_assertions+nightly-devel}"
SRC_URI[x86_64_v2_rust-static_assertions+nightly-devel.sha256sum] = "ec92b19e296bab4f359930c351071a93fe57f49a46528e1442b40f9dc06337b9"

URI_x86_64_v2_rust-static_assertions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-static_assertions-devel-1.1.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-static_assertions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-static_assertions-devel}"
SRC_URI[x86_64_v2_rust-static_assertions-devel.sha256sum] = "a41b1945a6b3b80c0ddc8f72c0da0cb92c2de5277065b0e4bf24cb5edc421b36"

URI_aarch64_rust-static_assertions+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-static_assertions+default-devel-1.1.0-15.el10_0.noarch.rpm;name=aarch64_rust-static_assertions+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-static_assertions+default-devel}"
SRC_URI[aarch64_rust-static_assertions+default-devel.sha256sum] = "6dbbdfec0522c4a6bf3fc139d4dde73ae698d82ec9620fb7dd7c75bfc5331410"

URI_aarch64_rust-static_assertions+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-static_assertions+nightly-devel-1.1.0-15.el10_0.noarch.rpm;name=aarch64_rust-static_assertions+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-static_assertions+nightly-devel}"
SRC_URI[aarch64_rust-static_assertions+nightly-devel.sha256sum] = "62a73b392013740c9a035892d49965b6e44cc872454949e1c763692c493af48a"

URI_aarch64_rust-static_assertions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-static_assertions-devel-1.1.0-15.el10_0.noarch.rpm;name=aarch64_rust-static_assertions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-static_assertions-devel}"
SRC_URI[aarch64_rust-static_assertions-devel.sha256sum] = "57eedc19ada9fa5aef55c37e01893b641124ee0211976471a397845c78f67431"

RDEPENDS:rust-static_assertions+default-devel = " \
 cargo \
 rust-static_assertions-devel \
 "
RDEPENDS:rust-static_assertions+nightly-devel = " \
 cargo \
 rust-static_assertions-devel \
 "
RDEPENDS:rust-static_assertions-devel = " \
 cargo \
 "
