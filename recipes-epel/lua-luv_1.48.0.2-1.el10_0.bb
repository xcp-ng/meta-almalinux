# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-luv"
PV = "1.48.0.2"
PR = "1.el10_0"
PACKAGES = " \
 libluv \
 libluv-devel \
 lua-luv \
 lua5.1-luv \
 luajit2.1-luv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-luv-1.48.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd44b694224d02939f1d703ac65bb9d195803852c76cf1cb2111e30a2823f190"

URI_x86_64_v2_libluv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libluv-1.48.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libluv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libluv}"
SRC_URI[x86_64_v2_libluv.sha256sum] = "51a41c7e1d5e739e29e7fec3f1ef4a604a1e7d19fd0459e0bec02c383fa00f1f"

URI_x86_64_v2_libluv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libluv-devel-1.48.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libluv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libluv-devel}"
SRC_URI[x86_64_v2_libluv-devel.sha256sum] = "7219f442e101e38989f25073c5c591d26692096246984946d754ecdbef945250"

URI_x86_64_v2_lua-luv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-luv-1.48.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-luv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-luv}"
SRC_URI[x86_64_v2_lua-luv.sha256sum] = "16f98246ef42bed1f1f1ab913c4ae31cf69509ca4059b5ff7f2189ea2bafffac"

URI_x86_64_v2_lua5.1-luv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua5.1-luv-1.48.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua5.1-luv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua5.1-luv}"
SRC_URI[x86_64_v2_lua5.1-luv.sha256sum] = "c5475c84fcd4b334d65a94700c33a44f31582dd31105f303f3e08aa3d8fb9e95"

URI_x86_64_v2_luajit2.1-luv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/luajit2.1-luv-1.48.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_luajit2.1-luv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_luajit2.1-luv}"
SRC_URI[x86_64_v2_luajit2.1-luv.sha256sum] = "22a501f515afce4f9449b4ac7420f46a218bd5c2e469f7515544729e27f60655"

URI_aarch64_libluv = "${EPEL_MIRROR}/aarch64/Packages/l/libluv-1.48.0.2-1.el10_0.aarch64.rpm;name=aarch64_libluv;unpack=0"
SRC_URI:append = " ${URI_aarch64_libluv}"
SRC_URI[aarch64_libluv.sha256sum] = "c8b97068af1e0371f353f94df9aa42e095cefae4e3f25a6f1383573698f4b1e9"

URI_aarch64_libluv-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libluv-devel-1.48.0.2-1.el10_0.aarch64.rpm;name=aarch64_libluv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libluv-devel}"
SRC_URI[aarch64_libluv-devel.sha256sum] = "7aca5d38e84e9ebd799bb944f74b8452bd7edb04b211ce5c2f7e7c616ef0df2f"

URI_aarch64_lua-luv = "${EPEL_MIRROR}/aarch64/Packages/l/lua-luv-1.48.0.2-1.el10_0.aarch64.rpm;name=aarch64_lua-luv;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-luv}"
SRC_URI[aarch64_lua-luv.sha256sum] = "f2d8efc7420e9991075b49fcb65aa6ac9e7cb8d4c4c940fa2920c13eed6a235c"

URI_aarch64_lua5.1-luv = "${EPEL_MIRROR}/aarch64/Packages/l/lua5.1-luv-1.48.0.2-1.el10_0.aarch64.rpm;name=aarch64_lua5.1-luv;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua5.1-luv}"
SRC_URI[aarch64_lua5.1-luv.sha256sum] = "bf1030afd3f986efab4252e4c5d87d7038ec5f39986a716b46cbffaee0915566"

URI_aarch64_luajit2.1-luv = "${EPEL_MIRROR}/aarch64/Packages/l/luajit2.1-luv-1.48.0.2-1.el10_0.aarch64.rpm;name=aarch64_luajit2.1-luv;unpack=0"
SRC_URI:append = " ${URI_aarch64_luajit2.1-luv}"
SRC_URI[aarch64_luajit2.1-luv.sha256sum] = "797130bc3919d6ab6ab23910d0f8fe04102947a6841841d0e06f0c3dcc5a9ad8"

RDEPENDS:libluv = " \
 glibc \
 libuv \
 "
RDEPENDS:libluv-devel = " \
 libluv \
 pkgconf-pkg-config \
 "
RDEPENDS:lua-luv = " \
 glibc \
 libuv \
 lua-libs \
 "
RDEPENDS:lua5.1-luv = " \
 compat-lua-libs \
 glibc \
 libuv \
 "
RDEPENDS:luajit2.1-luv = " \
 compat-lua-libs \
 glibc \
 libuv \
 "
