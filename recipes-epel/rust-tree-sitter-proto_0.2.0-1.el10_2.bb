# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-proto"
PV = "0.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-proto+default-devel \
 rust-tree-sitter-proto-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-proto-0.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3f4cc46a4267699e2cbaaf4910679c20bfef7aeba9bb2c56423d402984283e6"

URI_x86_64_v2_rust-tree-sitter-proto+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-proto+default-devel-0.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-proto+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-proto+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-proto+default-devel.sha256sum] = "1b5ff224914110ccd7786de18528c3782610f43b8264e846d85042326c89d16a"

URI_x86_64_v2_rust-tree-sitter-proto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-proto-devel-0.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-proto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-proto-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-proto-devel.sha256sum] = "261e2beccddb5866e8ce09a93c37c90438ccb43826da1374ae41e30b0d651594"

URI_aarch64_rust-tree-sitter-proto+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-proto+default-devel-0.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-proto+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-proto+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-proto+default-devel.sha256sum] = "45c347cf04bea2d8b9914e523c5d0c199466cd66ddb76a7bc0043576cb6ac1b3"

URI_aarch64_rust-tree-sitter-proto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-proto-devel-0.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-proto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-proto-devel}"
SRC_URI[aarch64_rust-tree-sitter-proto-devel.sha256sum] = "6da43adbb01d7ac021adcdd71d185db831eff9a9c71d2d041345ea9373a13afd"

RDEPENDS:rust-tree-sitter-proto+default-devel = " \
 cargo \
 rust-tree-sitter-proto-devel \
 "
RDEPENDS:rust-tree-sitter-proto-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
