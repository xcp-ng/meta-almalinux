# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerocopy-derive"
PV = "0.8.59"
PR = "1.el10_2"
PACKAGES = " \
 rust-zerocopy-derive+default-devel \
 rust-zerocopy-derive-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-zerocopy-derive-0.8.59-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "82061da9e22153bb3cb5d024844f8e128307688e8da99b99080a5330d09a23e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-derive+default-devel-0.8.59-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-derive+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy-derive+default-devel.sha256sum] = "053be04ba8c30ad812c52170bdd59dbfd121933fe9569f9084aa959558c50acd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-derive-devel-0.8.59-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy-derive-devel.sha256sum] = "1d503beace3131eda49b43a5a79cd689211b53aaaba0e6f9137f4a3318db0b0e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-derive+default-devel-0.8.59-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy-derive+default-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy-derive+default-devel.sha256sum] = "845e42c06de9da8ecfc626356d04e603735331caa1c1f27af3f15394a4ae49b1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-derive-devel-0.8.59-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy-derive-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy-derive-devel.sha256sum] = "284bc2863b076a6134fca65bfe737101d242bf9e6b267f006bdc1f0063526f21"

RDEPENDS:rust-zerocopy-derive+default-devel = " \
 cargo \
 rust-zerocopy-derive-devel \
 "
RDEPENDS:rust-zerocopy-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
