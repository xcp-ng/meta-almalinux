# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-trml2pdf"
PV = "0.6"
PR = "18.el10_1"
PACKAGES = " \
 python3-trml2pdf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-trml2pdf-0.6-18.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e542609cc1a645c4be9f7cef6f4c26d2335cd6ae393ef12a2d2f8fada8189c65"

URI_x86_64_v2_python3-trml2pdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-trml2pdf-0.6-18.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-trml2pdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-trml2pdf}"
SRC_URI[x86_64_v2_python3-trml2pdf.sha256sum] = "f8e22856b014aafb4de1fa573d402150eaf9b5455dc86674b91a0997ec4ccd58"

URI_aarch64_python3-trml2pdf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-trml2pdf-0.6-18.el10_1.noarch.rpm;name=aarch64_python3-trml2pdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-trml2pdf}"
SRC_URI[aarch64_python3-trml2pdf.sha256sum] = "cda9c9ca928078bfff7e6cc33b9a11615482ea178645895d701ebef1615e0382"

RDEPENDS:python3-trml2pdf = " \
 python3 \
 python3-reportlab \
 python3-six \
 "
