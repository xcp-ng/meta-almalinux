# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aopalliance"
PV = "1.0"
PR = "40.el10"
PACKAGES = " \
 aopalliance \
 aopalliance-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/aopalliance-1.0-40.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59c46fb61df547c817ddac7b9d3c7f440e284ce760819216be3ccc94cfb7ce22"

URI_x86_64_v2_aopalliance = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aopalliance-1.0-40.el10.noarch.rpm;name=x86_64_v2_aopalliance;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aopalliance}"
SRC_URI[x86_64_v2_aopalliance.sha256sum] = "177bc31121b9d2f5398b6d38603b5d3862bcc59cb3ae472766e673cc3e8413d7"

URI_x86_64_v2_aopalliance-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/aopalliance-javadoc-1.0-40.el10.noarch.rpm;name=x86_64_v2_aopalliance-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aopalliance-javadoc}"
SRC_URI[x86_64_v2_aopalliance-javadoc.sha256sum] = "43ae39091df5a20f784c402f719d13c6818ca7770a47addd2bd5671740b7c219"

URI_aarch64_aopalliance = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aopalliance-1.0-40.el10.noarch.rpm;name=aarch64_aopalliance;unpack=0"
SRC_URI:append = " ${URI_aarch64_aopalliance}"
SRC_URI[aarch64_aopalliance.sha256sum] = "177bc31121b9d2f5398b6d38603b5d3862bcc59cb3ae472766e673cc3e8413d7"

URI_aarch64_aopalliance-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/aopalliance-javadoc-1.0-40.el10.noarch.rpm;name=aarch64_aopalliance-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_aopalliance-javadoc}"
SRC_URI[aarch64_aopalliance-javadoc.sha256sum] = "43ae39091df5a20f784c402f719d13c6818ca7770a47addd2bd5671740b7c219"

RDEPENDS:aopalliance = " \
 javapackages-filesystem \
 "
RDEPENDS:aopalliance-javadoc = " \
 javapackages-filesystem \
 "
