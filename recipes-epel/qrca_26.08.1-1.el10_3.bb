# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qrca"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 qrca \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/q/qrca-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c8e5f8bc189a359a37ff6c7bc15e17a819735a18195f803588c891f87770fff5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qrca-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qrca;unpack=0"
SRC_URI[x86_64_v2_qrca.sha256sum] = "e551bc353cfca597e0fa6a55311f5f23c58fc46314d3a70be125171ddc905e02"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qrca-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_qrca;unpack=0"
SRC_URI[aarch64_qrca.sha256sum] = "a784a465c3f330c33be6f8a2fb3d7953c057e018571dd1889587ee1d0768bd15"

RDEPENDS:qrca = " \
 glibc \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kservice \
 kf6-networkmanager-qt \
 kf6-prison \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xdg-utils \
 "
