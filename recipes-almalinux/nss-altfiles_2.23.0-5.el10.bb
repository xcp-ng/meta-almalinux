# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nss-altfiles"
PV = "2.23.0"
PR = "5.el10"
PACKAGES = " \
 nss-altfiles \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nss-altfiles-2.23.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d8310bacd8077022e5dd9c19c73e15953faca4383e1374dfa0593b62ac236ad"

URI_x86_64_v2_nss-altfiles = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-altfiles-2.23.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_nss-altfiles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-altfiles}"
SRC_URI[x86_64_v2_nss-altfiles.sha256sum] = "10b10bd24eec783b73722ce4ef5920fa4918dcaf7ab675a7d5e83c666b333340"

URI_aarch64_nss-altfiles = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-altfiles-2.23.0-5.el10.aarch64.rpm;name=aarch64_nss-altfiles;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-altfiles}"
SRC_URI[aarch64_nss-altfiles.sha256sum] = "fbfa1066b3158c779f61711216b3b236718181b1617fa8ba4a3136fbc438b530"

RDEPENDS:nss-altfiles = " \
 glibc \
 "
