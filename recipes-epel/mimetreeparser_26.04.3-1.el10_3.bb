# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mimetreeparser"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 mimetreeparser \
 mimetreeparser-devel \
 mimetreeparser-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mimetreeparser-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa9c7434aa62e416f924292381820e9139e3d16e0c5848d0206d911efd27673e"

URI_x86_64_v2_mimetreeparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimetreeparser-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimetreeparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimetreeparser}"
SRC_URI[x86_64_v2_mimetreeparser.sha256sum] = "935a404270b282171f50aa298c1017e5004fae5d182ee95b226552525c783f0a"

URI_x86_64_v2_mimetreeparser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimetreeparser-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimetreeparser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimetreeparser-devel}"
SRC_URI[x86_64_v2_mimetreeparser-devel.sha256sum] = "9626954b79e0433a0037793647f2a67698a2291f6f72c10863db41ec6be37aee"

URI_x86_64_v2_mimetreeparser-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimetreeparser-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mimetreeparser-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimetreeparser-doc}"
SRC_URI[x86_64_v2_mimetreeparser-doc.sha256sum] = "ef6c14ea8b14395fc3514c5b6c5ed5599d9a121d98a67476e5877f30f5f33a4c"

URI_aarch64_mimetreeparser = "${EPEL_MIRROR}/aarch64/Packages/m/mimetreeparser-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_mimetreeparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimetreeparser}"
SRC_URI[aarch64_mimetreeparser.sha256sum] = "3f4d1c74adf748c2d70a151f97bb5c1a9bc8cafff0e3502f66f6add5e0aba91c"

URI_aarch64_mimetreeparser-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mimetreeparser-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_mimetreeparser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimetreeparser-devel}"
SRC_URI[aarch64_mimetreeparser-devel.sha256sum] = "b112ab37cf1151d4c3f3133bc83626452b8bac994bee6b94650e8e2808ba819c"

URI_aarch64_mimetreeparser-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mimetreeparser-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_mimetreeparser-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimetreeparser-doc}"
SRC_URI[aarch64_mimetreeparser-doc.sha256sum] = "b3bb55b37f7f6815eb0c2b39e06b3d467adbbbcc6e1a6237e662394099f26405"

RDEPENDS:mimetreeparser = " \
 glibc \
 gpgme2pp \
 kf6-kcalendarcore \
 kf6-kcolorscheme \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kmbox \
 kmime \
 libkleo \
 libstdc++ \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:mimetreeparser-devel = " \
 cmake-filesystem \
 mimetreeparser \
 "
RDEPENDS:mimetreeparser-doc = " \
 "
