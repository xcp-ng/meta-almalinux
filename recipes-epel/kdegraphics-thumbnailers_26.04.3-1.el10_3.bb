# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdegraphics-thumbnailers"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdegraphics-thumbnailers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdegraphics-thumbnailers-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9237c58a6dff6f8ad2d0de63a3e4c8eecc496c8d0550ae9271afb4178bb5ee6b"

URI_x86_64_v2_kdegraphics-thumbnailers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdegraphics-thumbnailers-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdegraphics-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdegraphics-thumbnailers}"
SRC_URI[x86_64_v2_kdegraphics-thumbnailers.sha256sum] = "3230619ef61be280305c04baa200cee3fbe930303280cdfde6a85d2e13d5a825"

URI_aarch64_kdegraphics-thumbnailers = "${EPEL_MIRROR}/aarch64/Packages/k/kdegraphics-thumbnailers-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdegraphics-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdegraphics-thumbnailers}"
SRC_URI[aarch64_kdegraphics-thumbnailers.sha256sum] = "bd3f59a6ff5e96e22e44f66391da683b2dd82940c772b71f6550ce7a7065deaf"

RDEPENDS:kdegraphics-thumbnailers = " \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libkdcraw \
 libkexiv2-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
