# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iperf"
PV = "2.2.1"
PR = "3.el10_1"
PACKAGES = " \
 iperf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/iperf-2.2.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00e20235e835c07261868c775683eb65965f15a8d685cd62520c43953fdead2d"

URI_x86_64_v2_iperf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/iperf-2.2.1-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_iperf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iperf}"
SRC_URI[x86_64_v2_iperf.sha256sum] = "a860b2ea0e1764ab4e5d23fa695bcaab3b65358a1890e5bf2e8ce088f0354179"

URI_aarch64_iperf = "${EPEL_MIRROR}/aarch64/Packages/i/iperf-2.2.1-3.el10_1.aarch64.rpm;name=aarch64_iperf;unpack=0"
SRC_URI:append = " ${URI_aarch64_iperf}"
SRC_URI[aarch64_iperf.sha256sum] = "f33d03c0e70515a92011e0767870ca0ddf8c1fa7bdf3418f4442f63cc01bf833"

RDEPENDS:iperf = " \
 glibc \
 libgcc \
 libstdc++ \
 "
