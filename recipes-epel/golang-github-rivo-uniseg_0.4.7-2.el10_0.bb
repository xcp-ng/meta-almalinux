# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-rivo-uniseg"
PV = "0.4.7"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-rivo-uniseg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-rivo-uniseg-0.4.7-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b86a2df5644cd1bf415251e3dfe7b09672ba594c6e266d0dba8fe419fd52df9c"

URI_x86_64_v2_golang-github-rivo-uniseg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-rivo-uniseg-devel-0.4.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-rivo-uniseg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-rivo-uniseg-devel}"
SRC_URI[x86_64_v2_golang-github-rivo-uniseg-devel.sha256sum] = "e5466032bde1d9f57113d46c3d83684801624a951e3bf9ce644c70bab72958c2"

URI_aarch64_golang-github-rivo-uniseg-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-rivo-uniseg-devel-0.4.7-2.el10_0.noarch.rpm;name=aarch64_golang-github-rivo-uniseg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-rivo-uniseg-devel}"
SRC_URI[aarch64_golang-github-rivo-uniseg-devel.sha256sum] = "8912f7f1d4ddabfedda15534d4723ea593c1e1cce790f30d0ff3b6ae6d7403de"

RDEPENDS:golang-github-rivo-uniseg-devel = " \
 go-filesystem \
 "
