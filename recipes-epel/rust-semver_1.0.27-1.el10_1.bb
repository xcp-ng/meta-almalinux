# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-semver"
PV = "1.0.27"
PR = "1.el10_1"
PACKAGES = " \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-semver+std-devel \
 rust-semver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-semver-1.0.27-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fa64b90caec0d076786daf67fc808c409bd47e1fa7a3f33702d9a7ff43b12f7"

URI_x86_64_v2_rust-semver+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver+default-devel-1.0.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver+default-devel}"
SRC_URI[x86_64_v2_rust-semver+default-devel.sha256sum] = "0c8a762e68211a1a63ecc36d2ef24b5b445674d9407ea43743a1f3e4bcf4796f"

URI_x86_64_v2_rust-semver+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver+serde-devel-1.0.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver+serde-devel}"
SRC_URI[x86_64_v2_rust-semver+serde-devel.sha256sum] = "0ee5f7f2b9aa001c676297624357c4c17d328237684a6bec42a4140c888d898f"

URI_x86_64_v2_rust-semver+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver+std-devel-1.0.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver+std-devel}"
SRC_URI[x86_64_v2_rust-semver+std-devel.sha256sum] = "8933a030f10cc3f0bfb931cee8a933eee12144f4e8cc9cf16d7d6fd2113d1235"

URI_x86_64_v2_rust-semver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver-devel-1.0.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver-devel}"
SRC_URI[x86_64_v2_rust-semver-devel.sha256sum] = "1c8643babf375e2c422d981d772003fb878351aff52a5cce10270a6e423c8f1e"

URI_aarch64_rust-semver+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver+default-devel-1.0.27-1.el10_1.noarch.rpm;name=aarch64_rust-semver+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver+default-devel}"
SRC_URI[aarch64_rust-semver+default-devel.sha256sum] = "97fb26b79b923b0165a88140a90dd2773bc6fac1de8e898e402ba0bf3da3b286"

URI_aarch64_rust-semver+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver+serde-devel-1.0.27-1.el10_1.noarch.rpm;name=aarch64_rust-semver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver+serde-devel}"
SRC_URI[aarch64_rust-semver+serde-devel.sha256sum] = "fc3ff0448a8845837f2fe2e80fde226ea9736e1f68e0e0c3b99d3dc05731572c"

URI_aarch64_rust-semver+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver+std-devel-1.0.27-1.el10_1.noarch.rpm;name=aarch64_rust-semver+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver+std-devel}"
SRC_URI[aarch64_rust-semver+std-devel.sha256sum] = "8c88bf501c442b27e756bb95d228739710ef55bf0c2b066025ce87b66632032d"

URI_aarch64_rust-semver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver-devel-1.0.27-1.el10_1.noarch.rpm;name=aarch64_rust-semver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver-devel}"
SRC_URI[aarch64_rust-semver-devel.sha256sum] = "11c4fcb68de8ec77acbfc681d89c8b696120d177ac1d4c31480618d10b267f97"

RDEPENDS:rust-semver+default-devel = " \
 cargo \
 rust-semver+std-devel \
 rust-semver-devel \
 "
RDEPENDS:rust-semver+serde-devel = " \
 cargo \
 rust-semver-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-semver+std-devel = " \
 cargo \
 rust-semver-devel \
 "
RDEPENDS:rust-semver-devel = " \
 cargo \
 rust \
 "
