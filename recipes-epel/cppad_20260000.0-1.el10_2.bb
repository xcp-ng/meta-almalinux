# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cppad"
PV = "20260000.0"
PR = "1.el10_2"
PACKAGES = " \
 cppad \
 cppad-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cppad-20260000.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ca2fd8746d8d7dd0a2af81db5d0afa43d422e5cc56b7fab53f7a7ec9e17f38c"

URI_x86_64_v2_cppad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cppad-20260000.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cppad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cppad}"
SRC_URI[x86_64_v2_cppad.sha256sum] = "b79421941ae8556a7be6fcd11415ce4c5e50d6dae99fe333c6784e9d37bb1709"

URI_x86_64_v2_cppad-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cppad-devel-20260000.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cppad-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cppad-devel}"
SRC_URI[x86_64_v2_cppad-devel.sha256sum] = "e5820433a99f036c65b4748b2484db65bf53acc351b2612f7f76bfce12952337"

URI_aarch64_cppad = "${EPEL_MIRROR}/aarch64/Packages/c/cppad-20260000.0-1.el10_2.aarch64.rpm;name=aarch64_cppad;unpack=0"
SRC_URI:append = " ${URI_aarch64_cppad}"
SRC_URI[aarch64_cppad.sha256sum] = "4c4cf6884cf1e71f84a988c25f4e767c7747081601626b818e0a95c4bf91f744"

URI_aarch64_cppad-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cppad-devel-20260000.0-1.el10_2.aarch64.rpm;name=aarch64_cppad-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cppad-devel}"
SRC_URI[aarch64_cppad-devel.sha256sum] = "d5296d5795f74b8cc2777937b2c9721b15e8c851d5db9a7a9aef5d60ea53e82d"

RDEPENDS:cppad = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:cppad-devel = " \
 cppad \
 pkgconf-pkg-config \
 "
