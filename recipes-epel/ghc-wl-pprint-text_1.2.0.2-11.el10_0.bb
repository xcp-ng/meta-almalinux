# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-wl-pprint-text"
PV = "1.2.0.2"
PR = "11.el10_0"
PACKAGES = " \
 ghc-wl-pprint-text \
 ghc-wl-pprint-text-devel \
 ghc-wl-pprint-text-doc \
 ghc-wl-pprint-text-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-wl-pprint-text-1.2.0.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d328c3f7b81e7c1723e02448fc0d815d7da91419dfda331a791f06f4665f7ae"

URI_x86_64_v2_ghc-wl-pprint-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wl-pprint-text-1.2.0.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wl-pprint-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wl-pprint-text}"
SRC_URI[x86_64_v2_ghc-wl-pprint-text.sha256sum] = "f16d3d237a38eee6ba2ffcc44f8d5ab1af1f1c7f1e6e6b71d7a063ffca11cfd9"

URI_x86_64_v2_ghc-wl-pprint-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wl-pprint-text-devel-1.2.0.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wl-pprint-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wl-pprint-text-devel}"
SRC_URI[x86_64_v2_ghc-wl-pprint-text-devel.sha256sum] = "36200377910fc9a7dce3de62d0904893a1d9a0a24eb662a1538d0249b21e5a00"

URI_x86_64_v2_ghc-wl-pprint-text-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wl-pprint-text-doc-1.2.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-wl-pprint-text-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wl-pprint-text-doc}"
SRC_URI[x86_64_v2_ghc-wl-pprint-text-doc.sha256sum] = "f10428167b23c5919d7645d496f3ad7918387057f99be2778b9029ea38c0cf78"

URI_x86_64_v2_ghc-wl-pprint-text-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wl-pprint-text-prof-1.2.0.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wl-pprint-text-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wl-pprint-text-prof}"
SRC_URI[x86_64_v2_ghc-wl-pprint-text-prof.sha256sum] = "736823133e33996d0f4bd37a9d53432e6147f57981470f58bb926a674c26e599"

URI_aarch64_ghc-wl-pprint-text = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wl-pprint-text-1.2.0.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-wl-pprint-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wl-pprint-text}"
SRC_URI[aarch64_ghc-wl-pprint-text.sha256sum] = "766e580dbddffbd6be8a195169ae33c5782376f0809314685178895139c3471c"

URI_aarch64_ghc-wl-pprint-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wl-pprint-text-devel-1.2.0.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-wl-pprint-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wl-pprint-text-devel}"
SRC_URI[aarch64_ghc-wl-pprint-text-devel.sha256sum] = "a2212c2fbc24a38f220265667d484795087f90815c6f86eca7e2c43af7e23843"

URI_aarch64_ghc-wl-pprint-text-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wl-pprint-text-doc-1.2.0.2-11.el10_0.noarch.rpm;name=aarch64_ghc-wl-pprint-text-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wl-pprint-text-doc}"
SRC_URI[aarch64_ghc-wl-pprint-text-doc.sha256sum] = "e674ada2715b37c66bea929974fe92086798135dc73cd8526601ad39699ed5b6"

URI_aarch64_ghc-wl-pprint-text-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wl-pprint-text-prof-1.2.0.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-wl-pprint-text-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wl-pprint-text-prof}"
SRC_URI[aarch64_ghc-wl-pprint-text-prof.sha256sum] = "dd1775064883c20bd2cefdfd866c475f1f4301e9353bd79d9fc3c717eb66b9f5"

RDEPENDS:ghc-wl-pprint-text = " \
 ghc-array \
 ghc-base \
 ghc-base-compat \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-wl-pprint-text-devel = " \
 ghc-base-compat-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-text-devel \
 ghc-wl-pprint-text \
 "
RDEPENDS:ghc-wl-pprint-text-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-wl-pprint-text-prof = " \
 ghc-base-compat-prof \
 ghc-base-prof \
 ghc-text-prof \
 ghc-wl-pprint-text-devel \
 "
