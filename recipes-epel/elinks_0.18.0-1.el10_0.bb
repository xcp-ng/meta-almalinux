# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "elinks"
PV = "0.18.0"
PR = "1.el10_0"
PACKAGES = " \
 elinks \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/elinks-0.18.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "161e1e337654135d40e5f7069025b9b39f5c3e91665b6154e8546f8fc2812711"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/elinks-0.18.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_elinks;unpack=0"
SRC_URI[x86_64_v2_elinks.sha256sum] = "8eeda49df0bfcbb94df5e63b16a4107eff327226c8b630f59ce0eb17e4619883"
RPROVIDES:elinks:append:x86_64_v2 = " virtual/text-www-browser"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/elinks-0.18.0-1.el10_0.aarch64.rpm;name=aarch64_elinks;unpack=0"
SRC_URI[aarch64_elinks.sha256sum] = "05c1fe69b778b81d33eb64510048ea038dce957fb04d74e01e96c984f5e11680"
RPROVIDES:elinks:append:aarch64 = " virtual/text-www-browser"

RDEPENDS:elinks = " \
 alternatives \
 bash \
 bzip2-libs \
 expat \
 glibc \
 krb5-libs \
 libidn2 \
 openssl-libs \
 virtual/coreutils \
 zlib-ng-compat \
 "
