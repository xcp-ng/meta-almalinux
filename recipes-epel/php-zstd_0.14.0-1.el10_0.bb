# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-zstd"
PV = "0.14.0"
PR = "1.el10_0"
PACKAGES = " \
 php-zstd \
 php-zstd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-zstd-0.14.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cb2beccb11020a67020ac299476503bc2e742596254f3e497d7aebfe210945e"

URI_x86_64_v2_php-zstd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-zstd-0.14.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-zstd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-zstd}"
SRC_URI[x86_64_v2_php-zstd.sha256sum] = "77b87a15e236e14d90dc1cc7c17830cdede8889ae3c8d966e2144c56aff4804c"

URI_x86_64_v2_php-zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-zstd-devel-0.14.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-zstd-devel}"
SRC_URI[x86_64_v2_php-zstd-devel.sha256sum] = "eaa28486658bab3a63c9bcc73bbbde8256002240e7119683438fc4c4fb6266c6"

URI_aarch64_php-zstd = "${EPEL_MIRROR}/aarch64/Packages/p/php-zstd-0.14.0-1.el10_0.aarch64.rpm;name=aarch64_php-zstd;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-zstd}"
SRC_URI[aarch64_php-zstd.sha256sum] = "757ac5864c58b855dc3ff6a9dafa3f037fe799da0d98051dabdc02e54d1a36a9"

URI_aarch64_php-zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-zstd-devel-0.14.0-1.el10_0.aarch64.rpm;name=aarch64_php-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-zstd-devel}"
SRC_URI[aarch64_php-zstd-devel.sha256sum] = "ff01035293cc35a5f235dc066a47045315a04fca368a52244d72bb4079bd7d59"

RDEPENDS:php-zstd = " \
 glibc \
 libzstd \
 php-common \
 "
RDEPENDS:php-zstd-devel = " \
 php-devel \
 php-zstd \
 "
