# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "highway"
PV = "1.2.0"
PR = "7.el10_0"
PACKAGES = " \
 highway \
 highway-devel \
 highway-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/highway-1.2.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c86e2aa04cae8a35a15bfe2c520848df73627e135727251cb21c30616826a958"

URI_x86_64_v2_highway = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/highway-1.2.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_highway;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_highway}"
SRC_URI[x86_64_v2_highway.sha256sum] = "945456542c39e9d6afef526da9275f61bc58e340fe73f75317756093aac56d11"

URI_x86_64_v2_highway-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/highway-devel-1.2.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_highway-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_highway-devel}"
SRC_URI[x86_64_v2_highway-devel.sha256sum] = "0f4519643e52593f20b49ad59c825e506bf7ff37b84bbe38315d311aabeeb088"

URI_x86_64_v2_highway-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/highway-doc-1.2.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_highway-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_highway-doc}"
SRC_URI[x86_64_v2_highway-doc.sha256sum] = "ce6dd451226ac01fe428bc2016446e7c7be269cae08ddb4415cc9d7505e1d98b"

URI_aarch64_highway = "${EPEL_MIRROR}/aarch64/Packages/h/highway-1.2.0-7.el10_0.aarch64.rpm;name=aarch64_highway;unpack=0"
SRC_URI:append = " ${URI_aarch64_highway}"
SRC_URI[aarch64_highway.sha256sum] = "c09c9291ce1a5d9c43e6e3e00a166339a324ad28cfd72a7cb9ee4a9ab42b0eb1"

URI_aarch64_highway-devel = "${EPEL_MIRROR}/aarch64/Packages/h/highway-devel-1.2.0-7.el10_0.aarch64.rpm;name=aarch64_highway-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_highway-devel}"
SRC_URI[aarch64_highway-devel.sha256sum] = "0cad680eacefc67bd8ae82a528ca34bb26ff6202bef3d146b1ff3480232fb6ea"

URI_aarch64_highway-doc = "${EPEL_MIRROR}/aarch64/Packages/h/highway-doc-1.2.0-7.el10_0.noarch.rpm;name=aarch64_highway-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_highway-doc}"
SRC_URI[aarch64_highway-doc.sha256sum] = "72fd4e01ebe38270012978a5f049ebbd34bfc0c9321ccec05ba5e9bb5fe33d0a"

RDEPENDS:highway:x86_64_v2 = " \
 glibc \
 libgcc \
 libstdc++ \
"
RDEPENDS:highway:aarch64 = " \
 glibc \
 libstdc++ \
"
RDEPENDS:highway-devel = " \
 cmake-filesystem \
 gtest-devel \
 highway \
 pkgconf-pkg-config \
 "
RDEPENDS:highway-doc = " \
 "
