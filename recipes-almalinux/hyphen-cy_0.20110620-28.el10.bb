# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-cy"
PV = "0.20110620"
PR = "28.el10"
PACKAGES = " \
 hyphen-cy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-cy-0.20110620-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "283b1c79c4956c3cb852aeeef922ec1818d818e825987cb166bb236bbe617adf"

URI_x86_64_v2_hyphen-cy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-cy-0.20110620-28.el10.noarch.rpm;name=x86_64_v2_hyphen-cy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-cy}"
SRC_URI[x86_64_v2_hyphen-cy.sha256sum] = "a278972757f4b61ac41f5424463dd60f3ca8f7011e0de82f7bfd5172b927f94b"

URI_aarch64_hyphen-cy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-cy-0.20110620-28.el10.noarch.rpm;name=aarch64_hyphen-cy;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-cy}"
SRC_URI[aarch64_hyphen-cy.sha256sum] = "a278972757f4b61ac41f5424463dd60f3ca8f7011e0de82f7bfd5172b927f94b"

RDEPENDS:hyphen-cy = " \
 hyphen \
 "
