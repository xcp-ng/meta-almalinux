# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-webpki-roots"
PV = "1.0.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-webpki-roots+default-devel \
 rust-webpki-roots-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-webpki-roots-1.0.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54a4d28b68ef4900cb4d67f0af6cce5d1c4b035fbe91d0ec98120eebf7642e91"

URI_x86_64_v2_rust-webpki-roots+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webpki-roots+default-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webpki-roots+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webpki-roots+default-devel}"
SRC_URI[x86_64_v2_rust-webpki-roots+default-devel.sha256sum] = "765d310568bc8ca600c063e5ddbba8cb3bbb1e09ae6482d28d3314bf9c5def29"

URI_x86_64_v2_rust-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webpki-roots-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-webpki-roots-devel.sha256sum] = "27672163669b38e210b7d3ac86f350d166239de46b8981b91dec8de4c7bd9e91"

URI_aarch64_rust-webpki-roots+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webpki-roots+default-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-webpki-roots+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webpki-roots+default-devel}"
SRC_URI[aarch64_rust-webpki-roots+default-devel.sha256sum] = "d72eeb8c01ef5e00772899bb6e109d06719f1eeba55e86ddd0d783b0bbabac28"

URI_aarch64_rust-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webpki-roots-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webpki-roots-devel}"
SRC_URI[aarch64_rust-webpki-roots-devel.sha256sum] = "ee725f1e1cab9e96e8c9ed1bfde6f6f50a813a9cfe9d39b3bc69ec08b7885894"

RDEPENDS:rust-webpki-roots+default-devel = " \
 cargo \
 rust-webpki-roots-devel \
 "
RDEPENDS:rust-webpki-roots-devel = " \
 cargo \
 rust \
 rust-rustls-pki-types-devel \
 "
