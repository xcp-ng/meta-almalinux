# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gsl"
PV = "2.7.1"
PR = "13.el10_2"
PACKAGES = " \
 gsl \
 gsl-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gsl-2.7.1-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "54a2cf35013358c19f02e4b706417753cc7427204fda47eb3649fde1a8ea5217"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsl-2.7.1-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsl;unpack=0"
SRC_URI[x86_64_v2_gsl.sha256sum] = "f0139c30bfcb26383e0f27302e83880c97430ff6a3e714b5d237d94e58ffd663"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsl-devel-2.7.1-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsl-devel;unpack=0"
SRC_URI[x86_64_v2_gsl-devel.sha256sum] = "e80f1f3da8297d102fbad5dc1d277f2c84aecb9e30ca38799de5a3a5d24afcaa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gsl-2.7.1-13.el10_2.aarch64.rpm;name=aarch64_gsl;unpack=0"
SRC_URI[aarch64_gsl.sha256sum] = "3d46f09ffffd8b5a5620b98fd79cf051abd64349351bd954a5520f26197c76c1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gsl-devel-2.7.1-13.el10_2.aarch64.rpm;name=aarch64_gsl-devel;unpack=0"
SRC_URI[aarch64_gsl-devel.sha256sum] = "e6cf3757b88b6d65b30240eae279cdbb3130b3d69ae53425fd5f6978c3cfbabc"

RDEPENDS:gsl = " \
 glibc \
 "
RDEPENDS:gsl-devel = " \
 bash \
 gsl \
 pkgconf-pkg-config \
 "
