# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bpaf"
PV = "0.9.20"
PR = "1.el10_1"
PACKAGES = " \
 rust-bpaf+autocomplete-devel \
 rust-bpaf+batteries-devel \
 rust-bpaf+bpaf_derive-devel \
 rust-bpaf+bright-color-devel \
 rust-bpaf+color-devel \
 rust-bpaf+default-devel \
 rust-bpaf+derive-devel \
 rust-bpaf+docgen-devel \
 rust-bpaf+dull-color-devel \
 rust-bpaf+extradocs-devel \
 rust-bpaf+owo-colors-devel \
 rust-bpaf+supports-color-devel \
 rust-bpaf+unstable-docs-devel \
 rust-bpaf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bpaf-0.9.20-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d051c2647bb2c69908df5d96d4b1b1ba181fbaf98d20bfd773c5c69d955e689"

URI_x86_64_v2_rust-bpaf+autocomplete-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+autocomplete-devel-0.9.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+autocomplete-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+autocomplete-devel}"
SRC_URI[x86_64_v2_rust-bpaf+autocomplete-devel.sha256sum] = "7fa7a455a0117243a343ed9b41f7dae79f6c69713c735f0595c969b4ba9109a8"

URI_x86_64_v2_rust-bpaf+batteries-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+batteries-devel-0.9.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+batteries-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+batteries-devel}"
SRC_URI[x86_64_v2_rust-bpaf+batteries-devel.sha256sum] = "ce8da717b41b71c0376513ff83a17b7855333aceb6c2aa5a15e8a230b9942a9d"

URI_x86_64_v2_rust-bpaf+bpaf_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+bpaf_derive-devel-0.9.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+bpaf_derive-devel}"
SRC_URI[x86_64_v2_rust-bpaf+bpaf_derive-devel.sha256sum] = "c01f47b35159c4276d5d057cee399cf59a9c70d92b77aa030f92b963d7836e37"

URI_x86_64_v2_rust-bpaf+bright-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+bright-color-devel-0.9.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+bright-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+bright-color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+bright-color-devel.sha256sum] = "85c4951cb3e2672566665aa3d13896fb864615a839d7f811d4cc3ead4372abe5"

URI_x86_64_v2_rust-bpaf+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+color-devel-0.9.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+color-devel.sha256sum] = "f0d623cb052ca079813bc97dc0bc4f2d4fdfc7142326e4a4ae80cca058a2a8dd"

URI_x86_64_v2_rust-bpaf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+default-devel-0.9.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+default-devel}"
SRC_URI[x86_64_v2_rust-bpaf+default-devel.sha256sum] = "0bc571f071953525d7274372978947e9643551317d7149709dd3b26357ed6d9e"

URI_x86_64_v2_rust-bpaf+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+derive-devel-0.9.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+derive-devel}"
SRC_URI[x86_64_v2_rust-bpaf+derive-devel.sha256sum] = "af97441b2b650c2f4ec4c2a6852cdfe9d8d33895b74c1a9d00dc84553e67594f"

URI_x86_64_v2_rust-bpaf+docgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+docgen-devel-0.9.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+docgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+docgen-devel}"
SRC_URI[x86_64_v2_rust-bpaf+docgen-devel.sha256sum] = "b2772c769768cae9d5a410aa01836599fdb81c33fdfb6718d225d9dff1a4cffa"

URI_x86_64_v2_rust-bpaf+dull-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+dull-color-devel-0.9.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+dull-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+dull-color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+dull-color-devel.sha256sum] = "05459e279cd509b0baac523ccd0be5f98928104791548cf8eaff149cec1d7fe3"

URI_x86_64_v2_rust-bpaf+extradocs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+extradocs-devel-0.9.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+extradocs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+extradocs-devel}"
SRC_URI[x86_64_v2_rust-bpaf+extradocs-devel.sha256sum] = "1998e09df4e95fbbf38c2213a029be895b3fb3bfb9bacbad25bb1062d2b48f03"

URI_x86_64_v2_rust-bpaf+owo-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+owo-colors-devel-0.9.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+owo-colors-devel}"
SRC_URI[x86_64_v2_rust-bpaf+owo-colors-devel.sha256sum] = "1ab34513ddfcbf85c6525b806f3fee8f5c25ea65480352086ca4dfaf08d17867"

URI_x86_64_v2_rust-bpaf+supports-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+supports-color-devel-0.9.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+supports-color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+supports-color-devel.sha256sum] = "61cdfb505736788344ab84d419b76d3964c8020d11621e2ea147fa3fb39db751"

URI_x86_64_v2_rust-bpaf+unstable-docs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+unstable-docs-devel-0.9.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+unstable-docs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+unstable-docs-devel}"
SRC_URI[x86_64_v2_rust-bpaf+unstable-docs-devel.sha256sum] = "0be8540e486bbc99bb18678b634576124179823cb8b45274c784b6d18adab824"

URI_x86_64_v2_rust-bpaf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf-devel-0.9.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf-devel}"
SRC_URI[x86_64_v2_rust-bpaf-devel.sha256sum] = "58c695742e32b8fda54850cdd1d4ebfbd8082b1e76e0eddf5e68f848e907fe45"

URI_aarch64_rust-bpaf+autocomplete-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+autocomplete-devel-0.9.20-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf+autocomplete-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+autocomplete-devel}"
SRC_URI[aarch64_rust-bpaf+autocomplete-devel.sha256sum] = "ea2ba4280a414759191c6f559af7327df60006e9bb1df2f2e0f7e50c5f84c7b9"

URI_aarch64_rust-bpaf+batteries-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+batteries-devel-0.9.20-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf+batteries-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+batteries-devel}"
SRC_URI[aarch64_rust-bpaf+batteries-devel.sha256sum] = "9d980ac87c0c01e6f0ce23ed59e4b283476ae2db7f588e9f3c17f661ced06f7a"

URI_aarch64_rust-bpaf+bpaf_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+bpaf_derive-devel-0.9.20-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf+bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+bpaf_derive-devel}"
SRC_URI[aarch64_rust-bpaf+bpaf_derive-devel.sha256sum] = "d7a695ea275d5258edd07548a007445d4e131d0b6178d2bff7cf77e4d414f81c"

URI_aarch64_rust-bpaf+bright-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+bright-color-devel-0.9.20-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf+bright-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+bright-color-devel}"
SRC_URI[aarch64_rust-bpaf+bright-color-devel.sha256sum] = "afac18438a21d9be02496904622d9d555e77959bd05dee06549eed10a3c80231"

URI_aarch64_rust-bpaf+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+color-devel-0.9.20-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+color-devel}"
SRC_URI[aarch64_rust-bpaf+color-devel.sha256sum] = "af99a1dc0a59a568eb16936450aef5f9544eb02210f65d66c891806533329701"

URI_aarch64_rust-bpaf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+default-devel-0.9.20-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+default-devel}"
SRC_URI[aarch64_rust-bpaf+default-devel.sha256sum] = "bf6e961f202f164d6b0a47b2c9bd21df973f7b166538263d2149eca02881fc19"

URI_aarch64_rust-bpaf+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+derive-devel-0.9.20-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+derive-devel}"
SRC_URI[aarch64_rust-bpaf+derive-devel.sha256sum] = "5324a107a01541e5dbe48af432cf0e71b13881de1da0c9962dd296d2d99c8163"

URI_aarch64_rust-bpaf+docgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+docgen-devel-0.9.20-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf+docgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+docgen-devel}"
SRC_URI[aarch64_rust-bpaf+docgen-devel.sha256sum] = "c11ce75dffe00ef45c58f032cecd41a00bba0cc82cd6e2e6ce1730cc486592b8"

URI_aarch64_rust-bpaf+dull-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+dull-color-devel-0.9.20-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf+dull-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+dull-color-devel}"
SRC_URI[aarch64_rust-bpaf+dull-color-devel.sha256sum] = "32d480688eb86091ef89ad28bf6dbbff24cebd0e66b69ebd14a5c2963e7dbffc"

URI_aarch64_rust-bpaf+extradocs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+extradocs-devel-0.9.20-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf+extradocs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+extradocs-devel}"
SRC_URI[aarch64_rust-bpaf+extradocs-devel.sha256sum] = "6444ced52de4b3489826b85b3dbf71d4af348fe8dd2eb423690e0136ae40363f"

URI_aarch64_rust-bpaf+owo-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+owo-colors-devel-0.9.20-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf+owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+owo-colors-devel}"
SRC_URI[aarch64_rust-bpaf+owo-colors-devel.sha256sum] = "ed2193a1639a4e6332043ac1f8493f72036debcb9ef4d77f5a59bfac88b890bf"

URI_aarch64_rust-bpaf+supports-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+supports-color-devel-0.9.20-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+supports-color-devel}"
SRC_URI[aarch64_rust-bpaf+supports-color-devel.sha256sum] = "f15d9bbc1cdacf870b72909e1b8e12e0f531d8b71d75539d20f4403b47c16da4"

URI_aarch64_rust-bpaf+unstable-docs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+unstable-docs-devel-0.9.20-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf+unstable-docs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+unstable-docs-devel}"
SRC_URI[aarch64_rust-bpaf+unstable-docs-devel.sha256sum] = "b33dc44863b20426cde1c445cee8467fd43cf69334b0c4444c301903d9dbc4a6"

URI_aarch64_rust-bpaf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf-devel-0.9.20-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf-devel}"
SRC_URI[aarch64_rust-bpaf-devel.sha256sum] = "471ee626785a1d203740ce2967e79c1b9487d3112ae649be311cace2810e19d0"

RDEPENDS:rust-bpaf+autocomplete-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+batteries-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+bpaf_derive-devel = " \
 cargo \
 rust-bpaf-devel \
 rust-bpaf_derive+default-devel \
 "
RDEPENDS:rust-bpaf+bright-color-devel = " \
 cargo \
 rust-bpaf+color-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+color-devel = " \
 cargo \
 rust-bpaf+owo-colors-devel \
 rust-bpaf+supports-color-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+default-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+derive-devel = " \
 cargo \
 rust-bpaf+bpaf_derive-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+docgen-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+dull-color-devel = " \
 cargo \
 rust-bpaf+color-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+extradocs-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+owo-colors-devel = " \
 cargo \
 rust-bpaf-devel \
 virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~ \
 "
RDEPENDS:rust-bpaf+supports-color-devel = " \
 cargo \
 rust-bpaf-devel \
 virtual/crate_supports-color/default__ge_2.0.0_with_crate_supports-color/default__lt_4.0.0~ \
 "
RDEPENDS:rust-bpaf+unstable-docs-devel = " \
 cargo \
 rust-bpaf+autocomplete-devel \
 rust-bpaf+batteries-devel \
 rust-bpaf+derive-devel \
 rust-bpaf+docgen-devel \
 rust-bpaf+extradocs-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf-devel = " \
 cargo \
 rust \
 "
