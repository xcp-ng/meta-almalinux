# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Email-Simple"
PV = "2.218"
PR = "6.el10_0"
PACKAGES = " \
 perl-Email-Simple \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Email-Simple-2.218-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ec2d97d510c5d41023da66f3b4cb7bf6d0de34737a8175ca923ddc9b7ff35a16"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Email-Simple-2.218-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Email-Simple;unpack=0"
SRC_URI[x86_64_v2_perl-Email-Simple.sha256sum] = "9002c2711e7a8737c706f2d8d88b3b62dcc926d0d85310a7acaeff8be8432402"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Email-Simple-2.218-6.el10_0.noarch.rpm;name=aarch64_perl-Email-Simple;unpack=0"
SRC_URI[aarch64_perl-Email-Simple.sha256sum] = "61298601cc2d09a8d1feaf156ce20323791fd2dd0899b4720d56b582ab9c4b9b"

RDEPENDS:perl-Email-Simple = " \
 perl-Carp \
 perl-Email-Date-Format \
 perl-Email-Simple \
 perl-libs \
 "
