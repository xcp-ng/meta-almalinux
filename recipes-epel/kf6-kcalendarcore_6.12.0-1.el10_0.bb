# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcalendarcore"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kcalendarcore \
 kf6-kcalendarcore-devel \
 kf6-kcalendarcore-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcalendarcore-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09b4a30498281a7d39d9d0598aaa1a443f21f2c75a890a0d1bfe49e355fea38b"

URI_x86_64_v2_kf6-kcalendarcore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcalendarcore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcalendarcore}"
SRC_URI[x86_64_v2_kf6-kcalendarcore.sha256sum] = "75d3115eae9ab2ef0955fb2f7724be984090d83915efe4b341f88d3300c0912e"

URI_x86_64_v2_kf6-kcalendarcore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcalendarcore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcalendarcore-devel}"
SRC_URI[x86_64_v2_kf6-kcalendarcore-devel.sha256sum] = "78f177c63a63e90ef7df438768469340ac9d382a83acd15bd1d337d356dec217"

URI_x86_64_v2_kf6-kcalendarcore-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcalendarcore-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcalendarcore-doc}"
SRC_URI[x86_64_v2_kf6-kcalendarcore-doc.sha256sum] = "29bd793bad1f8aa6081c22ce1b3576151b4de700b7cde9afd8a2a6839757445d"

URI_aarch64_kf6-kcalendarcore = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcalendarcore;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcalendarcore}"
SRC_URI[aarch64_kf6-kcalendarcore.sha256sum] = "cfbeec6434e424f6e07533fcae9c638d65042bc072bc342924254b7747adc30f"

URI_aarch64_kf6-kcalendarcore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcalendarcore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcalendarcore-devel}"
SRC_URI[aarch64_kf6-kcalendarcore-devel.sha256sum] = "45bc5623f0510abde82fe7ddb0c4264df27d5b1eefb5fd7b85e3c13b3e67051d"

URI_aarch64_kf6-kcalendarcore-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kcalendarcore-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcalendarcore-doc}"
SRC_URI[aarch64_kf6-kcalendarcore-doc.sha256sum] = "d601f3c40f1de48b1ac49f4207af5b2f7177a72aabbe0bf1550b223ef7b7b9e0"

RDEPENDS:kf6-kcalendarcore = " \
 glibc \
 libical \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcalendarcore-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore \
 libical-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcalendarcore-doc = " \
 "
