# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mistune"
PV = "3.1.3"
PR = "1.el10_1"
PACKAGES = " \
 python-mistune-doc \
 python3-mistune \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mistune-3.1.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10e863b5b2ac25de4bab492ad78f1b409e65d0998b09aec50c4254669f3727b4"

URI_x86_64_v2_python-mistune-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-mistune-doc-3.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-mistune-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-mistune-doc}"
SRC_URI[x86_64_v2_python-mistune-doc.sha256sum] = "14d29ae7d1f041b2fc0391ffebe52b6f33c3d83fbc8f517f39e7624ac42fdd27"

URI_x86_64_v2_python3-mistune = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mistune-3.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mistune;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mistune}"
SRC_URI[x86_64_v2_python3-mistune.sha256sum] = "38598537361170f76681c445101efbb8018efc0e8f363b4393e63969f6b1a107"

URI_aarch64_python-mistune-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-mistune-doc-3.1.3-1.el10_1.noarch.rpm;name=aarch64_python-mistune-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-mistune-doc}"
SRC_URI[aarch64_python-mistune-doc.sha256sum] = "51bbd6e3aa8fead62044fb80d720419bfffed2bcd2dc386da58a191ae39f64d1"

URI_aarch64_python3-mistune = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mistune-3.1.3-1.el10_1.noarch.rpm;name=aarch64_python3-mistune;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mistune}"
SRC_URI[aarch64_python3-mistune.sha256sum] = "5347938fc69bbbc901999cbfc125375c2c37f75fc6124002aa1b02d509b0ac78"

RDEPENDS:python-mistune-doc = " \
 "
RDEPENDS:python3-mistune = " \
 python3 \
 "
