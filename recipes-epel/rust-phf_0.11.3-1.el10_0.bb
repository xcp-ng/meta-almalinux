# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf"
PV = "0.11.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-phf+default-devel \
 rust-phf+macros-devel \
 rust-phf+phf_macros-devel \
 rust-phf+serde-devel \
 rust-phf+std-devel \
 rust-phf+uncased-devel \
 rust-phf+unicase-devel \
 rust-phf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf-0.11.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5b4659333d7aeb4ca13ad0b1dbce13f197fbccb1481e6c7e937db1098cfde43"

URI_x86_64_v2_rust-phf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+default-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+default-devel}"
SRC_URI[x86_64_v2_rust-phf+default-devel.sha256sum] = "8dcb5d66c90000498a7cbeb0d81a021bba08f3354287cb922d7885dd5eda1f8d"

URI_x86_64_v2_rust-phf+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+macros-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+macros-devel}"
SRC_URI[x86_64_v2_rust-phf+macros-devel.sha256sum] = "f3bd916ecfec7656d5ff2ffc4c960c6fd650d0fa7faea8307a2ec6f74352bd53"

URI_x86_64_v2_rust-phf+phf_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+phf_macros-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+phf_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+phf_macros-devel}"
SRC_URI[x86_64_v2_rust-phf+phf_macros-devel.sha256sum] = "a897a2a0de49ef733a782ad72be2734c946fe745b9b16dc2bc0613ac50cb6ff3"

URI_x86_64_v2_rust-phf+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+serde-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+serde-devel}"
SRC_URI[x86_64_v2_rust-phf+serde-devel.sha256sum] = "9d8187612251a1d53285515b0dd6d66d2554ddd4b5827d1e647d95feb3523a99"

URI_x86_64_v2_rust-phf+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+std-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+std-devel}"
SRC_URI[x86_64_v2_rust-phf+std-devel.sha256sum] = "a92da29350f839e1db8d2ea7d75dad4d0d43f2e2f6954b0125930ffcf406d355"

URI_x86_64_v2_rust-phf+uncased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+uncased-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+uncased-devel}"
SRC_URI[x86_64_v2_rust-phf+uncased-devel.sha256sum] = "90ff1affc77485218f0dbd2d991cbc7616fc9bfd81dfaa1815977ab70e49bab4"

URI_x86_64_v2_rust-phf+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+unicase-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+unicase-devel}"
SRC_URI[x86_64_v2_rust-phf+unicase-devel.sha256sum] = "2fb1f7d2d212062fe51b228b5d587b9a8bb353765e9ff1094c1ff1a5137bcf26"

URI_x86_64_v2_rust-phf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf-devel}"
SRC_URI[x86_64_v2_rust-phf-devel.sha256sum] = "4fdd5be38395de6e1ef8e5463b41a2a423e2a7211693428df01271fd92d42081"

URI_aarch64_rust-phf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+default-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+default-devel}"
SRC_URI[aarch64_rust-phf+default-devel.sha256sum] = "4f0b467dd89696e0116199e4a33e8f842455ba828e27b21234f09d808f273681"

URI_aarch64_rust-phf+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+macros-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+macros-devel}"
SRC_URI[aarch64_rust-phf+macros-devel.sha256sum] = "1d502b00cb8a036239283fe333eb958cf6c2fc753900cd50270bfc917b16e01c"

URI_aarch64_rust-phf+phf_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+phf_macros-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf+phf_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+phf_macros-devel}"
SRC_URI[aarch64_rust-phf+phf_macros-devel.sha256sum] = "7c722416b145a82c75726f9ac023aea9e9eaa7d3356f407ea35474940ca05e4c"

URI_aarch64_rust-phf+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+serde-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+serde-devel}"
SRC_URI[aarch64_rust-phf+serde-devel.sha256sum] = "505caf69df5ca0e305f897a21734363b4285e2c51f75b102e234a13c5cf2529c"

URI_aarch64_rust-phf+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+std-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+std-devel}"
SRC_URI[aarch64_rust-phf+std-devel.sha256sum] = "35507de3af3b0cc77b7e70c1694249cfb83539f13f053859f41c60c0ba880da3"

URI_aarch64_rust-phf+uncased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+uncased-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+uncased-devel}"
SRC_URI[aarch64_rust-phf+uncased-devel.sha256sum] = "b9c77892c57f7c73bbac80cb25a39a5a80f0e0c78a4d552ed6a36ed28e3fcbf8"

URI_aarch64_rust-phf+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+unicase-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+unicase-devel}"
SRC_URI[aarch64_rust-phf+unicase-devel.sha256sum] = "4da1e51f58349c878643c13cb1a904acc2278a3b400c4c770b460f1f6ff80b2d"

URI_aarch64_rust-phf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf-devel}"
SRC_URI[aarch64_rust-phf-devel.sha256sum] = "0228480014922ba7ff45be7b4de2d138f5b1e4662e5ac063fec9bc640d51edb7"

RDEPENDS:rust-phf+default-devel = " \
 cargo \
 rust-phf+std-devel \
 rust-phf-devel \
 "
RDEPENDS:rust-phf+macros-devel = " \
 cargo \
 rust-phf+phf_macros-devel \
 rust-phf-devel \
 "
RDEPENDS:rust-phf+phf_macros-devel = " \
 cargo \
 rust-phf-devel \
 rust-phf_macros+default-devel \
 "
RDEPENDS:rust-phf+serde-devel = " \
 cargo \
 rust-phf-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-phf+std-devel = " \
 cargo \
 rust-phf-devel \
 rust-phf_shared+std-devel \
 "
RDEPENDS:rust-phf+uncased-devel = " \
 cargo \
 rust-phf-devel \
 rust-phf_shared+uncased-devel \
 "
RDEPENDS:rust-phf+unicase-devel = " \
 cargo \
 rust-phf-devel \
 rust-phf_macros+default-devel \
 rust-phf_macros+unicase-devel \
 rust-phf_shared+unicase-devel \
 "
RDEPENDS:rust-phf-devel = " \
 cargo \
 rust \
 rust-phf_shared-devel \
 "
