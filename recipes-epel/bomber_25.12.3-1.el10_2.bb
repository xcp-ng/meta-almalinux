# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bomber"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 bomber \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bomber-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd9516da333104ad17966e66ba5f648d7484af6e4f6092366185053138e7f7f9"

URI_x86_64_v2_bomber = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bomber-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bomber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bomber}"
SRC_URI[x86_64_v2_bomber.sha256sum] = "ad6dca6d11fbea0300172b1b9d1168b80a9920b20a1450c42e7ea15d81fcad5a"

URI_aarch64_bomber = "${EPEL_MIRROR}/aarch64/Packages/b/bomber-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_bomber;unpack=0"
SRC_URI:append = " ${URI_aarch64_bomber}"
SRC_URI[aarch64_bomber.sha256sum] = "b76c1effd3166f08ffe830be279702b6c6792bba848969a1afe46ca161b80471"

RDEPENDS:bomber = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
