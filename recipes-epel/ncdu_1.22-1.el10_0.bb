# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ncdu"
PV = "1.22"
PR = "1.el10_0"
PACKAGES = " \
 ncdu \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/ncdu-1.22-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "42ef22851e40356814f661ff6256ec24fd524e3e9b89192dc6666b2f30ba86e8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ncdu-1.22-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ncdu;unpack=0"
SRC_URI[x86_64_v2_ncdu.sha256sum] = "e0f56ee96e846881b62d1cfc739feb6e277698e84cb587fdf7b1270109a876bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/ncdu-1.22-1.el10_0.aarch64.rpm;name=aarch64_ncdu;unpack=0"
SRC_URI[aarch64_ncdu.sha256sum] = "81c7bdc7a73dbe166e6eccf278967258b9a126373a3639b9f7c6231c6d7141d4"

RDEPENDS:ncdu = " \
 glibc \
 ncurses-libs \
 "
