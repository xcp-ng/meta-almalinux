# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnvme"
PV = "1.16.2"
PR = "1.el10"
PACKAGES = " \
 libnvme \
 libnvme-devel \
 python3-libnvme \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libnvme-1.16.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7750ae555f7938aab128bfb206b36a46ed9d0ea91d293e3cdf94350b0f953898"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnvme-1.16.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnvme;unpack=0"
SRC_URI[x86_64_v2_libnvme.sha256sum] = "a9b171fecc1bbaa7fe8c3b5462d053e8cf0cb8ae1197a8470e8f2f7b160f7fb6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnvme-devel-1.16.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnvme-devel;unpack=0"
SRC_URI[x86_64_v2_libnvme-devel.sha256sum] = "3f2c0c75ae69308b49a8a8e062594977f5e3fb4eb1e9637c07e7557367d60eff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnvme-1.16.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libnvme;unpack=0"
SRC_URI[x86_64_v2_python3-libnvme.sha256sum] = "e42826eb6d42cc3295944ca2dbcfb2647cbe92b46490edba7c026a44f9c5851e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnvme-1.16.2-1.el10.aarch64.rpm;name=aarch64_libnvme;unpack=0"
SRC_URI[aarch64_libnvme.sha256sum] = "3e4058eb7d56a013588dc0ce2cd0b72cb2fdc33cd00c4c896aece0e629f43838"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnvme-devel-1.16.2-1.el10.aarch64.rpm;name=aarch64_libnvme-devel;unpack=0"
SRC_URI[aarch64_libnvme-devel.sha256sum] = "8f84c4d688add57e6c7ad8632bf4ab4c9499161ee68d24340854a745dd168151"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnvme-1.16.2-1.el10.aarch64.rpm;name=aarch64_python3-libnvme;unpack=0"
SRC_URI[aarch64_python3-libnvme.sha256sum] = "6d20e67c221b36f19ba64d1567cd1f64fc209ba6b323832060279aca6e0dafee"

RDEPENDS:libnvme = " \
 dbus-libs \
 glibc \
 json-c \
 keyutils-libs \
 libgcc \
 openssl-libs \
 "
RDEPENDS:libnvme-devel = " \
 dbus-devel \
 json-c-devel \
 keyutils-libs-devel \
 libnvme \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libnvme = " \
 glibc \
 libnvme \
 python3 \
 "
