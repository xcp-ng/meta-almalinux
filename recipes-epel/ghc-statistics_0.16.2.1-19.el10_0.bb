# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-statistics"
PV = "0.16.2.1"
PR = "19.el10_0"
PACKAGES = " \
 ghc-dense-linear-algebra \
 ghc-dense-linear-algebra-devel \
 ghc-dense-linear-algebra-doc \
 ghc-dense-linear-algebra-prof \
 ghc-statistics \
 ghc-statistics-devel \
 ghc-statistics-doc \
 ghc-statistics-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-statistics-0.16.2.1-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcc0f143e1071f432d9b7ab5117f2b2d6183748e251ac6e4e7288addca773ada"

URI_x86_64_v2_ghc-dense-linear-algebra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dense-linear-algebra-0.1.0.0-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dense-linear-algebra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dense-linear-algebra}"
SRC_URI[x86_64_v2_ghc-dense-linear-algebra.sha256sum] = "2f4dae3e376a331ac86e8d9d4bf2bf402a5c5033d2680fe65ef97c3a4b870ae9"

URI_x86_64_v2_ghc-dense-linear-algebra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dense-linear-algebra-devel-0.1.0.0-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dense-linear-algebra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dense-linear-algebra-devel}"
SRC_URI[x86_64_v2_ghc-dense-linear-algebra-devel.sha256sum] = "5035c24e1cbd16fc10b26c11d6a2de19eddab7261ddf33634f3ff36eaa21e4a6"

URI_x86_64_v2_ghc-dense-linear-algebra-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dense-linear-algebra-doc-0.1.0.0-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-dense-linear-algebra-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dense-linear-algebra-doc}"
SRC_URI[x86_64_v2_ghc-dense-linear-algebra-doc.sha256sum] = "eaec585ee041c884758cbcf65b9dfaffb0131e01d4aa777bc135015a9216fba7"

URI_x86_64_v2_ghc-dense-linear-algebra-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dense-linear-algebra-prof-0.1.0.0-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dense-linear-algebra-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dense-linear-algebra-prof}"
SRC_URI[x86_64_v2_ghc-dense-linear-algebra-prof.sha256sum] = "be3a16289d071089a4c5bfb885dd1a903e1130e463c5dd5827ab54b9d6a2f1f4"

URI_x86_64_v2_ghc-statistics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-statistics-0.16.2.1-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-statistics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-statistics}"
SRC_URI[x86_64_v2_ghc-statistics.sha256sum] = "8109566344710bad884f60c177cb6d6f57967954bc6b68f998666bd90a0dafe2"

URI_x86_64_v2_ghc-statistics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-statistics-devel-0.16.2.1-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-statistics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-statistics-devel}"
SRC_URI[x86_64_v2_ghc-statistics-devel.sha256sum] = "c78a64fcc5715f31c5c56f0f56f203a151eb124a6448df3e105151fe84cb305c"

URI_x86_64_v2_ghc-statistics-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-statistics-doc-0.16.2.1-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-statistics-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-statistics-doc}"
SRC_URI[x86_64_v2_ghc-statistics-doc.sha256sum] = "791fa2b4c77b8ccdb66374675b8275286f4627365354a1fdccaaa95144a844d5"

URI_x86_64_v2_ghc-statistics-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-statistics-prof-0.16.2.1-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-statistics-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-statistics-prof}"
SRC_URI[x86_64_v2_ghc-statistics-prof.sha256sum] = "e1930714fa06874d7b4f71b92e4d8eb378038ca60cffa132c4845eac780cad78"

URI_aarch64_ghc-dense-linear-algebra = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dense-linear-algebra-0.1.0.0-19.el10_0.aarch64.rpm;name=aarch64_ghc-dense-linear-algebra;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dense-linear-algebra}"
SRC_URI[aarch64_ghc-dense-linear-algebra.sha256sum] = "f51aca52d6734ea4920609d4f92bbffcd2963558c32915726d800fc9d089762d"

URI_aarch64_ghc-dense-linear-algebra-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dense-linear-algebra-devel-0.1.0.0-19.el10_0.aarch64.rpm;name=aarch64_ghc-dense-linear-algebra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dense-linear-algebra-devel}"
SRC_URI[aarch64_ghc-dense-linear-algebra-devel.sha256sum] = "bfb513cde8abd5e2b7d764d05523069295370747291422ccf439a1a0b2228575"

URI_aarch64_ghc-dense-linear-algebra-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dense-linear-algebra-doc-0.1.0.0-19.el10_0.noarch.rpm;name=aarch64_ghc-dense-linear-algebra-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dense-linear-algebra-doc}"
SRC_URI[aarch64_ghc-dense-linear-algebra-doc.sha256sum] = "cd940bbaacf31ab7f1b534f6afa7f01d7f7adec21e03235e1e465254e8f8a366"

URI_aarch64_ghc-dense-linear-algebra-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dense-linear-algebra-prof-0.1.0.0-19.el10_0.aarch64.rpm;name=aarch64_ghc-dense-linear-algebra-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dense-linear-algebra-prof}"
SRC_URI[aarch64_ghc-dense-linear-algebra-prof.sha256sum] = "571798bda44de0ef4afac54e2e8ac0f937ceccbc52b93baaa0f320961c79f239"

URI_aarch64_ghc-statistics = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-statistics-0.16.2.1-19.el10_0.aarch64.rpm;name=aarch64_ghc-statistics;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-statistics}"
SRC_URI[aarch64_ghc-statistics.sha256sum] = "f9f6658fcac2563c379bf5c959ec40ae431893696bc4a363db2ea67b8d2c4638"

URI_aarch64_ghc-statistics-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-statistics-devel-0.16.2.1-19.el10_0.aarch64.rpm;name=aarch64_ghc-statistics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-statistics-devel}"
SRC_URI[aarch64_ghc-statistics-devel.sha256sum] = "af7bc7b8a09caf99b40b5f076b10723e298210853ee1eca5416929222afa67fe"

URI_aarch64_ghc-statistics-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-statistics-doc-0.16.2.1-19.el10_0.noarch.rpm;name=aarch64_ghc-statistics-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-statistics-doc}"
SRC_URI[aarch64_ghc-statistics-doc.sha256sum] = "287113ca0b6493e3ab69be7dd1171899eaf4d45da2e568d15849feaf75d86714"

URI_aarch64_ghc-statistics-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-statistics-prof-0.16.2.1-19.el10_0.aarch64.rpm;name=aarch64_ghc-statistics-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-statistics-prof}"
SRC_URI[aarch64_ghc-statistics-prof.sha256sum] = "d6aabb10edc8c57e162dff7f3802c4e1970df67f52df90a0848cb91133691de9"

RDEPENDS:ghc-dense-linear-algebra = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bitvec \
 ghc-bytestring \
 ghc-containers \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-math-functions \
 ghc-pretty \
 ghc-primitive \
 ghc-template-haskell \
 ghc-transformers \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-binary-instances \
 ghc-vector-stream \
 ghc-vector-th-unbox \
 glibc \
 gmp \
 "
RDEPENDS:ghc-dense-linear-algebra-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-dense-linear-algebra \
 ghc-math-functions-devel \
 ghc-primitive-devel \
 ghc-vector-algorithms-devel \
 ghc-vector-binary-instances-devel \
 ghc-vector-devel \
 ghc-vector-th-unbox-devel \
 "
RDEPENDS:ghc-dense-linear-algebra-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-dense-linear-algebra-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-dense-linear-algebra-devel \
 ghc-math-functions-prof \
 ghc-primitive-prof \
 ghc-vector-algorithms-prof \
 ghc-vector-binary-instances-prof \
 ghc-vector-prof \
 ghc-vector-th-unbox-prof \
 "
RDEPENDS:ghc-statistics = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-dense-linear-algebra \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-math-functions \
 ghc-mtl \
 ghc-mwc-random \
 ghc-os-string \
 ghc-parallel \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-binary-instances \
 ghc-vector-stream \
 ghc-vector-th-unbox \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-statistics-devel = " \
 ghc-aeson-devel \
 ghc-async-devel \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-compiler \
 ghc-data-default-class-devel \
 ghc-deepseq-devel \
 ghc-dense-linear-algebra-devel \
 ghc-math-functions-devel \
 ghc-mwc-random-devel \
 ghc-parallel-devel \
 ghc-primitive-devel \
 ghc-random-devel \
 ghc-statistics \
 ghc-vector-algorithms-devel \
 ghc-vector-binary-instances-devel \
 ghc-vector-devel \
 ghc-vector-th-unbox-devel \
 "
RDEPENDS:ghc-statistics-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-statistics-prof = " \
 ghc-aeson-prof \
 ghc-async-prof \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-data-default-class-prof \
 ghc-deepseq-prof \
 ghc-dense-linear-algebra-prof \
 ghc-math-functions-prof \
 ghc-mwc-random-prof \
 ghc-parallel-prof \
 ghc-primitive-prof \
 ghc-random-prof \
 ghc-statistics-devel \
 ghc-vector-algorithms-prof \
 ghc-vector-binary-instances-prof \
 ghc-vector-prof \
 ghc-vector-th-unbox-prof \
 "
