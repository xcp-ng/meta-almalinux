# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sqlx-core"
PV = "0.8.6"
PR = "4.el10_2"
PACKAGES = " \
 rust-sqlx-core+_rt-tokio-devel \
 rust-sqlx-core+_tls-native-tls-devel \
 rust-sqlx-core+_tls-none-devel \
 rust-sqlx-core+_tls-rustls-devel \
 rust-sqlx-core+_tls-rustls-ring-native-roots-devel \
 rust-sqlx-core+_tls-rustls-ring-webpki-devel \
 rust-sqlx-core+any-devel \
 rust-sqlx-core+bigdecimal-devel \
 rust-sqlx-core+bit-vec-devel \
 rust-sqlx-core+bstr-devel \
 rust-sqlx-core+chrono-devel \
 rust-sqlx-core+crc-devel \
 rust-sqlx-core+default-devel \
 rust-sqlx-core+ipnet-devel \
 rust-sqlx-core+ipnetwork-devel \
 rust-sqlx-core+json-devel \
 rust-sqlx-core+mac_address-devel \
 rust-sqlx-core+migrate-devel \
 rust-sqlx-core+native-tls-devel \
 rust-sqlx-core+offline-devel \
 rust-sqlx-core+regex-devel \
 rust-sqlx-core+rust_decimal-devel \
 rust-sqlx-core+rustls-devel \
 rust-sqlx-core+rustls-native-certs-devel \
 rust-sqlx-core+serde-devel \
 rust-sqlx-core+serde_json-devel \
 rust-sqlx-core+sha2-devel \
 rust-sqlx-core+time-devel \
 rust-sqlx-core+tokio-devel \
 rust-sqlx-core+tokio-stream-devel \
 rust-sqlx-core+uuid-devel \
 rust-sqlx-core+webpki-roots-devel \
 rust-sqlx-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sqlx-core-0.8.6-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "082c00bd8fd6d03336892eddccb8e6c6dc0a5924cb47225ab9249275d651fadc"

URI_x86_64_v2_rust-sqlx-core+_rt-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+_rt-tokio-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+_rt-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+_rt-tokio-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+_rt-tokio-devel.sha256sum] = "3b39b54d6603674e2b7fa43765ae6e7e874bdd178a11ff5b65af06799a7a44b4"

URI_x86_64_v2_rust-sqlx-core+_tls-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+_tls-native-tls-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+_tls-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+_tls-native-tls-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+_tls-native-tls-devel.sha256sum] = "bde174ab938cfbf7125a208f28631e8c9c1f4cffcea4c35255513a38a5bfd852"

URI_x86_64_v2_rust-sqlx-core+_tls-none-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+_tls-none-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+_tls-none-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+_tls-none-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+_tls-none-devel.sha256sum] = "78378c7bafb3f2a90429efb98867803d20df6e6ff22cc24813f75fa4587cb434"

URI_x86_64_v2_rust-sqlx-core+_tls-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+_tls-rustls-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+_tls-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+_tls-rustls-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+_tls-rustls-devel.sha256sum] = "df5c300b7d93acf743eed646f816165359779a5efc9f0c22a94cfb2ba088fa5c"

URI_x86_64_v2_rust-sqlx-core+_tls-rustls-ring-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+_tls-rustls-ring-native-roots-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+_tls-rustls-ring-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+_tls-rustls-ring-native-roots-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+_tls-rustls-ring-native-roots-devel.sha256sum] = "460f1bbd7c85c79784fe95dea97a18d32c706605888e61e64be774fdf302466f"

URI_x86_64_v2_rust-sqlx-core+_tls-rustls-ring-webpki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+_tls-rustls-ring-webpki-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+_tls-rustls-ring-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+_tls-rustls-ring-webpki-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+_tls-rustls-ring-webpki-devel.sha256sum] = "db0739daf3cff327dd7fe304c640ce81d20ebed0b412dfaafe49d5756ee5a289"

URI_x86_64_v2_rust-sqlx-core+any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+any-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+any-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+any-devel.sha256sum] = "8c921e4ff4cb62d3ea6f0d2d773aaa3385aac8072d26dd6217b4058cd4bc5b1a"

URI_x86_64_v2_rust-sqlx-core+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+bigdecimal-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+bigdecimal-devel.sha256sum] = "5e28467b9d5dfe05e1afb366b3786a5c9ea10643d29f77fb5924710e9770c1ad"

URI_x86_64_v2_rust-sqlx-core+bit-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+bit-vec-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+bit-vec-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+bit-vec-devel.sha256sum] = "f5242d1f4801c86e14ae67831bf86ba6485c13eceb29c0e349aeb289cf0c9dbf"

URI_x86_64_v2_rust-sqlx-core+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+bstr-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+bstr-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+bstr-devel.sha256sum] = "c752c23a1825f07bbb75ec634eac5eecc6b1d8b2b95debb56b25aef8fff0c981"

URI_x86_64_v2_rust-sqlx-core+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+chrono-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+chrono-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+chrono-devel.sha256sum] = "de351561330cada4fa119d123bd925eb50d697a2e43518b070d66a1044b362ac"

URI_x86_64_v2_rust-sqlx-core+crc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+crc-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+crc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+crc-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+crc-devel.sha256sum] = "931fe2e77338a83ded88bcdce0f196d741e593f785d45b4121b949d9b9c0df4e"

URI_x86_64_v2_rust-sqlx-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+default-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+default-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+default-devel.sha256sum] = "5e9faf162625a3b1266d272703775c8c14169a3beedada89b6b84c2e3cac2aa1"

URI_x86_64_v2_rust-sqlx-core+ipnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+ipnet-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+ipnet-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+ipnet-devel.sha256sum] = "5fc27d5205a43ba3e55240baefd1d4797d258122141e1b0016db03b35d574ed6"

URI_x86_64_v2_rust-sqlx-core+ipnetwork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+ipnetwork-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+ipnetwork-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+ipnetwork-devel.sha256sum] = "7b6e52f7130ad2667dbc26ed61a59ac5cab88c535f0bb71820bd6051559a2267"

URI_x86_64_v2_rust-sqlx-core+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+json-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+json-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+json-devel.sha256sum] = "55faca11648f79bd154f001f0aefd86cd44afb1b4a2eb132c6d8959fd2c0bda4"

URI_x86_64_v2_rust-sqlx-core+mac_address-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+mac_address-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+mac_address-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+mac_address-devel.sha256sum] = "c52e96d8333cc9f94ad629aa1ee7efef7eeefcc177ec749a21df301954e3d8dc"

URI_x86_64_v2_rust-sqlx-core+migrate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+migrate-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+migrate-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+migrate-devel.sha256sum] = "ff98501e816e0fd618ea28d2394db2f849d4a1ea0f90ee6bc05d734b8ccc3a07"

URI_x86_64_v2_rust-sqlx-core+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+native-tls-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+native-tls-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+native-tls-devel.sha256sum] = "51bc0821a1d9ac923272e342773eecccf04afbb9e5d29c581aaf8402c1f75220"

URI_x86_64_v2_rust-sqlx-core+offline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+offline-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+offline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+offline-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+offline-devel.sha256sum] = "6769fde279529734598471f67c6927dda9ab438175a8e3cbe9ea0091d67bb6e6"

URI_x86_64_v2_rust-sqlx-core+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+regex-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+regex-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+regex-devel.sha256sum] = "ca96e9d81d6a2de5628951bc5f1d6108519176a946ec16768ec0f945a06f35e3"

URI_x86_64_v2_rust-sqlx-core+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+rust_decimal-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+rust_decimal-devel.sha256sum] = "f5db5ca10354305105640aa8e7513304ca26462a29277152c9729d0f6d302bba"

URI_x86_64_v2_rust-sqlx-core+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+rustls-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+rustls-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+rustls-devel.sha256sum] = "f7459986b11a458d04b7a28b702ec65134dadbed27568460448d2511cc811793"

URI_x86_64_v2_rust-sqlx-core+rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+rustls-native-certs-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+rustls-native-certs-devel.sha256sum] = "66fee665701ba705e7b86e543a90a3947329447786bec632015a0b9d9729c86a"

URI_x86_64_v2_rust-sqlx-core+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+serde-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+serde-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+serde-devel.sha256sum] = "93648cd54aee18509cf7dd38caaf4e6b70ced30cbf6ab3e67adeabe4ec1d1870"

URI_x86_64_v2_rust-sqlx-core+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+serde_json-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+serde_json-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+serde_json-devel.sha256sum] = "0489cf1dc11e5b25552f14a181a6156fc0031e9dad2327160f8827375164acdc"

URI_x86_64_v2_rust-sqlx-core+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+sha2-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+sha2-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+sha2-devel.sha256sum] = "500c1511cb279314abb4e59dbfafb0829d1d3cdbfc0f1f5f6b0997d7f0d7bc2e"

URI_x86_64_v2_rust-sqlx-core+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+time-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+time-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+time-devel.sha256sum] = "6f3a93acc19af6a64f3aea1594facb15899ffbd78d6a961452c1953012d9e173"

URI_x86_64_v2_rust-sqlx-core+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+tokio-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+tokio-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+tokio-devel.sha256sum] = "63f99574299a434737651aeb39e1168cc1e7ce1e1914fe830eaddca00c7356fd"

URI_x86_64_v2_rust-sqlx-core+tokio-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+tokio-stream-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+tokio-stream-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+tokio-stream-devel.sha256sum] = "e28a9ea6a4cc9f838b05e6385762d5e01d40c620ad2397455351c01107f1ac65"

URI_x86_64_v2_rust-sqlx-core+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+uuid-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+uuid-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+uuid-devel.sha256sum] = "2aadfb023084f0f2e6c0c4a7a817a42a16d7fbc5404d7d26099e6d81c778b334"

URI_x86_64_v2_rust-sqlx-core+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+webpki-roots-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+webpki-roots-devel.sha256sum] = "6f1c1f46ed0fca4b2f25d97f685e52b1c873aad7d3a89289c128612d3eaec182"

URI_x86_64_v2_rust-sqlx-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core-devel.sha256sum] = "d4f724bce69caa43e8a52c1be255219ce5a0f8eee76ae02f9530abf89d5b1da8"

URI_aarch64_rust-sqlx-core+_rt-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+_rt-tokio-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+_rt-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+_rt-tokio-devel}"
SRC_URI[aarch64_rust-sqlx-core+_rt-tokio-devel.sha256sum] = "c6a61e0736092836799908b88b4927313047f30c91bdecf366da54125c6f68fc"

URI_aarch64_rust-sqlx-core+_tls-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+_tls-native-tls-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+_tls-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+_tls-native-tls-devel}"
SRC_URI[aarch64_rust-sqlx-core+_tls-native-tls-devel.sha256sum] = "d3158870e3d87d0be0359053ffc00f8129087763b253e928d170afd2bdc96d59"

URI_aarch64_rust-sqlx-core+_tls-none-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+_tls-none-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+_tls-none-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+_tls-none-devel}"
SRC_URI[aarch64_rust-sqlx-core+_tls-none-devel.sha256sum] = "b9699684a928cd553e0d1bdf1777c6732b0bbbb7d9907403a42cfdab641e9fb8"

URI_aarch64_rust-sqlx-core+_tls-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+_tls-rustls-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+_tls-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+_tls-rustls-devel}"
SRC_URI[aarch64_rust-sqlx-core+_tls-rustls-devel.sha256sum] = "8f54921c05cc47c309209da9903ec4bd7ddc2bf45f27cf7cda0142af03528a85"

URI_aarch64_rust-sqlx-core+_tls-rustls-ring-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+_tls-rustls-ring-native-roots-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+_tls-rustls-ring-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+_tls-rustls-ring-native-roots-devel}"
SRC_URI[aarch64_rust-sqlx-core+_tls-rustls-ring-native-roots-devel.sha256sum] = "815338af8a28737aff443c3ef03b6085eacd71561acf7c13f4473e06bf1c0ca9"

URI_aarch64_rust-sqlx-core+_tls-rustls-ring-webpki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+_tls-rustls-ring-webpki-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+_tls-rustls-ring-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+_tls-rustls-ring-webpki-devel}"
SRC_URI[aarch64_rust-sqlx-core+_tls-rustls-ring-webpki-devel.sha256sum] = "1cbf586500ae93336918de82e5b94ece7fcaa29b507e727206790a03f8382b41"

URI_aarch64_rust-sqlx-core+any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+any-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+any-devel}"
SRC_URI[aarch64_rust-sqlx-core+any-devel.sha256sum] = "9314a0269267d846cb9f49e971e42db2fb862fb308b672dd21abf760c1f8ed2c"

URI_aarch64_rust-sqlx-core+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+bigdecimal-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+bigdecimal-devel}"
SRC_URI[aarch64_rust-sqlx-core+bigdecimal-devel.sha256sum] = "5ee80b14c37b1e1e50f5689d0afeb90653a64691c465a3fe0e8103964776fb7e"

URI_aarch64_rust-sqlx-core+bit-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+bit-vec-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+bit-vec-devel}"
SRC_URI[aarch64_rust-sqlx-core+bit-vec-devel.sha256sum] = "653b7eb8f2c35300c1d6d33330b90258cfac3936794bd56c46243a71fb801242"

URI_aarch64_rust-sqlx-core+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+bstr-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+bstr-devel}"
SRC_URI[aarch64_rust-sqlx-core+bstr-devel.sha256sum] = "7ce02581df16a550c3c2864ebd7f615bff698e3596b5c0f413ab239ac5867605"

URI_aarch64_rust-sqlx-core+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+chrono-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+chrono-devel}"
SRC_URI[aarch64_rust-sqlx-core+chrono-devel.sha256sum] = "cea5037689638edfa655d5b760f5ceef8d27e2f4a116e1eb49e334cd6409511d"

URI_aarch64_rust-sqlx-core+crc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+crc-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+crc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+crc-devel}"
SRC_URI[aarch64_rust-sqlx-core+crc-devel.sha256sum] = "ef2c501a52705f84a15eabb216735d94c8f3c14b824002e1f356431dec832a05"

URI_aarch64_rust-sqlx-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+default-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+default-devel}"
SRC_URI[aarch64_rust-sqlx-core+default-devel.sha256sum] = "f93030556ffbe94ad5edadd2956f71a34d4d890a3cfa277def02d255dc76edba"

URI_aarch64_rust-sqlx-core+ipnet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+ipnet-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+ipnet-devel}"
SRC_URI[aarch64_rust-sqlx-core+ipnet-devel.sha256sum] = "b376bd42b35219deab9139809f5e43a92bd4a282b4474be3413d46cd8a462c28"

URI_aarch64_rust-sqlx-core+ipnetwork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+ipnetwork-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+ipnetwork-devel}"
SRC_URI[aarch64_rust-sqlx-core+ipnetwork-devel.sha256sum] = "e311ebd1e666f5a850f992af33c856bf7d4bd68a56a06ac38250e19b9e21485a"

URI_aarch64_rust-sqlx-core+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+json-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+json-devel}"
SRC_URI[aarch64_rust-sqlx-core+json-devel.sha256sum] = "c8411267be7073011948778ddb122ff2710cae61344f65ddaabebcc2e8afb699"

URI_aarch64_rust-sqlx-core+mac_address-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+mac_address-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+mac_address-devel}"
SRC_URI[aarch64_rust-sqlx-core+mac_address-devel.sha256sum] = "c798d84427fc918c4ac559560359e775672f2cbd81df439b73ff6fa1a61ca4d8"

URI_aarch64_rust-sqlx-core+migrate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+migrate-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+migrate-devel}"
SRC_URI[aarch64_rust-sqlx-core+migrate-devel.sha256sum] = "c96a5da5b34066e6b7cd09f74693d274a01eead57819f9dc21877771dedb2d1c"

URI_aarch64_rust-sqlx-core+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+native-tls-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+native-tls-devel}"
SRC_URI[aarch64_rust-sqlx-core+native-tls-devel.sha256sum] = "acb0dafdc6cef6a54ad7dd1d2e392406f42b37199e6301edadb05b1f6d5680e2"

URI_aarch64_rust-sqlx-core+offline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+offline-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+offline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+offline-devel}"
SRC_URI[aarch64_rust-sqlx-core+offline-devel.sha256sum] = "62949770d6972c5fc434645ad7a7b77766f94eb15a836a208f99923c1e62a1cb"

URI_aarch64_rust-sqlx-core+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+regex-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+regex-devel}"
SRC_URI[aarch64_rust-sqlx-core+regex-devel.sha256sum] = "bceead3bda1779029e0101e6b1fc1dbd034ff2d98fdb4986f839129b37f1a725"

URI_aarch64_rust-sqlx-core+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+rust_decimal-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+rust_decimal-devel}"
SRC_URI[aarch64_rust-sqlx-core+rust_decimal-devel.sha256sum] = "9b533e001778d100fe2dca00edebb872f02684de505fe14300c9be4e70b6d9cc"

URI_aarch64_rust-sqlx-core+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+rustls-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+rustls-devel}"
SRC_URI[aarch64_rust-sqlx-core+rustls-devel.sha256sum] = "714a40b37552978fc93e88f0d0d9a5847417e14410d391320c1e18db5e28f4db"

URI_aarch64_rust-sqlx-core+rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+rustls-native-certs-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+rustls-native-certs-devel}"
SRC_URI[aarch64_rust-sqlx-core+rustls-native-certs-devel.sha256sum] = "b5cc93c24ba182a4677fb4d9ed0fd07eaf3eed75dede0b3d2fce0bd4597e3df7"

URI_aarch64_rust-sqlx-core+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+serde-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+serde-devel}"
SRC_URI[aarch64_rust-sqlx-core+serde-devel.sha256sum] = "943c8aa80928ff1d9636c125afc3469ceac4c9117287cac8b1f26849f820c291"

URI_aarch64_rust-sqlx-core+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+serde_json-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+serde_json-devel}"
SRC_URI[aarch64_rust-sqlx-core+serde_json-devel.sha256sum] = "27e372085c0de6aeeebec1cc351ad23568554a670aa2cc06acbee3f97a0352d5"

URI_aarch64_rust-sqlx-core+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+sha2-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+sha2-devel}"
SRC_URI[aarch64_rust-sqlx-core+sha2-devel.sha256sum] = "9783dc6bb7d7761568a81f1795d506d793bc0c0c4b048f09c7a8962c9cd700a5"

URI_aarch64_rust-sqlx-core+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+time-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+time-devel}"
SRC_URI[aarch64_rust-sqlx-core+time-devel.sha256sum] = "60fe4f25b85479896c8612debed8b67309ebb812c923228be61f64dc6f3ffcd2"

URI_aarch64_rust-sqlx-core+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+tokio-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+tokio-devel}"
SRC_URI[aarch64_rust-sqlx-core+tokio-devel.sha256sum] = "8897815fab3ba48c891e785471426ba74953b4b43ec0c0dfa600bcb9529dffb8"

URI_aarch64_rust-sqlx-core+tokio-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+tokio-stream-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+tokio-stream-devel}"
SRC_URI[aarch64_rust-sqlx-core+tokio-stream-devel.sha256sum] = "bedbd38561c0a21b1598be666e11020412e66e3148a548209d27220265ce233d"

URI_aarch64_rust-sqlx-core+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+uuid-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+uuid-devel}"
SRC_URI[aarch64_rust-sqlx-core+uuid-devel.sha256sum] = "c935f6227e1e18a3e4cf6af613cc2e9f9934b4cfaf192e992f086bbf17e2fc12"

URI_aarch64_rust-sqlx-core+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+webpki-roots-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+webpki-roots-devel}"
SRC_URI[aarch64_rust-sqlx-core+webpki-roots-devel.sha256sum] = "e7b9d30daa0bd5c02b947fa8c5506b474c7ea0e09d52c11c2a40bc6ac9a5194f"

URI_aarch64_rust-sqlx-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core-devel}"
SRC_URI[aarch64_rust-sqlx-core-devel.sha256sum] = "2cb18a4949184fdd197d888288d55540fa88d565b10b9daf8662b0103ef85777"

RDEPENDS:rust-sqlx-core+_rt-tokio-devel = " \
 cargo \
 rust-sqlx-core+tokio-devel \
 rust-sqlx-core+tokio-stream-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+_tls-native-tls-devel = " \
 cargo \
 rust-sqlx-core+native-tls-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+_tls-none-devel = " \
 cargo \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+_tls-rustls-devel = " \
 cargo \
 rust-sqlx-core+rustls-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+_tls-rustls-ring-native-roots-devel = " \
 cargo \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-sqlx-core+_tls-rustls-devel \
 rust-sqlx-core+rustls-native-certs-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+_tls-rustls-ring-webpki-devel = " \
 cargo \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-sqlx-core+_tls-rustls-devel \
 rust-sqlx-core+webpki-roots-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+any-devel = " \
 cargo \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+bigdecimal-devel = " \
 cargo \
 rust-bigdecimal+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+bit-vec-devel = " \
 cargo \
 rust-bit-vec0.6+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+bstr-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+crc-devel = " \
 cargo \
 rust-crc+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+default-devel = " \
 cargo \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+ipnet-devel = " \
 cargo \
 rust-ipnet+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+ipnetwork-devel = " \
 cargo \
 rust-ipnetwork+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+json-devel = " \
 cargo \
 rust-sqlx-core+serde-devel \
 rust-sqlx-core+serde_json-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+mac_address-devel = " \
 cargo \
 rust-mac_address+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+migrate-devel = " \
 cargo \
 rust-sqlx-core+crc-devel \
 rust-sqlx-core+sha2-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+native-tls-devel = " \
 cargo \
 rust-native-tls+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+offline-devel = " \
 cargo \
 rust-either+serde-devel \
 rust-sqlx-core+serde-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+regex-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+rust_decimal-devel = " \
 cargo \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+rustls-devel = " \
 cargo \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+rustls-native-certs-devel = " \
 cargo \
 rust-rustls-native-certs+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+serde_json-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-serde_json+raw_value-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+sha2-devel = " \
 cargo \
 rust-sha2-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+time-devel = " \
 cargo \
 rust-sqlx-core-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-sqlx-core+tokio-devel = " \
 cargo \
 rust-sqlx-core-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-sqlx-core+tokio-stream-devel = " \
 cargo \
 rust-sqlx-core-devel \
 rust-tokio-stream+default-devel \
 rust-tokio-stream+fs-devel \
 "
RDEPENDS:rust-sqlx-core+uuid-devel = " \
 cargo \
 rust-sqlx-core-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-sqlx-core+webpki-roots-devel = " \
 cargo \
 rust-sqlx-core-devel \
 rust-webpki-roots0.26+default-devel \
 "
RDEPENDS:rust-sqlx-core-devel = " \
 cargo \
 rust-base64+std-devel \
 rust-base64-devel \
 rust-bytes+default-devel \
 rust-crossbeam-queue+default-devel \
 rust-either+default-devel \
 rust-event-listener+default-devel \
 rust-futures-core-devel \
 rust-futures-intrusive+default-devel \
 rust-futures-io+default-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util+io-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 rust-hashbrown0.15+default-devel \
 rust-hashlink0.10+default-devel \
 rust-indexmap+default-devel \
 rust-log-devel \
 rust-memchr-devel \
 rust-once_cell+default-devel \
 rust-percent-encoding+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 rust-tracing+default-devel \
 rust-tracing+log-devel \
 rust-url+default-devel \
 "
