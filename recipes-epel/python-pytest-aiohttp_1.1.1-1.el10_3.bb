# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-aiohttp"
PV = "1.1.1"
PR = "1.el10_3"
PACKAGES = " \
 python3-pytest-aiohttp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-aiohttp-1.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65da449eefb83d0ad2ec6bbade74ca6e417bdc61770eeefa7bf99f4588b2821c"

URI_x86_64_v2_python3-pytest-aiohttp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-aiohttp-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-aiohttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-aiohttp}"
SRC_URI[x86_64_v2_python3-pytest-aiohttp.sha256sum] = "d27fc23508b510ed7af271a62af7be3c57236a796482eed518aa5f0a15e23ee5"

URI_aarch64_python3-pytest-aiohttp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-aiohttp-1.1.1-1.el10_3.noarch.rpm;name=aarch64_python3-pytest-aiohttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-aiohttp}"
SRC_URI[aarch64_python3-pytest-aiohttp.sha256sum] = "1a6be2017a619046c5502d855ac215f1f5856cdf88098a061f57da4a93aba72d"

RDEPENDS:python3-pytest-aiohttp = " \
 python3 \
 python3-aiohttp \
 python3-pytest \
 python3-pytest-asyncio \
 "
