# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-Builder"
PV = "0.020"
PR = "2.el10_2"
PACKAGES = " \
 perl-ExtUtils-Builder \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-ExtUtils-Builder-0.020-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8baa0cf931318d514f9ac077d959b175756333342ba6a6e3636fff73ebf73284"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-Builder-0.020-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Builder;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-Builder.sha256sum] = "948cc1756519e727bc2f31fd574bd6108ac9f92c98831a4dd64e0afd6a8046b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-Builder-0.020-2.el10_2.noarch.rpm;name=aarch64_perl-ExtUtils-Builder;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-Builder.sha256sum] = "9d04a8d7bb15a15dd42a4cc0068f75bab7166fc74a994a11cf856f8bcac51ca8"

RDEPENDS:perl-ExtUtils-Builder = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-ExtUtils-Builder \
 perl-ExtUtils-Config \
 perl-ExtUtils-Helpers \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-File-Basename \
 perl-PathTools \
 perl-Perl-OSType \
 perl-Scalar-List-Utils \
 perl-base \
 perl-libs \
 perl-parent \
 perl-version \
 "
