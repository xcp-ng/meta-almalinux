# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mbox-importer"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 mbox-importer \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/mbox-importer-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ce907171a8a2a75272f6bfa9d8a2c0b8a79ea6db5e5afc0da2a09be90ffe9c3d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbox-importer-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mbox-importer;unpack=0"
SRC_URI[x86_64_v2_mbox-importer.sha256sum] = "d6e50f1eab1a4566dfe34e1f88cefc04b498c80772500e2dc2e071b8480f408b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mbox-importer-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_mbox-importer;unpack=0"
SRC_URI[aarch64_mbox-importer.sha256sum] = "0a068e970743127600f9cb17e08496e6e948f20b1aa776a277ef98f400999016"

RDEPENDS:mbox-importer = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 libgcc \
 libstdc++ \
 mailcommon \
 mailimporter \
 mailimporter-akonadi \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
