# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-dev-scripts"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kde-dev-scripts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-dev-scripts-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c53f748f4721b9ca6102cfe69611f4583b11cc39df6496cdb920e3d00dd135b"

URI_x86_64_v2_kde-dev-scripts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-dev-scripts-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kde-dev-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-dev-scripts}"
SRC_URI[x86_64_v2_kde-dev-scripts.sha256sum] = "fb9c2db1a45686502afac217035d777de8342d5ca5ff46c3a6fb718548d630c7"

URI_aarch64_kde-dev-scripts = "${EPEL_MIRROR}/aarch64/Packages/k/kde-dev-scripts-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kde-dev-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-dev-scripts}"
SRC_URI[aarch64_kde-dev-scripts.sha256sum] = "93010e32370b9154c7db635bdeddc31d3944fca9417f799e4f32039e538415d4"

RDEPENDS:kde-dev-scripts = " \
 advancecomp \
 bash \
 optipng \
 perl-Data-Dumper \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Term-ANSIColor \
 perl-Time-Local \
 perl-XML-DOM \
 perl-constant \
 perl-interpreter \
 perl-libs \
 python3 \
 "
