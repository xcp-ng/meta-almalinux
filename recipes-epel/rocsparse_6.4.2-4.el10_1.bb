# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocsparse"
PV = "6.4.2"
PR = "4.el10_1"
PACKAGES:x86_64_v2 = " \
 rocsparse \
 rocsparse-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocsparse-6.4.2-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afe7ecc2cd423e4547c61ce326b89e960ac74979cd349efa6bbe2c9aa6add355"

URI_x86_64_v2_rocsparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocsparse-6.4.2-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocsparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocsparse}"
SRC_URI[x86_64_v2_rocsparse.sha256sum] = "4cb39a7d837f69d2fad79b71d034fcf4741a62da760555f1b703ad69c4b2ad49"

URI_x86_64_v2_rocsparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocsparse-devel-6.4.2-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocsparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocsparse-devel}"
SRC_URI[x86_64_v2_rocsparse-devel.sha256sum] = "e903df89b7da9036c9d9bfd6ceef4f518e0461239c28da58632f82af020d509b"

RDEPENDS:rocsparse = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 "
RDEPENDS:rocsparse-devel = " \
 cmake-filesystem \
 rocsparse \
 "
