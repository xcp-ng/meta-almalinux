# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-WWW-Curl"
PV = "4.17"
PR = "48.el10_2"
PACKAGES = " \
 perl-WWW-Curl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-WWW-Curl-4.17-48.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79ea588eba0134eaf9937e040e8a0f2c8aa29ddd228cefa2362499067b6997d1"

URI_x86_64_v2_perl-WWW-Curl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-WWW-Curl-4.17-48.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-WWW-Curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-WWW-Curl}"
SRC_URI[x86_64_v2_perl-WWW-Curl.sha256sum] = "bb56760efcf212fc031b43d5636fde5d96d08e1d025d7c013e5b3830cd74bfb7"

URI_aarch64_perl-WWW-Curl = "${EPEL_MIRROR}/aarch64/Packages/p/perl-WWW-Curl-4.17-48.el10_2.aarch64.rpm;name=aarch64_perl-WWW-Curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-WWW-Curl}"
SRC_URI[aarch64_perl-WWW-Curl.sha256sum] = "53ffc3dea48683bc4bdd24913a3fb9ce4d09c6e3d1d1b0c8a1a9183af56cd142"

RDEPENDS:perl-WWW-Curl = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-WWW-Curl \
 perl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
