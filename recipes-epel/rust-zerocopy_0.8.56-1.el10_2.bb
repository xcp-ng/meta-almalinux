# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerocopy"
PV = "0.8.56"
PR = "1.el10_2"
PACKAGES = " \
 rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel \
 rust-zerocopy+alloc-devel \
 rust-zerocopy+default-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+float-nightly-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy+simd-nightly-devel \
 rust-zerocopy+std-devel \
 rust-zerocopy+zerocopy-derive-devel \
 rust-zerocopy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerocopy-0.8.56-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2c5410cb0bde46add2933049e269b495b331adb160d8805b2ba32cb8c23f324"

URI_x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel-0.8.56-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel.sha256sum] = "b7a984edc05f1fdaac092cdb2ff5ad27fa0be3ea3e177ac1c0e0235a82f26363"

URI_x86_64_v2_rust-zerocopy+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+alloc-devel-0.8.56-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+alloc-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+alloc-devel.sha256sum] = "264f89602039ce7c3e8be93d09d5f892273260d74f8766b115a20321c1b6e175"

URI_x86_64_v2_rust-zerocopy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+default-devel-0.8.56-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+default-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+default-devel.sha256sum] = "9f7ca0d42db9576b2b6a93aaa1a4c1a353b6cb6217b24028315af895a0c58d2e"

URI_x86_64_v2_rust-zerocopy+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+derive-devel-0.8.56-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+derive-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+derive-devel.sha256sum] = "c99c228a81ab89eebed24aa86fac940760272f676d5ec0016e6c8b620339ebbf"

URI_x86_64_v2_rust-zerocopy+float-nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+float-nightly-devel-0.8.56-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+float-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+float-nightly-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+float-nightly-devel.sha256sum] = "72795a6ffb3f068f56f7cd2236f77e18ba6537f3e4d5f6a539fd2f96d521b11c"

URI_x86_64_v2_rust-zerocopy+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+simd-devel-0.8.56-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+simd-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+simd-devel.sha256sum] = "48947f72f0e2446fc16ad4f74893766b543105c24ddbd7f1f3f3000b5cebd07f"

URI_x86_64_v2_rust-zerocopy+simd-nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+simd-nightly-devel-0.8.56-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+simd-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+simd-nightly-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+simd-nightly-devel.sha256sum] = "f749ca16f540d7b340c9e7a156da46209f75559b21a0f8d424f6620a0372f8e4"

URI_x86_64_v2_rust-zerocopy+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+std-devel-0.8.56-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+std-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+std-devel.sha256sum] = "42bedffd9f49b1853bc41f8d0bda4aad71b64ca32c4fe230f4d124a71f27b627"

URI_x86_64_v2_rust-zerocopy+zerocopy-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+zerocopy-derive-devel-0.8.56-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+zerocopy-derive-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+zerocopy-derive-devel.sha256sum] = "006d48d02fd91eba0a8da301e072b4893b254ebbd9de288785ed4e6f6b7ce877"

URI_x86_64_v2_rust-zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-devel-0.8.56-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy-devel}"
SRC_URI[x86_64_v2_rust-zerocopy-devel.sha256sum] = "ca38c0ceb90516dc4138fbacbde60454e3144a597efa84d56779a16274510213"

URI_aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel-0.8.56-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel}"
SRC_URI[aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel.sha256sum] = "49ef70528333b27cae20cbee62118905fcd8c9f0af9d15c4b28e6d6560b818b8"

URI_aarch64_rust-zerocopy+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+alloc-devel-0.8.56-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+alloc-devel}"
SRC_URI[aarch64_rust-zerocopy+alloc-devel.sha256sum] = "d32396c8c05513bae84b423d0049f1dfb9d718d78d88ffee84183a0ff5079949"

URI_aarch64_rust-zerocopy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+default-devel-0.8.56-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+default-devel}"
SRC_URI[aarch64_rust-zerocopy+default-devel.sha256sum] = "528fe1fc0eabcb9ed5b30946100d78205029c5dcaa17e88c41c7a7497e99d089"

URI_aarch64_rust-zerocopy+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+derive-devel-0.8.56-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+derive-devel}"
SRC_URI[aarch64_rust-zerocopy+derive-devel.sha256sum] = "8a023b656cd24f9926d7c69f73fa29b9ac28dcc9ded8d1d853cf278eb03d5959"

URI_aarch64_rust-zerocopy+float-nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+float-nightly-devel-0.8.56-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+float-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+float-nightly-devel}"
SRC_URI[aarch64_rust-zerocopy+float-nightly-devel.sha256sum] = "7cf6a82d999fe7acd3866a8e08ed99d04992f1c72a3e08a4ac21040a8927c287"

URI_aarch64_rust-zerocopy+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+simd-devel-0.8.56-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+simd-devel}"
SRC_URI[aarch64_rust-zerocopy+simd-devel.sha256sum] = "5f4bfb20aab8c98eca7ac17514034cbc887d4bfc332e82195c5cd75004860bf6"

URI_aarch64_rust-zerocopy+simd-nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+simd-nightly-devel-0.8.56-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+simd-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+simd-nightly-devel}"
SRC_URI[aarch64_rust-zerocopy+simd-nightly-devel.sha256sum] = "27fa17eb380653049f52d7c13d9d8968dca77af393e07b2944c5593b66882262"

URI_aarch64_rust-zerocopy+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+std-devel-0.8.56-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+std-devel}"
SRC_URI[aarch64_rust-zerocopy+std-devel.sha256sum] = "b60e43630e0f056b4592fd1fa17aba4eb41c167d368137f5a58b9812ad67e311"

URI_aarch64_rust-zerocopy+zerocopy-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+zerocopy-derive-devel-0.8.56-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+zerocopy-derive-devel}"
SRC_URI[aarch64_rust-zerocopy+zerocopy-derive-devel.sha256sum] = "2492a62d282ebfec73388c497131f6b0adf5a33503c786ec7a9b9f991460275e"

URI_aarch64_rust-zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-devel-0.8.56-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy-devel}"
SRC_URI[aarch64_rust-zerocopy-devel.sha256sum] = "a1f6686de9eeb40b3167ae2a1689b899d12a0aa0bb3b7bb372bd43b4fad2bb61"

RDEPENDS:rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel = " \
 cargo \
 rust-zerocopy+alloc-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy+std-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+alloc-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+default-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+derive-devel = " \
 cargo \
 rust-zerocopy+zerocopy-derive-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+float-nightly-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+simd-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+simd-nightly-devel = " \
 cargo \
 rust-zerocopy+simd-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+std-devel = " \
 cargo \
 rust-zerocopy+alloc-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+zerocopy-derive-devel = " \
 cargo \
 rust-zerocopy-derive+default-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy-devel = " \
 cargo \
 rust \
 rust-zerocopy-derive+default-devel \
 "
