# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "boost"
PV = "1.83.0"
PR = "7.el10"
PACKAGES = " \
 boost \
 boost-atomic \
 boost-b2 \
 boost-build \
 boost-chrono \
 boost-container \
 boost-context \
 boost-contract \
 boost-coroutine \
 boost-date-time \
 boost-devel \
 boost-doc \
 boost-doctools \
 boost-examples \
 boost-fiber \
 boost-filesystem \
 boost-graph \
 boost-graph-mpich \
 boost-graph-openmpi \
 boost-iostreams \
 boost-json \
 boost-locale \
 boost-log \
 boost-math \
 boost-mpich \
 boost-mpich-devel \
 boost-mpich-python3 \
 boost-nowide \
 boost-numpy3 \
 boost-openmpi \
 boost-openmpi-devel \
 boost-openmpi-python3 \
 boost-program-options \
 boost-python3 \
 boost-random \
 boost-regex \
 boost-serialization \
 boost-stacktrace \
 boost-static \
 boost-system \
 boost-test \
 boost-thread \
 boost-timer \
 boost-type_erasure \
 boost-url \
 boost-wave \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/boost-1.83.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "921ea5df638455a4df83954ecd3f38fe5f6784b1fe90ddb4209bbd36d560da55"

URI_x86_64_v2_boost = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost}"
SRC_URI[x86_64_v2_boost.sha256sum] = "a1c9c918f5562f40746afcc16355d505cc6f852a8f5af0ebec2e52e2f82a7673"

URI_x86_64_v2_boost-atomic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-atomic-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-atomic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-atomic}"
SRC_URI[x86_64_v2_boost-atomic.sha256sum] = "d7a155d9742c4d588ab9d074cc82e1db0abd11700b9ce3430d3e0247cad8a366"

URI_x86_64_v2_boost-b2 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-b2-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-b2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-b2}"
SRC_URI[x86_64_v2_boost-b2.sha256sum] = "d9cd42c8e3c5db191fcb2d8edbb6ba0cff1c4d7445405da79d861948c8b07c9d"

URI_x86_64_v2_boost-build = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-build-1.83.0-7.el10.noarch.rpm;name=x86_64_v2_boost-build;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-build}"
SRC_URI[x86_64_v2_boost-build.sha256sum] = "ffb209e7f8f3411dd19f42470c65b4d109284298e3b0789264783157396dd487"

URI_x86_64_v2_boost-chrono = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-chrono-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-chrono;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-chrono}"
SRC_URI[x86_64_v2_boost-chrono.sha256sum] = "0c0fae2d3656bed383586e63865110b9d9fbde4712426dfdc7c02590ce01beff"

URI_x86_64_v2_boost-container = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-container-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-container;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-container}"
SRC_URI[x86_64_v2_boost-container.sha256sum] = "573b055eb965435c2771f32654b0c2fa51eef735c4bfe5af8c67854e5dd1a88e"

URI_x86_64_v2_boost-context = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-context-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-context;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-context}"
SRC_URI[x86_64_v2_boost-context.sha256sum] = "a28bed226a314c184182b5b492f5f65c4dd872f473a4165413119a0217cb1a0a"

URI_x86_64_v2_boost-contract = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-contract-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-contract;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-contract}"
SRC_URI[x86_64_v2_boost-contract.sha256sum] = "43cdb80735b37e797dc233c87645d18075eeaa7f2c41cbb971dd2dece3a31742"

URI_x86_64_v2_boost-coroutine = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-coroutine-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-coroutine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-coroutine}"
SRC_URI[x86_64_v2_boost-coroutine.sha256sum] = "7240faffecfee079c1c06f3216f571fce1e4eac26bb5b6cc63c2f198e4b9e65a"

URI_x86_64_v2_boost-date-time = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-date-time-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-date-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-date-time}"
SRC_URI[x86_64_v2_boost-date-time.sha256sum] = "0c89db371c97cb2a1012aa345237e2e1ca7f86f88c3e339bda1cde0925a81d68"

URI_x86_64_v2_boost-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-devel-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-devel}"
SRC_URI[x86_64_v2_boost-devel.sha256sum] = "e10e714f8fd21d18a07d68591381c93d94b2d0e4c46622b5ed77c83c82d97f3a"

URI_x86_64_v2_boost-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-doc-1.83.0-7.el10.noarch.rpm;name=x86_64_v2_boost-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-doc}"
SRC_URI[x86_64_v2_boost-doc.sha256sum] = "02cb44fbc531fe8bba709c25b4f690f39a6f849c4d3034dccaddc648eca30c99"

URI_x86_64_v2_boost-doctools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-doctools-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-doctools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-doctools}"
SRC_URI[x86_64_v2_boost-doctools.sha256sum] = "a526a231369222be90e7d0acac9dc945f56fb5dcb183228ba779d35ca4170cc4"

URI_x86_64_v2_boost-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-examples-1.83.0-7.el10.noarch.rpm;name=x86_64_v2_boost-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-examples}"
SRC_URI[x86_64_v2_boost-examples.sha256sum] = "aed88afbf20487b15a9fe10e57a6aeebcc13e1fa7f418196ce9c2fd8772f24b2"

URI_x86_64_v2_boost-fiber = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-fiber-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-fiber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-fiber}"
SRC_URI[x86_64_v2_boost-fiber.sha256sum] = "68e93ac6b9670f72df865d0bb4e11bc26453e3fca0b23c4d722e67a425b29ed9"

URI_x86_64_v2_boost-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-filesystem-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-filesystem}"
SRC_URI[x86_64_v2_boost-filesystem.sha256sum] = "389d901be917fb4aaff2b196ce33ee1b0e68d8f00947d507196b3b9eb77dd2ac"

URI_x86_64_v2_boost-graph = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-graph-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-graph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-graph}"
SRC_URI[x86_64_v2_boost-graph.sha256sum] = "eff9181ae54bc428b54d92ed0590fd4beb203e47a22f43509e177f7b3509a37a"

URI_x86_64_v2_boost-graph-mpich = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-graph-mpich-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-graph-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-graph-mpich}"
SRC_URI[x86_64_v2_boost-graph-mpich.sha256sum] = "260e315908d09aab0e8fa56ec402f5e258f2de2acfdb899a85d7fcdd5888f95f"

URI_x86_64_v2_boost-graph-openmpi = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-graph-openmpi-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-graph-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-graph-openmpi}"
SRC_URI[x86_64_v2_boost-graph-openmpi.sha256sum] = "f1df88710196ac9b54127c0da8c946b6b2b806246e5bdd149021acb0cbe1ef44"

URI_x86_64_v2_boost-iostreams = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-iostreams-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-iostreams;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-iostreams}"
SRC_URI[x86_64_v2_boost-iostreams.sha256sum] = "936929145632936830777594ba580b1868a49c1d9538eff93f859478e3a0e600"

URI_x86_64_v2_boost-json = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-json-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-json}"
SRC_URI[x86_64_v2_boost-json.sha256sum] = "33b514c8f981e255eae9457bb5a95aba3d90817df3fbf9d80277bce5c5736e18"

URI_x86_64_v2_boost-locale = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-locale-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-locale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-locale}"
SRC_URI[x86_64_v2_boost-locale.sha256sum] = "0440033614c29014a977a22213924bf83a21147b800b24c81687ec8bcedf8eb5"

URI_x86_64_v2_boost-log = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-log-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-log}"
SRC_URI[x86_64_v2_boost-log.sha256sum] = "4f110cc5f34b16388c7e962af2cf5ebc8c4635f9f4428811ca96890cebc0b41c"

URI_x86_64_v2_boost-math = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-math-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-math;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-math}"
SRC_URI[x86_64_v2_boost-math.sha256sum] = "9a0ae817fa1b380ccea57f5b0570a605a060d90c8960d7886a1651f5191f72e0"

URI_x86_64_v2_boost-mpich = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-mpich-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-mpich}"
SRC_URI[x86_64_v2_boost-mpich.sha256sum] = "5fb53449816c112da2757cf8f4c0a7726eeb6908ade2e6923d1679fb74926997"

URI_x86_64_v2_boost-mpich-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-mpich-devel-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-mpich-devel}"
SRC_URI[x86_64_v2_boost-mpich-devel.sha256sum] = "69f6d7308b15fb6c281a5d78b018715b0338e16a4b9963e50c023ec26893123e"

URI_x86_64_v2_boost-mpich-python3 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-mpich-python3-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-mpich-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-mpich-python3}"
SRC_URI[x86_64_v2_boost-mpich-python3.sha256sum] = "4bd3ba3e68d6cca88e4c198734f675df34ab624aeeb6e365d610fe252d3b5a3f"

URI_x86_64_v2_boost-nowide = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-nowide-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-nowide;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-nowide}"
SRC_URI[x86_64_v2_boost-nowide.sha256sum] = "5c55bf16490725e364fa61636c455c01409c9fa7a817aee8242f0e2a28eb8e96"

URI_x86_64_v2_boost-numpy3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-numpy3-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-numpy3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-numpy3}"
SRC_URI[x86_64_v2_boost-numpy3.sha256sum] = "5e4a965b9c177da1e3351ae76c1514a994b597c51140708ffb5c345513d822bf"

URI_x86_64_v2_boost-openmpi = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-openmpi-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-openmpi}"
SRC_URI[x86_64_v2_boost-openmpi.sha256sum] = "376c14d2451221bdffdf239b6c76a0adbe28cbd37bb9198a2377880a1ce7bc7f"

URI_x86_64_v2_boost-openmpi-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-openmpi-devel-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-openmpi-devel}"
SRC_URI[x86_64_v2_boost-openmpi-devel.sha256sum] = "a35ce554a8c8098b468df56386784d5441142d287d66094115ddf662cb1c33a1"

URI_x86_64_v2_boost-openmpi-python3 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-openmpi-python3-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-openmpi-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-openmpi-python3}"
SRC_URI[x86_64_v2_boost-openmpi-python3.sha256sum] = "9ddcba50bee8708dacb6fa1dbbc996b210f0fa96b243cda21df9e7366055ee3a"

URI_x86_64_v2_boost-program-options = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-program-options-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-program-options;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-program-options}"
SRC_URI[x86_64_v2_boost-program-options.sha256sum] = "73b05ec86f30ca89790b24b36f4e4f9d2439d2a682f44fac8640f97d328a8a5e"

URI_x86_64_v2_boost-python3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-python3-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-python3}"
SRC_URI[x86_64_v2_boost-python3.sha256sum] = "145ada965271864c5ca2f5a0c60213e27b089ed029ccb987118c3a42fbfca083"

URI_x86_64_v2_boost-random = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-random-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-random;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-random}"
SRC_URI[x86_64_v2_boost-random.sha256sum] = "55c434bb384714f6d164ebea956874b021088d9085db45cebd9fe3964ea7122c"

URI_x86_64_v2_boost-regex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-regex-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-regex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-regex}"
SRC_URI[x86_64_v2_boost-regex.sha256sum] = "28fff586d778a7cb6b87eb0200625898ebb78dcc62fb3bd119d80521767b417e"

URI_x86_64_v2_boost-serialization = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-serialization-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-serialization;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-serialization}"
SRC_URI[x86_64_v2_boost-serialization.sha256sum] = "d0b056ff8392acd13a9692fb77137266d53d66de0e78e2f26df5e35efa968058"

URI_x86_64_v2_boost-stacktrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-stacktrace-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-stacktrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-stacktrace}"
SRC_URI[x86_64_v2_boost-stacktrace.sha256sum] = "bd63c452ce6fcc2cc97f381dcf5af31aab51a5469473c60d7e0d96bd5b7a1eb1"

URI_x86_64_v2_boost-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-static-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-static}"
SRC_URI[x86_64_v2_boost-static.sha256sum] = "8f1c9900d64ef43bf31b43c03a0c6e426d6cfb1101b58cb503a5358f32fd690d"

URI_x86_64_v2_boost-system = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-system-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-system;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-system}"
SRC_URI[x86_64_v2_boost-system.sha256sum] = "5b708714f354d274fd2bda0bc624efe632d1e69b2af36ae768f67e3080f81749"

URI_x86_64_v2_boost-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-test-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-test}"
SRC_URI[x86_64_v2_boost-test.sha256sum] = "1606cc26409cd1a125a79902ced10a5c2044e185b4224f2ac510c4071fb651ad"

URI_x86_64_v2_boost-thread = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-thread-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-thread;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-thread}"
SRC_URI[x86_64_v2_boost-thread.sha256sum] = "a9482a2351b25e09e4c6a3de5511d6d8c2061d343202bed3bbeb26b7b4aa040c"

URI_x86_64_v2_boost-timer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-timer-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-timer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-timer}"
SRC_URI[x86_64_v2_boost-timer.sha256sum] = "c7e3aaf6593be31279f19cbd8a8395a89c75961a690d29620767f1001694c6f8"

URI_x86_64_v2_boost-type_erasure = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-type_erasure-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-type_erasure;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-type_erasure}"
SRC_URI[x86_64_v2_boost-type_erasure.sha256sum] = "002709601595fff395ea2dfc144bcf9877d93ae518709a89140b896857f91add"

URI_x86_64_v2_boost-url = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-url-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-url;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-url}"
SRC_URI[x86_64_v2_boost-url.sha256sum] = "62fc03aaa2dea2306ede4405f24bf29b6d494ed3c929a93a48df074e634c773f"

URI_x86_64_v2_boost-wave = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-wave-1.83.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_boost-wave;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-wave}"
SRC_URI[x86_64_v2_boost-wave.sha256sum] = "f1b1e4054c71476999eb07f7c78619683d5a1709c9480a9b7348e8d339b72674"

URI_aarch64_boost = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost}"
SRC_URI[aarch64_boost.sha256sum] = "4bdbe9c5c60b98ca3b2f459243c8844f06a83634679285416b757373fb867e69"

URI_aarch64_boost-atomic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-atomic-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-atomic;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-atomic}"
SRC_URI[aarch64_boost-atomic.sha256sum] = "1a23f1ce6983251ec71010359d1606148ecc8bb40acc3c4de513ec3daae88703"

URI_aarch64_boost-b2 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-b2-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-b2;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-b2}"
SRC_URI[aarch64_boost-b2.sha256sum] = "095e8282d4e2f8c2e55b80de209c5c73f5a86dbe0e1fe04ab1e2f05a4c6fb25d"

URI_aarch64_boost-build = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-build-1.83.0-7.el10.noarch.rpm;name=aarch64_boost-build;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-build}"
SRC_URI[aarch64_boost-build.sha256sum] = "ffb209e7f8f3411dd19f42470c65b4d109284298e3b0789264783157396dd487"

URI_aarch64_boost-chrono = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-chrono-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-chrono;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-chrono}"
SRC_URI[aarch64_boost-chrono.sha256sum] = "07f314670905e0a4b76245d5eb8455b2f6cbc838019b3d3d726db25eafa87fbe"

URI_aarch64_boost-container = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-container-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-container;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-container}"
SRC_URI[aarch64_boost-container.sha256sum] = "e74144d7744fea2e7fb9a5f99b1e0b6b1dc69d393fc48d763e41e96b1b4e22eb"

URI_aarch64_boost-context = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-context-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-context;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-context}"
SRC_URI[aarch64_boost-context.sha256sum] = "d6d5872c7e7625dcdecd38f497bbb37202e7436dc48faffe87f744889a3d8e60"

URI_aarch64_boost-contract = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-contract-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-contract;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-contract}"
SRC_URI[aarch64_boost-contract.sha256sum] = "bb9c51bf3b16f96e548c98c32f90361051c1e921c6d6ef6ae3d0a3416b4cdcf8"

URI_aarch64_boost-coroutine = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-coroutine-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-coroutine;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-coroutine}"
SRC_URI[aarch64_boost-coroutine.sha256sum] = "48a5b1ac2fe8eaf5e6a2af0ef17e82720988e01bea00a945477bb8650d75a252"

URI_aarch64_boost-date-time = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-date-time-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-date-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-date-time}"
SRC_URI[aarch64_boost-date-time.sha256sum] = "20aea9377efb1cf4e60a7128b0d90e3e9c4f5249fba78766322dbc579e6a5acb"

URI_aarch64_boost-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-devel-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-devel}"
SRC_URI[aarch64_boost-devel.sha256sum] = "37768d8dab18e0453b7098f34c6d00ce3c5bedb01bb60ba904b2fda0c8f351c7"

URI_aarch64_boost-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-doc-1.83.0-7.el10.noarch.rpm;name=aarch64_boost-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-doc}"
SRC_URI[aarch64_boost-doc.sha256sum] = "02cb44fbc531fe8bba709c25b4f690f39a6f849c4d3034dccaddc648eca30c99"

URI_aarch64_boost-doctools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-doctools-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-doctools;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-doctools}"
SRC_URI[aarch64_boost-doctools.sha256sum] = "456e92ad3661b6085d49362bb16714ee3172ee6b6c641d9c509920759909bdfc"

URI_aarch64_boost-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-examples-1.83.0-7.el10.noarch.rpm;name=aarch64_boost-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-examples}"
SRC_URI[aarch64_boost-examples.sha256sum] = "aed88afbf20487b15a9fe10e57a6aeebcc13e1fa7f418196ce9c2fd8772f24b2"

URI_aarch64_boost-fiber = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-fiber-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-fiber;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-fiber}"
SRC_URI[aarch64_boost-fiber.sha256sum] = "8870c11cab1ef50ed0d4f70400b2b1c50dfd247fd2567425dffa01674b25e67c"

URI_aarch64_boost-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-filesystem-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-filesystem}"
SRC_URI[aarch64_boost-filesystem.sha256sum] = "711196b0b10c49f21973903863fe82e9ccc839ca2f0d32c9d20e8d342761ea98"

URI_aarch64_boost-graph = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-graph-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-graph;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-graph}"
SRC_URI[aarch64_boost-graph.sha256sum] = "2015ec8f66767dd695374a9ec88583e88365291aa66d7d6c8dd102dc3c613e07"

URI_aarch64_boost-graph-mpich = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-graph-mpich-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-graph-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-graph-mpich}"
SRC_URI[aarch64_boost-graph-mpich.sha256sum] = "0be226f467fd5a7c612588ea0f05bcdf3a6d4df76141da1971316e4737d29d27"

URI_aarch64_boost-graph-openmpi = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-graph-openmpi-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-graph-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-graph-openmpi}"
SRC_URI[aarch64_boost-graph-openmpi.sha256sum] = "ae273da21d57620a459709127309eb8a97d263996bcf0cc172664a5f51081549"

URI_aarch64_boost-iostreams = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-iostreams-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-iostreams;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-iostreams}"
SRC_URI[aarch64_boost-iostreams.sha256sum] = "119bc82d11ce259faa46e0d922c0c7244643be3809547cc3bde9409e04ad5822"

URI_aarch64_boost-json = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-json-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-json;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-json}"
SRC_URI[aarch64_boost-json.sha256sum] = "1b63d5837c2e787d133c214a69292675224f9c5f87b33c90665eb514d8948ebf"

URI_aarch64_boost-locale = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-locale-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-locale;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-locale}"
SRC_URI[aarch64_boost-locale.sha256sum] = "85ecaacd161eaf74b7e776b5467d409c92a2034159bbf93b38a586018805e6bc"

URI_aarch64_boost-log = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-log-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-log;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-log}"
SRC_URI[aarch64_boost-log.sha256sum] = "c85e4f633d8350b9e7a3a74e2ade92a8ab48d8d2a2d5804031a05fe1bc2e309e"

URI_aarch64_boost-math = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-math-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-math;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-math}"
SRC_URI[aarch64_boost-math.sha256sum] = "0c3aa78c9b71f524006d1fa0f592d310af94862f2f81ed882218d74693b3c7a0"

URI_aarch64_boost-mpich = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-mpich-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-mpich}"
SRC_URI[aarch64_boost-mpich.sha256sum] = "82f0c8c244d7214aba0c1ab0c4988da13d10b481f7c5df58eea0e5b47bec74d7"

URI_aarch64_boost-mpich-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-mpich-devel-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-mpich-devel}"
SRC_URI[aarch64_boost-mpich-devel.sha256sum] = "645a9208e88cad1d284c78e88160a9201b49fec36dc56c74677720471a47855d"

URI_aarch64_boost-mpich-python3 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-mpich-python3-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-mpich-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-mpich-python3}"
SRC_URI[aarch64_boost-mpich-python3.sha256sum] = "de67a48bdf53ae80648f956c61d0865af29f0a662f1de9abb2443c5178258364"

URI_aarch64_boost-nowide = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-nowide-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-nowide;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-nowide}"
SRC_URI[aarch64_boost-nowide.sha256sum] = "d6d64dd4dc9f6329cbf59470ef7d7e39df9895d174eade01bdf8bf7a40d979ce"

URI_aarch64_boost-numpy3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-numpy3-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-numpy3;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-numpy3}"
SRC_URI[aarch64_boost-numpy3.sha256sum] = "1386b5464da382e752de070ddd73b602399a33e05431a1e9b52e230440b64870"

URI_aarch64_boost-openmpi = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-openmpi-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-openmpi}"
SRC_URI[aarch64_boost-openmpi.sha256sum] = "7f5428814429f40a65c694a99b0f22095f16faebe1233124271521e00edd2fa3"

URI_aarch64_boost-openmpi-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-openmpi-devel-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-openmpi-devel}"
SRC_URI[aarch64_boost-openmpi-devel.sha256sum] = "525e3916742af2d39c759849325545bc6e4d60218c0864d05a6116b213f644a3"

URI_aarch64_boost-openmpi-python3 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-openmpi-python3-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-openmpi-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-openmpi-python3}"
SRC_URI[aarch64_boost-openmpi-python3.sha256sum] = "f605731a1b227139a3b8b35a3ee2e1e069f5f75b4d319b54e44234f03c363b55"

URI_aarch64_boost-program-options = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-program-options-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-program-options;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-program-options}"
SRC_URI[aarch64_boost-program-options.sha256sum] = "e4af80fb91007a5c0e36593d0467c6f2b8cf00d7f9c652a019b9c1d4e21bed89"

URI_aarch64_boost-python3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-python3-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-python3}"
SRC_URI[aarch64_boost-python3.sha256sum] = "9d73bd37aef043941e40afca7de2d004b7877ef1ace47eec9e17bdd6916e27ad"

URI_aarch64_boost-random = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-random-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-random;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-random}"
SRC_URI[aarch64_boost-random.sha256sum] = "d1c96373f979f3dadc2f8efb586677ed1ea6a7184df3095a5cd462f7779c8a16"

URI_aarch64_boost-regex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-regex-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-regex;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-regex}"
SRC_URI[aarch64_boost-regex.sha256sum] = "28d7d085e644a55f65eddad7b6e8db72fb0b3c283b12e8068aa000a1e990da38"

URI_aarch64_boost-serialization = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-serialization-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-serialization;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-serialization}"
SRC_URI[aarch64_boost-serialization.sha256sum] = "19f5c0597aefe127607d7f51ecb40d6c8caeb5989ba76dee4807c949f85a309f"

URI_aarch64_boost-stacktrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-stacktrace-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-stacktrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-stacktrace}"
SRC_URI[aarch64_boost-stacktrace.sha256sum] = "f6446f2925dc024f9704f3a31ca5c6b4bbf9f03f67c8abf9d9cd2d4235b94e58"

URI_aarch64_boost-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-static-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-static}"
SRC_URI[aarch64_boost-static.sha256sum] = "472964d3088f072ce8fc5ad2befd362ce443ae83dc978282b633f9b85f03c315"

URI_aarch64_boost-system = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-system-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-system;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-system}"
SRC_URI[aarch64_boost-system.sha256sum] = "98078dbd8abb5c701af50c6b70305652900726dbebd7b6280a625620354c2020"

URI_aarch64_boost-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-test-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-test}"
SRC_URI[aarch64_boost-test.sha256sum] = "6b9b4dea4c69200b32343e06afb8f6d4fe7bbd0d214db8044456571036cb5182"

URI_aarch64_boost-thread = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-thread-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-thread;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-thread}"
SRC_URI[aarch64_boost-thread.sha256sum] = "d88e80f756135a06673eef69427ee1a2ee7f3121c66ace02d839e718b8d6603e"

URI_aarch64_boost-timer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-timer-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-timer;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-timer}"
SRC_URI[aarch64_boost-timer.sha256sum] = "c0efefa003a94468e073a6d8fa3ffdda9cb71b2855dd7bc75ac5fe8fc917408b"

URI_aarch64_boost-type_erasure = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-type_erasure-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-type_erasure;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-type_erasure}"
SRC_URI[aarch64_boost-type_erasure.sha256sum] = "6c9dc889507989e3ea73306cdb2250610550025f1abbeb12bf524a9a1d176e98"

URI_aarch64_boost-url = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-url-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-url;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-url}"
SRC_URI[aarch64_boost-url.sha256sum] = "a04b1d1d5b88ba5be0bc582680903e361f96ca35f55434ca0a08a7a6ea4f4087"

URI_aarch64_boost-wave = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-wave-1.83.0-7.el10.aarch64.rpm;name=aarch64_boost-wave;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-wave}"
SRC_URI[aarch64_boost-wave.sha256sum] = "bb7ae932c1a495aff97711f449929d712c33b879eb47c47b85164686932f2939"

RDEPENDS:boost = " \
 boost-atomic \
 boost-chrono \
 boost-container \
 boost-context \
 boost-contract \
 boost-coroutine \
 boost-date-time \
 boost-fiber \
 boost-filesystem \
 boost-graph \
 boost-iostreams \
 boost-json \
 boost-locale \
 boost-log \
 boost-math \
 boost-nowide \
 boost-program-options \
 boost-python3 \
 boost-random \
 boost-regex \
 boost-serialization \
 boost-stacktrace \
 boost-system \
 boost-test \
 boost-thread \
 boost-timer \
 boost-type_erasure \
 boost-url \
 boost-wave \
 "
RDEPENDS:boost-atomic = " \
 glibc \
 libstdc++ \
 "
RDEPENDS:boost-b2 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-build = " \
 boost-b2 \
 python3 \
 "
RDEPENDS:boost-chrono = " \
 boost-system \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-container = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-context = " \
 glibc \
 libstdc++ \
 "
RDEPENDS:boost-contract = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-coroutine = " \
 boost-context \
 glibc \
 libstdc++ \
 "
RDEPENDS:boost-date-time = " \
 glibc \
 "
RDEPENDS:boost-devel:x86_64_v2 = " \
 boost \
 boost-numpy3 \
 libicu-devel \
 libquadmath-devel \
"
RDEPENDS:boost-devel:aarch64 = " \
 boost \
 boost-numpy3 \
 libicu-devel \
"
RDEPENDS:boost-doc = " \
 "
RDEPENDS:boost-doctools = " \
 bash \
 docbook-dtds \
 docbook-style-xsl \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-examples = " \
 boost-devel \
 "
RDEPENDS:boost-fiber = " \
 boost-context \
 boost-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-filesystem = " \
 boost-atomic \
 boost-system \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-graph = " \
 boost-regex \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 "
RDEPENDS:boost-graph-mpich = " \
 boost-mpich \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 mpich \
 "
RDEPENDS:boost-graph-openmpi = " \
 boost-openmpi \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 openmpi \
 "
RDEPENDS:boost-iostreams = " \
 bzip2-libs \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:boost-json = " \
 boost-container \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-locale = " \
 boost-chrono \
 boost-system \
 boost-thread \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 "
RDEPENDS:boost-log = " \
 boost-atomic \
 boost-chrono \
 boost-filesystem \
 boost-regex \
 boost-thread \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 "
RDEPENDS:boost-math = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-mpich = " \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 mpich \
 "
RDEPENDS:boost-mpich-devel = " \
 boost-devel \
 boost-graph-mpich \
 boost-mpich \
 "
RDEPENDS:boost-mpich-python3 = " \
 boost-mpich \
 boost-python3 \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 mpich \
 python3 \
 python3-mpich \
 "
RDEPENDS:boost-nowide = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-numpy3 = " \
 boost-python3 \
 glibc \
 libgcc \
 libstdc++ \
 python3-numpy \
 "
RDEPENDS:boost-openmpi = " \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 openmpi \
 "
RDEPENDS:boost-openmpi-devel = " \
 boost-devel \
 boost-graph-openmpi \
 boost-openmpi \
 "
RDEPENDS:boost-openmpi-python3 = " \
 boost-openmpi \
 boost-python3 \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 openmpi \
 python3 \
 python3-openmpi \
 "
RDEPENDS:boost-program-options = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-python3 = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:boost-random = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-regex = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 "
RDEPENDS:boost-serialization = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-stacktrace = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-static = " \
 boost-devel \
 "
RDEPENDS:boost-system = " \
 glibc \
 "
RDEPENDS:boost-test = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-thread = " \
 boost-system \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-timer = " \
 boost-chrono \
 boost-system \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-type_erasure = " \
 boost-chrono \
 boost-system \
 boost-thread \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-url = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-wave = " \
 boost-chrono \
 boost-date-time \
 boost-filesystem \
 boost-system \
 boost-thread \
 glibc \
 libgcc \
 libstdc++ \
 "
