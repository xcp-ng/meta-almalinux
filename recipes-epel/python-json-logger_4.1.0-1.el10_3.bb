# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-json-logger"
PV = "4.1.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-json-logger \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-json-logger-4.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "63159ffef8e514219198d95ed005648d68516c84ab5adc7b86769b881690179c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-json-logger-4.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-json-logger;unpack=0"
SRC_URI[x86_64_v2_python3-json-logger.sha256sum] = "8faf553c943f1d086661192c9ba002bc39894bdcd9b64e863702aa76c899e543"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-json-logger-4.1.0-1.el10_3.noarch.rpm;name=aarch64_python3-json-logger;unpack=0"
SRC_URI[aarch64_python3-json-logger.sha256sum] = "7a89cd4d29417d30b33f95bec4dde8b4d4fe5f9027188b57bfdba5f2ddf674dc"

RDEPENDS:python3-json-logger = " \
 python3 \
 "
