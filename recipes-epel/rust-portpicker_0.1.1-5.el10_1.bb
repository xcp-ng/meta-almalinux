# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-portpicker"
PV = "0.1.1"
PR = "5.el10_1"
PACKAGES = " \
 rust-portpicker+default-devel \
 rust-portpicker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-portpicker-0.1.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61c984eda369b9e19f6e1d3e903ce672d99f529030222eacc202acc1cb8783e6"

URI_x86_64_v2_rust-portpicker+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portpicker+default-devel-0.1.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portpicker+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portpicker+default-devel}"
SRC_URI[x86_64_v2_rust-portpicker+default-devel.sha256sum] = "60fb260d37fbbaf8c25d8e2dfe1526cb816872ca97b4ec7a6bd81bcc0e0c409b"

URI_x86_64_v2_rust-portpicker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portpicker-devel-0.1.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portpicker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portpicker-devel}"
SRC_URI[x86_64_v2_rust-portpicker-devel.sha256sum] = "c5823b4fb728d644d394e5b2c290d67ed00eb803d4c4cced00d5cb93353c5c4a"

URI_aarch64_rust-portpicker+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portpicker+default-devel-0.1.1-5.el10_1.noarch.rpm;name=aarch64_rust-portpicker+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portpicker+default-devel}"
SRC_URI[aarch64_rust-portpicker+default-devel.sha256sum] = "73ac4ce6dbbdbd0dd90ba867a273c6d09a940ec6b71d3c578fa23898dfcbaf1b"

URI_aarch64_rust-portpicker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portpicker-devel-0.1.1-5.el10_1.noarch.rpm;name=aarch64_rust-portpicker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portpicker-devel}"
SRC_URI[aarch64_rust-portpicker-devel.sha256sum] = "c536556c5ca1ad8cc58f77c56c193e57e9a652ef66666364e281a659ff9c929e"

RDEPENDS:rust-portpicker+default-devel = " \
 cargo \
 rust-portpicker-devel \
 "
RDEPENDS:rust-portpicker-devel = " \
 cargo \
 rust-rand0.8+default-devel \
 "
