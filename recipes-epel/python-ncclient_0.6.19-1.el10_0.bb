# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ncclient"
PV = "0.6.19"
PR = "1.el10_0"
PACKAGES = " \
 python-ncclient-doc \
 python3-ncclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ncclient-0.6.19-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bab312c437e86d97dcca6a2fc749c3ceb67ec83df0d3405dea6ff05c7adbc6d6"

URI_x86_64_v2_python-ncclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-ncclient-doc-0.6.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-ncclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-ncclient-doc}"
SRC_URI[x86_64_v2_python-ncclient-doc.sha256sum] = "36b2919236b86fef03b4b05d2673278d289eede60822d2aec2cf1ab2050b7d04"

URI_x86_64_v2_python3-ncclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ncclient-0.6.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ncclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ncclient}"
SRC_URI[x86_64_v2_python3-ncclient.sha256sum] = "d2b32c1cb864c878112dad9a39d2aaf6bc95e34f9651bc28fee3cddecfb57e83"

URI_aarch64_python-ncclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-ncclient-doc-0.6.19-1.el10_0.noarch.rpm;name=aarch64_python-ncclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-ncclient-doc}"
SRC_URI[aarch64_python-ncclient-doc.sha256sum] = "1745b9bb8307c6d24791d583605e7e0dc8aa2906874415dcfd416e9ed497843f"

URI_aarch64_python3-ncclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ncclient-0.6.19-1.el10_0.noarch.rpm;name=aarch64_python3-ncclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ncclient}"
SRC_URI[aarch64_python3-ncclient.sha256sum] = "08f3005bb68ae24d8839121a483262c699c63ca70d0405a11add2b1f8c99db96"

RDEPENDS:python-ncclient-doc = " \
 "
RDEPENDS:python3-ncclient = " \
 python3 \
 python3-lxml \
 python3-paramiko \
 "
