# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ntpd-rs"
PV = "1.7.2"
PR = "1.el10_3"
PACKAGES = " \
 ntpd-rs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ntpd-rs-1.7.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d3d34aa424514fe610b48485040005bbb89251c1333e24b33ead9d9f1adada4"

URI_x86_64_v2_ntpd-rs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntpd-rs-1.7.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntpd-rs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntpd-rs}"
SRC_URI[x86_64_v2_ntpd-rs.sha256sum] = "f186f193142d2acbc2a5c3d67c047cd534585f003ce499b2a7501ccb407cb483"

URI_aarch64_ntpd-rs = "${EPEL_MIRROR}/aarch64/Packages/n/ntpd-rs-1.7.2-1.el10_3.aarch64.rpm;name=aarch64_ntpd-rs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntpd-rs}"
SRC_URI[aarch64_ntpd-rs.sha256sum] = "da3c3e6f5038b5b25d0023150e502586668ac5f5907868a2664e69cd0a9adc48"

RDEPENDS:ntpd-rs = " \
 bash \
 glibc \
 libgcc \
 systemd \
 "
