# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gsi-credential"
PV = "8.5"
PR = "1.el10_1"
PACKAGES = " \
 globus-gsi-credential \
 globus-gsi-credential-devel \
 globus-gsi-credential-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gsi-credential-8.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b49a3374ce72b77e98ccc2a59475468f94bd796f3c19766a85332deacb1e3cd"

URI_x86_64_v2_globus-gsi-credential = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-credential-8.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-credential;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-credential}"
SRC_URI[x86_64_v2_globus-gsi-credential.sha256sum] = "25e3a60bd889abbe8990ec5c4e0191f34cbdb34bcb24e5fa64966575469ac0f8"

URI_x86_64_v2_globus-gsi-credential-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-credential-devel-8.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-credential-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-credential-devel}"
SRC_URI[x86_64_v2_globus-gsi-credential-devel.sha256sum] = "2135bd28f756f6bcb6bd79ecccbfb6182c5c7a7300f61bf23389befed55ea050"

URI_x86_64_v2_globus-gsi-credential-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-credential-doc-8.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gsi-credential-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-credential-doc}"
SRC_URI[x86_64_v2_globus-gsi-credential-doc.sha256sum] = "d426bfaeccdd4efde48c8f4dbd55ec0f3635d12fb0e510bc2eea2d593cae2bc4"

URI_aarch64_globus-gsi-credential = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-credential-8.5-1.el10_1.aarch64.rpm;name=aarch64_globus-gsi-credential;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-credential}"
SRC_URI[aarch64_globus-gsi-credential.sha256sum] = "09b4a1c6754aa764ab85310af625f721fd48d3d5103a9678a75d25d45e662a91"

URI_aarch64_globus-gsi-credential-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-credential-devel-8.5-1.el10_1.aarch64.rpm;name=aarch64_globus-gsi-credential-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-credential-devel}"
SRC_URI[aarch64_globus-gsi-credential-devel.sha256sum] = "c34b2f2f1ec68d88ef35671929f7fdfdba1438523100d89638013fcb3b6ab7e2"

URI_aarch64_globus-gsi-credential-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-credential-doc-8.5-1.el10_1.noarch.rpm;name=aarch64_globus-gsi-credential-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-credential-doc}"
SRC_URI[aarch64_globus-gsi-credential-doc.sha256sum] = "cfb79a7da1c9145217c982aeea589dfdc7234d10360593e32167c16c60f9228e"

RDEPENDS:globus-gsi-credential = " \
 glibc \
 globus-common \
 globus-gsi-callback \
 globus-gsi-cert-utils \
 globus-gsi-openssl-error \
 globus-gsi-sysconfig \
 openssl-libs \
 "
RDEPENDS:globus-gsi-credential-devel = " \
 globus-common-devel \
 globus-gsi-callback-devel \
 globus-gsi-cert-utils-devel \
 globus-gsi-credential \
 globus-gsi-openssl-error-devel \
 globus-gsi-sysconfig-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gsi-credential-doc = " \
 "
