# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "binutils"
PV = "2.41"
PR = "53.el10.alma.1"
PACKAGES = " \
 binutils \
 binutils-devel \
 binutils-gold \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/binutils-2.41-53.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb23e3a6f67fdf081dde241611e9971dc24e30b3790c08ec492e17a72c8c84d9"

URI_x86_64_v2_binutils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/binutils-2.41-53.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils}"
SRC_URI[x86_64_v2_binutils.sha256sum] = "2bca11c86881689f71dac612a7e4ce69495a59b070c15fdb27a22fd9e95f3a13"

URI_x86_64_v2_binutils-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/binutils-devel-2.41-53.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-devel}"
SRC_URI[x86_64_v2_binutils-devel.sha256sum] = "a9ac6b6d75d5058a9aa89a867aa7a73c8783a4ff41de7a09135fffd536960301"

URI_x86_64_v2_binutils-gold = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/binutils-gold-2.41-53.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils-gold;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-gold}"
SRC_URI[x86_64_v2_binutils-gold.sha256sum] = "5d35559c2fcff9ef169ba97092bbca4d0b710986fb572958cb2b6df15a6c2aff"

URI_aarch64_binutils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/binutils-2.41-53.el10.alma.1.aarch64.rpm;name=aarch64_binutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils}"
SRC_URI[aarch64_binutils.sha256sum] = "26035f8d680a36cd267a370f8e4df5106564f4c8bcef256d90f2a22e595aa29c"

URI_aarch64_binutils-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/binutils-devel-2.41-53.el10.alma.1.aarch64.rpm;name=aarch64_binutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-devel}"
SRC_URI[aarch64_binutils-devel.sha256sum] = "30e9dbc7ef9ca0aaa0b6887bbd6ad948304c4e9a6d34e2b16ff8605c7bbb50aa"

URI_aarch64_binutils-gold = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/binutils-gold-2.41-53.el10.alma.1.aarch64.rpm;name=aarch64_binutils-gold;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-gold}"
SRC_URI[aarch64_binutils-gold.sha256sum] = "4e452a204ef88509e616b4bd6c783e8147bc8d308a881e958179d7e8f75faf39"

RDEPENDS:binutils = " \
 alternatives \
 bash \
 binutils-gold \
 elfutils-debuginfod-client \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:binutils-devel = " \
 binutils \
 virtual/coreutils \
 zlib-ng-compat-devel \
 "
RDEPENDS:binutils-gold = " \
 bash \
 binutils \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
