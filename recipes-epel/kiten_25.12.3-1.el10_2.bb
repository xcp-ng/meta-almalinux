# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiten"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kiten \
 kiten-devel \
 kiten-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kiten-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10588dc7ccfd9325eb7ac6f82f2488bdcba45a1921aa22fa3787b53e7d42ad3a"

URI_x86_64_v2_kiten = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiten-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiten;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiten}"
SRC_URI[x86_64_v2_kiten.sha256sum] = "6689f831d00008ab037fc1f15a1afac63c36cd9ace0921e4a9c71e752cc6d5f9"

URI_x86_64_v2_kiten-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiten-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiten-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiten-devel}"
SRC_URI[x86_64_v2_kiten-devel.sha256sum] = "b6a1896d95b5a6c31995b755c91fc820c1cf1a5c939e49e7f61fb829da51fb81"

URI_x86_64_v2_kiten-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiten-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiten-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiten-libs}"
SRC_URI[x86_64_v2_kiten-libs.sha256sum] = "274220b4964cb72a5b2595f8ddb08f20fe564771e87504df8431327c982ad9de"

URI_aarch64_kiten = "${EPEL_MIRROR}/aarch64/Packages/k/kiten-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kiten;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiten}"
SRC_URI[aarch64_kiten.sha256sum] = "c92494bb388a5d4689c6858e610d434a97e39d68d5ec572cadc52fed8f12a74d"

URI_aarch64_kiten-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kiten-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kiten-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiten-devel}"
SRC_URI[aarch64_kiten-devel.sha256sum] = "17cfaf72d8da7a365e569ae4f6bbb01a348e8643b171237048c145cfd43aaad9"

URI_aarch64_kiten-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kiten-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kiten-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiten-libs}"
SRC_URI[aarch64_kiten-libs.sha256sum] = "b79fc23c9ab2d6e88d5856afc52e7daf552aeb8d8797b6f47a9f9895ed52c3cd"

RDEPENDS:kiten = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kiten-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kiten-devel = " \
 kiten-libs \
 "
RDEPENDS:kiten-libs = " \
 glibc \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kiten \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
