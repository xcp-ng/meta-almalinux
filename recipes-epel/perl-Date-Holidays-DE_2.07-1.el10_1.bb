# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Date-Holidays-DE"
PV = "2.07"
PR = "1.el10_1"
PACKAGES = " \
 perl-Date-Holidays-DE \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Date-Holidays-DE-2.07-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5359feeecc99e659f99779092e4e7f2c4bc1bb3407a3e0a18c5f3078451a7403"

URI_x86_64_v2_perl-Date-Holidays-DE = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Date-Holidays-DE-2.07-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Date-Holidays-DE;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Date-Holidays-DE}"
SRC_URI[x86_64_v2_perl-Date-Holidays-DE.sha256sum] = "bf202970343484d88d39cb02f65e3489e93f064ccd323856147ebe819950f691"

URI_aarch64_perl-Date-Holidays-DE = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Date-Holidays-DE-2.07-1.el10_1.noarch.rpm;name=aarch64_perl-Date-Holidays-DE;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Date-Holidays-DE}"
SRC_URI[aarch64_perl-Date-Holidays-DE.sha256sum] = "4d0cc2c8dcf7f4df202006d95461dd1d7e5e4f89fc4a73b3a4beff7b703b110e"

RDEPENDS:perl-Date-Holidays-DE = " \
 perl-Date-Calc \
 perl-Exporter \
 perl-POSIX \
 perl-Time-Local \
 perl-libs \
 "
