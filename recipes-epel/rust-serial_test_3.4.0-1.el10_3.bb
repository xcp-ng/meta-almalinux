# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serial_test"
PV = "3.4.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-serial_test+async-devel \
 rust-serial_test+default-devel \
 rust-serial_test+docsrs-devel \
 rust-serial_test+file_locks-devel \
 rust-serial_test+logging-devel \
 rust-serial_test+test_logging-devel \
 rust-serial_test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serial_test-3.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29fb514d845cdd7616391252914d4677b0436c3093848752dc941613b4d2e6d2"

URI_x86_64_v2_rust-serial_test+async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+async-devel-3.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+async-devel}"
SRC_URI[x86_64_v2_rust-serial_test+async-devel.sha256sum] = "f1ca326b768d2431881c414b5c99bfaa604ce767870bef5260964dfc6d3e3bea"

URI_x86_64_v2_rust-serial_test+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+default-devel-3.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+default-devel}"
SRC_URI[x86_64_v2_rust-serial_test+default-devel.sha256sum] = "78d6113d80f399f4b30b68ebcde59a6a657cf414ffb78ecf0c1646612a9d532e"

URI_x86_64_v2_rust-serial_test+docsrs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+docsrs-devel-3.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+docsrs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+docsrs-devel}"
SRC_URI[x86_64_v2_rust-serial_test+docsrs-devel.sha256sum] = "7a17173ade14be09b8deefd92106fb904a031ea4142177576bb1aba723d31132"

URI_x86_64_v2_rust-serial_test+file_locks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+file_locks-devel-3.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+file_locks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+file_locks-devel}"
SRC_URI[x86_64_v2_rust-serial_test+file_locks-devel.sha256sum] = "b6bf3d963a797fed84db919a2565c74a9cf56b00e91689ec4bcb6dc6023b78ea"

URI_x86_64_v2_rust-serial_test+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+logging-devel-3.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+logging-devel}"
SRC_URI[x86_64_v2_rust-serial_test+logging-devel.sha256sum] = "6868a52c9f602e570e4d586890e9140074511ec61b8b462c26ab474457ffddd0"

URI_x86_64_v2_rust-serial_test+test_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+test_logging-devel-3.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+test_logging-devel}"
SRC_URI[x86_64_v2_rust-serial_test+test_logging-devel.sha256sum] = "ead18cae9fd328188f61136d1fc06bb6d442624c274ccbf8ba1a3736b27a4714"

URI_x86_64_v2_rust-serial_test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test-devel-3.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test-devel}"
SRC_URI[x86_64_v2_rust-serial_test-devel.sha256sum] = "72e2eaaf82e9b170851a51e6953f34a487751dc175fa28eb9e42e50a9ad629af"

URI_aarch64_rust-serial_test+async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+async-devel-3.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-serial_test+async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+async-devel}"
SRC_URI[aarch64_rust-serial_test+async-devel.sha256sum] = "184b81c0cdbd2b7fc538d817ba55c4abf0da9f674090021b60e8de427c9f247c"

URI_aarch64_rust-serial_test+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+default-devel-3.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-serial_test+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+default-devel}"
SRC_URI[aarch64_rust-serial_test+default-devel.sha256sum] = "599176ef9d624e76bfbdfb10e7b4c9a5d7eb89a28c3ae815960692d60dc7d4cb"

URI_aarch64_rust-serial_test+docsrs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+docsrs-devel-3.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-serial_test+docsrs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+docsrs-devel}"
SRC_URI[aarch64_rust-serial_test+docsrs-devel.sha256sum] = "212e85733624d02ec4aed73d8ee1cac2c2064662ae5781aa12a91a5a2519ebbc"

URI_aarch64_rust-serial_test+file_locks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+file_locks-devel-3.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-serial_test+file_locks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+file_locks-devel}"
SRC_URI[aarch64_rust-serial_test+file_locks-devel.sha256sum] = "7b2122509ee0328c1d0f3e24e278004df3337170238f220354a595246941767f"

URI_aarch64_rust-serial_test+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+logging-devel-3.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-serial_test+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+logging-devel}"
SRC_URI[aarch64_rust-serial_test+logging-devel.sha256sum] = "76bfbf5f37abfbf65cec054e301ed7fd34dd52c3c85468e1be11f72f462ded2f"

URI_aarch64_rust-serial_test+test_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+test_logging-devel-3.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-serial_test+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+test_logging-devel}"
SRC_URI[aarch64_rust-serial_test+test_logging-devel.sha256sum] = "474670e1a9376c840d9a19deab3320e9afa52d12bab7a4ae03375f86219a169e"

URI_aarch64_rust-serial_test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test-devel-3.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-serial_test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test-devel}"
SRC_URI[aarch64_rust-serial_test-devel.sha256sum] = "6cdd50da030765c38b4a5ecb6e3d5407892f6bdf14554dc27f2f92b1998e28b5"

RDEPENDS:rust-serial_test+async-devel = " \
 cargo \
 rust-futures-executor+std-devel \
 rust-futures-executor-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-serial_test-devel \
 rust-serial_test_derive+async-devel \
 "
RDEPENDS:rust-serial_test+default-devel = " \
 cargo \
 rust-serial_test+async-devel \
 rust-serial_test+logging-devel \
 rust-serial_test-devel \
 "
RDEPENDS:rust-serial_test+docsrs-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-serial_test-devel \
 "
RDEPENDS:rust-serial_test+file_locks-devel = " \
 cargo \
 rust-fslock+std-devel \
 rust-fslock-devel \
 rust-serial_test-devel \
 "
RDEPENDS:rust-serial_test+logging-devel = " \
 cargo \
 rust-log+default-devel \
 rust-serial_test-devel \
 "
RDEPENDS:rust-serial_test+test_logging-devel = " \
 cargo \
 rust-serial_test+logging-devel \
 rust-serial_test-devel \
 rust-serial_test_derive+test_logging-devel \
 virtual/crate_env_logger__ge_0.6.1 \
 "
RDEPENDS:rust-serial_test-devel = " \
 cargo \
 rust \
 rust-once_cell+std-devel \
 rust-once_cell-devel \
 rust-parking_lot-devel \
 rust-scc-devel \
 rust-serial_test_derive+default-devel \
 "
