# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-ed"
PV = "0.3.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-ed \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-ed-0.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06bbe72cd20bce09746b64e564d15eeb5f3fd4ad9bc4d95fb9e80ebf16de18f5"

URI_x86_64_v2_python3-colcon-ed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-ed-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-ed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-ed}"
SRC_URI[x86_64_v2_python3-colcon-ed.sha256sum] = "0c976abfb6d3906d1aec921eb79ef381002b56779a591c4fca5fe2563e5b8a33"

URI_aarch64_python3-colcon-ed = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-ed-0.3.0-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-ed;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-ed}"
SRC_URI[aarch64_python3-colcon-ed.sha256sum] = "1cd0d042e9bef2ec023422d6270c7a47e8351cc04755ea940ef851c5610a5de9"

RDEPENDS:python3-colcon-ed = " \
 python3 \
 python3-colcon-core \
 "
