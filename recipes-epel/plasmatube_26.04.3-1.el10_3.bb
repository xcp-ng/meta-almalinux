# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasmatube"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 plasmatube \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasmatube-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "980718932b640f362239c2623a6f5a0c9d183bbac1aba61b0d54886b488a7975"

URI_x86_64_v2_plasmatube = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasmatube-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasmatube;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasmatube}"
SRC_URI[x86_64_v2_plasmatube.sha256sum] = "e0994a308182ed303ec5470021190b1bbd84275f3868c7c27ea6e5b7241b1f78"

URI_aarch64_plasmatube = "${EPEL_MIRROR}/aarch64/Packages/p/plasmatube-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_plasmatube;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasmatube}"
SRC_URI[aarch64_plasmatube.sha256sum] = "d99cbc38548ffc7592468beded2a4b8b207b12949f0de9f446e3b8624c3800af"

RDEPENDS:plasmatube = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kwindowsystem \
 kf6-purpose \
 libstdc++ \
 mpvqt \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qtkeychain-qt6 \
 "
