# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c-icap"
PV = "0.6.3"
PR = "2.el10_1"
PACKAGES = " \
 c-icap \
 c-icap-devel \
 c-icap-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/c-icap-0.6.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb3a06a96a2cd8df0e6776864c638a0c17767a9bf67bc430128c895fe15714d1"

URI_x86_64_v2_c-icap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c-icap-0.6.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c-icap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c-icap}"
SRC_URI[x86_64_v2_c-icap.sha256sum] = "aac830b2836f2de7c1861828a80a9f1006084c9ba2bab8ef5946dce967837c73"

URI_x86_64_v2_c-icap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c-icap-devel-0.6.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c-icap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c-icap-devel}"
SRC_URI[x86_64_v2_c-icap-devel.sha256sum] = "79642522597103da284334809015b15d12ded5bc350b1590b10369b22ea97822"

URI_x86_64_v2_c-icap-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c-icap-libs-0.6.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c-icap-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c-icap-libs}"
SRC_URI[x86_64_v2_c-icap-libs.sha256sum] = "36751b0be795b034be0bbff27c18a4f6dcf04624e6228da062ca79d6778d38b2"

URI_aarch64_c-icap = "${EPEL_MIRROR}/aarch64/Packages/c/c-icap-0.6.3-2.el10_1.aarch64.rpm;name=aarch64_c-icap;unpack=0"
SRC_URI:append = " ${URI_aarch64_c-icap}"
SRC_URI[aarch64_c-icap.sha256sum] = "7ac18dbea5c518aa833dbadec314dabba482302faf6a34f7d139cb15c57225b1"

URI_aarch64_c-icap-devel = "${EPEL_MIRROR}/aarch64/Packages/c/c-icap-devel-0.6.3-2.el10_1.aarch64.rpm;name=aarch64_c-icap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_c-icap-devel}"
SRC_URI[aarch64_c-icap-devel.sha256sum] = "fb64a2d8f56b5325d7555b408db8b35f1edba7e2e6df5653a26afb3e58534964"

URI_aarch64_c-icap-libs = "${EPEL_MIRROR}/aarch64/Packages/c/c-icap-libs-0.6.3-2.el10_1.aarch64.rpm;name=aarch64_c-icap-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_c-icap-libs}"
SRC_URI[aarch64_c-icap-libs.sha256sum] = "3352114cd8a74f1e239bf6223e3e250c6797a23d1119533673fb8fe4733f8745"

RDEPENDS:c-icap = " \
 bash \
 c-icap-libs \
 glibc \
 libatomic \
 lmdb-libs \
 logrotate \
 openldap \
 shadow-utils \
 "
RDEPENDS:c-icap-devel = " \
 bash \
 c-icap-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:c-icap-libs = " \
 bzip2-libs \
 glibc \
 libatomic \
 libbrotli \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
