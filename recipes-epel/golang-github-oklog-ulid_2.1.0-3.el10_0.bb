# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-oklog-ulid"
PV = "2.1.0"
PR = "3.el10_0"
PACKAGES = " \
 compat-golang-github-oklog-ulid2-devel \
 golang-github-oklog-ulid \
 golang-github-oklog-ulid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-oklog-ulid-2.1.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae949d9b43f4ffd9f4f31112dd1d3a789c39402a07f1e7be4e3349180c9f25b2"

URI_x86_64_v2_compat-golang-github-oklog-ulid2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-oklog-ulid2-devel-2.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-oklog-ulid2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-oklog-ulid2-devel}"
SRC_URI[x86_64_v2_compat-golang-github-oklog-ulid2-devel.sha256sum] = "1a2820f4634ccf2e0ee7708b49bb57a1de77383e679be24f78c3ac1827e21620"

URI_x86_64_v2_golang-github-oklog-ulid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-oklog-ulid-2.1.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-oklog-ulid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-oklog-ulid}"
SRC_URI[x86_64_v2_golang-github-oklog-ulid.sha256sum] = "2252ed76d3d1117abd9624b7b39f60dfe6259d58d3022dda1418f145bdd42bfb"

URI_x86_64_v2_golang-github-oklog-ulid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-oklog-ulid-devel-2.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-oklog-ulid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-oklog-ulid-devel}"
SRC_URI[x86_64_v2_golang-github-oklog-ulid-devel.sha256sum] = "7dccce7497b87da8369c80eb69bf3b617123bfa66374bf24866ea01de5f04615"

URI_aarch64_compat-golang-github-oklog-ulid2-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-oklog-ulid2-devel-2.1.0-3.el10_0.noarch.rpm;name=aarch64_compat-golang-github-oklog-ulid2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-oklog-ulid2-devel}"
SRC_URI[aarch64_compat-golang-github-oklog-ulid2-devel.sha256sum] = "5cd9b10d79c070c223c8c9592bb2128f9eaadff2ca060c8793dc5f6d51768bc0"

URI_aarch64_golang-github-oklog-ulid = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-oklog-ulid-2.1.0-3.el10_0.aarch64.rpm;name=aarch64_golang-github-oklog-ulid;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-oklog-ulid}"
SRC_URI[aarch64_golang-github-oklog-ulid.sha256sum] = "10dd5a25f6847da513b58a7790c4f26112c38950b46b9cf5997ba8db1ceeff9d"

URI_aarch64_golang-github-oklog-ulid-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-oklog-ulid-devel-2.1.0-3.el10_0.noarch.rpm;name=aarch64_golang-github-oklog-ulid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-oklog-ulid-devel}"
SRC_URI[aarch64_golang-github-oklog-ulid-devel.sha256sum] = "2cf492e86b161a597f432f944fef95f76a3f73c8ce51fa6678de3e1e7bac8f0d"

RDEPENDS:compat-golang-github-oklog-ulid2-devel = " \
 go-filesystem \
 golang-github-oklog-ulid-devel \
 "
RDEPENDS:golang-github-oklog-ulid = " \
 glibc \
 "
RDEPENDS:golang-github-oklog-ulid-devel = " \
 go-filesystem \
 golang-github-pborman-getopt-devel \
 "
