# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-bug-serial-1"
PV = "1.6.2"
PR = "2.el10_0"
PACKAGES = " \
 golang-bug-serial-1 \
 golang-bug-serial-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-bug-serial-1-1.6.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2374c6026f3cd558619e8b425d9452bd985a40c6d22f6f18fa59d1f3ddf48d96"

URI_x86_64_v2_golang-bug-serial-1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-bug-serial-1-1.6.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-bug-serial-1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-bug-serial-1}"
SRC_URI[x86_64_v2_golang-bug-serial-1.sha256sum] = "6374948a95dad7c17a423eea6ff80729b9314a91407372615cc7b2d78e19d73e"

URI_x86_64_v2_golang-bug-serial-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-bug-serial-devel-1.6.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-bug-serial-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-bug-serial-devel}"
SRC_URI[x86_64_v2_golang-bug-serial-devel.sha256sum] = "beead9134211016fcb3e6272f31dddd634d2aa67a7c4d1487a09a18eed2b3282"

URI_aarch64_golang-bug-serial-1 = "${EPEL_MIRROR}/aarch64/Packages/g/golang-bug-serial-1-1.6.2-2.el10_0.aarch64.rpm;name=aarch64_golang-bug-serial-1;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-bug-serial-1}"
SRC_URI[aarch64_golang-bug-serial-1.sha256sum] = "8706c43ccdee486fe821c5b6dc70dc1076c195384e0eec7fad269a78b669e152"

URI_aarch64_golang-bug-serial-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-bug-serial-devel-1.6.2-2.el10_0.noarch.rpm;name=aarch64_golang-bug-serial-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-bug-serial-devel}"
SRC_URI[aarch64_golang-bug-serial-devel.sha256sum] = "9e616fcf9f08fbfe25f71f9eca3dbf2f6fc13fa8f86e31f596cb2d82ab156a27"

RDEPENDS:golang-bug-serial-1 = " \
 glibc \
 "
RDEPENDS:golang-bug-serial-devel = " \
 go-filesystem \
 golang-github-creack-goselect-devel \
 golang-x-sys-devel \
 "
