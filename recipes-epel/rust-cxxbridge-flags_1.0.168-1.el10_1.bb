# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxxbridge-flags"
PV = "1.0.168"
PR = "1.el10_1"
PACKAGES = " \
 rust-cxxbridge-flags+c++14-devel \
 rust-cxxbridge-flags+c++17-devel \
 rust-cxxbridge-flags+c++20-devel \
 rust-cxxbridge-flags+default-devel \
 rust-cxxbridge-flags-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxxbridge-flags-1.0.168-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45a31f9ea692831ae130ed5f5adfdd3cfb23a5d963eb09eef69d887e9bafab01"

URI_x86_64_v2_rust-cxxbridge-flags+c++14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+c++14-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+c++14-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+c++14-devel.sha256sum] = "09f1afdef59d9984fa06263cf1321d154dac1853308359221ab823c673abe3ac"

URI_x86_64_v2_rust-cxxbridge-flags+c++17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+c++17-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+c++17-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+c++17-devel.sha256sum] = "4f5cdcd865f49af7b9bf6607d43cfb016ba27ef20903a35eb8747bb4ef416129"

URI_x86_64_v2_rust-cxxbridge-flags+c++20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+c++20-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+c++20-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+c++20-devel.sha256sum] = "c62a2f6e50b08673555a5d335ee564f979d3fde86f32c20c9dd99650bd7040cb"

URI_x86_64_v2_rust-cxxbridge-flags+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+default-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+default-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+default-devel.sha256sum] = "982950e8eac9d544c0ace663df8e0372a9c2b47a5260495568fa1bcfb947cc49"

URI_x86_64_v2_rust-cxxbridge-flags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags-devel.sha256sum] = "8bc40cc44a03937b89df4df3a3d12b4df4e4fef0f113dce3c3880626c6f54fd2"

URI_aarch64_rust-cxxbridge-flags+c++14-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+c++14-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxxbridge-flags+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+c++14-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+c++14-devel.sha256sum] = "da2b2b98845b86f3cc2f1977ec058c1f488562ed3513bac7acdb83715522cf6c"

URI_aarch64_rust-cxxbridge-flags+c++17-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+c++17-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxxbridge-flags+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+c++17-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+c++17-devel.sha256sum] = "db23b9ce2bdce8916fe09cfbafba7b93131fa74b6757667532eb0a612c49aa03"

URI_aarch64_rust-cxxbridge-flags+c++20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+c++20-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxxbridge-flags+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+c++20-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+c++20-devel.sha256sum] = "3afa96434be2379eae072b5762448fc74bd05983d59943f9d11502f4147b132c"

URI_aarch64_rust-cxxbridge-flags+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+default-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxxbridge-flags+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+default-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+default-devel.sha256sum] = "a968dee0ef33755aaad82cd20fbdd2291b317280bf88962472658ee88586d2cb"

URI_aarch64_rust-cxxbridge-flags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxxbridge-flags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags-devel.sha256sum] = "ed76fdb631c51109b49037949695d00d74e476206aa9c7782c24ac1be3358440"

RDEPENDS:rust-cxxbridge-flags+c++14-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags+c++17-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags+c++20-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags+default-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags-devel = " \
 cargo \
 rust \
 "
