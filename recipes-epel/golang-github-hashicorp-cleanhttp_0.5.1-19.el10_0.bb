# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hashicorp-cleanhttp"
PV = "0.5.1"
PR = "19.el10_0"
PACKAGES = " \
 golang-github-hashicorp-cleanhttp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-hashicorp-cleanhttp-0.5.1-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e777321223e4be068566cf16cbf3f78cffb2561e8ad87b39ab529e85e36e5ce6"

URI_x86_64_v2_golang-github-hashicorp-cleanhttp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hashicorp-cleanhttp-devel-0.5.1-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hashicorp-cleanhttp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hashicorp-cleanhttp-devel}"
SRC_URI[x86_64_v2_golang-github-hashicorp-cleanhttp-devel.sha256sum] = "dca852dbbfe863b868562046754314c078523c2f22ba3e3b412cf204b656aca4"

URI_aarch64_golang-github-hashicorp-cleanhttp-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hashicorp-cleanhttp-devel-0.5.1-19.el10_0.noarch.rpm;name=aarch64_golang-github-hashicorp-cleanhttp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hashicorp-cleanhttp-devel}"
SRC_URI[aarch64_golang-github-hashicorp-cleanhttp-devel.sha256sum] = "92023649a6b44697d7ab9258c42e2b25330e9daa26824e7a7547d89d269af77e"

RDEPENDS:golang-github-hashicorp-cleanhttp-devel = " \
 go-filesystem \
 "
