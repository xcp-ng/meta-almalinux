# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-fs"
PV = "0.13.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-fs+default-devel \
 rust-gix-fs+serde-devel \
 rust-gix-fs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-fs-0.13.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb59d50bc6d404525a386542ae07ebd0ce97c47741be7d1b96b164f8891d5174"

URI_x86_64_v2_rust-gix-fs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-fs+default-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-fs+default-devel}"
SRC_URI[x86_64_v2_rust-gix-fs+default-devel.sha256sum] = "7aeec56ea33abc9f6ab8cfa42a35ecdaf7792bf28c46315e0651e8fa38f86be1"

URI_x86_64_v2_rust-gix-fs+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-fs+serde-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-fs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-fs+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-fs+serde-devel.sha256sum] = "c657036548c5583c8981b7f36acb8811b23ef1b872137789c0b6be0cac454d5b"

URI_x86_64_v2_rust-gix-fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-fs-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-fs-devel}"
SRC_URI[x86_64_v2_rust-gix-fs-devel.sha256sum] = "63b7318259904d04e590b421a65c455e1cb19409ccb5157fc6ea40f1e8dfa7df"

URI_aarch64_rust-gix-fs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-fs+default-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-fs+default-devel}"
SRC_URI[aarch64_rust-gix-fs+default-devel.sha256sum] = "ff1e0985ccf0905d0211b9be0d096c1b3aa2481e61982562b25534c837e9f7a1"

URI_aarch64_rust-gix-fs+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-fs+serde-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-fs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-fs+serde-devel}"
SRC_URI[aarch64_rust-gix-fs+serde-devel.sha256sum] = "facd4664f8a821dda07f267e75079bb8efc6bfed649f4b8349cfd60acea47c29"

URI_aarch64_rust-gix-fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-fs-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-fs-devel}"
SRC_URI[aarch64_rust-gix-fs-devel.sha256sum] = "0d73d65af4e2edb5b31821f88ab78265d5dd4d4aaf519b9c30e0573b50b3a92a"

RDEPENDS:rust-gix-fs+default-devel = " \
 cargo \
 rust-gix-fs-devel \
 "
RDEPENDS:rust-gix-fs+serde-devel = " \
 cargo \
 rust-gix-fs-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-fs-devel = " \
 cargo \
 rust \
 rust-fastrand+std-devel \
 rust-fastrand-devel \
 rust-gix-features+default-devel \
 rust-gix-features+fs-read-dir-devel \
 rust-gix-utils+default-devel \
 "
