# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-DNS"
PV = "1.57"
PR = "1.el10_3"
PACKAGES = " \
 perl-Net-DNS \
 perl-Net-DNS-Nameserver \
 perl-Net-DNS-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Net-DNS-1.57-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "15fd64c7179b5cbbc45d04ed60b44b73ff65f39770e38a39ca3b2186de47540b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-DNS-1.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-DNS;unpack=0"
SRC_URI[x86_64_v2_perl-Net-DNS.sha256sum] = "0e4ac37ad3d42417f3c72cb0641f74b1423ec03f7cf4945b892121858a2da8d6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-DNS-Nameserver-1.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-DNS-Nameserver;unpack=0"
SRC_URI[x86_64_v2_perl-Net-DNS-Nameserver.sha256sum] = "171b30edabcf21411bbc8fd151e7fa732e7b74ddd02fc793098bc5a095965361"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-DNS-tests-1.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-DNS-tests;unpack=0"
SRC_URI[x86_64_v2_perl-Net-DNS-tests.sha256sum] = "3e04342dfc3d3bfbff1b7daae3e95399ab6182be78be8fd66c921b5695379891"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-DNS-1.57-1.el10_3.noarch.rpm;name=aarch64_perl-Net-DNS;unpack=0"
SRC_URI[aarch64_perl-Net-DNS.sha256sum] = "366c49f77e8ab3b7c552188ed41bccbd13215955f80e2f52b62f9e629768e57c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-DNS-Nameserver-1.57-1.el10_3.noarch.rpm;name=aarch64_perl-Net-DNS-Nameserver;unpack=0"
SRC_URI[aarch64_perl-Net-DNS-Nameserver.sha256sum] = "01757ee53b6f60484f3669f5790cc1c4f0092e95e8bfcc4dd1dd5d704dc7a206"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-DNS-tests-1.57-1.el10_3.noarch.rpm;name=aarch64_perl-Net-DNS-tests;unpack=0"
SRC_URI[aarch64_perl-Net-DNS-tests.sha256sum] = "d034490da17e19e239f0f6f1732c975a6a0f785a33d0354b56b6755459e42b09"

RDEPENDS:perl-Net-DNS = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Digest-HMAC \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Encode \
 perl-Exporter \
 perl-IO \
 perl-MIME-Base64 \
 perl-Net-DNS \
 perl-Socket \
 perl-Time-Local \
 perl-base \
 perl-constant \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Net-DNS-Nameserver = " \
 perl-Carp \
 perl-IO \
 perl-IO-Socket-IP \
 perl-Net-DNS \
 perl-Socket \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Net-DNS-tests = " \
 bash \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-Net-DNS \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
