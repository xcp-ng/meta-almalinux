# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rsa"
PV = "0.9.10"
PR = "1.el10_2"
PACKAGES = " \
 rust-rsa+default-devel \
 rust-rsa+getrandom-devel \
 rust-rsa+hazmat-devel \
 rust-rsa+pem-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+serde-devel \
 rust-rsa+sha1-devel \
 rust-rsa+sha2-devel \
 rust-rsa+std-devel \
 rust-rsa+u64_digit-devel \
 rust-rsa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rsa-0.9.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26e052b616e8a44846b9759326b2892809d6b1c0a8ffe8881ef0c94f3200d5c0"

URI_x86_64_v2_rust-rsa+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+default-devel-0.9.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+default-devel}"
SRC_URI[x86_64_v2_rust-rsa+default-devel.sha256sum] = "fec5b716ac993a8c484e644aa566537bd44270bd451b1a29e9a90e910d75f0a3"

URI_x86_64_v2_rust-rsa+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+getrandom-devel-0.9.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+getrandom-devel}"
SRC_URI[x86_64_v2_rust-rsa+getrandom-devel.sha256sum] = "1f0ab52fab0782f69b078facb12caec3ad5737ae0e183b949d430a6bac4427f4"

URI_x86_64_v2_rust-rsa+hazmat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+hazmat-devel-0.9.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+hazmat-devel}"
SRC_URI[x86_64_v2_rust-rsa+hazmat-devel.sha256sum] = "b8fa12ba6a57c16b85aa55b368c1f686cbf68d2ebc2e73e9b9a43ff9a16c95c3"

URI_x86_64_v2_rust-rsa+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+pem-devel-0.9.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+pem-devel}"
SRC_URI[x86_64_v2_rust-rsa+pem-devel.sha256sum] = "341c9a120d987acab25155809cd1db4d2ed1ed9a958dee646e95e6f3b09d81a6"

URI_x86_64_v2_rust-rsa+pkcs5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+pkcs5-devel-0.9.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+pkcs5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+pkcs5-devel}"
SRC_URI[x86_64_v2_rust-rsa+pkcs5-devel.sha256sum] = "71f1e533b065e46ed5e6ba1ede45836af2c75a4fd2a2f0dc35fbb67863de72c3"

URI_x86_64_v2_rust-rsa+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+serde-devel-0.9.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+serde-devel}"
SRC_URI[x86_64_v2_rust-rsa+serde-devel.sha256sum] = "d8cdd3432e1bd03db2bdb0421900933cf7c4bc03648f839cc66c26cab98d23bc"

URI_x86_64_v2_rust-rsa+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+sha1-devel-0.9.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+sha1-devel}"
SRC_URI[x86_64_v2_rust-rsa+sha1-devel.sha256sum] = "17ff9058b8943dc520b6001fd1a725471e04d9050455c1f512a180f60527609b"

URI_x86_64_v2_rust-rsa+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+sha2-devel-0.9.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+sha2-devel}"
SRC_URI[x86_64_v2_rust-rsa+sha2-devel.sha256sum] = "c0dab6d71e94e3a8cba497d355b7edc4a895283afe7abe6ff4beac77a6ed013c"

URI_x86_64_v2_rust-rsa+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+std-devel-0.9.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+std-devel}"
SRC_URI[x86_64_v2_rust-rsa+std-devel.sha256sum] = "3bf35f20944d993dc00d5ff28c30c6ca9691f0c3dd3a33a23a0244df2aaff5d3"

URI_x86_64_v2_rust-rsa+u64_digit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+u64_digit-devel-0.9.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+u64_digit-devel}"
SRC_URI[x86_64_v2_rust-rsa+u64_digit-devel.sha256sum] = "dc946837f9a24f6bca7cbf2de3af6a3fb89d6af02537671ea3197d318683169e"

URI_x86_64_v2_rust-rsa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa-devel-0.9.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa-devel}"
SRC_URI[x86_64_v2_rust-rsa-devel.sha256sum] = "080f271ff7c05c779d48b1665a4986c4cb9831ec02414ed592fd43f9ef80b845"

URI_aarch64_rust-rsa+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+default-devel-0.9.10-1.el10_2.noarch.rpm;name=aarch64_rust-rsa+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+default-devel}"
SRC_URI[aarch64_rust-rsa+default-devel.sha256sum] = "5ca5fe673cc11aa3253b63c6258ef70d0b357717108bac9447a670767975c126"

URI_aarch64_rust-rsa+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+getrandom-devel-0.9.10-1.el10_2.noarch.rpm;name=aarch64_rust-rsa+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+getrandom-devel}"
SRC_URI[aarch64_rust-rsa+getrandom-devel.sha256sum] = "ebeb3c8a5232de5bd8841053ebbd6a635028c83cfe06a09d3fcba137b60e9ab2"

URI_aarch64_rust-rsa+hazmat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+hazmat-devel-0.9.10-1.el10_2.noarch.rpm;name=aarch64_rust-rsa+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+hazmat-devel}"
SRC_URI[aarch64_rust-rsa+hazmat-devel.sha256sum] = "fc10973b3114527b601cc74f89a68d12644038a14b5e1eec1bd5bddddb22c966"

URI_aarch64_rust-rsa+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+pem-devel-0.9.10-1.el10_2.noarch.rpm;name=aarch64_rust-rsa+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+pem-devel}"
SRC_URI[aarch64_rust-rsa+pem-devel.sha256sum] = "8cdedc5fa61eec074ade4d0f121497c68bcbced3235d5cfa893c49c46af6015c"

URI_aarch64_rust-rsa+pkcs5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+pkcs5-devel-0.9.10-1.el10_2.noarch.rpm;name=aarch64_rust-rsa+pkcs5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+pkcs5-devel}"
SRC_URI[aarch64_rust-rsa+pkcs5-devel.sha256sum] = "dee2b072110a3364ba7f9aaa56f0824213e4f837907c369b1ef9042db3ca8a70"

URI_aarch64_rust-rsa+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+serde-devel-0.9.10-1.el10_2.noarch.rpm;name=aarch64_rust-rsa+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+serde-devel}"
SRC_URI[aarch64_rust-rsa+serde-devel.sha256sum] = "809d354c94887249830afca7f30eae972ed1144c66f4426bddb7b1d8e4bdae49"

URI_aarch64_rust-rsa+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+sha1-devel-0.9.10-1.el10_2.noarch.rpm;name=aarch64_rust-rsa+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+sha1-devel}"
SRC_URI[aarch64_rust-rsa+sha1-devel.sha256sum] = "30a2d371b59b62ad28cf62bb5c5c0dcb1d3eb368a91ff2828523d852491ca930"

URI_aarch64_rust-rsa+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+sha2-devel-0.9.10-1.el10_2.noarch.rpm;name=aarch64_rust-rsa+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+sha2-devel}"
SRC_URI[aarch64_rust-rsa+sha2-devel.sha256sum] = "58936725ac1e326d8666a095f775b31f237a7691fb8762bfc7ca0d4591608bb3"

URI_aarch64_rust-rsa+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+std-devel-0.9.10-1.el10_2.noarch.rpm;name=aarch64_rust-rsa+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+std-devel}"
SRC_URI[aarch64_rust-rsa+std-devel.sha256sum] = "419cb81f2c9e0776745c78baf1870d129667aca42cfd680041e83121fbfaef40"

URI_aarch64_rust-rsa+u64_digit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+u64_digit-devel-0.9.10-1.el10_2.noarch.rpm;name=aarch64_rust-rsa+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+u64_digit-devel}"
SRC_URI[aarch64_rust-rsa+u64_digit-devel.sha256sum] = "848b708802a2893c64a300a537cf0b83b902c64f1b1048144725fd19ed1806c1"

URI_aarch64_rust-rsa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa-devel-0.9.10-1.el10_2.noarch.rpm;name=aarch64_rust-rsa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa-devel}"
SRC_URI[aarch64_rust-rsa-devel.sha256sum] = "312fdff6afae76d01bc14d6ae60a108ee29a88b5fe4774b6bcfdbc3cab318d2a"

RDEPENDS:rust-rsa+default-devel = " \
 cargo \
 rust-rsa+pem-devel \
 rust-rsa+std-devel \
 rust-rsa+u64_digit-devel \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa+getrandom-devel = " \
 cargo \
 rust-rand_core0.6+getrandom-devel \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa+hazmat-devel = " \
 cargo \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa+pem-devel = " \
 cargo \
 rust-pkcs1+pem-devel \
 rust-pkcs8+pem-devel \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa+pkcs5-devel = " \
 cargo \
 rust-pkcs8+encryption-devel \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa+serde-devel = " \
 cargo \
 rust-num-bigint-dig0.8+serde-devel \
 rust-rsa-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rsa+sha1-devel = " \
 cargo \
 rust-rsa-devel \
 rust-sha1_0.10+oid-devel \
 rust-sha1_0.10-devel \
 "
RDEPENDS:rust-rsa+sha2-devel = " \
 cargo \
 rust-rsa-devel \
 rust-sha2_0.10+oid-devel \
 rust-sha2_0.10-devel \
 "
RDEPENDS:rust-rsa+std-devel = " \
 cargo \
 rust-digest0.10+std-devel \
 rust-pkcs1+std-devel \
 rust-pkcs8+std-devel \
 rust-rand_core0.6+std-devel \
 rust-rsa-devel \
 rust-signature+std-devel \
 "
RDEPENDS:rust-rsa+u64_digit-devel = " \
 cargo \
 rust-num-bigint-dig0.8+u64_digit-devel \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa-devel = " \
 cargo \
 rust \
 rust-const-oid0.9-devel \
 rust-digest0.10+alloc-devel \
 rust-digest0.10+oid-devel \
 rust-digest0.10-devel \
 rust-num-bigint-dig0.8+i128-devel \
 rust-num-bigint-dig0.8+prime-devel \
 rust-num-bigint-dig0.8+zeroize-devel \
 rust-num-bigint-dig0.8-devel \
 rust-num-integer-devel \
 rust-num-traits+libm-devel \
 rust-num-traits-devel \
 rust-pkcs1+alloc-devel \
 rust-pkcs1+pkcs8-devel \
 rust-pkcs1-devel \
 rust-pkcs8+alloc-devel \
 rust-pkcs8-devel \
 rust-rand_core0.6-devel \
 rust-signature+alloc-devel \
 rust-signature+digest-devel \
 rust-signature+rand_core-devel \
 rust-signature-devel \
 rust-spki0.7+alloc-devel \
 rust-spki0.7-devel \
 rust-subtle-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize+default-devel \
 "
