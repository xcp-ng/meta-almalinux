# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openssh"
PV = "9.9p1"
PR = "7.el10_0"
PACKAGES = " \
 openssh \
 openssh-askpass \
 openssh-clients \
 openssh-keycat \
 openssh-keysign \
 openssh-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openssh-9.9p1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "878b62a43405c2838ebb158491182fb2730b75902b40bdfdb263e35e26ed8058"

URI_x86_64_v2_openssh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-9.9p1-7.el10_0.x86_64_v2.rpm;name=x86_64_v2_openssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh}"
SRC_URI[x86_64_v2_openssh.sha256sum] = "60f139f5d8b2bac6bfd6ba8f9de6aad16da07175c4acaa1f0f4866623885e526"

URI_x86_64_v2_openssh-askpass = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssh-askpass-9.9p1-7.el10_0.x86_64_v2.rpm;name=x86_64_v2_openssh-askpass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-askpass}"
SRC_URI[x86_64_v2_openssh-askpass.sha256sum] = "db9b762ea005564358947fe9ec5cbac53bd99d26174a5be84f05234a0ead0678"

URI_x86_64_v2_openssh-clients = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-clients-9.9p1-7.el10_0.x86_64_v2.rpm;name=x86_64_v2_openssh-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-clients}"
SRC_URI[x86_64_v2_openssh-clients.sha256sum] = "96f9100b962213396cc11a9bff4bebaf34a359c5247c05b7fffd18ce86f8689c"

URI_x86_64_v2_openssh-keycat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-keycat-9.9p1-7.el10_0.x86_64_v2.rpm;name=x86_64_v2_openssh-keycat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-keycat}"
SRC_URI[x86_64_v2_openssh-keycat.sha256sum] = "f6fc55b1695bd97e36549fe5437eca7a1faf78f0109c8fff1146092e6182aea2"

URI_x86_64_v2_openssh-keysign = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssh-keysign-9.9p1-7.el10_0.x86_64_v2.rpm;name=x86_64_v2_openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-keysign}"
SRC_URI[x86_64_v2_openssh-keysign.sha256sum] = "9bb729d94a013040c1e105f7131f3d45f0f17ef030c46f8e4f74eb663bc3bea9"

URI_x86_64_v2_openssh-server = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-server-9.9p1-7.el10_0.x86_64_v2.rpm;name=x86_64_v2_openssh-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-server}"
SRC_URI[x86_64_v2_openssh-server.sha256sum] = "985d197470a87f33c941172257a5cba30e602d4bd1ef9aa3d7643bb8bd5ffe53"

URI_aarch64_openssh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-9.9p1-7.el10_0.aarch64.rpm;name=aarch64_openssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh}"
SRC_URI[aarch64_openssh.sha256sum] = "5421820151e94087bc63a94c8108c377c3cb8c2a4d7bc3ca25e567c678b50d55"

URI_aarch64_openssh-askpass = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssh-askpass-9.9p1-7.el10_0.aarch64.rpm;name=aarch64_openssh-askpass;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-askpass}"
SRC_URI[aarch64_openssh-askpass.sha256sum] = "c5b3033232c78b3eabfbbd6e7451316148e6c40450b1cb0cc4a2650a99b89e0d"

URI_aarch64_openssh-clients = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-clients-9.9p1-7.el10_0.aarch64.rpm;name=aarch64_openssh-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-clients}"
SRC_URI[aarch64_openssh-clients.sha256sum] = "123e509fc5f48b1243817edbf05ce8b3ba00e85609d0f09e354694a3390067b3"

URI_aarch64_openssh-keycat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-keycat-9.9p1-7.el10_0.aarch64.rpm;name=aarch64_openssh-keycat;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-keycat}"
SRC_URI[aarch64_openssh-keycat.sha256sum] = "9a79fcebf912f4821a7b0289a56e250c0abb236d035f43f1eaf0563a61d873d8"

URI_aarch64_openssh-keysign = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssh-keysign-9.9p1-7.el10_0.aarch64.rpm;name=aarch64_openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-keysign}"
SRC_URI[aarch64_openssh-keysign.sha256sum] = "82ba4a436dce31850e8a330b84f7b2515f4f81a1ce62ff06611a0ac300a7f6d0"

URI_aarch64_openssh-server = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-server-9.9p1-7.el10_0.aarch64.rpm;name=aarch64_openssh-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-server}"
SRC_URI[aarch64_openssh-server.sha256sum] = "3388797299195014c6f632398d4316580db61bdd41fcac5a0d82e019761aa0fb"

RDEPENDS:openssh = " \
 audit-libs \
 glibc \
 libselinux \
 openssl-libs \
 util-linux \
 "
RDEPENDS:openssh-askpass = " \
 glib2 \
 glibc \
 gtk3 \
 openssh \
 "
RDEPENDS:openssh-clients = " \
 bash \
 crypto-policies \
 glibc \
 krb5-libs \
 libedit \
 libfido2 \
 libselinux \
 openssh \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:openssh-keycat = " \
 glibc \
 openssh \
 pam-libs \
 "
RDEPENDS:openssh-keysign = " \
 glibc \
 openssh \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:openssh-server = " \
 audit-libs \
 bash \
 crypto-policies \
 glibc \
 krb5-libs \
 libcom_err \
 libselinux \
 libxcrypt \
 openssh \
 openssl-libs \
 pam \
 pam-libs \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
