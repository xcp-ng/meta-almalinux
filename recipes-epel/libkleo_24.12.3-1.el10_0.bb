# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkleo"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 libkleo \
 libkleo-devel \
 libkleo-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkleo-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32f3cc1b15878865d62359cb69ad8df7b3a035e92e629b7c3f21af4ff0ae9163"

URI_x86_64_v2_libkleo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkleo-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkleo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkleo}"
SRC_URI[x86_64_v2_libkleo.sha256sum] = "b20f06734890391a509964ff800056de7f52928fece644f29c1ea6c22634cfbc"

URI_x86_64_v2_libkleo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkleo-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkleo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkleo-devel}"
SRC_URI[x86_64_v2_libkleo-devel.sha256sum] = "c65ba5143ee5ba4b7128fd8a684df55722bd6e0cb73e26fc249c98498fb64914"

URI_x86_64_v2_libkleo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkleo-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libkleo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkleo-doc}"
SRC_URI[x86_64_v2_libkleo-doc.sha256sum] = "f380943a1e4c797d6661aff7c784efc42699dbaebebb42d4563222388d575869"

URI_aarch64_libkleo = "${EPEL_MIRROR}/aarch64/Packages/l/libkleo-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkleo;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkleo}"
SRC_URI[aarch64_libkleo.sha256sum] = "892f1f35793f7e9482cdbade319e963462f08b3f2a910d73fae922773fb59503"

URI_aarch64_libkleo-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkleo-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkleo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkleo-devel}"
SRC_URI[aarch64_libkleo-devel.sha256sum] = "d8d06d5ed7f916326f2cdb671a9281abe12aabe25ac8d1db42cfcd2e6ab61bc0"

URI_aarch64_libkleo-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkleo-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_libkleo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkleo-doc}"
SRC_URI[aarch64_libkleo-doc.sha256sum] = "43295eeb5faa91e9064604a3d3fb37abe3f7b40a8c017cfb730f2888d8b4bee4"

RDEPENDS:libkleo = " \
 glibc \
 gpgmepp \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 libgcc \
 libstdc++ \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkleo-devel = " \
 cmake-filesystem \
 gpgmepp-devel \
 libkleo \
 qgpgme-qt6-devel \
 "
RDEPENDS:libkleo-doc = " \
 "
