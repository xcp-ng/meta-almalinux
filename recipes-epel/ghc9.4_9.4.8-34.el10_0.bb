# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc9.4"
PV = "9.4.8"
PR = "34.el10_0"
PACKAGES = " \
 ghc9.4 \
 ghc9.4-Cabal \
 ghc9.4-Cabal-devel \
 ghc9.4-Cabal-doc \
 ghc9.4-Cabal-prof \
 ghc9.4-Cabal-syntax \
 ghc9.4-Cabal-syntax-devel \
 ghc9.4-Cabal-syntax-doc \
 ghc9.4-Cabal-syntax-prof \
 ghc9.4-array \
 ghc9.4-array-devel \
 ghc9.4-array-doc \
 ghc9.4-array-prof \
 ghc9.4-base \
 ghc9.4-base-devel \
 ghc9.4-base-doc \
 ghc9.4-base-prof \
 ghc9.4-binary \
 ghc9.4-binary-devel \
 ghc9.4-binary-doc \
 ghc9.4-binary-prof \
 ghc9.4-bytestring \
 ghc9.4-bytestring-devel \
 ghc9.4-bytestring-doc \
 ghc9.4-bytestring-prof \
 ghc9.4-compiler \
 ghc9.4-compiler-default \
 ghc9.4-containers \
 ghc9.4-containers-devel \
 ghc9.4-containers-doc \
 ghc9.4-containers-prof \
 ghc9.4-deepseq \
 ghc9.4-deepseq-devel \
 ghc9.4-deepseq-doc \
 ghc9.4-deepseq-prof \
 ghc9.4-devel \
 ghc9.4-directory \
 ghc9.4-directory-devel \
 ghc9.4-directory-doc \
 ghc9.4-directory-prof \
 ghc9.4-doc \
 ghc9.4-doc-index \
 ghc9.4-exceptions \
 ghc9.4-exceptions-devel \
 ghc9.4-exceptions-doc \
 ghc9.4-exceptions-prof \
 ghc9.4-filepath \
 ghc9.4-filepath-devel \
 ghc9.4-filepath-doc \
 ghc9.4-filepath-prof \
 ghc9.4-filesystem \
 ghc9.4-ghc \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-bignum-devel \
 ghc9.4-ghc-bignum-doc \
 ghc9.4-ghc-bignum-prof \
 ghc9.4-ghc-boot \
 ghc9.4-ghc-boot-devel \
 ghc9.4-ghc-boot-doc \
 ghc9.4-ghc-boot-prof \
 ghc9.4-ghc-boot-th \
 ghc9.4-ghc-boot-th-devel \
 ghc9.4-ghc-boot-th-doc \
 ghc9.4-ghc-boot-th-prof \
 ghc9.4-ghc-compact \
 ghc9.4-ghc-compact-devel \
 ghc9.4-ghc-compact-doc \
 ghc9.4-ghc-compact-prof \
 ghc9.4-ghc-devel \
 ghc9.4-ghc-doc \
 ghc9.4-ghc-heap \
 ghc9.4-ghc-heap-devel \
 ghc9.4-ghc-heap-doc \
 ghc9.4-ghc-heap-prof \
 ghc9.4-ghc-prof \
 ghc9.4-ghci \
 ghc9.4-ghci-devel \
 ghc9.4-ghci-doc \
 ghc9.4-ghci-prof \
 ghc9.4-hadrian \
 ghc9.4-haskeline \
 ghc9.4-haskeline-devel \
 ghc9.4-haskeline-doc \
 ghc9.4-haskeline-prof \
 ghc9.4-hpc \
 ghc9.4-hpc-devel \
 ghc9.4-hpc-doc \
 ghc9.4-hpc-prof \
 ghc9.4-libiserv \
 ghc9.4-libiserv-devel \
 ghc9.4-libiserv-doc \
 ghc9.4-libiserv-prof \
 ghc9.4-manual \
 ghc9.4-mtl \
 ghc9.4-mtl-devel \
 ghc9.4-mtl-doc \
 ghc9.4-mtl-prof \
 ghc9.4-parsec \
 ghc9.4-parsec-devel \
 ghc9.4-parsec-doc \
 ghc9.4-parsec-prof \
 ghc9.4-pretty \
 ghc9.4-pretty-devel \
 ghc9.4-pretty-doc \
 ghc9.4-pretty-prof \
 ghc9.4-process \
 ghc9.4-process-devel \
 ghc9.4-process-doc \
 ghc9.4-process-prof \
 ghc9.4-prof \
 ghc9.4-stm \
 ghc9.4-stm-devel \
 ghc9.4-stm-doc \
 ghc9.4-stm-prof \
 ghc9.4-template-haskell \
 ghc9.4-template-haskell-devel \
 ghc9.4-template-haskell-doc \
 ghc9.4-template-haskell-prof \
 ghc9.4-terminfo \
 ghc9.4-terminfo-devel \
 ghc9.4-terminfo-doc \
 ghc9.4-terminfo-prof \
 ghc9.4-text \
 ghc9.4-text-devel \
 ghc9.4-text-doc \
 ghc9.4-text-prof \
 ghc9.4-time \
 ghc9.4-time-devel \
 ghc9.4-time-doc \
 ghc9.4-time-prof \
 ghc9.4-transformers \
 ghc9.4-transformers-devel \
 ghc9.4-transformers-doc \
 ghc9.4-transformers-prof \
 ghc9.4-unix \
 ghc9.4-unix-devel \
 ghc9.4-unix-doc \
 ghc9.4-unix-prof \
 ghc9.4-xhtml \
 ghc9.4-xhtml-devel \
 ghc9.4-xhtml-doc \
 ghc9.4-xhtml-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc9.4-9.4.8-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2ff0de9c0fe0c4c86d2ac5a436321bf1d34395a1ccf95f0ab5b468197b1af6e"

URI_x86_64_v2_ghc9.4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4}"
SRC_URI[x86_64_v2_ghc9.4.sha256sum] = "414aba6b2640d2ee960024df986cd1b89d042fdbd9390d88ab2eaf461a0b3c80"

URI_x86_64_v2_ghc9.4-Cabal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-Cabal-3.8.1.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-Cabal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-Cabal}"
SRC_URI[x86_64_v2_ghc9.4-Cabal.sha256sum] = "a81135c541d291dda5a0700aaa66185af42576fb8e1604e256cb9a1f33d36167"

URI_x86_64_v2_ghc9.4-Cabal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-Cabal-devel-3.8.1.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-Cabal-devel}"
SRC_URI[x86_64_v2_ghc9.4-Cabal-devel.sha256sum] = "79f1e77c00f5ddc4a0562f8ba94f2b05c123fd1f8bb960b577917f0f07aa8aa8"

URI_x86_64_v2_ghc9.4-Cabal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-Cabal-doc-3.8.1.0-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-Cabal-doc}"
SRC_URI[x86_64_v2_ghc9.4-Cabal-doc.sha256sum] = "f0d6d0802c7aeec6767ec6c4fd44bebb22b43844b8ee665fdacadd0cf60bf1ee"

URI_x86_64_v2_ghc9.4-Cabal-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-Cabal-prof-3.8.1.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-Cabal-prof}"
SRC_URI[x86_64_v2_ghc9.4-Cabal-prof.sha256sum] = "274658542fc66597b5975320e9f2065e770fdf2837ac79cbae8a95e9cb6e2c4f"

URI_x86_64_v2_ghc9.4-Cabal-syntax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-Cabal-syntax-3.8.1.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-Cabal-syntax}"
SRC_URI[x86_64_v2_ghc9.4-Cabal-syntax.sha256sum] = "42a5b352a19885280bccdc63365d635eeda156d9b82e8954a44ba7471f861b15"

URI_x86_64_v2_ghc9.4-Cabal-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-Cabal-syntax-devel-3.8.1.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-Cabal-syntax-devel}"
SRC_URI[x86_64_v2_ghc9.4-Cabal-syntax-devel.sha256sum] = "5b7d23034cd319645cb4660f0b4e2c1c477fa46ad0d19f5258c6f2263f225a40"

URI_x86_64_v2_ghc9.4-Cabal-syntax-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-Cabal-syntax-doc-3.8.1.0-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-Cabal-syntax-doc}"
SRC_URI[x86_64_v2_ghc9.4-Cabal-syntax-doc.sha256sum] = "1a5e728196bd7b1fca63865d6283353fba320906d9f5c7826edc4af91687f60d"

URI_x86_64_v2_ghc9.4-Cabal-syntax-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-Cabal-syntax-prof-3.8.1.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-Cabal-syntax-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-Cabal-syntax-prof}"
SRC_URI[x86_64_v2_ghc9.4-Cabal-syntax-prof.sha256sum] = "4bd7fa949eb3d2f3c762b7619b3b7d37355e1fb7ee12b2e30ab5ed8ef6ac5eb7"

URI_x86_64_v2_ghc9.4-array = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-array-0.5.4.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-array}"
SRC_URI[x86_64_v2_ghc9.4-array.sha256sum] = "75c445fc8e80dabb2d17177c93f820c63d41b56c765183338baca25f82967091"

URI_x86_64_v2_ghc9.4-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-array-devel-0.5.4.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-array-devel}"
SRC_URI[x86_64_v2_ghc9.4-array-devel.sha256sum] = "9ddb484e94e56214bab3711e8b8ea8f69f0bfb467bcb2fbb0f5184b481ff68f1"

URI_x86_64_v2_ghc9.4-array-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-array-doc-0.5.4.0-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-array-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-array-doc}"
SRC_URI[x86_64_v2_ghc9.4-array-doc.sha256sum] = "c28f4aca3aef5a332cd30d9d9daa55c5eccb6221454c24d0e7b16fbdb0f3129b"

URI_x86_64_v2_ghc9.4-array-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-array-prof-0.5.4.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-array-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-array-prof}"
SRC_URI[x86_64_v2_ghc9.4-array-prof.sha256sum] = "cd8719069c868e1a6bb73df84fa560fbeb009a97591ccadca5cb6b525377053c"

URI_x86_64_v2_ghc9.4-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-base-4.17.2.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-base}"
SRC_URI[x86_64_v2_ghc9.4-base.sha256sum] = "7ce950482f9ea9b9ff4709180711b7a0ffd3a456af689a2986bf3d3abf9a1b1d"

URI_x86_64_v2_ghc9.4-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-base-devel-4.17.2.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-base-devel}"
SRC_URI[x86_64_v2_ghc9.4-base-devel.sha256sum] = "f1f629d978b57b10dcc09771691b06f06b886e6363d52cca827eaa7d9a03e419"

URI_x86_64_v2_ghc9.4-base-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-base-doc-4.17.2.1-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-base-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-base-doc}"
SRC_URI[x86_64_v2_ghc9.4-base-doc.sha256sum] = "de8b8e65fea9fb02af9787a4be445b5901703eaf88564e6c217504d07b5081d5"

URI_x86_64_v2_ghc9.4-base-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-base-prof-4.17.2.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-base-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-base-prof}"
SRC_URI[x86_64_v2_ghc9.4-base-prof.sha256sum] = "dd9ec05257da1a89ba2479185211d8a6f4697900feab11d7b526e68f935bb2da"

URI_x86_64_v2_ghc9.4-binary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-binary-0.8.9.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-binary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-binary}"
SRC_URI[x86_64_v2_ghc9.4-binary.sha256sum] = "fedb0396d0ca5fb8dbbd5a03ce292205a489e14c7d5206e942d6b506b5b7237a"

URI_x86_64_v2_ghc9.4-binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-binary-devel-0.8.9.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-binary-devel}"
SRC_URI[x86_64_v2_ghc9.4-binary-devel.sha256sum] = "0b31871ff56a3a65ea0d75f21cc1f3399ab60349fff30f22fb0b4bce04530acf"

URI_x86_64_v2_ghc9.4-binary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-binary-doc-0.8.9.1-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-binary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-binary-doc}"
SRC_URI[x86_64_v2_ghc9.4-binary-doc.sha256sum] = "d696de0007ea7c93622ed4d50ab4fbffa1ecb328efab7e1c40c21c41a260c274"

URI_x86_64_v2_ghc9.4-binary-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-binary-prof-0.8.9.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-binary-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-binary-prof}"
SRC_URI[x86_64_v2_ghc9.4-binary-prof.sha256sum] = "ac2fa6e2fa7573d82ea582627e1ce113be64366e8cb5c6db38b30329e9e59fde"

URI_x86_64_v2_ghc9.4-bytestring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-bytestring-0.11.5.3-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-bytestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-bytestring}"
SRC_URI[x86_64_v2_ghc9.4-bytestring.sha256sum] = "cd031b6f22cfc911a5487e9c826bc2dfdc95d7c4c3d4324ad094240d3ced259d"

URI_x86_64_v2_ghc9.4-bytestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-bytestring-devel-0.11.5.3-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-bytestring-devel}"
SRC_URI[x86_64_v2_ghc9.4-bytestring-devel.sha256sum] = "52f0c3f568512ee62d993bafee98437bddff797b54c272119f9101abe5407672"

URI_x86_64_v2_ghc9.4-bytestring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-bytestring-doc-0.11.5.3-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-bytestring-doc}"
SRC_URI[x86_64_v2_ghc9.4-bytestring-doc.sha256sum] = "53880c7d6ed350c90abfcb019cac09d087c72f7ef439e372890c110ea002a208"

URI_x86_64_v2_ghc9.4-bytestring-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-bytestring-prof-0.11.5.3-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-bytestring-prof}"
SRC_URI[x86_64_v2_ghc9.4-bytestring-prof.sha256sum] = "4b4b7df6937386c52ad3afed26cfd1e6f235651ecfb9ab64e771a342101bd8e0"

URI_x86_64_v2_ghc9.4-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-compiler-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-compiler}"
SRC_URI[x86_64_v2_ghc9.4-compiler.sha256sum] = "11f0148ec4a14310214e45e2076bbecc3edfadf6bb0d5f0bb08640ebbdc2871a"

URI_x86_64_v2_ghc9.4-compiler-default = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-compiler-default-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-compiler-default;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-compiler-default}"
SRC_URI[x86_64_v2_ghc9.4-compiler-default.sha256sum] = "d06ae5010066861bdd1de749223b32e30a18512e0f1ed8b6257fb36f76fb177f"

URI_x86_64_v2_ghc9.4-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-containers-0.6.7-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-containers}"
SRC_URI[x86_64_v2_ghc9.4-containers.sha256sum] = "5b2f1077edc07dccc563dc93b6127894b37deb224b87a42f83038ec258684538"

URI_x86_64_v2_ghc9.4-containers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-containers-devel-0.6.7-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-containers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-containers-devel}"
SRC_URI[x86_64_v2_ghc9.4-containers-devel.sha256sum] = "e7706c6d9a6f282b2157c1ae422624f8380d8c80c7bf153e4275849a21a51f5a"

URI_x86_64_v2_ghc9.4-containers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-containers-doc-0.6.7-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-containers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-containers-doc}"
SRC_URI[x86_64_v2_ghc9.4-containers-doc.sha256sum] = "424dca1ae0433e97f9ac8b5930c6dabb82dc050d2cb87aac55e0eef06986604c"

URI_x86_64_v2_ghc9.4-containers-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-containers-prof-0.6.7-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-containers-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-containers-prof}"
SRC_URI[x86_64_v2_ghc9.4-containers-prof.sha256sum] = "f72facb1c3ca81acdc6d7ce9c7a148ca5d664cfef06bb8d4ceb417c1e7576934"

URI_x86_64_v2_ghc9.4-deepseq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-deepseq-1.4.8.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-deepseq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-deepseq}"
SRC_URI[x86_64_v2_ghc9.4-deepseq.sha256sum] = "cf8386e9467104448342d74658b8b1dbcb26ad041b4cb922ff1c31b33c5adff8"

URI_x86_64_v2_ghc9.4-deepseq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-deepseq-devel-1.4.8.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-deepseq-devel}"
SRC_URI[x86_64_v2_ghc9.4-deepseq-devel.sha256sum] = "2adc3dd2956b19b33f413a5e558909b0e8c50f03f39fdfc144dd60a318ce73bb"

URI_x86_64_v2_ghc9.4-deepseq-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-deepseq-doc-1.4.8.0-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-deepseq-doc}"
SRC_URI[x86_64_v2_ghc9.4-deepseq-doc.sha256sum] = "d320f572234b715836d29f47f490fce83a2aed8957d44bb80b6b806347ae3a6b"

URI_x86_64_v2_ghc9.4-deepseq-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-deepseq-prof-1.4.8.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-deepseq-prof}"
SRC_URI[x86_64_v2_ghc9.4-deepseq-prof.sha256sum] = "c3b3199b294e7e54554995c3043b4f83e4c3094ff57bc779f0c0ac21c3a200df"

URI_x86_64_v2_ghc9.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-devel-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-devel}"
SRC_URI[x86_64_v2_ghc9.4-devel.sha256sum] = "9e169094954c0bc515641a179b6d2395569461989d50892a490711c0f6789c7e"

URI_x86_64_v2_ghc9.4-directory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-directory-1.3.7.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-directory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-directory}"
SRC_URI[x86_64_v2_ghc9.4-directory.sha256sum] = "d09252aeb19670dd7639b7c4b7eaed9c3c753c114ff7c98469b4f2e764755b9f"

URI_x86_64_v2_ghc9.4-directory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-directory-devel-1.3.7.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-directory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-directory-devel}"
SRC_URI[x86_64_v2_ghc9.4-directory-devel.sha256sum] = "44143fc1d79f9fbbbbbb0a242a9fca7d08f36a5f7807c0669cb7144e509cde64"

URI_x86_64_v2_ghc9.4-directory-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-directory-doc-1.3.7.1-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-directory-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-directory-doc}"
SRC_URI[x86_64_v2_ghc9.4-directory-doc.sha256sum] = "bfeb92e6b5b1a7721abcf451930702647c863b91df16efaca82f5f73b979ac80"

URI_x86_64_v2_ghc9.4-directory-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-directory-prof-1.3.7.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-directory-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-directory-prof}"
SRC_URI[x86_64_v2_ghc9.4-directory-prof.sha256sum] = "4ae317f5ac05b818cb86174eea350114271db278cdccfca095190f6776310b33"

URI_x86_64_v2_ghc9.4-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-doc-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-doc}"
SRC_URI[x86_64_v2_ghc9.4-doc.sha256sum] = "38feaca28a50953937bfbd687a23c28d8c5e755e431554c30126f7262892db7b"

URI_x86_64_v2_ghc9.4-doc-index = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-doc-index-9.4.8-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-doc-index;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-doc-index}"
SRC_URI[x86_64_v2_ghc9.4-doc-index.sha256sum] = "37488ae348515e35075940d0f7e3f75399292660d24167725357c305a816cb80"

URI_x86_64_v2_ghc9.4-exceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-exceptions-0.10.5-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-exceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-exceptions}"
SRC_URI[x86_64_v2_ghc9.4-exceptions.sha256sum] = "e779c088551ee217ee1b6be8069ebbbc1971de068f2efea6601880c286abeb49"

URI_x86_64_v2_ghc9.4-exceptions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-exceptions-devel-0.10.5-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-exceptions-devel}"
SRC_URI[x86_64_v2_ghc9.4-exceptions-devel.sha256sum] = "4ec3351bdc19d2cf8f4c00d076d469408eca79e9ff5b00b1cb0ba04cbc6a445b"

URI_x86_64_v2_ghc9.4-exceptions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-exceptions-doc-0.10.5-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-exceptions-doc}"
SRC_URI[x86_64_v2_ghc9.4-exceptions-doc.sha256sum] = "24048cee11511fecf53b02a0da206468bd457920a6294134f031b0ca68d3fd6f"

URI_x86_64_v2_ghc9.4-exceptions-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-exceptions-prof-0.10.5-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-exceptions-prof}"
SRC_URI[x86_64_v2_ghc9.4-exceptions-prof.sha256sum] = "c6538c16a61b8c94670d5d50e85fc3ea9fc84fded1e8016bee38080b2a505b5d"

URI_x86_64_v2_ghc9.4-filepath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-filepath-1.4.2.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-filepath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-filepath}"
SRC_URI[x86_64_v2_ghc9.4-filepath.sha256sum] = "b535dba6af83a91822c1f26b5f92219c61987a061567c8a0708fa726fe9d1afd"

URI_x86_64_v2_ghc9.4-filepath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-filepath-devel-1.4.2.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-filepath-devel}"
SRC_URI[x86_64_v2_ghc9.4-filepath-devel.sha256sum] = "a44dbe897abe3ba0f5cf454ea2d632b3a69e9eecbbc6c8729a2843941b2153eb"

URI_x86_64_v2_ghc9.4-filepath-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-filepath-doc-1.4.2.2-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-filepath-doc}"
SRC_URI[x86_64_v2_ghc9.4-filepath-doc.sha256sum] = "2a24215eee3525b7611d4b6fec8cd0425883dba13e3913069159d03c3f4c99f4"

URI_x86_64_v2_ghc9.4-filepath-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-filepath-prof-1.4.2.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-filepath-prof}"
SRC_URI[x86_64_v2_ghc9.4-filepath-prof.sha256sum] = "25bc4638ab2e972ba595fb614f623ea7af5dd94143c7afa041ce09ba885d94bd"

URI_x86_64_v2_ghc9.4-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-filesystem-9.4.8-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-filesystem}"
SRC_URI[x86_64_v2_ghc9.4-filesystem.sha256sum] = "4a213e2b73a65a71aaacdfeae298a734dd1f6aff37ca37aa23ffa8fa3d028299"

URI_x86_64_v2_ghc9.4-ghc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc}"
SRC_URI[x86_64_v2_ghc9.4-ghc.sha256sum] = "62c080ce204412e0eea41d24d5755fa452f1e0a8fb9bca0f9a39bf29bb9d1a51"

URI_x86_64_v2_ghc9.4-ghc-bignum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-bignum-1.3-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-bignum}"
SRC_URI[x86_64_v2_ghc9.4-ghc-bignum.sha256sum] = "4602342f419c8bde95a268fdc26bb06b21198d9e7513371083cbc87628bf3123"

URI_x86_64_v2_ghc9.4-ghc-bignum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-bignum-devel-1.3-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-bignum-devel}"
SRC_URI[x86_64_v2_ghc9.4-ghc-bignum-devel.sha256sum] = "ae5d7d1f0a87884d31675a4f217425d171b193c2f25cabed3b011b81023ffd38"

URI_x86_64_v2_ghc9.4-ghc-bignum-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-bignum-doc-1.3-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-bignum-doc}"
SRC_URI[x86_64_v2_ghc9.4-ghc-bignum-doc.sha256sum] = "9f4b74e773835bc81cf8e3d9ce1fc0103c04b58b15b61ad1fc66770beedd80b6"

URI_x86_64_v2_ghc9.4-ghc-bignum-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-bignum-prof-1.3-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-bignum-prof}"
SRC_URI[x86_64_v2_ghc9.4-ghc-bignum-prof.sha256sum] = "07048f848d4df0d4c96b299b10dcbbc6a03120a7c6f8b5e5d90d85e534b70a46"

URI_x86_64_v2_ghc9.4-ghc-boot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-boot-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-boot}"
SRC_URI[x86_64_v2_ghc9.4-ghc-boot.sha256sum] = "1f2004425118c00bad5011b8ec0f8eb35ae123d1447574d7734a7e3ff75b53c1"

URI_x86_64_v2_ghc9.4-ghc-boot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-boot-devel-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-boot-devel}"
SRC_URI[x86_64_v2_ghc9.4-ghc-boot-devel.sha256sum] = "573acf6e97deb8e6ae94460f7b18d6a59fba4971db6f225d219e627295f1d1c6"

URI_x86_64_v2_ghc9.4-ghc-boot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-boot-doc-9.4.8-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-boot-doc}"
SRC_URI[x86_64_v2_ghc9.4-ghc-boot-doc.sha256sum] = "6a31139b6d65bedff9ebda46d9d069f9ccf524e35b6e10caec907188e70bfde6"

URI_x86_64_v2_ghc9.4-ghc-boot-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-boot-prof-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-boot-prof}"
SRC_URI[x86_64_v2_ghc9.4-ghc-boot-prof.sha256sum] = "acd15e51812417053bf6c8357439e5d1194fc1678fb7b9ebaa07749a0e81bd1a"

URI_x86_64_v2_ghc9.4-ghc-boot-th = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-boot-th-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-boot-th}"
SRC_URI[x86_64_v2_ghc9.4-ghc-boot-th.sha256sum] = "d0427ae95a7b400a705cca8fd5f169e2a4a7c83c8be7c99019180e3f933789fb"

URI_x86_64_v2_ghc9.4-ghc-boot-th-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-boot-th-devel-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-boot-th-devel}"
SRC_URI[x86_64_v2_ghc9.4-ghc-boot-th-devel.sha256sum] = "910ce4ac085f5b21de2e9973dd248c5fd388325ca274a97c3b062df73a0c67f7"

URI_x86_64_v2_ghc9.4-ghc-boot-th-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-boot-th-doc-9.4.8-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-boot-th-doc}"
SRC_URI[x86_64_v2_ghc9.4-ghc-boot-th-doc.sha256sum] = "2dc6a7d90fb6acc8e86170ccc6ae9bca04df6786f4ad80d9a435dad50096aa1c"

URI_x86_64_v2_ghc9.4-ghc-boot-th-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-boot-th-prof-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-boot-th-prof}"
SRC_URI[x86_64_v2_ghc9.4-ghc-boot-th-prof.sha256sum] = "99f373ac9674f16297e664f96a425d562b18c0e60b862c4a0a6f0f904fd84c95"

URI_x86_64_v2_ghc9.4-ghc-compact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-compact-0.1.0.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-compact}"
SRC_URI[x86_64_v2_ghc9.4-ghc-compact.sha256sum] = "7c7278f6edf006d686757322490e46dafa9422955e234df11f2de41addc7e560"

URI_x86_64_v2_ghc9.4-ghc-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-compact-devel-0.1.0.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-compact-devel}"
SRC_URI[x86_64_v2_ghc9.4-ghc-compact-devel.sha256sum] = "2e6a1acfeedc62ea7b909bf7fbd9244e163fa9462e7b9d694edef1ae2da3e3ec"

URI_x86_64_v2_ghc9.4-ghc-compact-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-compact-doc-0.1.0.0-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-compact-doc}"
SRC_URI[x86_64_v2_ghc9.4-ghc-compact-doc.sha256sum] = "12d1eae9ec9014fa98e4c1cf27be7600268585875dcb79b5168b8f23263463e7"

URI_x86_64_v2_ghc9.4-ghc-compact-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-compact-prof-0.1.0.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-compact-prof}"
SRC_URI[x86_64_v2_ghc9.4-ghc-compact-prof.sha256sum] = "e4d58143ac7514c87a67a33249b598b86cd0acb9c31bdd77fbf90e9564f65027"

URI_x86_64_v2_ghc9.4-ghc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-devel-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-devel}"
SRC_URI[x86_64_v2_ghc9.4-ghc-devel.sha256sum] = "b9f9e57c3232869ab810b16517da361297132db001dbc726e0d62554aee7e189"

URI_x86_64_v2_ghc9.4-ghc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-doc-9.4.8-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-doc}"
SRC_URI[x86_64_v2_ghc9.4-ghc-doc.sha256sum] = "9365f16bbfcda89bec27e33208713831057928de496b31b6e2d6a5ec7edd2c82"

URI_x86_64_v2_ghc9.4-ghc-heap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-heap-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-heap}"
SRC_URI[x86_64_v2_ghc9.4-ghc-heap.sha256sum] = "c654faee54f44bfe311914f7515b8ae6db4b1ec5d590e96071b907930179f99e"

URI_x86_64_v2_ghc9.4-ghc-heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-heap-devel-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-heap-devel}"
SRC_URI[x86_64_v2_ghc9.4-ghc-heap-devel.sha256sum] = "f88a488de29adb2ccc26eca01bc67ac9534c9f88db6b0efffe0c2398039f1e31"

URI_x86_64_v2_ghc9.4-ghc-heap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-heap-doc-9.4.8-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-heap-doc}"
SRC_URI[x86_64_v2_ghc9.4-ghc-heap-doc.sha256sum] = "59a157c6e651e73a7fcc91ada991b3206d280f840a216a114c93bbe7ac24a190"

URI_x86_64_v2_ghc9.4-ghc-heap-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-heap-prof-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-heap-prof}"
SRC_URI[x86_64_v2_ghc9.4-ghc-heap-prof.sha256sum] = "86779e06045eee0e7edfc022cbeec4d5e72bed8096e25cf2d13e5f8a2e5f9335"

URI_x86_64_v2_ghc9.4-ghc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghc-prof-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghc-prof}"
SRC_URI[x86_64_v2_ghc9.4-ghc-prof.sha256sum] = "1717eca3b48e09d12695162356d03b5d5e7069ba01687698d4e5de1b4507c775"

URI_x86_64_v2_ghc9.4-ghci = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghci-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghci}"
SRC_URI[x86_64_v2_ghc9.4-ghci.sha256sum] = "c38cdd5fbf478d4f3bc96655f22a4d01a7dcd81153a2891b72b2bebafedd8f89"

URI_x86_64_v2_ghc9.4-ghci-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghci-devel-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghci-devel}"
SRC_URI[x86_64_v2_ghc9.4-ghci-devel.sha256sum] = "48241a0ddac28e50a57551e52b34e8febad0274b4f01e39106fcabdb2cac64fe"

URI_x86_64_v2_ghc9.4-ghci-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghci-doc-9.4.8-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghci-doc}"
SRC_URI[x86_64_v2_ghc9.4-ghci-doc.sha256sum] = "fd7865daf4f28ee6eaf3567c6d7ad9040757605b71c04060306127fd068b2201"

URI_x86_64_v2_ghc9.4-ghci-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-ghci-prof-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-ghci-prof}"
SRC_URI[x86_64_v2_ghc9.4-ghci-prof.sha256sum] = "b7dec84dd683158c350828d9759b706b38c96dca988be4ca261884efbd72b004"

URI_x86_64_v2_ghc9.4-hadrian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-hadrian-0.1.0.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-hadrian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-hadrian}"
SRC_URI[x86_64_v2_ghc9.4-hadrian.sha256sum] = "1b6f5125111c9b1be2d42f406184c75ae6c5cfaec5d571239009a09f9186d786"

URI_x86_64_v2_ghc9.4-haskeline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-haskeline-0.8.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-haskeline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-haskeline}"
SRC_URI[x86_64_v2_ghc9.4-haskeline.sha256sum] = "505f466e8e70f67265842e123ada6dff37ac233896fcf7b4f9fd8ccbd9eaff4f"

URI_x86_64_v2_ghc9.4-haskeline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-haskeline-devel-0.8.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-haskeline-devel}"
SRC_URI[x86_64_v2_ghc9.4-haskeline-devel.sha256sum] = "f5f40171ce241e53b315d81d5e97dc77070a406e0fe4e2a1441f9d8bba53f074"

URI_x86_64_v2_ghc9.4-haskeline-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-haskeline-doc-0.8.2-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-haskeline-doc}"
SRC_URI[x86_64_v2_ghc9.4-haskeline-doc.sha256sum] = "77aecd97be49b1388b57f9f233439eb9196efee5355dc1c0992cdab0bd416c55"

URI_x86_64_v2_ghc9.4-haskeline-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-haskeline-prof-0.8.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-haskeline-prof}"
SRC_URI[x86_64_v2_ghc9.4-haskeline-prof.sha256sum] = "9b52979e128250d9db06bc3b8fe87a34ee03c2f24eecd29cb6a68c32aa4f3818"

URI_x86_64_v2_ghc9.4-hpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-hpc-0.6.1.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-hpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-hpc}"
SRC_URI[x86_64_v2_ghc9.4-hpc.sha256sum] = "59c44df2727650917e73f30450d61f678e840adb35387415d097335d3a3a7f9b"

URI_x86_64_v2_ghc9.4-hpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-hpc-devel-0.6.1.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-hpc-devel}"
SRC_URI[x86_64_v2_ghc9.4-hpc-devel.sha256sum] = "a7fe2ea7f34f4d1fef03e9c0f1391ab6582d854e09ee5d65ddcd3b804c05da3c"

URI_x86_64_v2_ghc9.4-hpc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-hpc-doc-0.6.1.0-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-hpc-doc}"
SRC_URI[x86_64_v2_ghc9.4-hpc-doc.sha256sum] = "24051946b31d45759686c1d89107a61935e14c32f51666b44c109d85a85d5bfc"

URI_x86_64_v2_ghc9.4-hpc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-hpc-prof-0.6.1.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-hpc-prof}"
SRC_URI[x86_64_v2_ghc9.4-hpc-prof.sha256sum] = "35be3b620ea25d51b6d35d5fd3de6b1306296473c97954b95e9a8c8e6d0fc3c0"

URI_x86_64_v2_ghc9.4-libiserv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-libiserv-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-libiserv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-libiserv}"
SRC_URI[x86_64_v2_ghc9.4-libiserv.sha256sum] = "f8c1fa73095f340c02243a5b3079ff1bce8399a659840d8bc56d6cd1750a1951"

URI_x86_64_v2_ghc9.4-libiserv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-libiserv-devel-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-libiserv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-libiserv-devel}"
SRC_URI[x86_64_v2_ghc9.4-libiserv-devel.sha256sum] = "a29b4ccfcb0bcb24c664618828a5df6e15d28078caa9352866a36a4074bf6dc2"

URI_x86_64_v2_ghc9.4-libiserv-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-libiserv-doc-9.4.8-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-libiserv-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-libiserv-doc}"
SRC_URI[x86_64_v2_ghc9.4-libiserv-doc.sha256sum] = "9cc5044f1c1dce4d7c1d2faeb9a212e28f892aebfbbce41204ab524c56dd6c95"

URI_x86_64_v2_ghc9.4-libiserv-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-libiserv-prof-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-libiserv-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-libiserv-prof}"
SRC_URI[x86_64_v2_ghc9.4-libiserv-prof.sha256sum] = "6c2b12b480a0b47af43b59e10fa5120ae12d9fea999de412604c17a5381de5b9"

URI_x86_64_v2_ghc9.4-manual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-manual-9.4.8-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-manual}"
SRC_URI[x86_64_v2_ghc9.4-manual.sha256sum] = "97e755c41f8c38be5694358f027f232ce8fb0c57f93cf208d4c5b0fa2622e55b"

URI_x86_64_v2_ghc9.4-mtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-mtl-2.2.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-mtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-mtl}"
SRC_URI[x86_64_v2_ghc9.4-mtl.sha256sum] = "dbe005407d36de339caafc4dd5d63dbe275c8d6da6403e1a0b3deb248a0a08d9"

URI_x86_64_v2_ghc9.4-mtl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-mtl-devel-2.2.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-mtl-devel}"
SRC_URI[x86_64_v2_ghc9.4-mtl-devel.sha256sum] = "40756b6d504c3923a986d9c848af84c16fde5f0850e4e2dc516fee7327d7fdf2"

URI_x86_64_v2_ghc9.4-mtl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-mtl-doc-2.2.2-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-mtl-doc}"
SRC_URI[x86_64_v2_ghc9.4-mtl-doc.sha256sum] = "aede6a4dbd2a0f951f1a7116680758aee86bc777f1225d2aec1571424d1aa5b5"

URI_x86_64_v2_ghc9.4-mtl-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-mtl-prof-2.2.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-mtl-prof}"
SRC_URI[x86_64_v2_ghc9.4-mtl-prof.sha256sum] = "819aac3c4a3fb6c4fcf053d24a596540db87453ed701cd21fc29d0fb51acd911"

URI_x86_64_v2_ghc9.4-parsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-parsec-3.1.16.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-parsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-parsec}"
SRC_URI[x86_64_v2_ghc9.4-parsec.sha256sum] = "b2b6af09328c05566e0ba3408a1ed12c061bf28e37c27daee3b1d99a15c4b3c3"

URI_x86_64_v2_ghc9.4-parsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-parsec-devel-3.1.16.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-parsec-devel}"
SRC_URI[x86_64_v2_ghc9.4-parsec-devel.sha256sum] = "c406e50cdde39f0fdf742f3489cf0107acd1f7544478cec8188b97db8fa4f025"

URI_x86_64_v2_ghc9.4-parsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-parsec-doc-3.1.16.1-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-parsec-doc}"
SRC_URI[x86_64_v2_ghc9.4-parsec-doc.sha256sum] = "59edef103ac9f181b865e4ad23b4766a14106e94c35caad0568b8b509a506041"

URI_x86_64_v2_ghc9.4-parsec-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-parsec-prof-3.1.16.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-parsec-prof}"
SRC_URI[x86_64_v2_ghc9.4-parsec-prof.sha256sum] = "1830b66353521edcd1eef29b0f03b90c7512ce27ab0c3040ec6117feebb1fccf"

URI_x86_64_v2_ghc9.4-pretty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-pretty-1.1.3.6-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-pretty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-pretty}"
SRC_URI[x86_64_v2_ghc9.4-pretty.sha256sum] = "6f0fddb3d08398b6c4cd0f542d87a36443e327bd4a7ffdf9c433136921917ed6"

URI_x86_64_v2_ghc9.4-pretty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-pretty-devel-1.1.3.6-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-pretty-devel}"
SRC_URI[x86_64_v2_ghc9.4-pretty-devel.sha256sum] = "96aa0ef4296940db53c161613139934ae272ffafa06ca29514b18cbb3d298377"

URI_x86_64_v2_ghc9.4-pretty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-pretty-doc-1.1.3.6-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-pretty-doc}"
SRC_URI[x86_64_v2_ghc9.4-pretty-doc.sha256sum] = "a601d068741516296306cf072dc9f2e17e74d16c05ccea8ed8768c9cc30adcde"

URI_x86_64_v2_ghc9.4-pretty-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-pretty-prof-1.1.3.6-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-pretty-prof}"
SRC_URI[x86_64_v2_ghc9.4-pretty-prof.sha256sum] = "ae177f20b7bcd9c6778954390c25576edf72c12c0a1ed02e7fe4fbf9499d93c1"

URI_x86_64_v2_ghc9.4-process = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-process-1.6.18.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-process}"
SRC_URI[x86_64_v2_ghc9.4-process.sha256sum] = "c8e12edcc9a5e121bc5ad891ccf6756773ab4931885038e61098eacff527d56d"

URI_x86_64_v2_ghc9.4-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-process-devel-1.6.18.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-process-devel}"
SRC_URI[x86_64_v2_ghc9.4-process-devel.sha256sum] = "0d1c575f338d9209908e71668a34382b6a210868948cd792f07c7c685623bd30"

URI_x86_64_v2_ghc9.4-process-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-process-doc-1.6.18.0-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-process-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-process-doc}"
SRC_URI[x86_64_v2_ghc9.4-process-doc.sha256sum] = "b03a1b342ed895752c3c41755b1bd1e0fc56e5999fd298a4ba62cbc6310de69a"

URI_x86_64_v2_ghc9.4-process-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-process-prof-1.6.18.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-process-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-process-prof}"
SRC_URI[x86_64_v2_ghc9.4-process-prof.sha256sum] = "7d3a8b5fa11a64879a47c31d3b55eebe1da6e8fcc24ecc12c6408fa36f93864e"

URI_x86_64_v2_ghc9.4-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-prof-9.4.8-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-prof}"
SRC_URI[x86_64_v2_ghc9.4-prof.sha256sum] = "9677d2711d0a89beb74274be22929eef3533ca4c1fe9da8d3c204d76725bcb64"

URI_x86_64_v2_ghc9.4-stm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-stm-2.5.1.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-stm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-stm}"
SRC_URI[x86_64_v2_ghc9.4-stm.sha256sum] = "ea2ec3fa787688bd5877e5b2d4158f0203e78382578cc1fa9f5d4bdec6ea2e04"

URI_x86_64_v2_ghc9.4-stm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-stm-devel-2.5.1.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-stm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-stm-devel}"
SRC_URI[x86_64_v2_ghc9.4-stm-devel.sha256sum] = "522b2d3652d33dc7c12c07ffdd0bb49eb6010ec2f36c2a54d4bbb20f268c22be"

URI_x86_64_v2_ghc9.4-stm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-stm-doc-2.5.1.0-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-stm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-stm-doc}"
SRC_URI[x86_64_v2_ghc9.4-stm-doc.sha256sum] = "bc2c761b4f647212e78e0435be0b6fe335254462228afc00ea41d3b7e9dd569e"

URI_x86_64_v2_ghc9.4-stm-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-stm-prof-2.5.1.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-stm-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-stm-prof}"
SRC_URI[x86_64_v2_ghc9.4-stm-prof.sha256sum] = "e59eddd662e3017cd8d232c277193b36f0ee8fd34f899f4117ec7bb420260373"

URI_x86_64_v2_ghc9.4-template-haskell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-template-haskell-2.19.0.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-template-haskell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-template-haskell}"
SRC_URI[x86_64_v2_ghc9.4-template-haskell.sha256sum] = "01d5b29c2b2006e26577ad29f52ef1f6f8f13b1d877f50b12e270b96febe1bec"

URI_x86_64_v2_ghc9.4-template-haskell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-template-haskell-devel-2.19.0.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-template-haskell-devel}"
SRC_URI[x86_64_v2_ghc9.4-template-haskell-devel.sha256sum] = "a1e5be8551c6491613585503d57ab5ae53886b1c363818dc2f4ca77e9ee958e1"

URI_x86_64_v2_ghc9.4-template-haskell-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-template-haskell-doc-2.19.0.0-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-template-haskell-doc}"
SRC_URI[x86_64_v2_ghc9.4-template-haskell-doc.sha256sum] = "c78d6e99b44455e843b55b7a969198ce990ba28ad281362b1608039288126dc4"

URI_x86_64_v2_ghc9.4-template-haskell-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-template-haskell-prof-2.19.0.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-template-haskell-prof}"
SRC_URI[x86_64_v2_ghc9.4-template-haskell-prof.sha256sum] = "e7f0c85df0262bdb0c1bedaf26973070b18cc7d0c5d0b9161252098dc2e00488"

URI_x86_64_v2_ghc9.4-terminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-terminfo-0.4.1.5-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-terminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-terminfo}"
SRC_URI[x86_64_v2_ghc9.4-terminfo.sha256sum] = "f5ba7dd29e39fe7a74e9efeeed822f136a1a370c168a6fa614d1de63f073c795"

URI_x86_64_v2_ghc9.4-terminfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-terminfo-devel-0.4.1.5-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-terminfo-devel}"
SRC_URI[x86_64_v2_ghc9.4-terminfo-devel.sha256sum] = "024bf2e6288ddbdd319e178649255d0f3f605f9fed5b1ee72df98b20a1cb2faf"

URI_x86_64_v2_ghc9.4-terminfo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-terminfo-doc-0.4.1.5-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-terminfo-doc}"
SRC_URI[x86_64_v2_ghc9.4-terminfo-doc.sha256sum] = "53e123c1e011e215872a5a7017089263e0b1ee96cf2d8d30fe564c30ed5e656f"

URI_x86_64_v2_ghc9.4-terminfo-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-terminfo-prof-0.4.1.5-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-terminfo-prof}"
SRC_URI[x86_64_v2_ghc9.4-terminfo-prof.sha256sum] = "93334c02faa43a6be03486ec3eca7ad6dc5fc47752b3b7e3d6d895e8a5e0e75e"

URI_x86_64_v2_ghc9.4-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-text-2.0.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-text}"
SRC_URI[x86_64_v2_ghc9.4-text.sha256sum] = "54cd298671963b5f8715d64453944e514411d085a0c81384f21ef1eda253310d"

URI_x86_64_v2_ghc9.4-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-text-devel-2.0.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-text-devel}"
SRC_URI[x86_64_v2_ghc9.4-text-devel.sha256sum] = "5789d53018e91a9cf1f9ebf75d527ab17656a25492af70f38082c54c53bd6b8a"

URI_x86_64_v2_ghc9.4-text-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-text-doc-2.0.2-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-text-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-text-doc}"
SRC_URI[x86_64_v2_ghc9.4-text-doc.sha256sum] = "b5ca96161334f92e7d17778847840cd8e156c507b3e76ae0d748b73e1b2c0b99"

URI_x86_64_v2_ghc9.4-text-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-text-prof-2.0.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-text-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-text-prof}"
SRC_URI[x86_64_v2_ghc9.4-text-prof.sha256sum] = "bdac900fb5732eab64f98160bd7aa015c001ccc076a6eb202ca4014bd5ec9f82"

URI_x86_64_v2_ghc9.4-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-time-1.12.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-time}"
SRC_URI[x86_64_v2_ghc9.4-time.sha256sum] = "d9cd7cfbf36df3df8eee94f175097206580d8d6bbc39213e388e05c81dce7e23"

URI_x86_64_v2_ghc9.4-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-time-devel-1.12.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-time-devel}"
SRC_URI[x86_64_v2_ghc9.4-time-devel.sha256sum] = "79bb5af8c0155024a8075bda621a46cd654447368da0836d7b21b3664505dbde"

URI_x86_64_v2_ghc9.4-time-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-time-doc-1.12.2-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-time-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-time-doc}"
SRC_URI[x86_64_v2_ghc9.4-time-doc.sha256sum] = "04a3d854ef6b7193f09604fbe7763df08a1d942492d58b96897c40c8f1df8d57"

URI_x86_64_v2_ghc9.4-time-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-time-prof-1.12.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-time-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-time-prof}"
SRC_URI[x86_64_v2_ghc9.4-time-prof.sha256sum] = "ef716c9a772f70142576c9d80a460da9d373e00195969955618de1d91f7dae84"

URI_x86_64_v2_ghc9.4-transformers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-transformers-0.5.6.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-transformers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-transformers}"
SRC_URI[x86_64_v2_ghc9.4-transformers.sha256sum] = "b8b305c170c58606d58474fec9791f3dd944ac21529814ba1f65d4c6aeb875b0"

URI_x86_64_v2_ghc9.4-transformers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-transformers-devel-0.5.6.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-transformers-devel}"
SRC_URI[x86_64_v2_ghc9.4-transformers-devel.sha256sum] = "f928b8a2a62b51eb59736070f08cdfd8180fed94a1f6a378650566f47dbe9c04"

URI_x86_64_v2_ghc9.4-transformers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-transformers-doc-0.5.6.2-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-transformers-doc}"
SRC_URI[x86_64_v2_ghc9.4-transformers-doc.sha256sum] = "9717b6d106cbf1bfbc93f509b87842af6c4ed130fb2afee99013aa65a2fe0aa3"

URI_x86_64_v2_ghc9.4-transformers-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-transformers-prof-0.5.6.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-transformers-prof}"
SRC_URI[x86_64_v2_ghc9.4-transformers-prof.sha256sum] = "5bb60981a29b3092e61afe21f1fb18bc4142236c20dacf30d7195d743fde6d87"

URI_x86_64_v2_ghc9.4-unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-unix-2.7.3-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-unix}"
SRC_URI[x86_64_v2_ghc9.4-unix.sha256sum] = "83558218e927200c51fe5088035ea104e0731aeeac204f9b308dc387aa2646b6"

URI_x86_64_v2_ghc9.4-unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-unix-devel-2.7.3-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-unix-devel}"
SRC_URI[x86_64_v2_ghc9.4-unix-devel.sha256sum] = "206b589005f436a049c8780f9ec8901322c07591647b86200d97187b0bc9d0bc"

URI_x86_64_v2_ghc9.4-unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-unix-doc-2.7.3-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-unix-doc}"
SRC_URI[x86_64_v2_ghc9.4-unix-doc.sha256sum] = "227deaeee491acd710c7ad51788eb29504be09f9b775d0aebb5976d2003c67d4"

URI_x86_64_v2_ghc9.4-unix-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-unix-prof-2.7.3-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-unix-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-unix-prof}"
SRC_URI[x86_64_v2_ghc9.4-unix-prof.sha256sum] = "f87baea0b60b6b3d6c3138acb524fb23871c5dd880f639df35e0eb02daf07321"

URI_x86_64_v2_ghc9.4-xhtml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-xhtml-3000.2.2.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-xhtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-xhtml}"
SRC_URI[x86_64_v2_ghc9.4-xhtml.sha256sum] = "82ec959cf8f12c01ee7cec61f352693a7140e2dff1ae5c37208900a62027f661"

URI_x86_64_v2_ghc9.4-xhtml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-xhtml-devel-3000.2.2.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-xhtml-devel}"
SRC_URI[x86_64_v2_ghc9.4-xhtml-devel.sha256sum] = "c98d97667db57687811d9298bead9d9b724fac4df3de0d7ca9d6cb077daaecea"

URI_x86_64_v2_ghc9.4-xhtml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-xhtml-doc-3000.2.2.1-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.4-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-xhtml-doc}"
SRC_URI[x86_64_v2_ghc9.4-xhtml-doc.sha256sum] = "d1963efd477dde25b8197570af5ef9309d6d5aa5d70a72aaf36d5eda133995e4"

URI_x86_64_v2_ghc9.4-xhtml-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.4-xhtml-prof-3000.2.2.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.4-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.4-xhtml-prof}"
SRC_URI[x86_64_v2_ghc9.4-xhtml-prof.sha256sum] = "268bf39e0d141bc0eeb1f100519cddeaf6871267f1c075e258c68c22f934b305"

URI_aarch64_ghc9.4 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4}"
SRC_URI[aarch64_ghc9.4.sha256sum] = "917a3df1907ad210e611ee40d9ef90b3c13007e59ca71f6ed00c43151be18792"

URI_aarch64_ghc9.4-Cabal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-Cabal-3.8.1.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-Cabal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-Cabal}"
SRC_URI[aarch64_ghc9.4-Cabal.sha256sum] = "d053fd949b6b01c16fd73c60a4d91ef4cc7c7d549cb5d8552f2cfd49906f92f8"

URI_aarch64_ghc9.4-Cabal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-Cabal-devel-3.8.1.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-Cabal-devel}"
SRC_URI[aarch64_ghc9.4-Cabal-devel.sha256sum] = "d1c9d23c3c5e97def125599ebdde20118bf259cceb9b3e5b96587d9982992862"

URI_aarch64_ghc9.4-Cabal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-Cabal-doc-3.8.1.0-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-Cabal-doc}"
SRC_URI[aarch64_ghc9.4-Cabal-doc.sha256sum] = "9185a6be66354d340d9bc0ccbbba56f640f856ecea26fb05dbc3962c3cc602ff"

URI_aarch64_ghc9.4-Cabal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-Cabal-prof-3.8.1.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-Cabal-prof}"
SRC_URI[aarch64_ghc9.4-Cabal-prof.sha256sum] = "4c1ced5d73661e144e984acc737211daebaf34c22f7961838a96cbf63582936d"

URI_aarch64_ghc9.4-Cabal-syntax = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-Cabal-syntax-3.8.1.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-Cabal-syntax}"
SRC_URI[aarch64_ghc9.4-Cabal-syntax.sha256sum] = "b79fc6626e9f320214ffab239123860a4b23bf6e24ae1a1640b7d8cb1a308e08"

URI_aarch64_ghc9.4-Cabal-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-Cabal-syntax-devel-3.8.1.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-Cabal-syntax-devel}"
SRC_URI[aarch64_ghc9.4-Cabal-syntax-devel.sha256sum] = "6edd31b2947c29adade41cfeb2ea3b08c5f6378c0c4a6f038b6ef07fd7663e43"

URI_aarch64_ghc9.4-Cabal-syntax-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-Cabal-syntax-doc-3.8.1.0-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-Cabal-syntax-doc}"
SRC_URI[aarch64_ghc9.4-Cabal-syntax-doc.sha256sum] = "4e3c9cdaa436726c0239b8b544b24270a59b946d38642e70bafb0977e3fd31d3"

URI_aarch64_ghc9.4-Cabal-syntax-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-Cabal-syntax-prof-3.8.1.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-Cabal-syntax-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-Cabal-syntax-prof}"
SRC_URI[aarch64_ghc9.4-Cabal-syntax-prof.sha256sum] = "b26d18529d11ff186b802c4de755a77269a30159c9e958544a4207cf12df6202"

URI_aarch64_ghc9.4-array = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-array-0.5.4.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-array;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-array}"
SRC_URI[aarch64_ghc9.4-array.sha256sum] = "3f0609a288f667f2bb858c88feb3e919ea1694672af6ceb0916ac8837182d8fe"

URI_aarch64_ghc9.4-array-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-array-devel-0.5.4.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-array-devel}"
SRC_URI[aarch64_ghc9.4-array-devel.sha256sum] = "62505ed8725ca477098e9b0fc280bfd6bc5948f542c1504fcf19a1fa045bf374"

URI_aarch64_ghc9.4-array-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-array-doc-0.5.4.0-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-array-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-array-doc}"
SRC_URI[aarch64_ghc9.4-array-doc.sha256sum] = "819cc2fc2ef731e04f10bc7fbdce76d7924218ea0db246fe2723a4649e78a293"

URI_aarch64_ghc9.4-array-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-array-prof-0.5.4.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-array-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-array-prof}"
SRC_URI[aarch64_ghc9.4-array-prof.sha256sum] = "df6ea3b9c0e9dbeda16f5adf0e7b7e016b46930d2bc1a4ee404cf321f94ba874"

URI_aarch64_ghc9.4-base = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-base-4.17.2.1-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-base}"
SRC_URI[aarch64_ghc9.4-base.sha256sum] = "2f7de85f08167c8e8180bb71adbc8dcfb06d933ccba4f36ea607d1284b7971f7"

URI_aarch64_ghc9.4-base-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-base-devel-4.17.2.1-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-base-devel}"
SRC_URI[aarch64_ghc9.4-base-devel.sha256sum] = "36beff6a3570b12dbdaff8cd91990e16b64348420c4dc53615dcd179ef6fa045"

URI_aarch64_ghc9.4-base-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-base-doc-4.17.2.1-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-base-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-base-doc}"
SRC_URI[aarch64_ghc9.4-base-doc.sha256sum] = "23c5296c1ef2ecc63fd125ef094214caff291961813b531333f2b33ad48fc2a2"

URI_aarch64_ghc9.4-base-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-base-prof-4.17.2.1-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-base-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-base-prof}"
SRC_URI[aarch64_ghc9.4-base-prof.sha256sum] = "17398f93dd33264851d077f1b7732ef0f7b0cd0ea3be333c7beb73dd15e32907"

URI_aarch64_ghc9.4-binary = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-binary-0.8.9.1-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-binary;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-binary}"
SRC_URI[aarch64_ghc9.4-binary.sha256sum] = "45f93fe1ce9ad0659059307bc39aadf0bdb63fa3cf46ccabad3f365728d069c3"

URI_aarch64_ghc9.4-binary-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-binary-devel-0.8.9.1-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-binary-devel}"
SRC_URI[aarch64_ghc9.4-binary-devel.sha256sum] = "b6fe4725236630eff8535d5bd8223bb6c91ef2a5a55be8cae5b0794d8be9978f"

URI_aarch64_ghc9.4-binary-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-binary-doc-0.8.9.1-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-binary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-binary-doc}"
SRC_URI[aarch64_ghc9.4-binary-doc.sha256sum] = "86afe011231f2cfd88b77332ae752da861f20d273e08d8706f25afa4f98a175e"

URI_aarch64_ghc9.4-binary-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-binary-prof-0.8.9.1-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-binary-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-binary-prof}"
SRC_URI[aarch64_ghc9.4-binary-prof.sha256sum] = "fa342dc0fdbe1ec0ee12659045b5bd8fb3c7818d0165a401ca891adaf2e48f62"

URI_aarch64_ghc9.4-bytestring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-bytestring-0.11.5.3-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-bytestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-bytestring}"
SRC_URI[aarch64_ghc9.4-bytestring.sha256sum] = "41fc647d0b33ebb7c406db93e55bf871be24a6008a3dbc829ad9947014a10198"

URI_aarch64_ghc9.4-bytestring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-bytestring-devel-0.11.5.3-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-bytestring-devel}"
SRC_URI[aarch64_ghc9.4-bytestring-devel.sha256sum] = "9c230b7ba5a6ef3502501544e6bdfaeaf0c5b9ab054eb5c00ebbe2e7aef9992d"

URI_aarch64_ghc9.4-bytestring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-bytestring-doc-0.11.5.3-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-bytestring-doc}"
SRC_URI[aarch64_ghc9.4-bytestring-doc.sha256sum] = "7fe1c10a5461b43947112292161da5046f0d611d8e6dd9fcd91f46f9029aaa4c"

URI_aarch64_ghc9.4-bytestring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-bytestring-prof-0.11.5.3-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-bytestring-prof}"
SRC_URI[aarch64_ghc9.4-bytestring-prof.sha256sum] = "f1d542c8df51a8b08c13e82e8e6fcd65dca645f6c7916b18ff4eb1d3a85f094d"

URI_aarch64_ghc9.4-compiler = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-compiler-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-compiler}"
SRC_URI[aarch64_ghc9.4-compiler.sha256sum] = "514e93d0da7eb8d8bbb65d4d6e01f01d34fe027ebccc47e080b3eafedd4883d4"

URI_aarch64_ghc9.4-compiler-default = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-compiler-default-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-compiler-default;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-compiler-default}"
SRC_URI[aarch64_ghc9.4-compiler-default.sha256sum] = "44237f2bd30f6870972c67ce8a4fd101570091bba4bb5befe4d0f5fbc7cc4ce6"

URI_aarch64_ghc9.4-containers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-containers-0.6.7-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-containers}"
SRC_URI[aarch64_ghc9.4-containers.sha256sum] = "55497cd4485571eb98221825b8257c78c0d47becb5e1296544b465283322f893"

URI_aarch64_ghc9.4-containers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-containers-devel-0.6.7-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-containers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-containers-devel}"
SRC_URI[aarch64_ghc9.4-containers-devel.sha256sum] = "8656bad16601d0aa094a54fe78ec89df12b0a87aee4b6f821182fb222f1a3dd0"

URI_aarch64_ghc9.4-containers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-containers-doc-0.6.7-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-containers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-containers-doc}"
SRC_URI[aarch64_ghc9.4-containers-doc.sha256sum] = "aaff65316a4068700d8aceae0913054bee894516cd1111e9588946f51341828b"

URI_aarch64_ghc9.4-containers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-containers-prof-0.6.7-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-containers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-containers-prof}"
SRC_URI[aarch64_ghc9.4-containers-prof.sha256sum] = "99ace1f0a1c2ec7973a3eec85ed67af0f084238c2ad42987ef0071bd63a65fde"

URI_aarch64_ghc9.4-deepseq = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-deepseq-1.4.8.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-deepseq;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-deepseq}"
SRC_URI[aarch64_ghc9.4-deepseq.sha256sum] = "6f549f5efb0524d3750e2722e04b47384553110607b069f351e7db028129b933"

URI_aarch64_ghc9.4-deepseq-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-deepseq-devel-1.4.8.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-deepseq-devel}"
SRC_URI[aarch64_ghc9.4-deepseq-devel.sha256sum] = "f449e98cd9d9430cc00ba7294548002f422739e3fdcaf7d28079d194c4209538"

URI_aarch64_ghc9.4-deepseq-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-deepseq-doc-1.4.8.0-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-deepseq-doc}"
SRC_URI[aarch64_ghc9.4-deepseq-doc.sha256sum] = "e40139d1f5eeda7494a66866c98d7959984dbc967241522616e37ade494fdb95"

URI_aarch64_ghc9.4-deepseq-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-deepseq-prof-1.4.8.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-deepseq-prof}"
SRC_URI[aarch64_ghc9.4-deepseq-prof.sha256sum] = "89480cbfe5914950c8f4db84743031a184bc8caef44c2dded18c5ad838b8e7cf"

URI_aarch64_ghc9.4-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-devel-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-devel}"
SRC_URI[aarch64_ghc9.4-devel.sha256sum] = "f41b1e7bf0b16a1804d39074d7ffbfb100c6c03351e20553311baa75c26a270c"

URI_aarch64_ghc9.4-directory = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-directory-1.3.7.1-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-directory;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-directory}"
SRC_URI[aarch64_ghc9.4-directory.sha256sum] = "108f287f2700117573bff395c6463ecaa0ea8399e943d0853c8e84fb64303673"

URI_aarch64_ghc9.4-directory-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-directory-devel-1.3.7.1-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-directory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-directory-devel}"
SRC_URI[aarch64_ghc9.4-directory-devel.sha256sum] = "b9e334db46e64fc73a303d591e7645bf71e006bd76cdf77a90b0bd245a7c39d4"

URI_aarch64_ghc9.4-directory-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-directory-doc-1.3.7.1-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-directory-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-directory-doc}"
SRC_URI[aarch64_ghc9.4-directory-doc.sha256sum] = "942a0d12ed109c29dff0bc757625d93f4c16c569014d8139b92fbc5b13842e4a"

URI_aarch64_ghc9.4-directory-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-directory-prof-1.3.7.1-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-directory-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-directory-prof}"
SRC_URI[aarch64_ghc9.4-directory-prof.sha256sum] = "8072f68ff3c32316d4de93533c321c4ebdc37b6c2ce3804c6a2e7faba1c1df1e"

URI_aarch64_ghc9.4-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-doc-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-doc}"
SRC_URI[aarch64_ghc9.4-doc.sha256sum] = "a00690dfe52272aab56b2f0040127b835b1102b6a8610010cb194fde5d3a7a9e"

URI_aarch64_ghc9.4-doc-index = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-doc-index-9.4.8-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-doc-index;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-doc-index}"
SRC_URI[aarch64_ghc9.4-doc-index.sha256sum] = "8415eaa4d71c5024804ba236b02c1dfca5770406223820382a7d1531a407ec13"

URI_aarch64_ghc9.4-exceptions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-exceptions-0.10.5-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-exceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-exceptions}"
SRC_URI[aarch64_ghc9.4-exceptions.sha256sum] = "cfbbb3fcbff3cf58e7b038e5ae0e734ddc9155f5be28110a9703e7031526c316"

URI_aarch64_ghc9.4-exceptions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-exceptions-devel-0.10.5-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-exceptions-devel}"
SRC_URI[aarch64_ghc9.4-exceptions-devel.sha256sum] = "fd8a51f065138616547e5d29ad77619c8e72fc88277b3782665432c5489df891"

URI_aarch64_ghc9.4-exceptions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-exceptions-doc-0.10.5-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-exceptions-doc}"
SRC_URI[aarch64_ghc9.4-exceptions-doc.sha256sum] = "a1af768ab1b2d42d66f421878426171f40fed1de50c32c8fe3be9eab4b989e55"

URI_aarch64_ghc9.4-exceptions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-exceptions-prof-0.10.5-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-exceptions-prof}"
SRC_URI[aarch64_ghc9.4-exceptions-prof.sha256sum] = "eae174c01c08868f69c0c6a8a1262f461eea636cea3284ee54f828e7d66935e7"

URI_aarch64_ghc9.4-filepath = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-filepath-1.4.2.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-filepath;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-filepath}"
SRC_URI[aarch64_ghc9.4-filepath.sha256sum] = "6dc1132216f4c1b6204792625cc4c6bc6ca10346c4ea11463e5ea016ac9b3cc0"

URI_aarch64_ghc9.4-filepath-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-filepath-devel-1.4.2.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-filepath-devel}"
SRC_URI[aarch64_ghc9.4-filepath-devel.sha256sum] = "147665442203d12f532fd2d64499d164774485ef4cee9bb08eadf30a52cf50f5"

URI_aarch64_ghc9.4-filepath-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-filepath-doc-1.4.2.2-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-filepath-doc}"
SRC_URI[aarch64_ghc9.4-filepath-doc.sha256sum] = "7eae069a0e2441bec243bb2baf306fcaf3fcb216b4e7f4bf791c27d992b293af"

URI_aarch64_ghc9.4-filepath-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-filepath-prof-1.4.2.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-filepath-prof}"
SRC_URI[aarch64_ghc9.4-filepath-prof.sha256sum] = "5071b4c5d36f75e74046d9c9b900a7760b68c8d1b9389466ab1d984d0ce0f5d5"

URI_aarch64_ghc9.4-filesystem = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-filesystem-9.4.8-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-filesystem}"
SRC_URI[aarch64_ghc9.4-filesystem.sha256sum] = "da01f490f558ecef8a9adfa33ed96797f2d1baa883485206270cf0ca09cebe56"

URI_aarch64_ghc9.4-ghc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc}"
SRC_URI[aarch64_ghc9.4-ghc.sha256sum] = "57e34a6e10708527a43e00f6a1c485ce15f5fa440ec5e75e4ae90146ddc2b3fe"

URI_aarch64_ghc9.4-ghc-bignum = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-bignum-1.3-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-bignum}"
SRC_URI[aarch64_ghc9.4-ghc-bignum.sha256sum] = "7f00ab79880bb2092fb622fe5208e5624de7794ff965f59505f45f6ccf77a415"

URI_aarch64_ghc9.4-ghc-bignum-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-bignum-devel-1.3-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-bignum-devel}"
SRC_URI[aarch64_ghc9.4-ghc-bignum-devel.sha256sum] = "e1a294c6e66d761716ee15560cff986647ea4c522d776429762546237450b51c"

URI_aarch64_ghc9.4-ghc-bignum-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-bignum-doc-1.3-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-bignum-doc}"
SRC_URI[aarch64_ghc9.4-ghc-bignum-doc.sha256sum] = "c3f638f6ddfdae3b092b5c3914bc085fea1f5d1a7036fe3c6c8436ea455b8d9d"

URI_aarch64_ghc9.4-ghc-bignum-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-bignum-prof-1.3-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-bignum-prof}"
SRC_URI[aarch64_ghc9.4-ghc-bignum-prof.sha256sum] = "432225df23300433375200d6a3b68616e98699722738fa7201c8613e9c21f9ff"

URI_aarch64_ghc9.4-ghc-boot = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-boot-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-boot}"
SRC_URI[aarch64_ghc9.4-ghc-boot.sha256sum] = "6859ee691cfc7839def24736b33a3f440c6caed7fa9d3e59b48fb26c7447ae96"

URI_aarch64_ghc9.4-ghc-boot-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-boot-devel-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-boot-devel}"
SRC_URI[aarch64_ghc9.4-ghc-boot-devel.sha256sum] = "47e85df1cb4ef54a39c57f4605dc8f8abdadd967c7a94c1614639afa2816f697"

URI_aarch64_ghc9.4-ghc-boot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-boot-doc-9.4.8-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-boot-doc}"
SRC_URI[aarch64_ghc9.4-ghc-boot-doc.sha256sum] = "a7fcac115b3ef6183d57c3174591d27084d9938850173b7898c3173fa9f84be7"

URI_aarch64_ghc9.4-ghc-boot-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-boot-prof-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-boot-prof}"
SRC_URI[aarch64_ghc9.4-ghc-boot-prof.sha256sum] = "9b5d69d77243ba64e5a2f42772f65a9a8a51d8308f3f52647a9ca1f29fda336f"

URI_aarch64_ghc9.4-ghc-boot-th = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-boot-th-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-boot-th}"
SRC_URI[aarch64_ghc9.4-ghc-boot-th.sha256sum] = "33889054b59e0a646c2fceacc1501636ee6e2c6a3bd1270b8b9d7877c22e6bb6"

URI_aarch64_ghc9.4-ghc-boot-th-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-boot-th-devel-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-boot-th-devel}"
SRC_URI[aarch64_ghc9.4-ghc-boot-th-devel.sha256sum] = "60a4f67274cb26b34f77466f6c0c99f5249c81b5398559fec4179f64f5afdff5"

URI_aarch64_ghc9.4-ghc-boot-th-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-boot-th-doc-9.4.8-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-boot-th-doc}"
SRC_URI[aarch64_ghc9.4-ghc-boot-th-doc.sha256sum] = "f99dd5320f79c9954790d703b59cb86e55eaa1ee8a18536f91a89203ded06d80"

URI_aarch64_ghc9.4-ghc-boot-th-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-boot-th-prof-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-boot-th-prof}"
SRC_URI[aarch64_ghc9.4-ghc-boot-th-prof.sha256sum] = "92eedbab36d97c83f84f0fbb2065e895bcb7c9c7d3f3400babdf451ccd616521"

URI_aarch64_ghc9.4-ghc-compact = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-compact-0.1.0.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-compact}"
SRC_URI[aarch64_ghc9.4-ghc-compact.sha256sum] = "56426591e0006487ff26acae2cc9b6b4b7e7dd26ac4dc07f1580e2fdddbb4831"

URI_aarch64_ghc9.4-ghc-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-compact-devel-0.1.0.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-compact-devel}"
SRC_URI[aarch64_ghc9.4-ghc-compact-devel.sha256sum] = "14dd152197795239f9fcc38f923f94a68b09d53c8f2f3cfa664e4ad921bedf95"

URI_aarch64_ghc9.4-ghc-compact-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-compact-doc-0.1.0.0-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-compact-doc}"
SRC_URI[aarch64_ghc9.4-ghc-compact-doc.sha256sum] = "a5ab68f77d3fac7482b82d5f0015b2dfdfba92248c7af30b8f930f28efd279a8"

URI_aarch64_ghc9.4-ghc-compact-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-compact-prof-0.1.0.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-compact-prof}"
SRC_URI[aarch64_ghc9.4-ghc-compact-prof.sha256sum] = "04dc2f1dfe26885b090444a229c1e203a94a81dcd155f872b36306c82fc439d3"

URI_aarch64_ghc9.4-ghc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-devel-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-devel}"
SRC_URI[aarch64_ghc9.4-ghc-devel.sha256sum] = "a8fdb04ea282161a676cab91f46a649ae12820783cc2d56a1992b66312d26ab9"

URI_aarch64_ghc9.4-ghc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-doc-9.4.8-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-doc}"
SRC_URI[aarch64_ghc9.4-ghc-doc.sha256sum] = "fbde156d3289f1fe420dad5d38a4e7a1e68adfeacb538a5818df4f12a58efa1d"

URI_aarch64_ghc9.4-ghc-heap = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-heap-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-heap}"
SRC_URI[aarch64_ghc9.4-ghc-heap.sha256sum] = "8d6945301f1342f0142a5f5a6bf9cbae3cfb2c42c98f1f3a4bcdeb2373e09c06"

URI_aarch64_ghc9.4-ghc-heap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-heap-devel-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-heap-devel}"
SRC_URI[aarch64_ghc9.4-ghc-heap-devel.sha256sum] = "c1e61b2c1d0284df9908dfffefbb77c10bc546fcebd91738178aff13beaba9d9"

URI_aarch64_ghc9.4-ghc-heap-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-heap-doc-9.4.8-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-heap-doc}"
SRC_URI[aarch64_ghc9.4-ghc-heap-doc.sha256sum] = "a1d14bb6f024ff737b8bde6527eb9055d0845a29f98acb37829b34a31ebcafd0"

URI_aarch64_ghc9.4-ghc-heap-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-heap-prof-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-heap-prof}"
SRC_URI[aarch64_ghc9.4-ghc-heap-prof.sha256sum] = "e382733abe62f3a3cfe01548a9b0486cada30bbd7ca57bb272213eb90bc9e080"

URI_aarch64_ghc9.4-ghc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghc-prof-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghc-prof}"
SRC_URI[aarch64_ghc9.4-ghc-prof.sha256sum] = "56d27b480b103b22240395cb1505cf1d46fc7297875f318de71c2130a1cd5a54"

URI_aarch64_ghc9.4-ghci = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghci-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghci;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghci}"
SRC_URI[aarch64_ghc9.4-ghci.sha256sum] = "a7a380bff4cf1b0c941472af44221538bc8ef7d2dc774dfcd363eb5bac4977db"

URI_aarch64_ghc9.4-ghci-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghci-devel-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghci-devel}"
SRC_URI[aarch64_ghc9.4-ghci-devel.sha256sum] = "9f17812bad3e3037b07c314b8a77d65a29457bc9132aa4b1efd0ca1c58c8920d"

URI_aarch64_ghc9.4-ghci-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghci-doc-9.4.8-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghci-doc}"
SRC_URI[aarch64_ghc9.4-ghci-doc.sha256sum] = "eea31f802c138c614f0e786b351fb414eae79f5c80ecbc730071bec01563550e"

URI_aarch64_ghc9.4-ghci-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-ghci-prof-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-ghci-prof}"
SRC_URI[aarch64_ghc9.4-ghci-prof.sha256sum] = "91975564538e1763a9fc51406d8d12f5f260867f89e89889c2a5899a1da4b784"

URI_aarch64_ghc9.4-hadrian = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-hadrian-0.1.0.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-hadrian;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-hadrian}"
SRC_URI[aarch64_ghc9.4-hadrian.sha256sum] = "4d87a58af7a0dbc5da7e78a3782fcad41a5835beda91753cfda327c2052f2e77"

URI_aarch64_ghc9.4-haskeline = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-haskeline-0.8.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-haskeline;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-haskeline}"
SRC_URI[aarch64_ghc9.4-haskeline.sha256sum] = "bc8f8b9885cac91e1281abfe23d74cf543a8aca02678463d88c200de96645e1a"

URI_aarch64_ghc9.4-haskeline-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-haskeline-devel-0.8.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-haskeline-devel}"
SRC_URI[aarch64_ghc9.4-haskeline-devel.sha256sum] = "ca6660877c9feaed61ab9521d013c74eebabab7d52d7a13520a09e293e3e6ed5"

URI_aarch64_ghc9.4-haskeline-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-haskeline-doc-0.8.2-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-haskeline-doc}"
SRC_URI[aarch64_ghc9.4-haskeline-doc.sha256sum] = "a63e253b410e217842432c86164b47e04d130a88b15b719dbd1c0567e09bc5ac"

URI_aarch64_ghc9.4-haskeline-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-haskeline-prof-0.8.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-haskeline-prof}"
SRC_URI[aarch64_ghc9.4-haskeline-prof.sha256sum] = "22191537556e6bdd5c478e8cf35e27321960e3aa42d94818d87f0a3413d84216"

URI_aarch64_ghc9.4-hpc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-hpc-0.6.1.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-hpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-hpc}"
SRC_URI[aarch64_ghc9.4-hpc.sha256sum] = "2796b3082873871d023c245f57ea3a59631a114a10bd7e13f2bd9c18bb93fa46"

URI_aarch64_ghc9.4-hpc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-hpc-devel-0.6.1.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-hpc-devel}"
SRC_URI[aarch64_ghc9.4-hpc-devel.sha256sum] = "e5209639bcbf9f090a7bfa1e0bd3ebe66379ddfb0a069cb706f0d76a7e94ac27"

URI_aarch64_ghc9.4-hpc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-hpc-doc-0.6.1.0-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-hpc-doc}"
SRC_URI[aarch64_ghc9.4-hpc-doc.sha256sum] = "773545cd10a2de76840285b4b645cbaae867c62b112d04dc5cb3485293275cd3"

URI_aarch64_ghc9.4-hpc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-hpc-prof-0.6.1.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-hpc-prof}"
SRC_URI[aarch64_ghc9.4-hpc-prof.sha256sum] = "7e74fe56552f000e7949d0bb8fa11bd7a3922bd8724996787f0e6e21e70f0665"

URI_aarch64_ghc9.4-libiserv = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-libiserv-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-libiserv;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-libiserv}"
SRC_URI[aarch64_ghc9.4-libiserv.sha256sum] = "d8c0b9a0f3f527550b161024b2bb144174f253b787c72c23f60a94beffe6a45b"

URI_aarch64_ghc9.4-libiserv-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-libiserv-devel-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-libiserv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-libiserv-devel}"
SRC_URI[aarch64_ghc9.4-libiserv-devel.sha256sum] = "b6fa292a531e988f0afc45b519c2fb734eaa9af2d610c73ea48af7f0e7aecb30"

URI_aarch64_ghc9.4-libiserv-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-libiserv-doc-9.4.8-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-libiserv-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-libiserv-doc}"
SRC_URI[aarch64_ghc9.4-libiserv-doc.sha256sum] = "6a8c46d3b32bae5533ef79b1de8a55a12c6acba7e8e7407855d623dfcb92e210"

URI_aarch64_ghc9.4-libiserv-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-libiserv-prof-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-libiserv-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-libiserv-prof}"
SRC_URI[aarch64_ghc9.4-libiserv-prof.sha256sum] = "0d6e34a970be66925f6c336f86ea84d96b962215352f1bffea542849a164e12d"

URI_aarch64_ghc9.4-manual = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-manual-9.4.8-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-manual}"
SRC_URI[aarch64_ghc9.4-manual.sha256sum] = "7a834a2b5b8e91b103ddec58bf7ae94eab611dc9bf1575a8bd73fa4b48c5e2c9"

URI_aarch64_ghc9.4-mtl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-mtl-2.2.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-mtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-mtl}"
SRC_URI[aarch64_ghc9.4-mtl.sha256sum] = "3dbf8788bb47b8e5a1551b53d1862b3c48cebab8ee375f5bc9caff890bfabf8a"

URI_aarch64_ghc9.4-mtl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-mtl-devel-2.2.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-mtl-devel}"
SRC_URI[aarch64_ghc9.4-mtl-devel.sha256sum] = "2313c6aa4348c995ff84349969aaa95fe266f5381450bab7670d7e31a79aa57d"

URI_aarch64_ghc9.4-mtl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-mtl-doc-2.2.2-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-mtl-doc}"
SRC_URI[aarch64_ghc9.4-mtl-doc.sha256sum] = "3b24906cd1a46f84a83c39d88bce43796591eb757689a7c08a06acdad81eeaef"

URI_aarch64_ghc9.4-mtl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-mtl-prof-2.2.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-mtl-prof}"
SRC_URI[aarch64_ghc9.4-mtl-prof.sha256sum] = "f2f19966d1736d4c36992c614d635a63ffcdab72a143615d31494a6b7dc22fab"

URI_aarch64_ghc9.4-parsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-parsec-3.1.16.1-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-parsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-parsec}"
SRC_URI[aarch64_ghc9.4-parsec.sha256sum] = "92143d05180f5d5660c8e90355c1e7f11dc5d281fd86fc6a2d6cf84ebefa4b82"

URI_aarch64_ghc9.4-parsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-parsec-devel-3.1.16.1-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-parsec-devel}"
SRC_URI[aarch64_ghc9.4-parsec-devel.sha256sum] = "19710fae0d198c735be37f1d593962bee257fa14220255bebf75693acc2b6917"

URI_aarch64_ghc9.4-parsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-parsec-doc-3.1.16.1-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-parsec-doc}"
SRC_URI[aarch64_ghc9.4-parsec-doc.sha256sum] = "06f111b2e3e1ec04fefc4c7feccf29e8c5eefe1e2e911a491c0a6b9d408dbd63"

URI_aarch64_ghc9.4-parsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-parsec-prof-3.1.16.1-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-parsec-prof}"
SRC_URI[aarch64_ghc9.4-parsec-prof.sha256sum] = "ba15f94b9e6e2b50c11048a977d421eb3625479fe7c177f871424373ba2baf31"

URI_aarch64_ghc9.4-pretty = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-pretty-1.1.3.6-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-pretty;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-pretty}"
SRC_URI[aarch64_ghc9.4-pretty.sha256sum] = "90fa4712a188dbeda382a2c06d8f58e627b6956ab90557e032f7309f5fc53197"

URI_aarch64_ghc9.4-pretty-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-pretty-devel-1.1.3.6-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-pretty-devel}"
SRC_URI[aarch64_ghc9.4-pretty-devel.sha256sum] = "39d184db2b5a5f8f5f831a1e9300a419b6a6b9273e3a3a90d38085f794d2f1af"

URI_aarch64_ghc9.4-pretty-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-pretty-doc-1.1.3.6-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-pretty-doc}"
SRC_URI[aarch64_ghc9.4-pretty-doc.sha256sum] = "61fc7e48d5f52d1338213f26cffb348432ac9b32f9e66aa903689ac671fad2bd"

URI_aarch64_ghc9.4-pretty-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-pretty-prof-1.1.3.6-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-pretty-prof}"
SRC_URI[aarch64_ghc9.4-pretty-prof.sha256sum] = "2b8949c8ed989c50fe04724ba344e649ddd2463f3d9f39ecd235d886cb7b2744"

URI_aarch64_ghc9.4-process = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-process-1.6.18.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-process}"
SRC_URI[aarch64_ghc9.4-process.sha256sum] = "be3535e1879828f023ea5cbaa65d8072387d93f8881a47b9d85d841a2e895119"

URI_aarch64_ghc9.4-process-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-process-devel-1.6.18.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-process-devel}"
SRC_URI[aarch64_ghc9.4-process-devel.sha256sum] = "ea3c7edc88c393696cb3af11242e70c588b1f917ffcbd8986aa536b4302b3c1c"

URI_aarch64_ghc9.4-process-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-process-doc-1.6.18.0-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-process-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-process-doc}"
SRC_URI[aarch64_ghc9.4-process-doc.sha256sum] = "608749264c4e5ed042898620ff09983acd0cdbc65301ec6632ec8aa5ec05a8e9"

URI_aarch64_ghc9.4-process-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-process-prof-1.6.18.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-process-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-process-prof}"
SRC_URI[aarch64_ghc9.4-process-prof.sha256sum] = "951f2bcbe3361aa594446c71948d98dca665e985560586cd935f8bab823cbe05"

URI_aarch64_ghc9.4-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-prof-9.4.8-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-prof}"
SRC_URI[aarch64_ghc9.4-prof.sha256sum] = "8b5762a7621fe55ef06e61f8243c32520b435adea2ef9d63c68cf8efb034836d"

URI_aarch64_ghc9.4-stm = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-stm-2.5.1.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-stm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-stm}"
SRC_URI[aarch64_ghc9.4-stm.sha256sum] = "49d9a0fa19e85bd6c39e6dc5f888ee3d39669e00bd4adc13ea4df8765b8c0a63"

URI_aarch64_ghc9.4-stm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-stm-devel-2.5.1.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-stm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-stm-devel}"
SRC_URI[aarch64_ghc9.4-stm-devel.sha256sum] = "54f6b2142feb724357901362688893896820385a037323fb592ce98ccf555b8e"

URI_aarch64_ghc9.4-stm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-stm-doc-2.5.1.0-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-stm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-stm-doc}"
SRC_URI[aarch64_ghc9.4-stm-doc.sha256sum] = "010d0b9ac49494a617a8d5cc4c15b7cc3b21364b22ab3c9e6ac4372dd794d338"

URI_aarch64_ghc9.4-stm-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-stm-prof-2.5.1.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-stm-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-stm-prof}"
SRC_URI[aarch64_ghc9.4-stm-prof.sha256sum] = "f62a8ed9475e636860b7631a8288773db88dfc760df6429bd5d71d981598b2db"

URI_aarch64_ghc9.4-template-haskell = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-template-haskell-2.19.0.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-template-haskell;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-template-haskell}"
SRC_URI[aarch64_ghc9.4-template-haskell.sha256sum] = "3e53b0fec5353717c77525ee0087aa0d93e118d37895ae505a0d625605015ec1"

URI_aarch64_ghc9.4-template-haskell-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-template-haskell-devel-2.19.0.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-template-haskell-devel}"
SRC_URI[aarch64_ghc9.4-template-haskell-devel.sha256sum] = "94894ecf4f0a4264a37071b79e2ef48004bfc3956121649eb972f268af08a30a"

URI_aarch64_ghc9.4-template-haskell-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-template-haskell-doc-2.19.0.0-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-template-haskell-doc}"
SRC_URI[aarch64_ghc9.4-template-haskell-doc.sha256sum] = "2c9c4dd4a26b12933a9e0efe5f28889ce27bbd5c8d68baa65170869250e99bf3"

URI_aarch64_ghc9.4-template-haskell-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-template-haskell-prof-2.19.0.0-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-template-haskell-prof}"
SRC_URI[aarch64_ghc9.4-template-haskell-prof.sha256sum] = "4b4f1158e88170a415d5764ab1773a1f0bdbaee4d1610d3a21d6606306ec2cb2"

URI_aarch64_ghc9.4-terminfo = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-terminfo-0.4.1.5-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-terminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-terminfo}"
SRC_URI[aarch64_ghc9.4-terminfo.sha256sum] = "24673bb77a3112feda4045f29ef5341fe3d832547817a3f2c1bcfbedd4f69b6f"

URI_aarch64_ghc9.4-terminfo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-terminfo-devel-0.4.1.5-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-terminfo-devel}"
SRC_URI[aarch64_ghc9.4-terminfo-devel.sha256sum] = "24a775e22676b80a71f135957f940f403b6b502e6725406f4bf89daa875572dd"

URI_aarch64_ghc9.4-terminfo-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-terminfo-doc-0.4.1.5-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-terminfo-doc}"
SRC_URI[aarch64_ghc9.4-terminfo-doc.sha256sum] = "76def04df2487af9c927dc44b157c8addacd42ed7edaa43ddc60f733e401056c"

URI_aarch64_ghc9.4-terminfo-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-terminfo-prof-0.4.1.5-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-terminfo-prof}"
SRC_URI[aarch64_ghc9.4-terminfo-prof.sha256sum] = "a22704bf7ea025ea4ce527b9064a5718898ca56928ba6eb331706ddf51c924cb"

URI_aarch64_ghc9.4-text = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-text-2.0.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-text}"
SRC_URI[aarch64_ghc9.4-text.sha256sum] = "cee7a2b889106461070fd7962e41b6578922d2c931b48f51f330275f48ab525d"

URI_aarch64_ghc9.4-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-text-devel-2.0.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-text-devel}"
SRC_URI[aarch64_ghc9.4-text-devel.sha256sum] = "0aff05ee7674afe5fb0e4e9009381979624f379e6642d8c4dc764d9d4efbf1e5"

URI_aarch64_ghc9.4-text-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-text-doc-2.0.2-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-text-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-text-doc}"
SRC_URI[aarch64_ghc9.4-text-doc.sha256sum] = "a7858bd13218ee159b4aac09a94d59b776cf3e0a30a8ecc1c31c0ef0e990698a"

URI_aarch64_ghc9.4-text-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-text-prof-2.0.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-text-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-text-prof}"
SRC_URI[aarch64_ghc9.4-text-prof.sha256sum] = "5d3ed6e6fac946384a52195c57660cb11fe3c7ea0a1d62aa2598d06c29c5bdd1"

URI_aarch64_ghc9.4-time = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-time-1.12.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-time}"
SRC_URI[aarch64_ghc9.4-time.sha256sum] = "b5af017454bdbafb793bef782dc2cefcf1cacf6ba4505bc63d85c535de491ec2"

URI_aarch64_ghc9.4-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-time-devel-1.12.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-time-devel}"
SRC_URI[aarch64_ghc9.4-time-devel.sha256sum] = "f4b6b0f6f882624dce67584815a7e61bf6d6942c545b4d1e3cf8160b1cc02d65"

URI_aarch64_ghc9.4-time-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-time-doc-1.12.2-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-time-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-time-doc}"
SRC_URI[aarch64_ghc9.4-time-doc.sha256sum] = "b47f3756dad03cffa0d550eb9424ac43637370271ecc395e52a485d9fe23d34b"

URI_aarch64_ghc9.4-time-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-time-prof-1.12.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-time-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-time-prof}"
SRC_URI[aarch64_ghc9.4-time-prof.sha256sum] = "c9b2e6d8e2ba214caf07d257a1256d69c5517cfada2eddcb31804b327276a0d5"

URI_aarch64_ghc9.4-transformers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-transformers-0.5.6.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-transformers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-transformers}"
SRC_URI[aarch64_ghc9.4-transformers.sha256sum] = "7be938b4a46e50adf2cd867bbd86f15eb882eb34b54fe9d67035888f2812e9bc"

URI_aarch64_ghc9.4-transformers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-transformers-devel-0.5.6.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-transformers-devel}"
SRC_URI[aarch64_ghc9.4-transformers-devel.sha256sum] = "1cf2fb42605e4ffa9320045124e7282d85f104aa8f9cd69d270c291292056f27"

URI_aarch64_ghc9.4-transformers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-transformers-doc-0.5.6.2-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-transformers-doc}"
SRC_URI[aarch64_ghc9.4-transformers-doc.sha256sum] = "cec2319c37b4495416e3373476ddd72d7e3aab9698a4784e6c19ccca33050ef3"

URI_aarch64_ghc9.4-transformers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-transformers-prof-0.5.6.2-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-transformers-prof}"
SRC_URI[aarch64_ghc9.4-transformers-prof.sha256sum] = "da4a4cf30c12f9952bc413dc3cfc3ea7d5a664ab9a42d1e301428ff26a43ad92"

URI_aarch64_ghc9.4-unix = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-unix-2.7.3-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-unix}"
SRC_URI[aarch64_ghc9.4-unix.sha256sum] = "a45e2c2fcfe287539de063b13d86607af1eb7298d410f2c32cb946cc95ad54a8"

URI_aarch64_ghc9.4-unix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-unix-devel-2.7.3-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-unix-devel}"
SRC_URI[aarch64_ghc9.4-unix-devel.sha256sum] = "6917696441d0af67e0fc67f7d43d4a4e99af17805751a100f502c2795684c2d8"

URI_aarch64_ghc9.4-unix-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-unix-doc-2.7.3-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-unix-doc}"
SRC_URI[aarch64_ghc9.4-unix-doc.sha256sum] = "e99d1e09ef0910cb626d02c724b7e0f1b9d6a9b6a4965499e68c9580972bd331"

URI_aarch64_ghc9.4-unix-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-unix-prof-2.7.3-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-unix-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-unix-prof}"
SRC_URI[aarch64_ghc9.4-unix-prof.sha256sum] = "e50a003bf3f1b3e80561d6c804d21f3abe957cbbfc140d1ff89a859700b20fbc"

URI_aarch64_ghc9.4-xhtml = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-xhtml-3000.2.2.1-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-xhtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-xhtml}"
SRC_URI[aarch64_ghc9.4-xhtml.sha256sum] = "7c05b6599a18ec328f3a5396f1794a2ac35041e243d882482601d904f0a5d33f"

URI_aarch64_ghc9.4-xhtml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-xhtml-devel-3000.2.2.1-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-xhtml-devel}"
SRC_URI[aarch64_ghc9.4-xhtml-devel.sha256sum] = "05774db1074d996f0d49c3a1e6a0d511b08d7455e06ea003e5f2cb6f3de9e4f5"

URI_aarch64_ghc9.4-xhtml-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-xhtml-doc-3000.2.2.1-34.el10_0.noarch.rpm;name=aarch64_ghc9.4-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-xhtml-doc}"
SRC_URI[aarch64_ghc9.4-xhtml-doc.sha256sum] = "267bb7e8035735e36610c7fb1d1a8dd07c8efcd5db36e82bb45040f33914da42"

URI_aarch64_ghc9.4-xhtml-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.4-xhtml-prof-3000.2.2.1-34.el10_0.aarch64.rpm;name=aarch64_ghc9.4-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.4-xhtml-prof}"
SRC_URI[aarch64_ghc9.4-xhtml-prof.sha256sum] = "d8edcbcd6e6fc2185b7fd7af3a0a31868497d01bdd69a685b9fdb48864e3f2ba"

RDEPENDS:ghc9.4 = " \
 ghc9.4-compiler \
 ghc9.4-devel \
 ghc9.4-ghc-boot-devel \
 ghc9.4-ghc-compact-devel \
 ghc9.4-ghc-devel \
 ghc9.4-ghc-heap-devel \
 ghc9.4-ghci-devel \
 ghc9.4-hpc-devel \
 ghc9.4-libiserv-devel \
 "
RDEPENDS:ghc9.4-Cabal = " \
 ghc9.4-Cabal-syntax \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-binary \
 ghc9.4-bytestring \
 ghc9.4-containers \
 ghc9.4-deepseq \
 ghc9.4-directory \
 ghc9.4-filepath \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-mtl \
 ghc9.4-parsec \
 ghc9.4-pretty \
 ghc9.4-process \
 ghc9.4-template-haskell \
 ghc9.4-text \
 ghc9.4-time \
 ghc9.4-transformers \
 ghc9.4-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-Cabal-devel = " \
 ghc9.4-Cabal \
 ghc9.4-Cabal-syntax-devel \
 ghc9.4-array-devel \
 ghc9.4-base-devel \
 ghc9.4-bytestring-devel \
 ghc9.4-compiler \
 ghc9.4-containers-devel \
 ghc9.4-deepseq-devel \
 ghc9.4-directory-devel \
 ghc9.4-filepath-devel \
 ghc9.4-mtl-devel \
 ghc9.4-parsec-devel \
 ghc9.4-pretty-devel \
 ghc9.4-process-devel \
 ghc9.4-text-devel \
 ghc9.4-time-devel \
 ghc9.4-transformers-devel \
 ghc9.4-unix-devel \
 "
RDEPENDS:ghc9.4-Cabal-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-Cabal-prof = " \
 ghc9.4-Cabal-devel \
 ghc9.4-Cabal-syntax-prof \
 ghc9.4-array-prof \
 ghc9.4-base-prof \
 ghc9.4-bytestring-prof \
 ghc9.4-containers-prof \
 ghc9.4-deepseq-prof \
 ghc9.4-directory-prof \
 ghc9.4-filepath-prof \
 ghc9.4-mtl-prof \
 ghc9.4-parsec-prof \
 ghc9.4-pretty-prof \
 ghc9.4-process-prof \
 ghc9.4-text-prof \
 ghc9.4-time-prof \
 ghc9.4-transformers-prof \
 ghc9.4-unix-prof \
 "
RDEPENDS:ghc9.4-Cabal-syntax = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-binary \
 ghc9.4-bytestring \
 ghc9.4-containers \
 ghc9.4-deepseq \
 ghc9.4-directory \
 ghc9.4-filepath \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-mtl \
 ghc9.4-parsec \
 ghc9.4-pretty \
 ghc9.4-template-haskell \
 ghc9.4-text \
 ghc9.4-time \
 ghc9.4-transformers \
 ghc9.4-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-Cabal-syntax-devel = " \
 ghc9.4-Cabal-syntax \
 ghc9.4-array-devel \
 ghc9.4-base-devel \
 ghc9.4-binary-devel \
 ghc9.4-bytestring-devel \
 ghc9.4-compiler \
 ghc9.4-containers-devel \
 ghc9.4-deepseq-devel \
 ghc9.4-directory-devel \
 ghc9.4-filepath-devel \
 ghc9.4-mtl-devel \
 ghc9.4-parsec-devel \
 ghc9.4-pretty-devel \
 ghc9.4-text-devel \
 ghc9.4-time-devel \
 ghc9.4-transformers-devel \
 ghc9.4-unix-devel \
 "
RDEPENDS:ghc9.4-Cabal-syntax-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-Cabal-syntax-prof = " \
 ghc9.4-Cabal-syntax-devel \
 ghc9.4-array-prof \
 ghc9.4-base-prof \
 ghc9.4-binary-prof \
 ghc9.4-bytestring-prof \
 ghc9.4-containers-prof \
 ghc9.4-deepseq-prof \
 ghc9.4-directory-prof \
 ghc9.4-filepath-prof \
 ghc9.4-mtl-prof \
 ghc9.4-parsec-prof \
 ghc9.4-pretty-prof \
 ghc9.4-text-prof \
 ghc9.4-time-prof \
 ghc9.4-transformers-prof \
 ghc9.4-unix-prof \
 "
RDEPENDS:ghc9.4-array = " \
 ghc9.4-base \
 ghc9.4-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-array-devel = " \
 ghc9.4-array \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 "
RDEPENDS:ghc9.4-array-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-array-prof = " \
 ghc9.4-array-devel \
 ghc9.4-base-prof \
 "
RDEPENDS:ghc9.4-base = " \
 ghc9.4-ghc-bignum \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.4-base-devel = " \
 ghc9.4-base \
 ghc9.4-compiler \
 ghc9.4-ghc-bignum-devel \
 gmp-devel \
 libffi-devel \
 "
RDEPENDS:ghc9.4-base-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-base-prof = " \
 ghc9.4-base-devel \
 ghc9.4-ghc-bignum-prof \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.4-binary = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-bytestring \
 ghc9.4-containers \
 ghc9.4-deepseq \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-pretty \
 ghc9.4-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-binary-devel = " \
 ghc9.4-array-devel \
 ghc9.4-base-devel \
 ghc9.4-binary \
 ghc9.4-bytestring-devel \
 ghc9.4-compiler \
 ghc9.4-containers-devel \
 "
RDEPENDS:ghc9.4-binary-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-binary-prof = " \
 ghc9.4-array-prof \
 ghc9.4-base-prof \
 ghc9.4-binary-devel \
 ghc9.4-bytestring-prof \
 ghc9.4-containers-prof \
 "
RDEPENDS:ghc9.4-bytestring = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-deepseq \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-pretty \
 ghc9.4-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-bytestring-devel = " \
 ghc9.4-base-devel \
 ghc9.4-bytestring \
 ghc9.4-compiler \
 ghc9.4-deepseq-devel \
 ghc9.4-template-haskell-devel \
 "
RDEPENDS:ghc9.4-bytestring-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-bytestring-prof = " \
 ghc9.4-base-prof \
 ghc9.4-bytestring-devel \
 ghc9.4-deepseq-prof \
 ghc9.4-template-haskell-prof \
 "
RDEPENDS:ghc9.4-compiler = " \
 bash \
 binutils \
 gcc \
 ghc9.4-Cabal \
 ghc9.4-Cabal-syntax \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-base-devel \
 ghc9.4-binary \
 ghc9.4-bytestring \
 ghc9.4-containers \
 ghc9.4-deepseq \
 ghc9.4-directory \
 ghc9.4-exceptions \
 ghc9.4-filepath \
 ghc9.4-filesystem \
 ghc9.4-ghc \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot \
 ghc9.4-ghc-boot-th \
 ghc9.4-ghc-heap \
 ghc9.4-ghci \
 ghc9.4-haskeline \
 ghc9.4-hpc \
 ghc9.4-libiserv \
 ghc9.4-mtl \
 ghc9.4-parsec \
 ghc9.4-pretty \
 ghc9.4-process \
 ghc9.4-stm \
 ghc9.4-template-haskell \
 ghc9.4-terminfo \
 ghc9.4-text \
 ghc9.4-time \
 ghc9.4-transformers \
 ghc9.4-unix \
 ghc9.4-xhtml \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 "
RDEPENDS:ghc9.4-compiler-default = " \
 bash \
 ghc9.4-compiler \
 "
RDEPENDS:ghc9.4-containers = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-deepseq \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-pretty \
 ghc9.4-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-containers-devel = " \
 ghc9.4-array-devel \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-containers \
 ghc9.4-deepseq-devel \
 ghc9.4-template-haskell-devel \
 "
RDEPENDS:ghc9.4-containers-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-containers-prof = " \
 ghc9.4-array-prof \
 ghc9.4-base-prof \
 ghc9.4-containers-devel \
 ghc9.4-deepseq-prof \
 ghc9.4-template-haskell-prof \
 "
RDEPENDS:ghc9.4-deepseq = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-deepseq-devel = " \
 ghc9.4-array-devel \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-deepseq \
 "
RDEPENDS:ghc9.4-deepseq-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-deepseq-prof = " \
 ghc9.4-array-prof \
 ghc9.4-base-prof \
 ghc9.4-deepseq-devel \
 "
RDEPENDS:ghc9.4-devel = " \
 ghc9.4-Cabal-devel \
 ghc9.4-Cabal-syntax-devel \
 ghc9.4-array-devel \
 ghc9.4-base-devel \
 ghc9.4-binary-devel \
 ghc9.4-bytestring-devel \
 ghc9.4-compiler \
 ghc9.4-containers-devel \
 ghc9.4-deepseq-devel \
 ghc9.4-directory-devel \
 ghc9.4-exceptions-devel \
 ghc9.4-filepath-devel \
 ghc9.4-ghc-boot-th-devel \
 ghc9.4-haskeline-devel \
 ghc9.4-mtl-devel \
 ghc9.4-parsec-devel \
 ghc9.4-pretty-devel \
 ghc9.4-process-devel \
 ghc9.4-stm-devel \
 ghc9.4-template-haskell-devel \
 ghc9.4-terminfo-devel \
 ghc9.4-text-devel \
 ghc9.4-time-devel \
 ghc9.4-transformers-devel \
 ghc9.4-unix-devel \
 ghc9.4-xhtml-devel \
 "
RDEPENDS:ghc9.4-directory = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-bytestring \
 ghc9.4-deepseq \
 ghc9.4-filepath \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-pretty \
 ghc9.4-template-haskell \
 ghc9.4-time \
 ghc9.4-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-directory-devel = " \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-directory \
 ghc9.4-filepath-devel \
 ghc9.4-time-devel \
 ghc9.4-unix-devel \
 "
RDEPENDS:ghc9.4-directory-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-directory-prof = " \
 ghc9.4-base-prof \
 ghc9.4-directory-devel \
 ghc9.4-filepath-prof \
 ghc9.4-time-prof \
 ghc9.4-unix-prof \
 "
RDEPENDS:ghc9.4-doc = " \
 "
RDEPENDS:ghc9.4-doc-index = " \
 ghc9.4-compiler \
 "
RDEPENDS:ghc9.4-exceptions = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-deepseq \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-mtl \
 ghc9.4-pretty \
 ghc9.4-stm \
 ghc9.4-template-haskell \
 ghc9.4-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-exceptions-devel = " \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-exceptions \
 ghc9.4-mtl-devel \
 ghc9.4-stm-devel \
 ghc9.4-template-haskell-devel \
 ghc9.4-transformers-devel \
 "
RDEPENDS:ghc9.4-exceptions-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-exceptions-prof = " \
 ghc9.4-base-prof \
 ghc9.4-exceptions-devel \
 ghc9.4-mtl-prof \
 ghc9.4-stm-prof \
 ghc9.4-template-haskell-prof \
 ghc9.4-transformers-prof \
 "
RDEPENDS:ghc9.4-filepath = " \
 ghc9.4-base \
 ghc9.4-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-filepath-devel = " \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-filepath \
 "
RDEPENDS:ghc9.4-filepath-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-filepath-prof = " \
 ghc9.4-base-prof \
 ghc9.4-filepath-devel \
 "
RDEPENDS:ghc9.4-filesystem = " \
 "
RDEPENDS:ghc9.4-ghc = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-binary \
 ghc9.4-bytestring \
 ghc9.4-containers \
 ghc9.4-deepseq \
 ghc9.4-directory \
 ghc9.4-exceptions \
 ghc9.4-filepath \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot \
 ghc9.4-ghc-boot-th \
 ghc9.4-ghc-heap \
 ghc9.4-ghci \
 ghc9.4-hpc \
 ghc9.4-mtl \
 ghc9.4-pretty \
 ghc9.4-process \
 ghc9.4-stm \
 ghc9.4-template-haskell \
 ghc9.4-terminfo \
 ghc9.4-time \
 ghc9.4-transformers \
 ghc9.4-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.4-ghc-bignum = " \
 ghc9.4-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-ghc-bignum-devel = " \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-ghc-bignum \
 "
RDEPENDS:ghc9.4-ghc-bignum-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-ghc-bignum-prof = " \
 ghc9.4-base-prof \
 ghc9.4-ghc-bignum-devel \
 "
RDEPENDS:ghc9.4-ghc-boot = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-binary \
 ghc9.4-bytestring \
 ghc9.4-containers \
 ghc9.4-deepseq \
 ghc9.4-directory \
 ghc9.4-filepath \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-pretty \
 ghc9.4-template-haskell \
 ghc9.4-time \
 ghc9.4-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-ghc-boot-devel = " \
 ghc9.4-base-devel \
 ghc9.4-binary-devel \
 ghc9.4-bytestring-devel \
 ghc9.4-compiler \
 ghc9.4-containers-devel \
 ghc9.4-deepseq-devel \
 ghc9.4-directory-devel \
 ghc9.4-filepath-devel \
 ghc9.4-ghc-boot \
 ghc9.4-ghc-boot-th-devel \
 ghc9.4-unix-devel \
 "
RDEPENDS:ghc9.4-ghc-boot-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-ghc-boot-prof = " \
 ghc9.4-base-prof \
 ghc9.4-binary-prof \
 ghc9.4-bytestring-prof \
 ghc9.4-containers-prof \
 ghc9.4-deepseq-prof \
 ghc9.4-directory-prof \
 ghc9.4-filepath-prof \
 ghc9.4-ghc-boot-devel \
 ghc9.4-ghc-boot-th-prof \
 ghc9.4-unix-prof \
 "
RDEPENDS:ghc9.4-ghc-boot-th = " \
 ghc9.4-base \
 ghc9.4-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-ghc-boot-th-devel = " \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-ghc-boot-th \
 "
RDEPENDS:ghc9.4-ghc-boot-th-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-ghc-boot-th-prof = " \
 ghc9.4-base-prof \
 ghc9.4-ghc-boot-th-devel \
 "
RDEPENDS:ghc9.4-ghc-compact = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-bytestring \
 ghc9.4-deepseq \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-pretty \
 ghc9.4-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-ghc-compact-devel = " \
 ghc9.4-base-devel \
 ghc9.4-bytestring-devel \
 ghc9.4-compiler \
 ghc9.4-ghc-compact \
 "
RDEPENDS:ghc9.4-ghc-compact-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-ghc-compact-prof = " \
 ghc9.4-base-prof \
 ghc9.4-bytestring-prof \
 ghc9.4-ghc-compact-devel \
 "
RDEPENDS:ghc9.4-ghc-devel = " \
 ghc9.4-array-devel \
 ghc9.4-base-devel \
 ghc9.4-binary-devel \
 ghc9.4-bytestring-devel \
 ghc9.4-compiler \
 ghc9.4-containers-devel \
 ghc9.4-deepseq-devel \
 ghc9.4-directory-devel \
 ghc9.4-exceptions-devel \
 ghc9.4-filepath-devel \
 ghc9.4-ghc \
 ghc9.4-ghc-boot-devel \
 ghc9.4-ghc-heap-devel \
 ghc9.4-ghci-devel \
 ghc9.4-hpc-devel \
 ghc9.4-process-devel \
 ghc9.4-stm-devel \
 ghc9.4-template-haskell-devel \
 ghc9.4-terminfo-devel \
 ghc9.4-time-devel \
 ghc9.4-transformers-devel \
 ghc9.4-unix-devel \
 "
RDEPENDS:ghc9.4-ghc-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-ghc-heap = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-containers \
 ghc9.4-deepseq \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-pretty \
 ghc9.4-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-ghc-heap-devel = " \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-containers-devel \
 ghc9.4-ghc-heap \
 "
RDEPENDS:ghc9.4-ghc-heap-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-ghc-heap-prof = " \
 ghc9.4-base-prof \
 ghc9.4-containers-prof \
 ghc9.4-ghc-heap-devel \
 "
RDEPENDS:ghc9.4-ghc-prof = " \
 ghc9.4-array-prof \
 ghc9.4-base-prof \
 ghc9.4-binary-prof \
 ghc9.4-bytestring-prof \
 ghc9.4-containers-prof \
 ghc9.4-deepseq-prof \
 ghc9.4-directory-prof \
 ghc9.4-exceptions-prof \
 ghc9.4-filepath-prof \
 ghc9.4-ghc-boot-prof \
 ghc9.4-ghc-devel \
 ghc9.4-ghc-heap-prof \
 ghc9.4-ghci-prof \
 ghc9.4-hpc-prof \
 ghc9.4-process-prof \
 ghc9.4-stm-prof \
 ghc9.4-template-haskell-prof \
 ghc9.4-terminfo-prof \
 ghc9.4-time-prof \
 ghc9.4-transformers-prof \
 ghc9.4-unix-prof \
 "
RDEPENDS:ghc9.4-ghci = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-binary \
 ghc9.4-bytestring \
 ghc9.4-containers \
 ghc9.4-deepseq \
 ghc9.4-directory \
 ghc9.4-filepath \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot \
 ghc9.4-ghc-boot-th \
 ghc9.4-ghc-heap \
 ghc9.4-pretty \
 ghc9.4-template-haskell \
 ghc9.4-time \
 ghc9.4-transformers \
 ghc9.4-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-ghci-devel = " \
 ghc9.4-array-devel \
 ghc9.4-base-devel \
 ghc9.4-binary-devel \
 ghc9.4-bytestring-devel \
 ghc9.4-compiler \
 ghc9.4-containers-devel \
 ghc9.4-deepseq-devel \
 ghc9.4-filepath-devel \
 ghc9.4-ghc-boot-devel \
 ghc9.4-ghc-heap-devel \
 ghc9.4-ghci \
 ghc9.4-template-haskell-devel \
 ghc9.4-transformers-devel \
 ghc9.4-unix-devel \
 "
RDEPENDS:ghc9.4-ghci-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-ghci-prof = " \
 ghc9.4-array-prof \
 ghc9.4-base-prof \
 ghc9.4-binary-prof \
 ghc9.4-bytestring-prof \
 ghc9.4-containers-prof \
 ghc9.4-deepseq-prof \
 ghc9.4-filepath-prof \
 ghc9.4-ghc-boot-prof \
 ghc9.4-ghc-heap-prof \
 ghc9.4-ghci-devel \
 ghc9.4-template-haskell-prof \
 ghc9.4-transformers-prof \
 ghc9.4-unix-prof \
 "
RDEPENDS:ghc9.4-hadrian = " \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.4-haskeline = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-bytestring \
 ghc9.4-containers \
 ghc9.4-deepseq \
 ghc9.4-directory \
 ghc9.4-exceptions \
 ghc9.4-filepath \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-mtl \
 ghc9.4-pretty \
 ghc9.4-process \
 ghc9.4-stm \
 ghc9.4-template-haskell \
 ghc9.4-terminfo \
 ghc9.4-time \
 ghc9.4-transformers \
 ghc9.4-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.4-haskeline-devel = " \
 ghc9.4-base-devel \
 ghc9.4-bytestring-devel \
 ghc9.4-compiler \
 ghc9.4-containers-devel \
 ghc9.4-directory-devel \
 ghc9.4-exceptions-devel \
 ghc9.4-filepath-devel \
 ghc9.4-haskeline \
 ghc9.4-process-devel \
 ghc9.4-stm-devel \
 ghc9.4-terminfo-devel \
 ghc9.4-transformers-devel \
 ghc9.4-unix-devel \
 "
RDEPENDS:ghc9.4-haskeline-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-haskeline-prof = " \
 ghc9.4-base-prof \
 ghc9.4-bytestring-prof \
 ghc9.4-containers-prof \
 ghc9.4-directory-prof \
 ghc9.4-exceptions-prof \
 ghc9.4-filepath-prof \
 ghc9.4-haskeline-devel \
 ghc9.4-process-prof \
 ghc9.4-stm-prof \
 ghc9.4-terminfo-prof \
 ghc9.4-transformers-prof \
 ghc9.4-unix-prof \
 "
RDEPENDS:ghc9.4-hpc = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-bytestring \
 ghc9.4-containers \
 ghc9.4-deepseq \
 ghc9.4-directory \
 ghc9.4-filepath \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-pretty \
 ghc9.4-template-haskell \
 ghc9.4-time \
 ghc9.4-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-hpc-devel = " \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-containers-devel \
 ghc9.4-deepseq-devel \
 ghc9.4-directory-devel \
 ghc9.4-filepath-devel \
 ghc9.4-hpc \
 ghc9.4-time-devel \
 "
RDEPENDS:ghc9.4-hpc-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-hpc-prof = " \
 ghc9.4-base-prof \
 ghc9.4-containers-prof \
 ghc9.4-deepseq-prof \
 ghc9.4-directory-prof \
 ghc9.4-filepath-prof \
 ghc9.4-hpc-devel \
 ghc9.4-time-prof \
 "
RDEPENDS:ghc9.4-libiserv = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-binary \
 ghc9.4-bytestring \
 ghc9.4-containers \
 ghc9.4-deepseq \
 ghc9.4-directory \
 ghc9.4-filepath \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot \
 ghc9.4-ghc-boot-th \
 ghc9.4-ghc-heap \
 ghc9.4-ghci \
 ghc9.4-pretty \
 ghc9.4-template-haskell \
 ghc9.4-time \
 ghc9.4-transformers \
 ghc9.4-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-libiserv-devel = " \
 ghc9.4-base-devel \
 ghc9.4-binary-devel \
 ghc9.4-bytestring-devel \
 ghc9.4-compiler \
 ghc9.4-containers-devel \
 ghc9.4-deepseq-devel \
 ghc9.4-ghci-devel \
 ghc9.4-libiserv \
 ghc9.4-unix-devel \
 "
RDEPENDS:ghc9.4-libiserv-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-libiserv-prof = " \
 ghc9.4-base-prof \
 ghc9.4-binary-prof \
 ghc9.4-bytestring-prof \
 ghc9.4-containers-prof \
 ghc9.4-deepseq-prof \
 ghc9.4-ghci-prof \
 ghc9.4-libiserv-devel \
 ghc9.4-unix-prof \
 "
RDEPENDS:ghc9.4-manual = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-mtl = " \
 ghc9.4-base \
 ghc9.4-ghc-bignum \
 ghc9.4-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-mtl-devel = " \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-mtl \
 ghc9.4-transformers-devel \
 "
RDEPENDS:ghc9.4-mtl-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-mtl-prof = " \
 ghc9.4-base-prof \
 ghc9.4-mtl-devel \
 ghc9.4-transformers-prof \
 "
RDEPENDS:ghc9.4-parsec = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-binary \
 ghc9.4-bytestring \
 ghc9.4-containers \
 ghc9.4-deepseq \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-mtl \
 ghc9.4-pretty \
 ghc9.4-template-haskell \
 ghc9.4-text \
 ghc9.4-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-parsec-devel = " \
 ghc9.4-base-devel \
 ghc9.4-bytestring-devel \
 ghc9.4-compiler \
 ghc9.4-mtl-devel \
 ghc9.4-parsec \
 ghc9.4-text-devel \
 "
RDEPENDS:ghc9.4-parsec-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-parsec-prof = " \
 ghc9.4-base-prof \
 ghc9.4-bytestring-prof \
 ghc9.4-mtl-prof \
 ghc9.4-parsec-devel \
 ghc9.4-text-prof \
 "
RDEPENDS:ghc9.4-pretty = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-deepseq \
 ghc9.4-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-pretty-devel = " \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-deepseq-devel \
 ghc9.4-pretty \
 "
RDEPENDS:ghc9.4-pretty-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-pretty-prof = " \
 ghc9.4-base-prof \
 ghc9.4-deepseq-prof \
 ghc9.4-pretty-devel \
 "
RDEPENDS:ghc9.4-process = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-bytestring \
 ghc9.4-deepseq \
 ghc9.4-directory \
 ghc9.4-filepath \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-pretty \
 ghc9.4-template-haskell \
 ghc9.4-time \
 ghc9.4-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-process-devel = " \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-deepseq-devel \
 ghc9.4-directory-devel \
 ghc9.4-filepath-devel \
 ghc9.4-process \
 ghc9.4-unix-devel \
 "
RDEPENDS:ghc9.4-process-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-process-prof = " \
 ghc9.4-base-prof \
 ghc9.4-deepseq-prof \
 ghc9.4-directory-prof \
 ghc9.4-filepath-prof \
 ghc9.4-process-devel \
 ghc9.4-unix-prof \
 "
RDEPENDS:ghc9.4-prof = " \
 ghc9.4-compiler \
 "
RDEPENDS:ghc9.4-stm = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-stm-devel = " \
 ghc9.4-array-devel \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-stm \
 "
RDEPENDS:ghc9.4-stm-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-stm-prof = " \
 ghc9.4-array-prof \
 ghc9.4-base-prof \
 ghc9.4-stm-devel \
 "
RDEPENDS:ghc9.4-template-haskell = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-deepseq \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-template-haskell-devel = " \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-ghc-boot-th-devel \
 ghc9.4-pretty-devel \
 ghc9.4-template-haskell \
 "
RDEPENDS:ghc9.4-template-haskell-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-template-haskell-prof = " \
 ghc9.4-base-prof \
 ghc9.4-ghc-boot-th-prof \
 ghc9.4-pretty-prof \
 ghc9.4-template-haskell-devel \
 "
RDEPENDS:ghc9.4-terminfo = " \
 ghc9.4-base \
 ghc9.4-ghc-bignum \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.4-terminfo-devel = " \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-terminfo \
 ncurses-devel \
 "
RDEPENDS:ghc9.4-terminfo-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-terminfo-prof = " \
 ghc9.4-base-prof \
 ghc9.4-terminfo-devel \
 "
RDEPENDS:ghc9.4-text = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-binary \
 ghc9.4-bytestring \
 ghc9.4-containers \
 ghc9.4-deepseq \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-pretty \
 ghc9.4-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-text-devel = " \
 ghc9.4-array-devel \
 ghc9.4-base-devel \
 ghc9.4-binary-devel \
 ghc9.4-bytestring-devel \
 ghc9.4-compiler \
 ghc9.4-deepseq-devel \
 ghc9.4-template-haskell-devel \
 ghc9.4-text \
 "
RDEPENDS:ghc9.4-text-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-text-prof = " \
 ghc9.4-array-prof \
 ghc9.4-base-prof \
 ghc9.4-binary-prof \
 ghc9.4-bytestring-prof \
 ghc9.4-deepseq-prof \
 ghc9.4-template-haskell-prof \
 ghc9.4-text-devel \
 "
RDEPENDS:ghc9.4-time = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-deepseq \
 ghc9.4-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-time-devel = " \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-deepseq-devel \
 ghc9.4-time \
 "
RDEPENDS:ghc9.4-time-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-time-prof = " \
 ghc9.4-base-prof \
 ghc9.4-deepseq-prof \
 ghc9.4-time-devel \
 "
RDEPENDS:ghc9.4-transformers = " \
 ghc9.4-base \
 ghc9.4-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-transformers-devel = " \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-transformers \
 "
RDEPENDS:ghc9.4-transformers-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-transformers-prof = " \
 ghc9.4-base-prof \
 ghc9.4-transformers-devel \
 "
RDEPENDS:ghc9.4-unix = " \
 ghc9.4-array \
 ghc9.4-base \
 ghc9.4-bytestring \
 ghc9.4-deepseq \
 ghc9.4-ghc-bignum \
 ghc9.4-ghc-boot-th \
 ghc9.4-pretty \
 ghc9.4-template-haskell \
 ghc9.4-time \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-unix-devel = " \
 ghc9.4-base-devel \
 ghc9.4-bytestring-devel \
 ghc9.4-compiler \
 ghc9.4-time-devel \
 ghc9.4-unix \
 "
RDEPENDS:ghc9.4-unix-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-unix-prof = " \
 ghc9.4-base-prof \
 ghc9.4-bytestring-prof \
 ghc9.4-time-prof \
 ghc9.4-unix-devel \
 "
RDEPENDS:ghc9.4-xhtml = " \
 ghc9.4-base \
 ghc9.4-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.4-xhtml-devel = " \
 ghc9.4-base-devel \
 ghc9.4-compiler \
 ghc9.4-xhtml \
 "
RDEPENDS:ghc9.4-xhtml-doc = " \
 ghc9.4-filesystem \
 "
RDEPENDS:ghc9.4-xhtml-prof = " \
 ghc9.4-base-prof \
 ghc9.4-xhtml-devel \
 "
