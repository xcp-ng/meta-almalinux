# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pandocfilters"
PV = "1.5.1"
PR = "6.el10_0"
PACKAGES = " \
 python3-pandocfilters \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pandocfilters-1.5.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3169c8b919833493bcb0460f650ad2c05d6b122ae93a342568029e1c93001393"

URI_x86_64_v2_python3-pandocfilters = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pandocfilters-1.5.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pandocfilters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pandocfilters}"
SRC_URI[x86_64_v2_python3-pandocfilters.sha256sum] = "c36b3ed662348f247039edd03631d63889c17082fd5697f577d9df10acd5a7aa"

URI_aarch64_python3-pandocfilters = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pandocfilters-1.5.1-6.el10_0.noarch.rpm;name=aarch64_python3-pandocfilters;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pandocfilters}"
SRC_URI[aarch64_python3-pandocfilters.sha256sum] = "d279adf4096f15c89f9fb2b6a5f4b8be542b82bd2be8968c0ef69d0c5a2c1b95"

RDEPENDS:python3-pandocfilters = " \
 python3 \
 "
