# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openbgpd"
PV = "9.2"
PR = "1.el10_3"
PACKAGES = " \
 openbgpd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openbgpd-9.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9921109228af2c043019283b0d8716f195589a580dc96a4ff7266c1f63939345"

URI_x86_64_v2_openbgpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbgpd-9.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbgpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openbgpd}"
SRC_URI[x86_64_v2_openbgpd.sha256sum] = "16934ebfae35e55228189410f7a1f94dca8148955bcf1c15634a019d1663ef5d"

URI_aarch64_openbgpd = "${EPEL_MIRROR}/aarch64/Packages/o/openbgpd-9.2-1.el10_3.aarch64.rpm;name=aarch64_openbgpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_openbgpd}"
SRC_URI[aarch64_openbgpd.sha256sum] = "b7d323a787cee76e77a76a8d3594447985b966b65c33f4cb8aca59cac67864c3"

RDEPENDS:openbgpd = " \
 bash \
 glibc \
 libmnl \
 shadow-utils \
 systemd \
 "
