# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mcelog"
PE = "3"
PV = "202"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 mcelog \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mcelog-202-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "358fdafe18a07016bf9628b8f262252880cefaf0304e50b6e5fe074a316b8880"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mcelog-202-1.el10.x86_64_v2.rpm;name=x86_64_v2_mcelog;unpack=0"
SRC_URI[x86_64_v2_mcelog.sha256sum] = "77136a09fffd261634572d63825b1828adcee6776eabce2eaddd231ed978342b"

RDEPENDS:mcelog = " \
 bash \
 glibc \
 systemd \
 "
