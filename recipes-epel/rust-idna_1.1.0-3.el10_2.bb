# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-idna"
PV = "1.1.0"
PR = "3.el10_2"
PACKAGES = " \
 rust-idna+alloc-devel \
 rust-idna+compiled_data-devel \
 rust-idna+default-devel \
 rust-idna+std-devel \
 rust-idna-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-idna-1.1.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0267a64fc296af869730dfe1dec1120f91620454d98912d92080973206e5c701"

URI_x86_64_v2_rust-idna+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna+alloc-devel-1.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna+alloc-devel}"
SRC_URI[x86_64_v2_rust-idna+alloc-devel.sha256sum] = "b7b0ae99cc552d68744dc89ace79c80747b4f9155b605bb4d625233a7375810d"

URI_x86_64_v2_rust-idna+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna+compiled_data-devel-1.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-idna+compiled_data-devel.sha256sum] = "6da0933d50f4fd4c8ec69e7a275e7f98308c13b51ce705f78256629593230f64"

URI_x86_64_v2_rust-idna+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna+default-devel-1.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna+default-devel}"
SRC_URI[x86_64_v2_rust-idna+default-devel.sha256sum] = "bb110da3da30c7bcfb204e216832fc160ae61bb75c9e9303012f1d7d2460a593"

URI_x86_64_v2_rust-idna+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna+std-devel-1.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna+std-devel}"
SRC_URI[x86_64_v2_rust-idna+std-devel.sha256sum] = "b652fbda95c65df5d32b30a58d65844e2ffeee6c3d57cf26ee5b7d2e33c5795d"

URI_x86_64_v2_rust-idna-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna-devel-1.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna-devel}"
SRC_URI[x86_64_v2_rust-idna-devel.sha256sum] = "d7aa01f72812a9d4c8186458fe4098c35a0534b4f902eebadfbf1f3f1c5042e5"

URI_aarch64_rust-idna+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna+alloc-devel-1.1.0-3.el10_2.noarch.rpm;name=aarch64_rust-idna+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna+alloc-devel}"
SRC_URI[aarch64_rust-idna+alloc-devel.sha256sum] = "3f6b0ccf393ea62bb61686bc149e212a23951967a863117a8f0e77f1642ee8ea"

URI_aarch64_rust-idna+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna+compiled_data-devel-1.1.0-3.el10_2.noarch.rpm;name=aarch64_rust-idna+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna+compiled_data-devel}"
SRC_URI[aarch64_rust-idna+compiled_data-devel.sha256sum] = "bb1550fd2e6653c9d33775bcc82c52355686303d117ef8be4a6f8abd8efd761a"

URI_aarch64_rust-idna+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna+default-devel-1.1.0-3.el10_2.noarch.rpm;name=aarch64_rust-idna+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna+default-devel}"
SRC_URI[aarch64_rust-idna+default-devel.sha256sum] = "13805f6d344fbf2f596a1840d0d0e1fae80fefa12c6c5abebecfdf48b1a5100c"

URI_aarch64_rust-idna+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna+std-devel-1.1.0-3.el10_2.noarch.rpm;name=aarch64_rust-idna+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna+std-devel}"
SRC_URI[aarch64_rust-idna+std-devel.sha256sum] = "9adffadaa043fa0989f1e3460a39c9bbfa1713af4123778e9539589e75c30174"

URI_aarch64_rust-idna-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna-devel-1.1.0-3.el10_2.noarch.rpm;name=aarch64_rust-idna-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna-devel}"
SRC_URI[aarch64_rust-idna-devel.sha256sum] = "a5a64a3b736e6a7dd4a3e9017a9b2b4e002d4aa7c8f6d262094a0549f643fb87"

RDEPENDS:rust-idna+alloc-devel = " \
 cargo \
 rust-idna-devel \
 "
RDEPENDS:rust-idna+compiled_data-devel = " \
 cargo \
 rust-idna-devel \
 rust-idna_adapter+compiled_data-devel \
 "
RDEPENDS:rust-idna+default-devel = " \
 cargo \
 rust-idna+compiled_data-devel \
 rust-idna+std-devel \
 rust-idna-devel \
 "
RDEPENDS:rust-idna+std-devel = " \
 cargo \
 rust-idna+alloc-devel \
 rust-idna-devel \
 "
RDEPENDS:rust-idna-devel = " \
 cargo \
 rust \
 rust-idna_adapter+default-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+default-devel \
 rust-utf8_iter+default-devel \
 "
