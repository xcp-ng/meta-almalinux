# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdominate"
PV = "26.08.1"
PR = "2.el10_3"
PACKAGES = " \
 kdominate \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdominate-26.08.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b8de7a0585f6221926bf80103825de8fe9ab4f4803a7316dda18f69f62c800f9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdominate-26.08.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdominate;unpack=0"
SRC_URI[x86_64_v2_kdominate.sha256sum] = "0c8a56079e2654210f354054de65705774fb09409101096c7f24cb1675aa6515"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdominate-26.08.1-2.el10_3.aarch64.rpm;name=aarch64_kdominate;unpack=0"
SRC_URI[aarch64_kdominate.sha256sum] = "c8e43ac086037ed6e4783ee95b23680eb079ccb5a4a9b2769a6615db5c204ca9"

RDEPENDS:kdominate = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
