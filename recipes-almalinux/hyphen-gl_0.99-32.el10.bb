# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-gl"
PV = "0.99"
PR = "32.el10"
PACKAGES = " \
 hyphen-gl \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-gl-0.99-32.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "82536993d194eab5f10dc609da862175f28ba67881a34bfe9162adfd9db96579"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-gl-0.99-32.el10.noarch.rpm;name=x86_64_v2_hyphen-gl;unpack=0"
SRC_URI[x86_64_v2_hyphen-gl.sha256sum] = "f4b253d1b154656779865728e498e2d8a117120ceb5fb6cb050d1afb208b78d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-gl-0.99-32.el10.noarch.rpm;name=aarch64_hyphen-gl;unpack=0"
SRC_URI[aarch64_hyphen-gl.sha256sum] = "f4b253d1b154656779865728e498e2d8a117120ceb5fb6cb050d1afb208b78d1"

RDEPENDS:hyphen-gl = " \
 hyphen \
 "
