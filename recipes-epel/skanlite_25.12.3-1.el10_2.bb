# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skanlite"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 skanlite \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/skanlite-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "04e33b1e44bb8084d6f53051d123d35fda8412a7aec4ad64c4db98af0d2dd51a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/skanlite-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_skanlite;unpack=0"
SRC_URI[x86_64_v2_skanlite.sha256sum] = "e3260ae3bada340a6a54786add7df7db69030c88f02620e5d56e2f597f411476"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/skanlite-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_skanlite;unpack=0"
SRC_URI[aarch64_skanlite.sha256sum] = "6fa94eb96e91bb7328e40add63ec24641add614e0e2de1ff74bad9c93ba9b4e9"

RDEPENDS:skanlite = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libksane \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
