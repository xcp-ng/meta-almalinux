# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pin-project"
PV = "1.1.11"
PR = "1.el10_2"
PACKAGES = " \
 rust-pin-project+default-devel \
 rust-pin-project-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pin-project-1.1.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6439af3e4c549cad42e87b451eb23713e7de6d4311a03207db594cb75d2e265d"

URI_x86_64_v2_rust-pin-project+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project+default-devel-1.1.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project+default-devel}"
SRC_URI[x86_64_v2_rust-pin-project+default-devel.sha256sum] = "46245f6ed38c4cd6eeebc207cc4d5db837291ce914affafbac8291192fb41078"

URI_x86_64_v2_rust-pin-project-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-devel-1.1.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-devel}"
SRC_URI[x86_64_v2_rust-pin-project-devel.sha256sum] = "0dfc46b8618986db91896fde8388497b54d0264da96022ca76087c2de5a8cd12"

URI_aarch64_rust-pin-project+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project+default-devel-1.1.11-1.el10_2.noarch.rpm;name=aarch64_rust-pin-project+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project+default-devel}"
SRC_URI[aarch64_rust-pin-project+default-devel.sha256sum] = "25f6f1bb2d4be2b45f44cbd8f5716b71c7a2bfa0f1d3d70ebfd420b7ee9d6cfe"

URI_aarch64_rust-pin-project-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-devel-1.1.11-1.el10_2.noarch.rpm;name=aarch64_rust-pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-devel}"
SRC_URI[aarch64_rust-pin-project-devel.sha256sum] = "d32d1312e31e0d528633312ec19f6f93d1612b3575e13b84a3fe297f8dcb8035"

RDEPENDS:rust-pin-project+default-devel = " \
 cargo \
 rust-pin-project-devel \
 "
RDEPENDS:rust-pin-project-devel = " \
 cargo \
 rust \
 rust-pin-project-internal+default-devel \
 "
