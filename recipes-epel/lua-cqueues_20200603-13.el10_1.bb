# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-cqueues"
PV = "20200603"
PR = "13.el10_1"
PACKAGES = " \
 lua-cqueues \
 lua-cqueues-doc \
 lua5.1-cqueues \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-cqueues-20200603-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "161e66e0a6f3bf24d3efbdb5775208170b4583e1c8e1c66db7140097520697aa"

URI_x86_64_v2_lua-cqueues = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-cqueues-20200603-13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-cqueues;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-cqueues}"
SRC_URI[x86_64_v2_lua-cqueues.sha256sum] = "7de96cc17aa281b5fa9c02c2b5f099a87d53ce2ce9910d934e76b164ce263161"

URI_x86_64_v2_lua-cqueues-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-cqueues-doc-20200603-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lua-cqueues-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-cqueues-doc}"
SRC_URI[x86_64_v2_lua-cqueues-doc.sha256sum] = "d6cd358e8f33d37afa6bcaa5c646c763c327e21d8c4644b971c58bcb951c2a3c"

URI_x86_64_v2_lua5.1-cqueues = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua5.1-cqueues-20200603-13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua5.1-cqueues;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua5.1-cqueues}"
SRC_URI[x86_64_v2_lua5.1-cqueues.sha256sum] = "880626ef74936787592ecce10c0cfc6b8e885515fb84896e6b423c3ca78fb74e"

URI_aarch64_lua-cqueues = "${EPEL_MIRROR}/aarch64/Packages/l/lua-cqueues-20200603-13.el10_1.aarch64.rpm;name=aarch64_lua-cqueues;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-cqueues}"
SRC_URI[aarch64_lua-cqueues.sha256sum] = "f20cb0a377aba6751079b8b0b4134e58091909e658106cb38e1319bee4775f6c"

URI_aarch64_lua-cqueues-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lua-cqueues-doc-20200603-13.el10_1.noarch.rpm;name=aarch64_lua-cqueues-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-cqueues-doc}"
SRC_URI[aarch64_lua-cqueues-doc.sha256sum] = "82be8fd1fafb685dbde32aea5fd81d55ac05095f339fddca5d4d49f6db3ff0e2"

URI_aarch64_lua5.1-cqueues = "${EPEL_MIRROR}/aarch64/Packages/l/lua5.1-cqueues-20200603-13.el10_1.aarch64.rpm;name=aarch64_lua5.1-cqueues;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua5.1-cqueues}"
SRC_URI[aarch64_lua5.1-cqueues.sha256sum] = "044c158c4b706a21c74f16090cd1090792ffff0255701bd8726e106e9495ea61"

RDEPENDS:lua-cqueues = " \
 glibc \
 lua-libs \
 openssl-libs \
 "
RDEPENDS:lua-cqueues-doc = " \
 lua-cqueues \
 "
RDEPENDS:lua5.1-cqueues = " \
 compat-lua-libs \
 glibc \
 openssl-libs \
 "
