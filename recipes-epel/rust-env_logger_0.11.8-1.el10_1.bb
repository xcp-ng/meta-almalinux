# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_logger"
PV = "0.11.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-env_logger+auto-color-devel \
 rust-env_logger+color-devel \
 rust-env_logger+default-devel \
 rust-env_logger+humantime-devel \
 rust-env_logger+kv-devel \
 rust-env_logger+regex-devel \
 rust-env_logger+unstable-kv-devel \
 rust-env_logger-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_logger-0.11.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a86a28b8aba692b27a2f54e7cf9040c4014a7f901a2d93137e0826011cb2406"

URI_x86_64_v2_rust-env_logger+auto-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+auto-color-devel-0.11.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+auto-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+auto-color-devel}"
SRC_URI[x86_64_v2_rust-env_logger+auto-color-devel.sha256sum] = "bb9dbae2bf6553fdf16102815f4b9617b439afd5459f0ee29196c7b552739376"

URI_x86_64_v2_rust-env_logger+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+color-devel-0.11.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+color-devel}"
SRC_URI[x86_64_v2_rust-env_logger+color-devel.sha256sum] = "18ad9ded4b3c8e16c139e6057ae8db54e65db9c6341371fe4245332a870638c0"

URI_x86_64_v2_rust-env_logger+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+default-devel-0.11.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+default-devel}"
SRC_URI[x86_64_v2_rust-env_logger+default-devel.sha256sum] = "9352f04e95dd106e3bf8bb26eb2f126417932e826fcc730a14fcabebc31a174d"

URI_x86_64_v2_rust-env_logger+humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+humantime-devel-0.11.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+humantime-devel}"
SRC_URI[x86_64_v2_rust-env_logger+humantime-devel.sha256sum] = "301519e60e3fd8873a3075643190e7acfa812190ea196ce17886fa5059023852"

URI_x86_64_v2_rust-env_logger+kv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+kv-devel-0.11.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+kv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+kv-devel}"
SRC_URI[x86_64_v2_rust-env_logger+kv-devel.sha256sum] = "4186525866c262d08664a3a94509e06bfab6b686dae82d9df8c1cbfd232e2777"

URI_x86_64_v2_rust-env_logger+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+regex-devel-0.11.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+regex-devel}"
SRC_URI[x86_64_v2_rust-env_logger+regex-devel.sha256sum] = "50fc03d186357973e9a0d4c4cf1993c3a5fdbce5a57b1f2d169bef7cffa4983a"

URI_x86_64_v2_rust-env_logger+unstable-kv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+unstable-kv-devel-0.11.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+unstable-kv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+unstable-kv-devel}"
SRC_URI[x86_64_v2_rust-env_logger+unstable-kv-devel.sha256sum] = "33d911ab44a97a22885a5109203d71e6f53f5adf10cd8f3791731afff6faa7a8"

URI_x86_64_v2_rust-env_logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger-devel-0.11.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger-devel}"
SRC_URI[x86_64_v2_rust-env_logger-devel.sha256sum] = "fa223b1a89696c8e20136863903357f438d45c1f079e9798c59f7fbb8d715198"
RPROVIDES:rust-env_logger-devel:append:x86_64_v2 = " virtual/crate_env_logger__ge_0.6.1"

URI_aarch64_rust-env_logger+auto-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+auto-color-devel-0.11.8-1.el10_1.noarch.rpm;name=aarch64_rust-env_logger+auto-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+auto-color-devel}"
SRC_URI[aarch64_rust-env_logger+auto-color-devel.sha256sum] = "1176ba717213ef5dbf6152fb706729bc25aec4b587dccca73254a2239c993602"

URI_aarch64_rust-env_logger+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+color-devel-0.11.8-1.el10_1.noarch.rpm;name=aarch64_rust-env_logger+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+color-devel}"
SRC_URI[aarch64_rust-env_logger+color-devel.sha256sum] = "f0ab8fc287edfb231075554d8eb97ef0efc0e05a18101258aba07ccbc6c84fae"

URI_aarch64_rust-env_logger+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+default-devel-0.11.8-1.el10_1.noarch.rpm;name=aarch64_rust-env_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+default-devel}"
SRC_URI[aarch64_rust-env_logger+default-devel.sha256sum] = "60a22c8d044a562c604a17b2e334f4a0de016a05824172c902b5724a400aea27"

URI_aarch64_rust-env_logger+humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+humantime-devel-0.11.8-1.el10_1.noarch.rpm;name=aarch64_rust-env_logger+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+humantime-devel}"
SRC_URI[aarch64_rust-env_logger+humantime-devel.sha256sum] = "f9a6429efe7a633dc0557387f81235f434d64258d18a54f4b47f15066b3057b0"

URI_aarch64_rust-env_logger+kv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+kv-devel-0.11.8-1.el10_1.noarch.rpm;name=aarch64_rust-env_logger+kv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+kv-devel}"
SRC_URI[aarch64_rust-env_logger+kv-devel.sha256sum] = "5077b029dab194d5da5608c4c01642fa3753af7582664123c2c132d2ced4b877"

URI_aarch64_rust-env_logger+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+regex-devel-0.11.8-1.el10_1.noarch.rpm;name=aarch64_rust-env_logger+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+regex-devel}"
SRC_URI[aarch64_rust-env_logger+regex-devel.sha256sum] = "becb1cfcb40b21c69313e2fde2bab17ea28c9a7c17d5f4fe3696e3b8f434363a"

URI_aarch64_rust-env_logger+unstable-kv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+unstable-kv-devel-0.11.8-1.el10_1.noarch.rpm;name=aarch64_rust-env_logger+unstable-kv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+unstable-kv-devel}"
SRC_URI[aarch64_rust-env_logger+unstable-kv-devel.sha256sum] = "7f686e283a31fa388514372d69dfa3c27b46a88195dfcd0859bbbe9a3fb2fb1c"

URI_aarch64_rust-env_logger-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger-devel-0.11.8-1.el10_1.noarch.rpm;name=aarch64_rust-env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger-devel}"
SRC_URI[aarch64_rust-env_logger-devel.sha256sum] = "b65047e040b84ba77509a1f773aad71a39960b7ba27c03c2519ba88e695382a5"
RPROVIDES:rust-env_logger-devel:append:aarch64 = " virtual/crate_env_logger__ge_0.6.1"

RDEPENDS:rust-env_logger+auto-color-devel = " \
 cargo \
 rust-anstream+auto-devel \
 rust-anstream+wincon-devel \
 rust-anstream-devel \
 rust-env_logger+color-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+color-devel = " \
 cargo \
 rust-anstream+wincon-devel \
 rust-anstream-devel \
 rust-anstyle+default-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+default-devel = " \
 cargo \
 rust-env_logger+auto-color-devel \
 rust-env_logger+humantime-devel \
 rust-env_logger+regex-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+humantime-devel = " \
 cargo \
 rust-env_logger-devel \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-env_logger+kv-devel = " \
 cargo \
 rust-env_logger-devel \
 rust-log+kv-devel \
 "
RDEPENDS:rust-env_logger+regex-devel = " \
 cargo \
 rust-env_filter+regex-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+unstable-kv-devel = " \
 cargo \
 rust-env_logger+kv-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger-devel = " \
 cargo \
 rust \
 rust-env_filter-devel \
 rust-log+default-devel \
 rust-log+std-devel \
 "
