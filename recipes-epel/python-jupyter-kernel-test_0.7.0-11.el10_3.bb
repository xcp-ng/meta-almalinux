# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jupyter-kernel-test"
PV = "0.7.0"
PR = "11.el10_3"
PACKAGES = " \
 python3-jupyter-kernel-test \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jupyter-kernel-test-0.7.0-11.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55f172afe18dbd15da71fdec5a85d7a0c55e372d509c89f22e38e2a49d9d0758"

URI_x86_64_v2_python3-jupyter-kernel-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jupyter-kernel-test-0.7.0-11.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jupyter-kernel-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jupyter-kernel-test}"
SRC_URI[x86_64_v2_python3-jupyter-kernel-test.sha256sum] = "cd1e2f1ff42fcaa5e661da9c6b339bd5cbf874a86aaae17ba57c3cd584421c2b"

URI_aarch64_python3-jupyter-kernel-test = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jupyter-kernel-test-0.7.0-11.el10_3.noarch.rpm;name=aarch64_python3-jupyter-kernel-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jupyter-kernel-test}"
SRC_URI[aarch64_python3-jupyter-kernel-test.sha256sum] = "46f793531140ee07bd4a1d79e8f40d24f4d5fb7d31aeb910cca3953fca97a6b7"

RDEPENDS:python3-jupyter-kernel-test = " \
 python3 \
 python3-jsonschema \
 python3-jupyter-client \
 "
