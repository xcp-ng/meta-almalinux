# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-simple-cmd"
PV = "0.2.7"
PR = "7.el10_0"
PACKAGES = " \
 ghc-simple-cmd \
 ghc-simple-cmd-devel \
 ghc-simple-cmd-doc \
 ghc-simple-cmd-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-simple-cmd-0.2.7-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73f29cc692b1413ce516af27d2d1b3c4e43731bfd31cf24ec18f91dae4addd5a"

URI_x86_64_v2_ghc-simple-cmd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-simple-cmd-0.2.7-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-simple-cmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-simple-cmd}"
SRC_URI[x86_64_v2_ghc-simple-cmd.sha256sum] = "d32bee05544a11721ff59b3ceea4bea29149bf394dd709e6adf0aad4cdea459d"

URI_x86_64_v2_ghc-simple-cmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-simple-cmd-devel-0.2.7-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-simple-cmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-simple-cmd-devel}"
SRC_URI[x86_64_v2_ghc-simple-cmd-devel.sha256sum] = "0223e660ce6a9e6a68b587478dd0895d683dbe95b9521941ae24dd4a3ac72ffe"

URI_x86_64_v2_ghc-simple-cmd-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-simple-cmd-doc-0.2.7-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-simple-cmd-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-simple-cmd-doc}"
SRC_URI[x86_64_v2_ghc-simple-cmd-doc.sha256sum] = "89f02f8852cb27b64f18032e40fa9c48fd8419436e435c5e0b473502ff31b238"

URI_x86_64_v2_ghc-simple-cmd-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-simple-cmd-prof-0.2.7-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-simple-cmd-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-simple-cmd-prof}"
SRC_URI[x86_64_v2_ghc-simple-cmd-prof.sha256sum] = "10fae2711ea713df82efc16da62a2b9fa0312e9f4e4d5577386d68e233c3d734"

URI_aarch64_ghc-simple-cmd = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cmd-0.2.7-7.el10_0.aarch64.rpm;name=aarch64_ghc-simple-cmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cmd}"
SRC_URI[aarch64_ghc-simple-cmd.sha256sum] = "3d01c58f19d7c1da325bf72c9e85d84a942a04de6b51feb452b300e04c2b0578"

URI_aarch64_ghc-simple-cmd-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cmd-devel-0.2.7-7.el10_0.aarch64.rpm;name=aarch64_ghc-simple-cmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cmd-devel}"
SRC_URI[aarch64_ghc-simple-cmd-devel.sha256sum] = "e4be1b31e7db2f9c2d9a9b44c337b248841210cfb06a622480c43e8318106e0c"

URI_aarch64_ghc-simple-cmd-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cmd-doc-0.2.7-7.el10_0.noarch.rpm;name=aarch64_ghc-simple-cmd-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cmd-doc}"
SRC_URI[aarch64_ghc-simple-cmd-doc.sha256sum] = "d5889592e1438421121f0fcf252944b524d20b750e4a5f7dd94d3e07b9267824"

URI_aarch64_ghc-simple-cmd-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cmd-prof-0.2.7-7.el10_0.aarch64.rpm;name=aarch64_ghc-simple-cmd-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cmd-prof}"
SRC_URI[aarch64_ghc-simple-cmd-prof.sha256sum] = "8ea1fff7a7d9d1df7d1074b7444816c726b9cc688d356ea1817a9c7814bd6039"

RDEPENDS:ghc-simple-cmd = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-clock \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-extra \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-simple-cmd-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-extra-devel \
 ghc-filepath-devel \
 ghc-process-devel \
 ghc-simple-cmd \
 ghc-time-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-simple-cmd-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-simple-cmd-prof = " \
 ghc-base-prof \
 ghc-directory-prof \
 ghc-extra-prof \
 ghc-filepath-prof \
 ghc-process-prof \
 ghc-simple-cmd-devel \
 ghc-time-prof \
 ghc-unix-prof \
 "
