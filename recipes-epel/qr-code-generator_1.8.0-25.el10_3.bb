# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qr-code-generator"
PV = "1.8.0"
PR = "25.el10_3"
PACKAGES = " \
 libqrcodegen \
 libqrcodegen-devel \
 libqrcodegencpp \
 libqrcodegencpp-devel \
 python3-qrcodegen \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/q/qr-code-generator-1.8.0-25.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "364f0a404315c2a244ad6902f244ee1d4d5ce430c0deef84aa09b576de0714e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libqrcodegen-1.8.0-25.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libqrcodegen;unpack=0"
SRC_URI[x86_64_v2_libqrcodegen.sha256sum] = "6e69f65fcc49e999721357d57a2a3dba43563a085e0de28a07cc32e7e4cca077"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libqrcodegen-devel-1.8.0-25.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libqrcodegen-devel;unpack=0"
SRC_URI[x86_64_v2_libqrcodegen-devel.sha256sum] = "2e6912fdab875f0a9844d29fa233056ee739f950deffea9072982f77595b52ac"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libqrcodegencpp-1.8.0-25.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libqrcodegencpp;unpack=0"
SRC_URI[x86_64_v2_libqrcodegencpp.sha256sum] = "b8bd814b1dec678297802ff78493d980cd78d41ac34ee4a23b62bb61521883a5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libqrcodegencpp-devel-1.8.0-25.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libqrcodegencpp-devel;unpack=0"
SRC_URI[x86_64_v2_libqrcodegencpp-devel.sha256sum] = "eda57b658b28d853a0b85fba0dd7aa76a6e7690322facf2f4520981e305bbfd7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-qrcodegen-1.8.0-25.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-qrcodegen;unpack=0"
SRC_URI[x86_64_v2_python3-qrcodegen.sha256sum] = "98bbbc4c312f131bd25a072cfeec8ece869374333b47e8f30870e6d4335b2b9d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libqrcodegen-1.8.0-25.el10_3.aarch64.rpm;name=aarch64_libqrcodegen;unpack=0"
SRC_URI[aarch64_libqrcodegen.sha256sum] = "a2a1f9abd26ebc7c5b1144361369cd3d8042bc1ce4e04e6c0a3fb2e1beb54ffd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libqrcodegen-devel-1.8.0-25.el10_3.aarch64.rpm;name=aarch64_libqrcodegen-devel;unpack=0"
SRC_URI[aarch64_libqrcodegen-devel.sha256sum] = "6fab3e408818c9a61f015a8b9dad5dca9b0035283b606204dad946a0e4a9e1ab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libqrcodegencpp-1.8.0-25.el10_3.aarch64.rpm;name=aarch64_libqrcodegencpp;unpack=0"
SRC_URI[aarch64_libqrcodegencpp.sha256sum] = "b8c8659b58b59ced67228e03648c2232600ebe4a20e69138a40bb1ddb669005e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libqrcodegencpp-devel-1.8.0-25.el10_3.aarch64.rpm;name=aarch64_libqrcodegencpp-devel;unpack=0"
SRC_URI[aarch64_libqrcodegencpp-devel.sha256sum] = "c8214530d9f12aee0652ca00f46cbf658d477dd7093564fabf4f94d256edc2ba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-qrcodegen-1.8.0-25.el10_3.noarch.rpm;name=aarch64_python3-qrcodegen;unpack=0"
SRC_URI[aarch64_python3-qrcodegen.sha256sum] = "8943e9697e51740d2325ca8f1692f26c1387587bf92d79a548331df509138d03"

RDEPENDS:libqrcodegen = " \
 glibc \
 "
RDEPENDS:libqrcodegen-devel = " \
 cmake-filesystem \
 libqrcodegen \
 pkgconf-pkg-config \
 "
RDEPENDS:libqrcodegencpp = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libqrcodegencpp-devel = " \
 cmake-filesystem \
 libqrcodegencpp \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-qrcodegen = " \
 python3 \
 "
