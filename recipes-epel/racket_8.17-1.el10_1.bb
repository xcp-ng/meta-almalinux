# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "racket"
PV = "8.17"
PR = "1.el10_1"
PACKAGES = " \
 racket \
 racket-collects \
 racket-devel \
 racket-doc \
 racket-minimal \
 racket-pkgs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/racket-8.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3c7ee383c0d0b97706033f9ebcea12e79e93cd20845e72da281cb431b66abd3a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-8.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_racket;unpack=0"
SRC_URI[x86_64_v2_racket.sha256sum] = "697d387cbd0baddc8ce7de8b02c415cd457c60ac9a0b94c070c89482c25ee1b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-collects-8.17-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_racket-collects;unpack=0"
SRC_URI[x86_64_v2_racket-collects.sha256sum] = "81040a583ba064112a2ea2e5f63777b69a4b6083d659c95481dbb97ce2aba272"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-devel-8.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_racket-devel;unpack=0"
SRC_URI[x86_64_v2_racket-devel.sha256sum] = "6fbfe6c04871283fccd65622c8bb1a432851dffe6a75d2ed010b1443f56a882e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-doc-8.17-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_racket-doc;unpack=0"
SRC_URI[x86_64_v2_racket-doc.sha256sum] = "3406c64a538e6edbe19de9b5b20e1dd1333aeeef2e0fe0d313457fe98a98ebb7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-minimal-8.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_racket-minimal;unpack=0"
SRC_URI[x86_64_v2_racket-minimal.sha256sum] = "58e796816834da6088d9a777ebf269f1f98f5a3a40d6381ca246a0ca6dc52dbd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-pkgs-8.17-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_racket-pkgs;unpack=0"
SRC_URI[x86_64_v2_racket-pkgs.sha256sum] = "50428f123e81336474635587e3dd245cb7a2204e043640ac6e6744044e96845b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/racket-8.17-1.el10_1.aarch64.rpm;name=aarch64_racket;unpack=0"
SRC_URI[aarch64_racket.sha256sum] = "d92edcb5b305bfaaeac91cd64f76c071f2c4c3cc8ef9c36042c1ec5576fab9b0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/racket-collects-8.17-1.el10_1.noarch.rpm;name=aarch64_racket-collects;unpack=0"
SRC_URI[aarch64_racket-collects.sha256sum] = "e22fd98cabdb0eaff96b0128b97fc3d5934632ae2405378edbc75f5328f424c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/racket-devel-8.17-1.el10_1.aarch64.rpm;name=aarch64_racket-devel;unpack=0"
SRC_URI[aarch64_racket-devel.sha256sum] = "cab86f9f023ac36a4ce983acf68c26f342fe9b0f292bcafbe4e1d21682dabe71"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/racket-doc-8.17-1.el10_1.noarch.rpm;name=aarch64_racket-doc;unpack=0"
SRC_URI[aarch64_racket-doc.sha256sum] = "54380bcb2b6377954273ac44d3a5fd59ffb652450f3ff99801b334d3799d4ef4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/racket-minimal-8.17-1.el10_1.aarch64.rpm;name=aarch64_racket-minimal;unpack=0"
SRC_URI[aarch64_racket-minimal.sha256sum] = "b86da89b11a8170c1f5f69633539f343a92490cf3b23f1e386ba3fc977b90b97"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/racket-pkgs-8.17-1.el10_1.noarch.rpm;name=aarch64_racket-pkgs;unpack=0"
SRC_URI[aarch64_racket-pkgs.sha256sum] = "5e3dd8911885935c06bc3db0f84f6c80d60867d10b130fb53262167ab51055d0"

RDEPENDS:racket = " \
 bash \
 glibc \
 racket-minimal \
 racket-pkgs \
 "
RDEPENDS:racket-collects = " \
 "
RDEPENDS:racket-devel = " \
 racket-minimal \
 "
RDEPENDS:racket-doc = " \
 "
RDEPENDS:racket-minimal = " \
 bash \
 glibc \
 libgcc \
 racket-collects \
 "
RDEPENDS:racket-pkgs = " \
 bash \
 cairo \
 glib2 \
 gtk3 \
 libjpeg-turbo \
 libpng \
 pango \
 racket-minimal \
 "
