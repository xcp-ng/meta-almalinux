# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-merge3"
PV = "0.0.15"
PR = "1.el10_0"
PACKAGES = " \
 python3-merge3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-merge3-0.0.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01f3d02b2bfcc881e3a362add9303b67b24e2be0933a6c3ececa5ff9bb2faa40"

URI_x86_64_v2_python3-merge3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-merge3-0.0.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-merge3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-merge3}"
SRC_URI[x86_64_v2_python3-merge3.sha256sum] = "238676df72cc16a960050762bdafcc3298e33c109041d9670c4ced08c56d9871"

URI_aarch64_python3-merge3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-merge3-0.0.15-1.el10_0.noarch.rpm;name=aarch64_python3-merge3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-merge3}"
SRC_URI[aarch64_python3-merge3.sha256sum] = "e063c7af9b424a913758f9f07ffe93bad2a35e185aff60b55fcc39a0ffa15467"

RDEPENDS:python3-merge3 = " \
 python3 \
 "
