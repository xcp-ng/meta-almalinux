# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libopenmpt"
PV = "0.8.7"
PR = "1.el10_3"
PACKAGES = " \
 libopenmpt \
 libopenmpt-devel \
 openmpt123 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libopenmpt-0.8.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ec50f1b505c677bb1932ef128b3356a304e808db631186c986777bafe69e750"

URI_x86_64_v2_libopenmpt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenmpt-0.8.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenmpt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenmpt}"
SRC_URI[x86_64_v2_libopenmpt.sha256sum] = "8069706bebbe1c28588b50b7af41de48e4ba65935ce2a18f4105c9be4b5fee8a"

URI_x86_64_v2_libopenmpt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenmpt-devel-0.8.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenmpt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenmpt-devel}"
SRC_URI[x86_64_v2_libopenmpt-devel.sha256sum] = "7b881319963bcf829a0d9d629abe47c178db054fc5ba66b910cd5ee625604bec"

URI_x86_64_v2_openmpt123 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openmpt123-0.8.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openmpt123;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openmpt123}"
SRC_URI[x86_64_v2_openmpt123.sha256sum] = "c9f18158964b124bb1dd9b26813e9809cef3a2f7fbb796c7931de40a35250cbf"

URI_aarch64_libopenmpt = "${EPEL_MIRROR}/aarch64/Packages/l/libopenmpt-0.8.7-1.el10_3.aarch64.rpm;name=aarch64_libopenmpt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenmpt}"
SRC_URI[aarch64_libopenmpt.sha256sum] = "710f40e4dfe600d6bbaf033bb418abec8f7505dfb65ece45bd54cdb6e382136b"

URI_aarch64_libopenmpt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libopenmpt-devel-0.8.7-1.el10_3.aarch64.rpm;name=aarch64_libopenmpt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenmpt-devel}"
SRC_URI[aarch64_libopenmpt-devel.sha256sum] = "1d96988fc18a02aa294132f2dfdea061ff1f8380a4ff5e9694f00ca783410bdf"

URI_aarch64_openmpt123 = "${EPEL_MIRROR}/aarch64/Packages/o/openmpt123-0.8.7-1.el10_3.aarch64.rpm;name=aarch64_openmpt123;unpack=0"
SRC_URI:append = " ${URI_aarch64_openmpt123}"
SRC_URI[aarch64_openmpt123.sha256sum] = "3e6000f22054c729866fad171df1f09818ce49aa945ff4e7241ba90bffcdbdf9"

RDEPENDS:libopenmpt = " \
 glibc \
 libgcc \
 libogg \
 libstdc++ \
 libvorbis \
 mpg123-libs \
 zlib-ng-compat \
 "
RDEPENDS:libopenmpt-devel = " \
 libogg-devel \
 libopenmpt \
 libvorbis-devel \
 mpg123-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:openmpt123 = " \
 flac-libs \
 glibc \
 libgcc \
 libopenmpt \
 libsndfile \
 libstdc++ \
 pulseaudio-libs \
 "
