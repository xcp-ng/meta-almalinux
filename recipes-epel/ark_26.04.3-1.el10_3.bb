# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ark"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ark \
 ark-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ark-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d9282d9a083831abf1ee288ba97d1b01e09d0a45c60a9cb14d6a8f073008175"

URI_x86_64_v2_ark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ark-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ark}"
SRC_URI[x86_64_v2_ark.sha256sum] = "21bf7a369a64cd2f0f984a1d3c2a8f7b1fb37c3745f71ee3f3617cfccf227bd0"

URI_x86_64_v2_ark-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ark-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ark-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ark-libs}"
SRC_URI[x86_64_v2_ark-libs.sha256sum] = "a6f832c226fdad2e61bdab07bd1d3204d774c80fabe5cdca1f5559dc0f31db2f"

URI_aarch64_ark = "${EPEL_MIRROR}/aarch64/Packages/a/ark-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ark;unpack=0"
SRC_URI:append = " ${URI_aarch64_ark}"
SRC_URI[aarch64_ark.sha256sum] = "755f6b68b0143ff6612d2af86639572e33f9bb30e75f554f99c4b4633a84b414"

URI_aarch64_ark-libs = "${EPEL_MIRROR}/aarch64/Packages/a/ark-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ark-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ark-libs}"
SRC_URI[aarch64_ark-libs.sha256sum] = "116ef0ab11dfe3cdb2575973722f781c6857572d8ea2ad799817814f3b0092cd"

RDEPENDS:ark = " \
 ark-libs \
 bzip2 \
 glibc \
 gzip \
 kf6-breeze-icons \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 unzip \
 "
RDEPENDS:ark-libs = " \
 ark \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kpty \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libarchive \
 libgcc \
 libstdc++ \
 libzip \
 qt6-qtbase \
 qt6-qtbase-gui \
 zlib-ng-compat \
 "
