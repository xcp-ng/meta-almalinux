# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluechi"
PV = "1.3.0"
PR = "1.el10_2"
PACKAGES = " \
 bluechi-agent \
 bluechi-controller \
 bluechi-ctl \
 bluechi-is-online \
 bluechi-selinux \
 python3-bluechi \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/bluechi-1.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c0c4906a9ef4370c9ac600351d9042bc5803baf2827b6de4a233bc12a4c5f495"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-agent-1.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-agent;unpack=0"
SRC_URI[x86_64_v2_bluechi-agent.sha256sum] = "695a15283daf7a7bbfb05cca131542c945142494557de216539742f568c56cc2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-controller-1.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-controller;unpack=0"
SRC_URI[x86_64_v2_bluechi-controller.sha256sum] = "9f475a2256f2fdcda62501389376fb39c4da3daad94e4569c569f4036fd318d3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-ctl-1.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-ctl;unpack=0"
SRC_URI[x86_64_v2_bluechi-ctl.sha256sum] = "c5481c4c134d7050796d2d7abbdd4b091af8f53dc9680b2901cc517ef5c95631"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-is-online-1.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-is-online;unpack=0"
SRC_URI[x86_64_v2_bluechi-is-online.sha256sum] = "056f22b72407efba5f83b3d5e70d73a895f84aafac4db72ecbd694180437c42c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-selinux-1.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_bluechi-selinux;unpack=0"
SRC_URI[x86_64_v2_bluechi-selinux.sha256sum] = "e0276357155a23cc5825edab3b1ce0fa22d184ce9ea93f3006c7ee0a763b01fc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bluechi-1.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-bluechi;unpack=0"
SRC_URI[x86_64_v2_python3-bluechi.sha256sum] = "917198f0ced86062a2030b4f53ff95c83a662b7c82edd1e2e7568901f586f8ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bluechi-agent-1.3.0-1.el10_2.aarch64.rpm;name=aarch64_bluechi-agent;unpack=0"
SRC_URI[aarch64_bluechi-agent.sha256sum] = "a495ad47a188bb31ed53fd253139c202f5174162fecf773e1263596e0fba82e8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bluechi-controller-1.3.0-1.el10_2.aarch64.rpm;name=aarch64_bluechi-controller;unpack=0"
SRC_URI[aarch64_bluechi-controller.sha256sum] = "3d67d2f23600baea4e5944f283846b00795a8cbc7d9da9438cc41ecddc470391"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bluechi-ctl-1.3.0-1.el10_2.aarch64.rpm;name=aarch64_bluechi-ctl;unpack=0"
SRC_URI[aarch64_bluechi-ctl.sha256sum] = "e7f23b2ad44e9734d0fde0fc224b7b819b070aec5d615f8c5716c7ad35e41971"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bluechi-is-online-1.3.0-1.el10_2.aarch64.rpm;name=aarch64_bluechi-is-online;unpack=0"
SRC_URI[aarch64_bluechi-is-online.sha256sum] = "d7356b9ea5787905d8aa29e5c8d89911b5ec2e3bbdba91c50468a787d2cfbd06"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bluechi-selinux-1.3.0-1.el10_2.noarch.rpm;name=aarch64_bluechi-selinux;unpack=0"
SRC_URI[aarch64_bluechi-selinux.sha256sum] = "37b9ed297293f4f09af34cbd39254ba7f4cc551b8351db901063c0b67d210ed5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-bluechi-1.3.0-1.el10_2.noarch.rpm;name=aarch64_python3-bluechi;unpack=0"
SRC_URI[aarch64_python3-bluechi.sha256sum] = "f614b01e3929b404268541b9ef88f1c586a97f2f35d48ce711c2cf72bb94fac4"

RDEPENDS:bluechi-agent = " \
 bash \
 glibc \
 libgcc \
 systemd \
 systemd-libs \
 "
RDEPENDS:bluechi-controller = " \
 bash \
 glibc \
 libgcc \
 libselinux \
 systemd \
 systemd-libs \
 "
RDEPENDS:bluechi-ctl = " \
 bluechi-controller \
 glibc \
 libgcc \
 systemd-libs \
 "
RDEPENDS:bluechi-is-online = " \
 glibc \
 libgcc \
 systemd-libs \
 "
RDEPENDS:bluechi-selinux = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/selinux-policy-any_ge_42.1.18 \
 "
RDEPENDS:python3-bluechi = " \
 python3 \
 python3-dasbus \
 "
