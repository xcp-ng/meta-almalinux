# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cookie_store"
PV = "0.22.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-cookie_store+default-devel \
 rust-cookie_store+log_secure_cookie_values-devel \
 rust-cookie_store+preserve_order-devel \
 rust-cookie_store+public_suffix-devel \
 rust-cookie_store+serde-devel \
 rust-cookie_store+serde_json-devel \
 rust-cookie_store-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cookie_store-0.22.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9405210c1f8d7f365054c1731761142b6c82b423552d64960bd418c07ceefebd"

URI_x86_64_v2_rust-cookie_store+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+default-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+default-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+default-devel.sha256sum] = "0ac25bc7ff0333ecc2ea10d33b00cf8feb898450c4391d03cf9dc85d3eeae696"

URI_x86_64_v2_rust-cookie_store+log_secure_cookie_values-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+log_secure_cookie_values-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+log_secure_cookie_values-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+log_secure_cookie_values-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+log_secure_cookie_values-devel.sha256sum] = "0f83e453bd8735ff208a189a8c2792041e13f8adee005813c76ce8505f81b446"

URI_x86_64_v2_rust-cookie_store+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+preserve_order-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+preserve_order-devel.sha256sum] = "dc23ef3ce30b776eb94749fa9f0e4912a42ddb53b617a7804ca8fffa78cbcdb0"

URI_x86_64_v2_rust-cookie_store+public_suffix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+public_suffix-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+public_suffix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+public_suffix-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+public_suffix-devel.sha256sum] = "42fab96bce2fcd04abb2b93d32f08e48882761bfb6bbec57dcf130bee48d0079"

URI_x86_64_v2_rust-cookie_store+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+serde-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+serde-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+serde-devel.sha256sum] = "74d2dad113a5616decfd8be241db5966faabc9723569a22b6d4b7e4f5f071ba7"

URI_x86_64_v2_rust-cookie_store+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+serde_json-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+serde_json-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+serde_json-devel.sha256sum] = "4240ca26bbebbdf35f4daf8cf1f8a4d01f2dc135d399775eeac4bc9305475d1a"

URI_x86_64_v2_rust-cookie_store-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store-devel}"
SRC_URI[x86_64_v2_rust-cookie_store-devel.sha256sum] = "d39dc3ee385137ba7250c73dd2d1f64171546377e4f1058004ef9d5a0265a76e"

URI_aarch64_rust-cookie_store+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+default-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-cookie_store+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+default-devel}"
SRC_URI[aarch64_rust-cookie_store+default-devel.sha256sum] = "9f835dc31bcbe0daa37f76b45bc9b6256a1cdde1f5c49aea55097e1f80bc51d4"

URI_aarch64_rust-cookie_store+log_secure_cookie_values-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+log_secure_cookie_values-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-cookie_store+log_secure_cookie_values-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+log_secure_cookie_values-devel}"
SRC_URI[aarch64_rust-cookie_store+log_secure_cookie_values-devel.sha256sum] = "72724da61fb1810f78430503a4ce5923d4d74211f8f5a3ffbd03b4b74a7618f2"

URI_aarch64_rust-cookie_store+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+preserve_order-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-cookie_store+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+preserve_order-devel}"
SRC_URI[aarch64_rust-cookie_store+preserve_order-devel.sha256sum] = "224af351e760067c2b89391099197c28fe54dcc93762d025e4d44f525d437e32"

URI_aarch64_rust-cookie_store+public_suffix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+public_suffix-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-cookie_store+public_suffix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+public_suffix-devel}"
SRC_URI[aarch64_rust-cookie_store+public_suffix-devel.sha256sum] = "41b605d562b038b4499b7784c150c5092c790714d049d7b6fe19664d393ec828"

URI_aarch64_rust-cookie_store+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+serde-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-cookie_store+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+serde-devel}"
SRC_URI[aarch64_rust-cookie_store+serde-devel.sha256sum] = "fab1cbb7cb72e88afe44c020d72d6927ac500d7ae9d488d4bdaec34c44d08655"

URI_aarch64_rust-cookie_store+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+serde_json-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-cookie_store+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+serde_json-devel}"
SRC_URI[aarch64_rust-cookie_store+serde_json-devel.sha256sum] = "0daadf32fb4b96f99cdd8eb6c08f8d6870e352b090dea4aef5c777b2d14445b7"

URI_aarch64_rust-cookie_store-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-cookie_store-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store-devel}"
SRC_URI[aarch64_rust-cookie_store-devel.sha256sum] = "92dda3897127982346f6136480997af65bdb5a8a1605a6ec2c9ee4927c4b6379"

RDEPENDS:rust-cookie_store+default-devel = " \
 cargo \
 rust-cookie_store+public_suffix-devel \
 rust-cookie_store+serde_json-devel \
 rust-cookie_store-devel \
 "
RDEPENDS:rust-cookie_store+log_secure_cookie_values-devel = " \
 cargo \
 rust-cookie_store-devel \
 "
RDEPENDS:rust-cookie_store+preserve_order-devel = " \
 cargo \
 rust-cookie_store-devel \
 rust-indexmap+default-devel \
 "
RDEPENDS:rust-cookie_store+public_suffix-devel = " \
 cargo \
 rust-cookie_store-devel \
 rust-publicsuffix+default-devel \
 "
RDEPENDS:rust-cookie_store+serde-devel = " \
 cargo \
 rust-cookie_store-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-cookie_store+serde_json-devel = " \
 cargo \
 rust-cookie_store+serde-devel \
 rust-cookie_store-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-cookie_store-devel = " \
 bash \
 cargo \
 rust \
 rust-cookie+default-devel \
 rust-cookie+percent-encode-devel \
 rust-document-features+default-devel \
 rust-idna+default-devel \
 rust-log+default-devel \
 rust-time+default-devel \
 rust-url+default-devel \
 "
