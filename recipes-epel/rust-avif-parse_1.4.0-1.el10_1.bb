# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-avif-parse"
PV = "1.4.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-avif-parse+default-devel \
 rust-avif-parse+mp4parse_fallible-devel \
 rust-avif-parse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-avif-parse-1.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14b93c8ebd43fa9e1f726213553a5a25bd0c3e0d64f6212f68748db236be6717"

URI_x86_64_v2_rust-avif-parse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-avif-parse+default-devel-1.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-avif-parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-avif-parse+default-devel}"
SRC_URI[x86_64_v2_rust-avif-parse+default-devel.sha256sum] = "7d4ac187046d17f70cc429fefb2b0da38de4f4d842a34978af60577c00cfa50b"

URI_x86_64_v2_rust-avif-parse+mp4parse_fallible-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-avif-parse+mp4parse_fallible-devel-1.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-avif-parse+mp4parse_fallible-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-avif-parse+mp4parse_fallible-devel}"
SRC_URI[x86_64_v2_rust-avif-parse+mp4parse_fallible-devel.sha256sum] = "257cd4e65edf31b742074a684c2d379d0119de60e8418abd158fcaad923a739c"

URI_x86_64_v2_rust-avif-parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-avif-parse-devel-1.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-avif-parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-avif-parse-devel}"
SRC_URI[x86_64_v2_rust-avif-parse-devel.sha256sum] = "0c70bfd30965f3c0778ee02d3dc32414daf2202a449fd20303e7808db905bb54"

URI_aarch64_rust-avif-parse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-avif-parse+default-devel-1.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-avif-parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-avif-parse+default-devel}"
SRC_URI[aarch64_rust-avif-parse+default-devel.sha256sum] = "5ca3f75fe8182892a454d31cf200362a07c1644177e156563c458131b679139f"

URI_aarch64_rust-avif-parse+mp4parse_fallible-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-avif-parse+mp4parse_fallible-devel-1.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-avif-parse+mp4parse_fallible-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-avif-parse+mp4parse_fallible-devel}"
SRC_URI[aarch64_rust-avif-parse+mp4parse_fallible-devel.sha256sum] = "cdd5fbf88ae4348362ada7b263c0f8e944f21cc8cb3a784ee900026ea53480dd"

URI_aarch64_rust-avif-parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-avif-parse-devel-1.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-avif-parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-avif-parse-devel}"
SRC_URI[aarch64_rust-avif-parse-devel.sha256sum] = "e1ae1a5c599af94ba313cdc836d30abbe01d00c8e6fac0f6cfffc48e19dc73c3"

RDEPENDS:rust-avif-parse+default-devel = " \
 cargo \
 rust-avif-parse-devel \
 "
RDEPENDS:rust-avif-parse+mp4parse_fallible-devel = " \
 cargo \
 rust-avif-parse-devel \
 "
RDEPENDS:rust-avif-parse-devel = " \
 cargo \
 rust \
 rust-arrayvec+default-devel \
 rust-bitreader+default-devel \
 rust-byteorder+default-devel \
 rust-fallible_collections+std-devel \
 rust-fallible_collections-devel \
 rust-leb128+default-devel \
 rust-log+default-devel \
 "
