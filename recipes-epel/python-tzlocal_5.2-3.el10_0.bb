# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tzlocal"
PV = "5.2"
PR = "3.el10_0"
PACKAGES = " \
 python3-tzlocal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tzlocal-5.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97263fc268da1d9f5bcb117a90b08e0fa337bccf5c93b45763c50440653e0eb6"

URI_x86_64_v2_python3-tzlocal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tzlocal-5.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tzlocal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tzlocal}"
SRC_URI[x86_64_v2_python3-tzlocal.sha256sum] = "0ce7089ab7ed7d079a252bde69c40f2bd03c6c3109d022b63f20d854f3f42cc5"

URI_aarch64_python3-tzlocal = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tzlocal-5.2-3.el10_0.noarch.rpm;name=aarch64_python3-tzlocal;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tzlocal}"
SRC_URI[aarch64_python3-tzlocal.sha256sum] = "c79087ed04b648f424b74c0ec9a20338f6e8073f7cd99a1e6660321fcc9ac122"

RDEPENDS:python3-tzlocal = " \
 python3 \
 "
