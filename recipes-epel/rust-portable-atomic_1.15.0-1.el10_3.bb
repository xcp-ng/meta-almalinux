# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-portable-atomic"
PV = "1.15.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-portable-atomic+critical-section-devel \
 rust-portable-atomic+default-devel \
 rust-portable-atomic+disable-fiq-devel \
 rust-portable-atomic+fallback-devel \
 rust-portable-atomic+float-devel \
 rust-portable-atomic+force-amo-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic+s-mode-devel \
 rust-portable-atomic+serde-devel \
 rust-portable-atomic+std-devel \
 rust-portable-atomic+unsafe-assume-privileged-devel \
 rust-portable-atomic+unsafe-assume-single-core-devel \
 rust-portable-atomic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-portable-atomic-1.15.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09a71e6c65588eb1fe8dca9d738a99d0803bee07208391d0ad675d8e1527e500"

URI_x86_64_v2_rust-portable-atomic+critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+critical-section-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+critical-section-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+critical-section-devel.sha256sum] = "c128b0c39515c93722107074b76c7548be707c3650740edd69a9e0dddde4fee9"

URI_x86_64_v2_rust-portable-atomic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+default-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+default-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+default-devel.sha256sum] = "b11c710aa77522ed9c85c297df6bb5484ccebfb389af6f87c15d42b065013265"

URI_x86_64_v2_rust-portable-atomic+disable-fiq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+disable-fiq-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+disable-fiq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+disable-fiq-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+disable-fiq-devel.sha256sum] = "bd097cda95edfea3cf39eb24458bec1dea2883dbea77da551d100c8d452946d0"

URI_x86_64_v2_rust-portable-atomic+fallback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+fallback-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+fallback-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+fallback-devel.sha256sum] = "dd9857d4180aadf6220332f33587d426b63af665356588467ae384c00fb875cf"

URI_x86_64_v2_rust-portable-atomic+float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+float-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+float-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+float-devel.sha256sum] = "0ef2815f9e45d3b27c84cecab27e84b8c3afbc2d3349e1d72e68c04ffb8fdbd5"

URI_x86_64_v2_rust-portable-atomic+force-amo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+force-amo-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+force-amo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+force-amo-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+force-amo-devel.sha256sum] = "3c2583614a5a89b4b8fa7740c7b0171565b5424a0a70a22eac32d7fefc712665"

URI_x86_64_v2_rust-portable-atomic+require-cas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+require-cas-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+require-cas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+require-cas-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+require-cas-devel.sha256sum] = "c8b1629f77a42b9a03138cf09c0b3997e368bef16a332c9a86cc1f36ce6a2c58"

URI_x86_64_v2_rust-portable-atomic+s-mode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+s-mode-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+s-mode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+s-mode-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+s-mode-devel.sha256sum] = "e1311481ab4a160821bd37676d086d1c19c26d36eb659853745b192ec25fcf03"

URI_x86_64_v2_rust-portable-atomic+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+serde-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+serde-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+serde-devel.sha256sum] = "14d8c029575b5ea96af779b152f5a085c3b301d3c43ad7e70543d5680b03b6ab"

URI_x86_64_v2_rust-portable-atomic+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+std-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+std-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+std-devel.sha256sum] = "9686f164eab297fca6eea05325f248ef810d691eae623716f078c625ca28137c"

URI_x86_64_v2_rust-portable-atomic+unsafe-assume-privileged-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+unsafe-assume-privileged-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+unsafe-assume-privileged-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+unsafe-assume-privileged-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+unsafe-assume-privileged-devel.sha256sum] = "8702271e4b602b4a8a2c3aa008a2c0ab7b26d44c9cd5280d9f560b4c5517a21c"

URI_x86_64_v2_rust-portable-atomic+unsafe-assume-single-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+unsafe-assume-single-core-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+unsafe-assume-single-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+unsafe-assume-single-core-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+unsafe-assume-single-core-devel.sha256sum] = "2f7811c5b46840f7dbc5160ffd399d578a0167886717d351e8339704548cdea6"

URI_x86_64_v2_rust-portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-devel.sha256sum] = "d3ae0b6f6848e55bbc82ece551a1b516e0d78ee9461649465c1b513c2168e321"

URI_aarch64_rust-portable-atomic+critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+critical-section-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+critical-section-devel}"
SRC_URI[aarch64_rust-portable-atomic+critical-section-devel.sha256sum] = "ac0a3cbd9c531eb1ed4ca4f5f2ff6c518974d858e07d87ff374dc4653b078293"

URI_aarch64_rust-portable-atomic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+default-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+default-devel}"
SRC_URI[aarch64_rust-portable-atomic+default-devel.sha256sum] = "7b7fd9ec92b758c45b9845d54d6d4382ae0c6b27d9fbb43d69c3effd1a2f9a52"

URI_aarch64_rust-portable-atomic+disable-fiq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+disable-fiq-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic+disable-fiq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+disable-fiq-devel}"
SRC_URI[aarch64_rust-portable-atomic+disable-fiq-devel.sha256sum] = "28bee2a6d4c780e324bdfa77ef6a0c1e2241f3009b05ed3e7bb9a3ce133563f2"

URI_aarch64_rust-portable-atomic+fallback-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+fallback-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+fallback-devel}"
SRC_URI[aarch64_rust-portable-atomic+fallback-devel.sha256sum] = "12147d4391b4def8faf61ef350df6724124f626be0d94c5547a53c979ccad142"

URI_aarch64_rust-portable-atomic+float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+float-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic+float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+float-devel}"
SRC_URI[aarch64_rust-portable-atomic+float-devel.sha256sum] = "e7598a273fc4bea2a60933f568c59cf29fbb2dbb7a84f7f457fa799cdea14b66"

URI_aarch64_rust-portable-atomic+force-amo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+force-amo-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic+force-amo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+force-amo-devel}"
SRC_URI[aarch64_rust-portable-atomic+force-amo-devel.sha256sum] = "b797b21f93b6e6eb86acf567c7951fc1d69d6c611fc50a476f5b3e170ae715d4"

URI_aarch64_rust-portable-atomic+require-cas-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+require-cas-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic+require-cas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+require-cas-devel}"
SRC_URI[aarch64_rust-portable-atomic+require-cas-devel.sha256sum] = "de22f2d41ca2fdf5a9f64caa3636f0531f669608848bb393f8e767e8773cd7c6"

URI_aarch64_rust-portable-atomic+s-mode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+s-mode-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic+s-mode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+s-mode-devel}"
SRC_URI[aarch64_rust-portable-atomic+s-mode-devel.sha256sum] = "fd4157fdeea82c82e60a59deaa64f68265e8a231384071688a2f91c518635d02"

URI_aarch64_rust-portable-atomic+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+serde-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+serde-devel}"
SRC_URI[aarch64_rust-portable-atomic+serde-devel.sha256sum] = "ed0b3b3493fc15979bd356f172a4067d09748108b9fb9ad3a405045f90b87c28"

URI_aarch64_rust-portable-atomic+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+std-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+std-devel}"
SRC_URI[aarch64_rust-portable-atomic+std-devel.sha256sum] = "bb9deff5a0f27d521434eba52a5b755b7c820b74e0507b8337fdf49fa1d0c705"

URI_aarch64_rust-portable-atomic+unsafe-assume-privileged-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+unsafe-assume-privileged-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic+unsafe-assume-privileged-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+unsafe-assume-privileged-devel}"
SRC_URI[aarch64_rust-portable-atomic+unsafe-assume-privileged-devel.sha256sum] = "7f08305668805941869b0cceacbe0a6d05d6b3d1796e4d5eb02ef4363f10da80"

URI_aarch64_rust-portable-atomic+unsafe-assume-single-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+unsafe-assume-single-core-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic+unsafe-assume-single-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+unsafe-assume-single-core-devel}"
SRC_URI[aarch64_rust-portable-atomic+unsafe-assume-single-core-devel.sha256sum] = "b379bb315384659d817284f1c7b760fba65a078a504ee151718b16b35ac38242"

URI_aarch64_rust-portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-devel}"
SRC_URI[aarch64_rust-portable-atomic-devel.sha256sum] = "ab7f7efd1e74e0f3151951eb08986eff2adbf5c5aff730ef77b2fae85ff3eb50"

RDEPENDS:rust-portable-atomic+critical-section-devel = " \
 cargo \
 rust-critical-section+default-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+default-devel = " \
 cargo \
 rust-portable-atomic+fallback-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+disable-fiq-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+fallback-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+float-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+force-amo-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+require-cas-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+s-mode-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+serde-devel = " \
 cargo \
 rust-portable-atomic-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-portable-atomic+std-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+unsafe-assume-privileged-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+unsafe-assume-single-core-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic-devel = " \
 cargo \
 rust \
 "
