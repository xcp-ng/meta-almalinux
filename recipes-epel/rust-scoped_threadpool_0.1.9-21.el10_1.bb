# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scoped_threadpool"
PV = "0.1.9"
PR = "21.el10_1"
PACKAGES = " \
 rust-scoped_threadpool+default-devel \
 rust-scoped_threadpool+nightly-devel \
 rust-scoped_threadpool-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scoped_threadpool-0.1.9-21.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f392440895ed7e276b493f4e837593ce42bfbad70116fa203c79074daea6de7f"

URI_x86_64_v2_rust-scoped_threadpool+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scoped_threadpool+default-devel-0.1.9-21.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scoped_threadpool+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scoped_threadpool+default-devel}"
SRC_URI[x86_64_v2_rust-scoped_threadpool+default-devel.sha256sum] = "b24d19c3829290179a48e64272a65f9a5b2a47b013abc76f20ba242d2417976b"

URI_x86_64_v2_rust-scoped_threadpool+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scoped_threadpool+nightly-devel-0.1.9-21.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scoped_threadpool+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scoped_threadpool+nightly-devel}"
SRC_URI[x86_64_v2_rust-scoped_threadpool+nightly-devel.sha256sum] = "ce08006530d7ed5e0ed933e1b245403c1906c664a46a23be8ff736f32b289338"

URI_x86_64_v2_rust-scoped_threadpool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scoped_threadpool-devel-0.1.9-21.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scoped_threadpool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scoped_threadpool-devel}"
SRC_URI[x86_64_v2_rust-scoped_threadpool-devel.sha256sum] = "c91c2859fa50da8f613039a92cecbf820d8ea7ddc3c280d94245f2f8c36e8719"

URI_aarch64_rust-scoped_threadpool+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scoped_threadpool+default-devel-0.1.9-21.el10_1.noarch.rpm;name=aarch64_rust-scoped_threadpool+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scoped_threadpool+default-devel}"
SRC_URI[aarch64_rust-scoped_threadpool+default-devel.sha256sum] = "f657f967e0d0e3633d6d1caf238af2e4121744d754916b75b5fda56a2f9fb585"

URI_aarch64_rust-scoped_threadpool+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scoped_threadpool+nightly-devel-0.1.9-21.el10_1.noarch.rpm;name=aarch64_rust-scoped_threadpool+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scoped_threadpool+nightly-devel}"
SRC_URI[aarch64_rust-scoped_threadpool+nightly-devel.sha256sum] = "88968eba8b379900003acfa89885d8da20f55f2f09652ba462be67a910dad61b"

URI_aarch64_rust-scoped_threadpool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scoped_threadpool-devel-0.1.9-21.el10_1.noarch.rpm;name=aarch64_rust-scoped_threadpool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scoped_threadpool-devel}"
SRC_URI[aarch64_rust-scoped_threadpool-devel.sha256sum] = "6c2257fb771f00bf931d41e93c165269a5ba62ad402ded74e92e44568a5693f2"

RDEPENDS:rust-scoped_threadpool+default-devel = " \
 cargo \
 rust-scoped_threadpool-devel \
 "
RDEPENDS:rust-scoped_threadpool+nightly-devel = " \
 cargo \
 rust-scoped_threadpool-devel \
 "
RDEPENDS:rust-scoped_threadpool-devel = " \
 cargo \
 "
