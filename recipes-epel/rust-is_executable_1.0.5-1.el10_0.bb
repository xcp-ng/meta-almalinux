# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-is_executable"
PV = "1.0.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-is_executable+default-devel \
 rust-is_executable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-is_executable-1.0.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eeeb4e11b163c91f3e33e3e90dd30fd098db8cdbac9f43b9401adfe0d64d17f4"

URI_x86_64_v2_rust-is_executable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is_executable+default-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is_executable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is_executable+default-devel}"
SRC_URI[x86_64_v2_rust-is_executable+default-devel.sha256sum] = "bfdeca2820eeb066c81ad24578dface1971540422867babee30d4af8a464ee4c"

URI_x86_64_v2_rust-is_executable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is_executable-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is_executable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is_executable-devel}"
SRC_URI[x86_64_v2_rust-is_executable-devel.sha256sum] = "7e3998e4f2ce822ac39a0abf8cb77e9b6021a220c8a98fdd9953452946990797"

URI_aarch64_rust-is_executable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is_executable+default-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-is_executable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is_executable+default-devel}"
SRC_URI[aarch64_rust-is_executable+default-devel.sha256sum] = "f9c2afe3ec71d1cb669a58fb9d357df15dcc798db38472fad8dceccdb07633cd"

URI_aarch64_rust-is_executable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is_executable-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-is_executable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is_executable-devel}"
SRC_URI[aarch64_rust-is_executable-devel.sha256sum] = "76b4f1c6ef64347f3b24dcd8d00d2606340048c82912c727fdfb81aaa1b9c086"

RDEPENDS:rust-is_executable+default-devel = " \
 cargo \
 rust-is_executable-devel \
 "
RDEPENDS:rust-is_executable-devel = " \
 cargo \
 "
