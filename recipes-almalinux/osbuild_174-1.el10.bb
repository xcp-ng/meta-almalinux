# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osbuild"
PV = "174"
PR = "1.el10"
PACKAGES = " \
 osbuild \
 osbuild-container-selinux \
 osbuild-depsolve-dnf \
 osbuild-initrd \
 osbuild-luks2 \
 osbuild-lvm2 \
 osbuild-ostree \
 osbuild-selinux \
 python3-osbuild \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/osbuild-174-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7a22d02906fe2c486a1ac93dbe914fe847044489ff1f2e78399fcc0fca37dc6"

URI_x86_64_v2_osbuild = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-174-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild}"
SRC_URI[x86_64_v2_osbuild.sha256sum] = "c8dfd96eeb734fd86a742aac4f3e8b0b7ed6a7db8f2d739390c5aa49373dfbce"

URI_x86_64_v2_osbuild-container-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-container-selinux-174-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-container-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-container-selinux}"
SRC_URI[x86_64_v2_osbuild-container-selinux.sha256sum] = "04fc0f199bd4498acb92aa1fb6c1857177da4ce3190ca6421478d69577ea2f2c"

URI_x86_64_v2_osbuild-depsolve-dnf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-depsolve-dnf-174-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-depsolve-dnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-depsolve-dnf}"
SRC_URI[x86_64_v2_osbuild-depsolve-dnf.sha256sum] = "aad74e1d0073556756b9148e9683f6f1a5cf03dd0de39e543bdd3ac04a39095e"

URI_x86_64_v2_osbuild-initrd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-initrd-174-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-initrd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-initrd}"
SRC_URI[x86_64_v2_osbuild-initrd.sha256sum] = "60c694ff3bff82b21903b00caec247f935ff7b4d9e036500287d192d3aa92786"

URI_x86_64_v2_osbuild-luks2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-luks2-174-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-luks2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-luks2}"
SRC_URI[x86_64_v2_osbuild-luks2.sha256sum] = "b5a2a02de3def070fa6665aeb10fd2e6c4bc233a009e53a0ad5ff3dd95bf93a2"

URI_x86_64_v2_osbuild-lvm2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-lvm2-174-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-lvm2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-lvm2}"
SRC_URI[x86_64_v2_osbuild-lvm2.sha256sum] = "c29912c949254b6fc9857754cd82ebd6d53964bf7b72e5d3fbcb5e3eb00470b1"

URI_x86_64_v2_osbuild-ostree = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-ostree-174-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-ostree}"
SRC_URI[x86_64_v2_osbuild-ostree.sha256sum] = "5a85349aab224b1172336c06e3535f2b27fceaab7f173ce58a028ad96a0ca48b"

URI_x86_64_v2_osbuild-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-selinux-174-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-selinux}"
SRC_URI[x86_64_v2_osbuild-selinux.sha256sum] = "ba383059d30bb185cc1d4c27dd9d88aaf06accf01c476a0ad18fd8dc49599d1f"

URI_x86_64_v2_python3-osbuild = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-osbuild-174-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-osbuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-osbuild}"
SRC_URI[x86_64_v2_python3-osbuild.sha256sum] = "bfaec17d254e5311447b502681ad4873588067e10fbf59f7d6984d5213e98b79"

URI_aarch64_osbuild = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-174-1.el10.aarch64.rpm;name=aarch64_osbuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild}"
SRC_URI[aarch64_osbuild.sha256sum] = "e1906661f6c2772bf3078f3857d81b612f233f9b05c2f08e3c79984227b546c8"

URI_aarch64_osbuild-container-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-container-selinux-174-1.el10.aarch64.rpm;name=aarch64_osbuild-container-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-container-selinux}"
SRC_URI[aarch64_osbuild-container-selinux.sha256sum] = "109ad58ae193e40fe1612ef92a0297a948e02dee900a57b4b44e216fdd59dda7"

URI_aarch64_osbuild-depsolve-dnf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-depsolve-dnf-174-1.el10.aarch64.rpm;name=aarch64_osbuild-depsolve-dnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-depsolve-dnf}"
SRC_URI[aarch64_osbuild-depsolve-dnf.sha256sum] = "0b8d55a69160c945498a1bbf0abf2b6130a0123e7d68ea109f12c5628ed3b1f1"

URI_aarch64_osbuild-initrd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-initrd-174-1.el10.aarch64.rpm;name=aarch64_osbuild-initrd;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-initrd}"
SRC_URI[aarch64_osbuild-initrd.sha256sum] = "45a882e64457ccf900b974d68b79f53750ce98213af1c9c661e5c9329dab162e"

URI_aarch64_osbuild-luks2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-luks2-174-1.el10.aarch64.rpm;name=aarch64_osbuild-luks2;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-luks2}"
SRC_URI[aarch64_osbuild-luks2.sha256sum] = "1aac00422e80315b3d64fa2387a804e18e0629a104e6e3020302d47d19f2f1be"

URI_aarch64_osbuild-lvm2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-lvm2-174-1.el10.aarch64.rpm;name=aarch64_osbuild-lvm2;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-lvm2}"
SRC_URI[aarch64_osbuild-lvm2.sha256sum] = "efdc203b50b69206dcfe66874cf83934167909dd8df4eb1b2d33988cc79dc183"

URI_aarch64_osbuild-ostree = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-ostree-174-1.el10.aarch64.rpm;name=aarch64_osbuild-ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-ostree}"
SRC_URI[aarch64_osbuild-ostree.sha256sum] = "7a56a1e8225099ba14c593310838536162e61f68589ad9353ce0614d35abdfdd"

URI_aarch64_osbuild-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-selinux-174-1.el10.aarch64.rpm;name=aarch64_osbuild-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-selinux}"
SRC_URI[aarch64_osbuild-selinux.sha256sum] = "2faac99bef3b9394bdfd4cae79cd2c8a8c57054e71896a8feb4f57070dc3fa38"

URI_aarch64_python3-osbuild = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-osbuild-174-1.el10.aarch64.rpm;name=aarch64_python3-osbuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-osbuild}"
SRC_URI[aarch64_python3-osbuild.sha256sum] = "362b7c097da96b8871c602921bf6e5635863863c01ec20e145ae682ab50bfbf6"

RDEPENDS:osbuild = " \
 bash \
 bubblewrap \
 curl \
 e2fsprogs \
 glibc \
 osbuild-initrd \
 osbuild-selinux \
 policycoreutils \
 python3 \
 python3-librepo \
 python3-osbuild \
 qemu-img \
 skopeo \
 systemd \
 tar \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:osbuild-container-selinux = " \
 bash \
 container-selinux \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:osbuild-depsolve-dnf = " \
 osbuild \
 python3 \
 python3-dnf \
 "
RDEPENDS:osbuild-initrd = " \
 "
RDEPENDS:osbuild-luks2 = " \
 cryptsetup \
 osbuild \
 python3 \
 "
RDEPENDS:osbuild-lvm2 = " \
 lvm2 \
 osbuild \
 python3 \
 "
RDEPENDS:osbuild-ostree = " \
 osbuild \
 ostree \
 python3 \
 rpm-ostree \
 "
RDEPENDS:osbuild-selinux = " \
 bash \
 libselinux-utils \
 osbuild \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:python3-osbuild = " \
 python3 \
 python3-jsonschema \
 "
