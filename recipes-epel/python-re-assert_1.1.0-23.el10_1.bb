# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-re-assert"
PV = "1.1.0"
PR = "23.el10_1"
PACKAGES = " \
 python3-re-assert \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-re-assert-1.1.0-23.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bc64bddcc351130ab9ef64c36554bc5e2b9831b393005a3cc18fddc2530406e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-re-assert-1.1.0-23.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-re-assert;unpack=0"
SRC_URI[x86_64_v2_python3-re-assert.sha256sum] = "6497c805bf282ed35f6dad246c8dc7fd1aaadec11cd58f558780fe771d8610cc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-re-assert-1.1.0-23.el10_1.noarch.rpm;name=aarch64_python3-re-assert;unpack=0"
SRC_URI[aarch64_python3-re-assert.sha256sum] = "f13f9ae44b318bfabe909244ce5168b58571e311487a7b233ec8a0fbee405a26"

RDEPENDS:python3-re-assert = " \
 python3 \
 python3-regex \
 "
