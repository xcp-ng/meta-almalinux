# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-streaming-iterator"
PV = "0.1.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-streaming-iterator+alloc-devel \
 rust-streaming-iterator+default-devel \
 rust-streaming-iterator+std-devel \
 rust-streaming-iterator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-streaming-iterator-0.1.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14a997997cfebbeb0b60bed1f5327d69cbd63f258927b5c5dac6f3efba90fed8"

URI_x86_64_v2_rust-streaming-iterator+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streaming-iterator+alloc-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streaming-iterator+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streaming-iterator+alloc-devel}"
SRC_URI[x86_64_v2_rust-streaming-iterator+alloc-devel.sha256sum] = "ced2ac5600bcd8385839b709c3c0f773bb54c9a28c9151435086b785d0ebdfa6"

URI_x86_64_v2_rust-streaming-iterator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streaming-iterator+default-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streaming-iterator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streaming-iterator+default-devel}"
SRC_URI[x86_64_v2_rust-streaming-iterator+default-devel.sha256sum] = "7a625d7d4d765d4123e4699c67b4919f79f87e567edf80092c010715e47ee315"

URI_x86_64_v2_rust-streaming-iterator+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streaming-iterator+std-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streaming-iterator+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streaming-iterator+std-devel}"
SRC_URI[x86_64_v2_rust-streaming-iterator+std-devel.sha256sum] = "8541854539693058a33ace5c6488915636c4da128e06f2c8bb0e2e2d81125b1f"

URI_x86_64_v2_rust-streaming-iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streaming-iterator-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streaming-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streaming-iterator-devel}"
SRC_URI[x86_64_v2_rust-streaming-iterator-devel.sha256sum] = "9c1f6751740019654e3e0028cd9f3dc9b3768579198281a15751a72610dfd356"

URI_aarch64_rust-streaming-iterator+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streaming-iterator+alloc-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-streaming-iterator+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streaming-iterator+alloc-devel}"
SRC_URI[aarch64_rust-streaming-iterator+alloc-devel.sha256sum] = "edd0c6b16e70efe1ac30bf622ef7262146d3f90bfe0ab39a52b4f97ce5f96a60"

URI_aarch64_rust-streaming-iterator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streaming-iterator+default-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-streaming-iterator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streaming-iterator+default-devel}"
SRC_URI[aarch64_rust-streaming-iterator+default-devel.sha256sum] = "8b75c9e6d4ffb5ac3d73846665ab3686f97791a25b1e4be2d0fa4e5331094c44"

URI_aarch64_rust-streaming-iterator+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streaming-iterator+std-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-streaming-iterator+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streaming-iterator+std-devel}"
SRC_URI[aarch64_rust-streaming-iterator+std-devel.sha256sum] = "496e0374fbbb2ef2e7ecf600a947fcfa66679bfd1ea3a98f8d63893570722eb3"

URI_aarch64_rust-streaming-iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streaming-iterator-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-streaming-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streaming-iterator-devel}"
SRC_URI[aarch64_rust-streaming-iterator-devel.sha256sum] = "abab8d6c01c59c1f34242940ab16361164244b4a094b7cb809426c5f5d1beef5"

RDEPENDS:rust-streaming-iterator+alloc-devel = " \
 cargo \
 rust-streaming-iterator-devel \
 "
RDEPENDS:rust-streaming-iterator+default-devel = " \
 cargo \
 rust-streaming-iterator-devel \
 "
RDEPENDS:rust-streaming-iterator+std-devel = " \
 cargo \
 rust-streaming-iterator+alloc-devel \
 rust-streaming-iterator-devel \
 "
RDEPENDS:rust-streaming-iterator-devel = " \
 cargo \
 rust \
 "
