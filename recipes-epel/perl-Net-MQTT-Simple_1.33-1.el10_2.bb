# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-MQTT-Simple"
PV = "1.33"
PR = "1.el10_2"
PACKAGES = " \
 perl-Net-MQTT-Simple \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-MQTT-Simple-1.33-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71111813cf0d490ccffbfc0edda5ae59559a955d36f8df9f5b2586665286904b"

URI_x86_64_v2_perl-Net-MQTT-Simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-MQTT-Simple-1.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-MQTT-Simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-MQTT-Simple}"
SRC_URI[x86_64_v2_perl-Net-MQTT-Simple.sha256sum] = "03daa54f4d16a37c35c01a96620c5f33eeb689f32e196d0a2514c76c815cdc5b"

URI_aarch64_perl-Net-MQTT-Simple = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-MQTT-Simple-1.33-1.el10_2.noarch.rpm;name=aarch64_perl-Net-MQTT-Simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-MQTT-Simple}"
SRC_URI[aarch64_perl-Net-MQTT-Simple.sha256sum] = "d9ca238fd7eb41d6ebd7ac7ce3e738f361ee21c27dd5157c452c9be4487bcbce"

RDEPENDS:perl-Net-MQTT-Simple = " \
 perl-Getopt-Long \
 perl-IO-Socket-IP \
 perl-IO-Socket-SSL \
 perl-Net-MQTT-Simple \
 perl-Socket \
 perl-base \
 perl-interpreter \
 perl-libs \
 "
