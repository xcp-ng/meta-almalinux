# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-hypothesmith"
PV = "0.3.3"
PR = "6.el10_1"
PACKAGES = " \
 python3-hypothesmith \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-hypothesmith-0.3.3-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c314d510bdc98ce00c42e39f21ecf72102c925da619ee6222b6274e517931f4"

URI_x86_64_v2_python3-hypothesmith = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hypothesmith-0.3.3-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hypothesmith;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hypothesmith}"
SRC_URI[x86_64_v2_python3-hypothesmith.sha256sum] = "738f225de673c9747b623346981d601c060f9645e2d83bcc9ab01669d56a8f6a"

URI_aarch64_python3-hypothesmith = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hypothesmith-0.3.3-6.el10_1.noarch.rpm;name=aarch64_python3-hypothesmith;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hypothesmith}"
SRC_URI[aarch64_python3-hypothesmith.sha256sum] = "9e1e51f3432f51646260ad965c508ad18e74a9541e53157cf2d5b169afe8d5c4"

RDEPENDS:python3-hypothesmith = " \
 python3 \
 python3-hypothesis \
 python3-hypothesis+lark \
 python3-libcst \
 "
