# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-yaml-rust2"
PV = "0.10.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-yaml-rust2+debug_prints-devel \
 rust-yaml-rust2+default-devel \
 rust-yaml-rust2+encoding-devel \
 rust-yaml-rust2-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-yaml-rust2-0.10.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4dc045bc3903d19267177988c380e28226d7b626cb7d8f2bc3f743da4eddd245"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yaml-rust2+debug_prints-devel-0.10.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yaml-rust2+debug_prints-devel;unpack=0"
SRC_URI[x86_64_v2_rust-yaml-rust2+debug_prints-devel.sha256sum] = "cc89325b0e6d305d1a8523c72f7d3bf77752801fe5e7d64c8599c5b1cd601364"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yaml-rust2+default-devel-0.10.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yaml-rust2+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-yaml-rust2+default-devel.sha256sum] = "2020e00e9803cbbb167f86b0208629e02487050592d9bc84c3055949e6224ca4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yaml-rust2+encoding-devel-0.10.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yaml-rust2+encoding-devel;unpack=0"
SRC_URI[x86_64_v2_rust-yaml-rust2+encoding-devel.sha256sum] = "1851c8bc82afb28f5008c1e00ee602300d8966626f09b355f5246af34b7647a9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yaml-rust2-devel-0.10.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yaml-rust2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-yaml-rust2-devel.sha256sum] = "9e6eedcbacbc402fff483ba0d71bbff9db5a1454f5ee9fbc914613a8b7e219b1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-yaml-rust2+debug_prints-devel-0.10.4-1.el10_3.noarch.rpm;name=aarch64_rust-yaml-rust2+debug_prints-devel;unpack=0"
SRC_URI[aarch64_rust-yaml-rust2+debug_prints-devel.sha256sum] = "4bc753b19055021d8a7c48aa3343080951987127ef765fd10e44b4152e915f67"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-yaml-rust2+default-devel-0.10.4-1.el10_3.noarch.rpm;name=aarch64_rust-yaml-rust2+default-devel;unpack=0"
SRC_URI[aarch64_rust-yaml-rust2+default-devel.sha256sum] = "979b6e976b19eb8acd4ab82b1ce6829b10c9ee679993001e0e22e5fb7c752047"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-yaml-rust2+encoding-devel-0.10.4-1.el10_3.noarch.rpm;name=aarch64_rust-yaml-rust2+encoding-devel;unpack=0"
SRC_URI[aarch64_rust-yaml-rust2+encoding-devel.sha256sum] = "678ffa3548ec1e70ac09db59c125cfd64167de63b837e276b7d6d66dc4c237a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-yaml-rust2-devel-0.10.4-1.el10_3.noarch.rpm;name=aarch64_rust-yaml-rust2-devel;unpack=0"
SRC_URI[aarch64_rust-yaml-rust2-devel.sha256sum] = "a3fbdaf55d597af8f11f3b2625ed52597ad32b7818f2e4d04be0ff2a6ef01f40"

RDEPENDS:rust-yaml-rust2+debug_prints-devel = " \
 cargo \
 rust-yaml-rust2-devel \
 "
RDEPENDS:rust-yaml-rust2+default-devel = " \
 cargo \
 rust-yaml-rust2+encoding-devel \
 rust-yaml-rust2-devel \
 "
RDEPENDS:rust-yaml-rust2+encoding-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-yaml-rust2-devel \
 "
RDEPENDS:rust-yaml-rust2-devel = " \
 cargo \
 rust \
 rust-arraydeque+default-devel \
 rust-hashlink0.10+default-devel \
 "
