# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-Refcount"
PV = "0.10"
PR = "31.el10_0"
PACKAGES = " \
 perl-Devel-Refcount \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-Refcount-0.10-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92b9323ae67e3406f8ad73716578056e5af4ef40a7f05277f025ce72a49cddff"

URI_x86_64_v2_perl-Devel-Refcount = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-Refcount-0.10-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Devel-Refcount;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-Refcount}"
SRC_URI[x86_64_v2_perl-Devel-Refcount.sha256sum] = "7119978a53cf45a64248e723571db94afe6e9b96787963a76a3e8dbb25d12ae7"

URI_aarch64_perl-Devel-Refcount = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-Refcount-0.10-31.el10_0.aarch64.rpm;name=aarch64_perl-Devel-Refcount;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-Refcount}"
SRC_URI[aarch64_perl-Devel-Refcount.sha256sum] = "30364f0e3337dcb8444d37dcc12d874e134abe904c342a6e99a1e9f8296bed73"

RDEPENDS:perl-Devel-Refcount = " \
 glibc \
 perl-B \
 perl-Carp \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-libs \
 "
