# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xorg-x11-xbitmaps"
PV = "1.1.3"
PR = "1.el10_0"
PACKAGES = " \
 xorg-x11-xbitmaps \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xorg-x11-xbitmaps-1.1.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afaca4acfb02c83b664e99f53a4ebf7f5f26147889842933b15ffa09ef2970e2"

URI_x86_64_v2_xorg-x11-xbitmaps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xorg-x11-xbitmaps-1.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_xorg-x11-xbitmaps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-xbitmaps}"
SRC_URI[x86_64_v2_xorg-x11-xbitmaps.sha256sum] = "50b80fd71fd3d74735c268b69a08ce6cd84217d4ed2919baa8921014f4046978"

URI_aarch64_xorg-x11-xbitmaps = "${EPEL_MIRROR}/aarch64/Packages/x/xorg-x11-xbitmaps-1.1.3-1.el10_0.noarch.rpm;name=aarch64_xorg-x11-xbitmaps;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-xbitmaps}"
SRC_URI[aarch64_xorg-x11-xbitmaps.sha256sum] = "da648bf640c105abd159c2338b6039285f5420f29761f595f66e403326a43c7a"

RDEPENDS:xorg-x11-xbitmaps = " \
 pkgconf-pkg-config \
 "
