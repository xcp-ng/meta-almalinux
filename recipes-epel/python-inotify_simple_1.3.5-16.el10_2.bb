# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-inotify_simple"
PV = "1.3.5"
PR = "16.el10_2"
PACKAGES = " \
 python3-inotify_simple \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-inotify_simple-1.3.5-16.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec1575f08826fa103d588f3816883a0cd4e882510f486a947ecfd88648c1cf8e"

URI_x86_64_v2_python3-inotify_simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-inotify_simple-1.3.5-16.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-inotify_simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-inotify_simple}"
SRC_URI[x86_64_v2_python3-inotify_simple.sha256sum] = "9972ff6523da2bdb5a9109c2db130ccce8f0eebddf346009ac06356e01113387"

URI_aarch64_python3-inotify_simple = "${EPEL_MIRROR}/aarch64/Packages/p/python3-inotify_simple-1.3.5-16.el10_2.noarch.rpm;name=aarch64_python3-inotify_simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-inotify_simple}"
SRC_URI[aarch64_python3-inotify_simple.sha256sum] = "2869e98b79570636132538546d1c98c53587f25a9998c38b01de4411c46aea8c"

RDEPENDS:python3-inotify_simple = " \
 python3 \
 "
