# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Load-XS"
PV = "0.10"
PR = "20.el10_0"
PACKAGES = " \
 perl-Class-Load-XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-Load-XS-0.10-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a5d503404d2173be345047d2c823cf228e56ba18c25d26ed2e0dc6e1a47dbdc"

URI_x86_64_v2_perl-Class-Load-XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Load-XS-0.10-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Class-Load-XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Load-XS}"
SRC_URI[x86_64_v2_perl-Class-Load-XS.sha256sum] = "815ea20c73fe2f0e7f525b2b2b6b65e48c89b15d0332aec48f76123ede41d26e"

URI_aarch64_perl-Class-Load-XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Load-XS-0.10-20.el10_0.aarch64.rpm;name=aarch64_perl-Class-Load-XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Load-XS}"
SRC_URI[aarch64_perl-Class-Load-XS.sha256sum] = "feeef5476c9c0ecbadb4d0b875c35c19841a9635b5c109af54f2a0427166c273"

RDEPENDS:perl-Class-Load-XS = " \
 glibc \
 perl-Class-Load \
 perl-libs \
 "
