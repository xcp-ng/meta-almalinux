# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Finance-Quote"
PV = "1.6300"
PR = "1.el10_0"
PACKAGES = " \
 perl-Finance-Quote \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Finance-Quote-1.6300-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3dd89e8622257e1c3e934b8d45b2f9a160f75dea6c8fee56e60681efeff96f1f"

URI_x86_64_v2_perl-Finance-Quote = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Finance-Quote-1.6300-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Finance-Quote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Finance-Quote}"
SRC_URI[x86_64_v2_perl-Finance-Quote.sha256sum] = "487019eaa09e576ea5340512632c3e85d3b09a162425721a0988a1db056f902d"

URI_aarch64_perl-Finance-Quote = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Finance-Quote-1.6300-1.el10_0.noarch.rpm;name=aarch64_perl-Finance-Quote;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Finance-Quote}"
SRC_URI[aarch64_perl-Finance-Quote.sha256sum] = "b46446b7236c2217aa9de7e2ae40bbac87632d0ecdf92a89d1ec82de216dbae6"

RDEPENDS:perl-Finance-Quote = " \
 perl-Carp \
 perl-DateTime \
 perl-DateTime-Format-Strptime \
 perl-Encode \
 perl-Exporter \
 perl-Finance-Quote \
 perl-HTML-Parser \
 perl-HTML-TableExtract \
 perl-HTML-Tree \
 perl-HTML-TreeBuilder-XPath \
 perl-HTTP-CookieJar \
 perl-HTTP-Cookies \
 perl-HTTP-Message \
 perl-IO-Compress \
 perl-IO-String \
 perl-JSON \
 perl-LWP-Protocol-https \
 perl-Module-Load \
 perl-POSIX \
 perl-Readonly \
 perl-Scalar-List-Utils \
 perl-Spreadsheet-XLSX \
 perl-String-Util \
 perl-Text-Template \
 perl-Time-Piece \
 perl-Try-Tiny \
 perl-URI \
 perl-Web-Scraper \
 perl-XML-LibXML \
 perl-base \
 perl-constant \
 perl-if \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 "
