# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_uniq"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_uniq+default-devel \
 rust-uu_uniq-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_uniq-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e1fe6f0550bc76668f95b9f7dc35f5a67db6eaec601be12240ee6f9949d4578"

URI_x86_64_v2_rust-uu_uniq+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_uniq+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_uniq+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_uniq+default-devel}"
SRC_URI[x86_64_v2_rust-uu_uniq+default-devel.sha256sum] = "f8a68c35f6cf8a90b6385365d32b8717043a51b032f2c72a557eeee2ca60759a"

URI_x86_64_v2_rust-uu_uniq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_uniq-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_uniq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_uniq-devel}"
SRC_URI[x86_64_v2_rust-uu_uniq-devel.sha256sum] = "f6d1ee08388ff243983922396c839187c2c222f619b537a3d3908b1014607757"

URI_aarch64_rust-uu_uniq+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_uniq+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_uniq+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_uniq+default-devel}"
SRC_URI[aarch64_rust-uu_uniq+default-devel.sha256sum] = "abc7d8ae497d29f5c6a2a3916af9cd05220c45be748738abd4b19a77f14dbe93"

URI_aarch64_rust-uu_uniq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_uniq-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_uniq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_uniq-devel}"
SRC_URI[aarch64_rust-uu_uniq-devel.sha256sum] = "4fe04918c1a00b685c79424f47ff5eac587ff1488f77b96670577f4f672ec552"

RDEPENDS:rust-uu_uniq+default-devel = " \
 cargo \
 rust-uu_uniq-devel \
 "
RDEPENDS:rust-uu_uniq-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+parser-devel \
 "
