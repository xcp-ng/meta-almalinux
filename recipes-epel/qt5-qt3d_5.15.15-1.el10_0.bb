# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qt3d"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qt3d \
 qt5-qt3d-devel \
 qt5-qt3d-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qt3d-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8f38695272ac1559a2840ea5978fd3c02c3a6e07948abf1462c80dc35ebd673"

URI_x86_64_v2_qt5-qt3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qt3d-5.15.15-1.el10_0.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_qt5-qt3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qt3d}"
SRC_URI[x86_64_v2_qt5-qt3d.sha256sum] = "d4b666808ca74453749eb8516f3b714ca93c3a998ad3dba62900a6db96e354bb"

URI_x86_64_v2_qt5-qt3d-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qt3d-devel-5.15.15-1.el10_0.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_qt5-qt3d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qt3d-devel}"
SRC_URI[x86_64_v2_qt5-qt3d-devel.sha256sum] = "ec46dedd9bc9e8e39160298e58df67005332b7ec2b093adfd6a96077863e5d09"

URI_x86_64_v2_qt5-qt3d-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qt3d-examples-5.15.15-1.el10_0.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_qt5-qt3d-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qt3d-examples}"
SRC_URI[x86_64_v2_qt5-qt3d-examples.sha256sum] = "8e5348aa7f63781aef2ab6c05f94c467b926d08c2c2cf3db782e1fa0b7621dc6"

URI_aarch64_qt5-qt3d = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qt3d-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qt3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qt3d}"
SRC_URI[aarch64_qt5-qt3d.sha256sum] = "6db55e504a7ff7b5077d9c5a9ee1aadabbc13057c8096a735ab9e7a64d330f9a"

URI_aarch64_qt5-qt3d-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qt3d-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qt3d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qt3d-devel}"
SRC_URI[aarch64_qt5-qt3d-devel.sha256sum] = "6f3986cb090f9fd8b191fd68ed7441ccb4617e542cb558d01bd92315753eb6c1"

URI_aarch64_qt5-qt3d-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qt3d-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qt3d-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qt3d-examples}"
SRC_URI[aarch64_qt5-qt3d-examples.sha256sum] = "af9e870937238451789c40b1a05de3e5ab33a5cf79d99219303073db0df37f6f"

RDEPENDS:qt5-qt3d = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtimageformats \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qt3d-devel = " \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qt3d \
 qt5-qt3d-devel \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qt3d-examples = " \
 glibc \
 libstdc++ \
 qt5-qt3d \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
