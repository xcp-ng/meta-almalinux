# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-ffi"
PV = "0.27.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-pyo3-ffi+abi3-devel \
 rust-pyo3-ffi+abi3-py310-devel \
 rust-pyo3-ffi+abi3-py311-devel \
 rust-pyo3-ffi+abi3-py312-devel \
 rust-pyo3-ffi+abi3-py313-devel \
 rust-pyo3-ffi+abi3-py314-devel \
 rust-pyo3-ffi+abi3-py37-devel \
 rust-pyo3-ffi+abi3-py38-devel \
 rust-pyo3-ffi+abi3-py39-devel \
 rust-pyo3-ffi+default-devel \
 rust-pyo3-ffi+extension-module-devel \
 rust-pyo3-ffi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-ffi-0.27.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cd0d5a47c5fc84bab491613ce9cacdd615b6f8af5efc1578f77dc2d86096f62"

URI_x86_64_v2_rust-pyo3-ffi+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-devel.sha256sum] = "17a3b9d015801f67aeca07219bbd5ae0d142792aec07c807c4f76eeef9e427dc"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py310-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py310-devel.sha256sum] = "22cdaecc5950c6db692395ae1b0eadaf5e3d3bc1317cd884d93bba4d80782824"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py311-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py311-devel.sha256sum] = "bed1bce03223f31635abf18f9aaf7032348521ed9a3107128821dab735e3314c"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py312-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py312-devel.sha256sum] = "a089a92f8c9eed0d9c3d443aa6b33d547bb03fef165c334e01e5c21c6405cdad"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py313-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py313-devel.sha256sum] = "38eab9cbdf8bd3579858b1a0b5e005596ecc462c2a70502cc38b898d8461d1ca"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py314-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py314-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py314-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py314-devel.sha256sum] = "c112d7b45da7853658b6cadfcfe65140141a63525386bf6e0a9537f0f8febd8f"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py37-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py37-devel.sha256sum] = "b1951066a01c5fa8c7cd899f91e39ea515b0941fd69523e475b069f8412fabfd"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py38-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py38-devel.sha256sum] = "f9ed0d7ceea13375a6d026600b089280e1fa868acafaf0fc8cdc13a693e60f17"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py39-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py39-devel.sha256sum] = "53594f3dc5e9b33bf01ab3f632217ab46c603091d539994d0820a188f733d7c6"

URI_x86_64_v2_rust-pyo3-ffi+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+default-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+default-devel.sha256sum] = "ad69a130211ef9c5efc64c52b027e6d518336dc42c7c2b029a772f12f460d7a3"

URI_x86_64_v2_rust-pyo3-ffi+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+extension-module-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+extension-module-devel.sha256sum] = "345ae8da26697d889ac2bffe916341d32af9ef3adb5ce60f96cedc6abcb81612"

URI_x86_64_v2_rust-pyo3-ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi-devel.sha256sum] = "66a10ba701c274a81a74dc007b0e3ceb6c1752d5b2972458796637d066280f24"

URI_aarch64_rust-pyo3-ffi+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-devel.sha256sum] = "9753fd26159ef318505d15aaf1a4f4a485088a1fa21ebe1b567a505495e12524"

URI_aarch64_rust-pyo3-ffi+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py310-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py310-devel.sha256sum] = "0977aeed3ab9b1d85a2ecca1cedc1b235238004c22fd9c84d50e8bec64b68df6"

URI_aarch64_rust-pyo3-ffi+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py311-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py311-devel.sha256sum] = "4137a202dbac703f069ea76a9b65900ccee5beec7407b371f824a4444debcc67"

URI_aarch64_rust-pyo3-ffi+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py312-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py312-devel.sha256sum] = "e21ae5ef732afca03c26fa3a6f32cf8a9dfe0f812afe69a99a7e82f6a9704d38"

URI_aarch64_rust-pyo3-ffi+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py313-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py313-devel.sha256sum] = "3ff254dce72624f53ce96203bffbea3a68b73bbd25770ed08626676189e709bf"

URI_aarch64_rust-pyo3-ffi+abi3-py314-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py314-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py314-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py314-devel.sha256sum] = "0238babf428a1ac5415e759c79f0c273e7d0c8b63e7ad8f74be6745eff8675e4"

URI_aarch64_rust-pyo3-ffi+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py37-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py37-devel.sha256sum] = "d8de9e0c458234eeb47e53b11ce2f5c4662c5c0ad02aaf3917e80d18f6c9e57d"

URI_aarch64_rust-pyo3-ffi+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py38-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py38-devel.sha256sum] = "4935d60f6af94d3f4d53565cb4bf82964ba870d656541f10c62f183cc8884d0e"

URI_aarch64_rust-pyo3-ffi+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py39-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py39-devel.sha256sum] = "5ba558b252dccd4e8e7d0d5a73d7dff776f40ccf4042844ce7eb6280c439e8e4"

URI_aarch64_rust-pyo3-ffi+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+default-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+default-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+default-devel.sha256sum] = "aebcf131efc4c18936c1ed66638bc8a142c233f24123598f62cec8cc2958520f"

URI_aarch64_rust-pyo3-ffi+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+extension-module-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+extension-module-devel.sha256sum] = "14ce63efeb5686f15b5becf7217751b3c2692a02e2dff74342165f4e1ac450d2"

URI_aarch64_rust-pyo3-ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi-devel}"
SRC_URI[aarch64_rust-pyo3-ffi-devel.sha256sum] = "dd98689d3713ae623f9b8e83d086930b73f0575fb9723a3f11d569af1ba7a9d8"

RDEPENDS:rust-pyo3-ffi+abi3-devel = " \
 cargo \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py311-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py312-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py313-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py313-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py314-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py314-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py38-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py39-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py310-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+default-devel = " \
 cargo \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi-devel = " \
 cargo \
 python3-devel \
 rust \
 rust-libc+default-devel \
 rust-pyo3-build-config+default-devel \
 rust-pyo3-build-config+resolve-config-devel \
 "
