# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvpl-tools"
PV = "1.6.0"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 libvpl-tools \
 libvpl-tools-devel \
 libvpl-tools-libs \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/l/libvpl-tools-1.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e04cbb0c542eba8e641be984b82fb45019c26a2bcc92ed653df9444c629e411"

URI_x86_64_v2_libvpl-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-tools-1.6.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-tools}"
SRC_URI[x86_64_v2_libvpl-tools.sha256sum] = "bc5c4397b3ef98faaabce01981237dea01b15bf2f8107635281686cda18c4b89"

URI_x86_64_v2_libvpl-tools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-tools-devel-1.6.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-tools-devel}"
SRC_URI[x86_64_v2_libvpl-tools-devel.sha256sum] = "f51a202f3647640d0f1a21e1999d7e2080d585172f35190a8d1be3e77e801b69"

URI_x86_64_v2_libvpl-tools-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-tools-libs-1.6.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-tools-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-tools-libs}"
SRC_URI[x86_64_v2_libvpl-tools-libs.sha256sum] = "7b858b46a176dbdac7e62939998fc2850856a4dfbf918db59a4072965353a56e"

RDEPENDS:libvpl-tools = " \
 glib2 \
 glibc \
 glibmm2.68 \
 gtk4 \
 gtkmm4.0 \
 libX11 \
 libepoxy \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libva \
 libvpl \
 libvpl-tools-libs \
 "
RDEPENDS:libvpl-tools-devel = " \
 libvpl-tools-libs \
 "
RDEPENDS:libvpl-tools-libs = " \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libvpl-tools \
 libwayland-client \
 "
