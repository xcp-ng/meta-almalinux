# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scratch"
PV = "1.0.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-scratch+default-devel \
 rust-scratch-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scratch-1.0.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed48159a495f184cf85a092f65a762e17fa6bf2ac6adf47b839ae831202137fa"

URI_x86_64_v2_rust-scratch+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scratch+default-devel-1.0.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scratch+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scratch+default-devel}"
SRC_URI[x86_64_v2_rust-scratch+default-devel.sha256sum] = "ed827a43d5468b1056df99ee5f39333cc26ece1e39d9213b05c752595e6d4841"

URI_x86_64_v2_rust-scratch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scratch-devel-1.0.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scratch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scratch-devel}"
SRC_URI[x86_64_v2_rust-scratch-devel.sha256sum] = "a1608714d7df4306363bf36aea5b48a150baf3c8a5c1f8af659ecf47e07a243b"

URI_aarch64_rust-scratch+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scratch+default-devel-1.0.9-1.el10_0.noarch.rpm;name=aarch64_rust-scratch+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scratch+default-devel}"
SRC_URI[aarch64_rust-scratch+default-devel.sha256sum] = "6bec9f60895642741ffb2a18a410cbf10af1697102fc7561273a34afc567058f"

URI_aarch64_rust-scratch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scratch-devel-1.0.9-1.el10_0.noarch.rpm;name=aarch64_rust-scratch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scratch-devel}"
SRC_URI[aarch64_rust-scratch-devel.sha256sum] = "d1fccbdb86499d0d58d8f7919936ebab29479b30b0df2d515338a1558b8faa28"

RDEPENDS:rust-scratch+default-devel = " \
 cargo \
 rust-scratch-devel \
 "
RDEPENDS:rust-scratch-devel = " \
 cargo \
 rust \
 "
