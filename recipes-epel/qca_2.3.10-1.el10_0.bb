# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qca"
PV = "2.3.10"
PR = "1.el10_0"
PACKAGES = " \
 qca-qt5 \
 qca-qt5-cyrus-sasl \
 qca-qt5-devel \
 qca-qt5-gcrypt \
 qca-qt5-gnupg \
 qca-qt5-logger \
 qca-qt5-nss \
 qca-qt5-ossl \
 qca-qt5-pkcs11 \
 qca-qt5-softstore \
 qca-qt6 \
 qca-qt6-cyrus-sasl \
 qca-qt6-devel \
 qca-qt6-gcrypt \
 qca-qt6-gnupg \
 qca-qt6-logger \
 qca-qt6-nss \
 qca-qt6-ossl \
 qca-qt6-pkcs11 \
 qca-qt6-softstore \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qca-2.3.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8437c6d89d9f2a53470ebf4231ea8a9eb183c429848ae89f4d38554aed7cae5f"

URI_x86_64_v2_qca-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5}"
SRC_URI[x86_64_v2_qca-qt5.sha256sum] = "30a503fc5db10c8ac8c5ead85de42ab0bb0e3d8fb20753ae2e1ab343eb6489f3"

URI_x86_64_v2_qca-qt5-cyrus-sasl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-cyrus-sasl-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-cyrus-sasl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-cyrus-sasl}"
SRC_URI[x86_64_v2_qca-qt5-cyrus-sasl.sha256sum] = "d2a161badb6572b9d7893a151eaa8381ec88ff5871b4fb3e0a91f298ef04a64c"

URI_x86_64_v2_qca-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-devel-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-devel}"
SRC_URI[x86_64_v2_qca-qt5-devel.sha256sum] = "5911d8831deb28875108f0182c4071ec5f6cffb0465beaadd8c2d655b596bc66"

URI_x86_64_v2_qca-qt5-gcrypt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-gcrypt-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-gcrypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-gcrypt}"
SRC_URI[x86_64_v2_qca-qt5-gcrypt.sha256sum] = "c59eda71dd65d7ce6466898fe7480ba8fb2c958576d9e3596f7812b21144e2b2"

URI_x86_64_v2_qca-qt5-gnupg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-gnupg-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-gnupg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-gnupg}"
SRC_URI[x86_64_v2_qca-qt5-gnupg.sha256sum] = "dc40f68559ba56634cf546ef59d054382868c787de65189436356aca5d8a1bf8"

URI_x86_64_v2_qca-qt5-logger = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-logger-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-logger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-logger}"
SRC_URI[x86_64_v2_qca-qt5-logger.sha256sum] = "3dda7d23600bee281801331613150a2b0fd6a850f7695de54298130654ed0c39"

URI_x86_64_v2_qca-qt5-nss = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-nss-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-nss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-nss}"
SRC_URI[x86_64_v2_qca-qt5-nss.sha256sum] = "40d4d2d50c2a4f6f41b758c6705ea6212bdfe6d4ed4c60f3e35e8fc4a5e0b42d"

URI_x86_64_v2_qca-qt5-ossl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-ossl-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-ossl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-ossl}"
SRC_URI[x86_64_v2_qca-qt5-ossl.sha256sum] = "894742a93f445a884e199223d5e26619453d46f1f95c3af85a089ddbbdb1a462"

URI_x86_64_v2_qca-qt5-pkcs11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-pkcs11-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-pkcs11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-pkcs11}"
SRC_URI[x86_64_v2_qca-qt5-pkcs11.sha256sum] = "b9cab4f49a6173c5a51d4d5c0bfe0b7522987eac5bf1546abcc2160ba9877fbb"

URI_x86_64_v2_qca-qt5-softstore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-softstore-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-softstore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-softstore}"
SRC_URI[x86_64_v2_qca-qt5-softstore.sha256sum] = "dfa623f5549dd95d5bf143f762c4a59ce18dc2b64f98b30e908e718ff60c1c69"

URI_x86_64_v2_qca-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6}"
SRC_URI[x86_64_v2_qca-qt6.sha256sum] = "52267c46fc3715419b5e16c0e4620c970ab2df565c292967cb61c756d72aaf1b"

URI_x86_64_v2_qca-qt6-cyrus-sasl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-cyrus-sasl-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-cyrus-sasl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-cyrus-sasl}"
SRC_URI[x86_64_v2_qca-qt6-cyrus-sasl.sha256sum] = "828353e2f30f49a1844b9aff76c466f17fd709df53e952e70d7cdd4db67b3513"

URI_x86_64_v2_qca-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-devel-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-devel}"
SRC_URI[x86_64_v2_qca-qt6-devel.sha256sum] = "595e0f7a67f8d0f30cbace5b8b40eb86da0e04486a1d67cf4db3fcd5e4a5793f"

URI_x86_64_v2_qca-qt6-gcrypt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-gcrypt-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-gcrypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-gcrypt}"
SRC_URI[x86_64_v2_qca-qt6-gcrypt.sha256sum] = "c6553ede79e4d8c9e66113004b0b324e920fd63641d2d3748e8ff54182dcce3b"

URI_x86_64_v2_qca-qt6-gnupg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-gnupg-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-gnupg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-gnupg}"
SRC_URI[x86_64_v2_qca-qt6-gnupg.sha256sum] = "51238d91eabdba70cee47fb2a37a80edf3bbe01c5a689f583d0d403b175e5fe5"

URI_x86_64_v2_qca-qt6-logger = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-logger-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-logger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-logger}"
SRC_URI[x86_64_v2_qca-qt6-logger.sha256sum] = "11ab8739d5a5c777dddf6b0a07774447f00cf0737d4c21a1a4792d117f1d2bba"

URI_x86_64_v2_qca-qt6-nss = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-nss-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-nss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-nss}"
SRC_URI[x86_64_v2_qca-qt6-nss.sha256sum] = "7309c6f1150ae3733e48b8fcb7a8471f270b3aa141b4689933a97f39ba18f5f4"

URI_x86_64_v2_qca-qt6-ossl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-ossl-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-ossl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-ossl}"
SRC_URI[x86_64_v2_qca-qt6-ossl.sha256sum] = "4670757a1545304fa023a5d5a78f37094b65bf5a9041f538b6dd92d3d219c290"

URI_x86_64_v2_qca-qt6-pkcs11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-pkcs11-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-pkcs11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-pkcs11}"
SRC_URI[x86_64_v2_qca-qt6-pkcs11.sha256sum] = "e9594d3c79a97befb5e9fa9f998aa8e7f82d31058d018ed92d37de439dd23620"

URI_x86_64_v2_qca-qt6-softstore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-softstore-2.3.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-softstore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-softstore}"
SRC_URI[x86_64_v2_qca-qt6-softstore.sha256sum] = "4de53a5c080c49e085b38738abcae0f4b596dce9b71b935667c35be24b7cb007"

URI_aarch64_qca-qt5 = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5}"
SRC_URI[aarch64_qca-qt5.sha256sum] = "e3a4c32bb78d4de547cc9ca0a032637f38fb04d41ee9261f389ce2810d7b6e9f"

URI_aarch64_qca-qt5-cyrus-sasl = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-cyrus-sasl-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt5-cyrus-sasl;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-cyrus-sasl}"
SRC_URI[aarch64_qca-qt5-cyrus-sasl.sha256sum] = "1b94e0c2f17c96dc046935c054328c4d80b2c6d127462c4d2c0f70e06673bf39"

URI_aarch64_qca-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-devel-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-devel}"
SRC_URI[aarch64_qca-qt5-devel.sha256sum] = "a3be54c3dc036bc51546de6bd9858596cdb7bc3823fddbed73624e8835a9fe54"

URI_aarch64_qca-qt5-gcrypt = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-gcrypt-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt5-gcrypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-gcrypt}"
SRC_URI[aarch64_qca-qt5-gcrypt.sha256sum] = "796473431fade7a1a7d14284d4ad59b4c3d6d3b8407d2ad181eea20674394c67"

URI_aarch64_qca-qt5-gnupg = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-gnupg-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt5-gnupg;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-gnupg}"
SRC_URI[aarch64_qca-qt5-gnupg.sha256sum] = "d15c6ad78b61ee8185848fa3800a91005df23dcf6983195a18c717ada7470a01"

URI_aarch64_qca-qt5-logger = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-logger-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt5-logger;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-logger}"
SRC_URI[aarch64_qca-qt5-logger.sha256sum] = "3292bd72af00ee0890d2a4a67e3564c670e3646dd926c6187550409cf1540e23"

URI_aarch64_qca-qt5-nss = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-nss-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt5-nss;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-nss}"
SRC_URI[aarch64_qca-qt5-nss.sha256sum] = "bb98fa30ff173d4ec572b42e2bb8266ecfe814752a78c387241fd24297cb47bb"

URI_aarch64_qca-qt5-ossl = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-ossl-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt5-ossl;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-ossl}"
SRC_URI[aarch64_qca-qt5-ossl.sha256sum] = "c5d964dcb7e6c4f61e826e31f73aa903507f0142aa570f052c8be1b99e87d557"

URI_aarch64_qca-qt5-pkcs11 = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-pkcs11-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt5-pkcs11;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-pkcs11}"
SRC_URI[aarch64_qca-qt5-pkcs11.sha256sum] = "063789e385c741c111f81a69305b315a9bfd4030870807c092d69b39788b0487"

URI_aarch64_qca-qt5-softstore = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-softstore-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt5-softstore;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-softstore}"
SRC_URI[aarch64_qca-qt5-softstore.sha256sum] = "7b738fe382c9472d2020eda2df0725b076a7595b491c501918177c63e1f87df3"

URI_aarch64_qca-qt6 = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6}"
SRC_URI[aarch64_qca-qt6.sha256sum] = "7d843054f699a0d1b6728270823cbb0c288510ed3b699e7f7fc8f74d93ed82f6"

URI_aarch64_qca-qt6-cyrus-sasl = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-cyrus-sasl-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt6-cyrus-sasl;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-cyrus-sasl}"
SRC_URI[aarch64_qca-qt6-cyrus-sasl.sha256sum] = "8425bc8583b584a0b5acb47cd2d919f386236a4d6d7d613bc762794207f32784"

URI_aarch64_qca-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-devel-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-devel}"
SRC_URI[aarch64_qca-qt6-devel.sha256sum] = "806986c838ba161de0168dc5dfb9c027a109f95ca4a2b2dac8708bfab39a0239"

URI_aarch64_qca-qt6-gcrypt = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-gcrypt-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt6-gcrypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-gcrypt}"
SRC_URI[aarch64_qca-qt6-gcrypt.sha256sum] = "98f5dab7cbeca93544f08304a0d084cf1ca1bc923d707c4010df94cabc15fe71"

URI_aarch64_qca-qt6-gnupg = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-gnupg-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt6-gnupg;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-gnupg}"
SRC_URI[aarch64_qca-qt6-gnupg.sha256sum] = "dd658173de5aa3a7c9091e6307099ae8588483158942bda4f014537a149d8399"

URI_aarch64_qca-qt6-logger = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-logger-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt6-logger;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-logger}"
SRC_URI[aarch64_qca-qt6-logger.sha256sum] = "47100c1d3a8c67722ca27a029f51eeb4b0fca67310a3c5d9d848f3dbd7861e48"

URI_aarch64_qca-qt6-nss = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-nss-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt6-nss;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-nss}"
SRC_URI[aarch64_qca-qt6-nss.sha256sum] = "549760ee1490e80a4b53b229c539433702f77f0215a73e8cbb605e80d192f689"

URI_aarch64_qca-qt6-ossl = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-ossl-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt6-ossl;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-ossl}"
SRC_URI[aarch64_qca-qt6-ossl.sha256sum] = "3d24691d34ca31164a5d58dd87e193c4c623609374570a03365d343b16fc32e6"

URI_aarch64_qca-qt6-pkcs11 = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-pkcs11-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt6-pkcs11;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-pkcs11}"
SRC_URI[aarch64_qca-qt6-pkcs11.sha256sum] = "3b00ab70e53b6a67cd98663db8b9089aa7899b01df7a2d319c5b6911cd4c733b"

URI_aarch64_qca-qt6-softstore = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-softstore-2.3.10-1.el10_0.aarch64.rpm;name=aarch64_qca-qt6-softstore;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-softstore}"
SRC_URI[aarch64_qca-qt6-softstore.sha256sum] = "a3051a7855150e1c0e24f94de4f7bb7654a979ea224c302be593148ad2ab5df3"

RDEPENDS:qca-qt5 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-cyrus-sasl = " \
 cyrus-sasl-lib \
 glibc \
 libgcc \
 libstdc++ \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qca-qt5 \
 qt5-qtbase-devel \
 "
RDEPENDS:qca-qt5-gcrypt = " \
 glibc \
 libgcc \
 libgcrypt \
 libstdc++ \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-gnupg = " \
 glibc \
 gnupg2 \
 libgcc \
 libstdc++ \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-logger = " \
 glibc \
 libgcc \
 libstdc++ \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-nss = " \
 glibc \
 libgcc \
 libstdc++ \
 nss \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-ossl = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-pkcs11 = " \
 glibc \
 libgcc \
 libstdc++ \
 pkcs11-helper \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-softstore = " \
 glibc \
 libgcc \
 libstdc++ \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt6 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-cyrus-sasl = " \
 cyrus-sasl-lib \
 glibc \
 libgcc \
 libstdc++ \
 qca-qt6 \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qca-qt6 \
 qt6-qtbase-devel \
 "
RDEPENDS:qca-qt6-gcrypt = " \
 glibc \
 libgcc \
 libgcrypt \
 libstdc++ \
 qca-qt6 \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-gnupg = " \
 glibc \
 gnupg2 \
 libgcc \
 libstdc++ \
 qca-qt6 \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-logger = " \
 glibc \
 libgcc \
 libstdc++ \
 qca-qt6 \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-nss = " \
 glibc \
 libgcc \
 libstdc++ \
 nss \
 qca-qt6 \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-ossl = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 qca-qt6 \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-pkcs11 = " \
 glibc \
 libgcc \
 libstdc++ \
 pkcs11-helper \
 qca-qt6 \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-softstore = " \
 glibc \
 libgcc \
 libstdc++ \
 qca-qt6 \
 qt6-qtbase \
 "
