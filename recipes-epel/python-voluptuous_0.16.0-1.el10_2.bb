# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-voluptuous"
PV = "0.16.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-voluptuous \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-voluptuous-0.16.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa2b6053a4937fa4491538570755c067507db65452f1f2c213dfb074980f9ea6"

URI_x86_64_v2_python3-voluptuous = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-voluptuous-0.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-voluptuous;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-voluptuous}"
SRC_URI[x86_64_v2_python3-voluptuous.sha256sum] = "f07686ced5c242b213c716cc6b4e6af11380edfbf4c642653b5aed971c3f87c7"

URI_aarch64_python3-voluptuous = "${EPEL_MIRROR}/aarch64/Packages/p/python3-voluptuous-0.16.0-1.el10_2.noarch.rpm;name=aarch64_python3-voluptuous;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-voluptuous}"
SRC_URI[aarch64_python3-voluptuous.sha256sum] = "1d8dfd94c0b5440ca518797dc7caf3a7c682d848502a1437a25645818828928a"

RDEPENDS:python3-voluptuous = " \
 python3 \
 "
