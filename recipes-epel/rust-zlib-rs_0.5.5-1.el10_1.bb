# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zlib-rs"
PV = "0.5.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-zlib-rs+avx512-devel \
 rust-zlib-rs+c-allocator-devel \
 rust-zlib-rs+default-devel \
 rust-zlib-rs+rust-allocator-devel \
 rust-zlib-rs+std-devel \
 rust-zlib-rs+vpclmulqdq-devel \
 rust-zlib-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zlib-rs-0.5.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a14b0e70bb6c1482e0579aefd99b33ad567a75fc66e4e11a039183fbf9a5d607"

URI_x86_64_v2_rust-zlib-rs+avx512-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+avx512-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+avx512-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+avx512-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+avx512-devel.sha256sum] = "55ceaa105979ef1e6900cb93665e147c3fef629b14c1579fa17145306d44cfb1"

URI_x86_64_v2_rust-zlib-rs+c-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+c-allocator-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+c-allocator-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+c-allocator-devel.sha256sum] = "3d79498b7665e1fb12eb11cf94f8f47b5b9ff3bff1433828512fc7e4272cacb9"

URI_x86_64_v2_rust-zlib-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+default-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+default-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+default-devel.sha256sum] = "157efba5e6dabbbf48fd537970800503bdc627fe82719dcac335ddb4bb6ff54d"

URI_x86_64_v2_rust-zlib-rs+rust-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+rust-allocator-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+rust-allocator-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+rust-allocator-devel.sha256sum] = "1c6844b2ec6e9421cfcea8e7cdbff0b083b2053da3d33fdd9dbebb234b83fe29"

URI_x86_64_v2_rust-zlib-rs+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+std-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+std-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+std-devel.sha256sum] = "32f42ec95e22c72e1e1f2c5d6311cd30c062419ad5b1c404d365f4644c0835d6"

URI_x86_64_v2_rust-zlib-rs+vpclmulqdq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+vpclmulqdq-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+vpclmulqdq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs+vpclmulqdq-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs+vpclmulqdq-devel.sha256sum] = "da00a12b319dfddaf46898d39f69cc899e64f1177526a141c4b3a15b3707fc41"

URI_x86_64_v2_rust-zlib-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zlib-rs-devel}"
SRC_URI[x86_64_v2_rust-zlib-rs-devel.sha256sum] = "1cb64e25f840d459caab9146c00906d13b318e98bc3da2d4918a8d7aeb32590c"

URI_aarch64_rust-zlib-rs+avx512-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+avx512-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-zlib-rs+avx512-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+avx512-devel}"
SRC_URI[aarch64_rust-zlib-rs+avx512-devel.sha256sum] = "32bb857d1165bf5cc8e1c76aaadf44585cd45fde37d7e054d3b6e1895a1c756a"

URI_aarch64_rust-zlib-rs+c-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+c-allocator-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-zlib-rs+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+c-allocator-devel}"
SRC_URI[aarch64_rust-zlib-rs+c-allocator-devel.sha256sum] = "3c45ef782a8d64afd9e936fdbb4610ffbf7a6e02cd8be6350243bfd7492c1458"

URI_aarch64_rust-zlib-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+default-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-zlib-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+default-devel}"
SRC_URI[aarch64_rust-zlib-rs+default-devel.sha256sum] = "e7747be252cc55809bc81028afd243fd78b5d566bd6c44b13b7dce1d6dfa2218"

URI_aarch64_rust-zlib-rs+rust-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+rust-allocator-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-zlib-rs+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+rust-allocator-devel}"
SRC_URI[aarch64_rust-zlib-rs+rust-allocator-devel.sha256sum] = "281916e81056e8a502667c181ae186b14688860e6625faf8fa2c0a87c1fd349c"

URI_aarch64_rust-zlib-rs+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+std-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-zlib-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+std-devel}"
SRC_URI[aarch64_rust-zlib-rs+std-devel.sha256sum] = "6aa745156bb587277ec35ea04beb69688cb5503bd912c4637209b9b337b46c14"

URI_aarch64_rust-zlib-rs+vpclmulqdq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+vpclmulqdq-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-zlib-rs+vpclmulqdq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs+vpclmulqdq-devel}"
SRC_URI[aarch64_rust-zlib-rs+vpclmulqdq-devel.sha256sum] = "15e2cb7cada41b8a002c70e7023b41f42a512dafa85bc8f8917958bec6c00e58"

URI_aarch64_rust-zlib-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zlib-rs-devel}"
SRC_URI[aarch64_rust-zlib-rs-devel.sha256sum] = "f27e19b8f4c2dac1f44707b867679968ec06920f22cfc1045987771d416a1f9f"

RDEPENDS:rust-zlib-rs+avx512-devel = " \
 cargo \
 rust-zlib-rs+vpclmulqdq-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+c-allocator-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+default-devel = " \
 cargo \
 rust-zlib-rs+c-allocator-devel \
 rust-zlib-rs+std-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+rust-allocator-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+std-devel = " \
 cargo \
 rust-zlib-rs+rust-allocator-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+vpclmulqdq-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs-devel = " \
 cargo \
 rust \
 "
