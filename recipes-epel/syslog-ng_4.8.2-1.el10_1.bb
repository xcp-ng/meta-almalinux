# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "syslog-ng"
PV = "4.8.2"
PR = "1.el10_1"
PACKAGES = " \
 syslog-ng \
 syslog-ng-amqp \
 syslog-ng-bigquery \
 syslog-ng-bpf \
 syslog-ng-devel \
 syslog-ng-geoip \
 syslog-ng-grpc \
 syslog-ng-http \
 syslog-ng-kafka \
 syslog-ng-loki \
 syslog-ng-mongodb \
 syslog-ng-opentelemetry \
 syslog-ng-python \
 syslog-ng-python-modules \
 syslog-ng-redis \
 syslog-ng-riemann \
 syslog-ng-slog \
 syslog-ng-snmp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/syslog-ng-4.8.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20ee75fe38eb5d92f8477e9cc183b601b7e8885cc507d3a2dac88fbe489a1200"

URI_x86_64_v2_syslog-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng}"
SRC_URI[x86_64_v2_syslog-ng.sha256sum] = "208376f3d2db4e7cf969501b602b5c70b4624abc2a9230240f87944c46ba2435"
RPROVIDES:syslog-ng:x86_64_v2 = "virtual/syslog"

URI_x86_64_v2_syslog-ng-amqp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-amqp-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-amqp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-amqp}"
SRC_URI[x86_64_v2_syslog-ng-amqp.sha256sum] = "47e2c62b7109ca51cb0cdda9163ff25b2a6d378669be08e58a1b913a543c783d"

URI_x86_64_v2_syslog-ng-bigquery = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-bigquery-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-bigquery;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-bigquery}"
SRC_URI[x86_64_v2_syslog-ng-bigquery.sha256sum] = "6f7bb26f462945379b413942afc770bf9794f6a3b7748d2dd70458a61afc47fd"

URI_x86_64_v2_syslog-ng-bpf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-bpf-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-bpf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-bpf}"
SRC_URI[x86_64_v2_syslog-ng-bpf.sha256sum] = "660b471d163eed114ce9fb5094f130a314a3e2588d786d4d034cbe80f005a4a5"

URI_x86_64_v2_syslog-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-devel-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-devel}"
SRC_URI[x86_64_v2_syslog-ng-devel.sha256sum] = "5fa958f2e654ec97986e6ae967f22f7bd5f8373ff241e31c9b20e80112c86ec3"

URI_x86_64_v2_syslog-ng-geoip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-geoip-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-geoip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-geoip}"
SRC_URI[x86_64_v2_syslog-ng-geoip.sha256sum] = "b3d41dd4915f33bbe1cc48efdd7b0a4b84d396498a874ccaeee3a0473009ba0a"

URI_x86_64_v2_syslog-ng-grpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-grpc-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-grpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-grpc}"
SRC_URI[x86_64_v2_syslog-ng-grpc.sha256sum] = "e30cc36f5f0e3e35b85715bc10e6fbbd23d41ef0233ee8b991c86d176d4f1ace"

URI_x86_64_v2_syslog-ng-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-http-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-http}"
SRC_URI[x86_64_v2_syslog-ng-http.sha256sum] = "2587c905ae50a7647fc4c05e91112866ab30a81d0a3e78f9898a8684bbb2ce23"

URI_x86_64_v2_syslog-ng-kafka = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-kafka-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-kafka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-kafka}"
SRC_URI[x86_64_v2_syslog-ng-kafka.sha256sum] = "87bdeab7401ebff780f9fad4c7179d6bfedee95979f37b5454e950d2e45d01a9"

URI_x86_64_v2_syslog-ng-loki = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-loki-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-loki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-loki}"
SRC_URI[x86_64_v2_syslog-ng-loki.sha256sum] = "e58aed12db1b7fd0a1f043c1a09d83f24c9f1f184db1c21e0d3195e23b3235b9"

URI_x86_64_v2_syslog-ng-mongodb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-mongodb-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-mongodb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-mongodb}"
SRC_URI[x86_64_v2_syslog-ng-mongodb.sha256sum] = "726688670aaa1bb551687419dcc05bd13445811eb6675c85f7608ed972d6bfc9"

URI_x86_64_v2_syslog-ng-opentelemetry = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-opentelemetry-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-opentelemetry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-opentelemetry}"
SRC_URI[x86_64_v2_syslog-ng-opentelemetry.sha256sum] = "b81e357c90494e59eb853bda54ccbc2160af2252acc16cf6cb7e998c571a5e31"

URI_x86_64_v2_syslog-ng-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-python-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-python}"
SRC_URI[x86_64_v2_syslog-ng-python.sha256sum] = "db55479675cc451005f1e84423ec92d083c65502d9431b48e110519e3bf02f1e"

URI_x86_64_v2_syslog-ng-python-modules = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-python-modules-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-python-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-python-modules}"
SRC_URI[x86_64_v2_syslog-ng-python-modules.sha256sum] = "89064547e65310d3b41bfdc09730d42494bcf882c6d5996b447a53f3897ac8ce"

URI_x86_64_v2_syslog-ng-redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-redis-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-redis}"
SRC_URI[x86_64_v2_syslog-ng-redis.sha256sum] = "9c3e24fad56d85f289585d140beb6868aea2b40ebffc712b717d24bc6731a799"

URI_x86_64_v2_syslog-ng-riemann = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-riemann-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-riemann;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-riemann}"
SRC_URI[x86_64_v2_syslog-ng-riemann.sha256sum] = "b623aead2fbc040c48735f90308b87efdd56ce1ce1039142a024f892b92594a2"

URI_x86_64_v2_syslog-ng-slog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-slog-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-slog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-slog}"
SRC_URI[x86_64_v2_syslog-ng-slog.sha256sum] = "740e8add851c67ac1429b654a5a09300f742a5d20da9fb50ecdabad7e6545d05"

URI_x86_64_v2_syslog-ng-snmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syslog-ng-snmp-4.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syslog-ng-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslog-ng-snmp}"
SRC_URI[x86_64_v2_syslog-ng-snmp.sha256sum] = "60d83d405ad8020fb11992b6d8b6f23d6d8b1ec07dfdc49e4fa971e2598e52e6"

URI_aarch64_syslog-ng = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng}"
SRC_URI[aarch64_syslog-ng.sha256sum] = "1a3a1dc553f848ab26e649cf2aa2b317e260233a71989610f16e34a03132aa53"
RPROVIDES:syslog-ng:aarch64 = "virtual/syslog"

URI_aarch64_syslog-ng-amqp = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-amqp-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-amqp;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-amqp}"
SRC_URI[aarch64_syslog-ng-amqp.sha256sum] = "59acbc5a91909c9d51bc89f99413b1811315133ba6aff1925d0fb8a387eb92d8"

URI_aarch64_syslog-ng-bigquery = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-bigquery-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-bigquery;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-bigquery}"
SRC_URI[aarch64_syslog-ng-bigquery.sha256sum] = "35823e4ed7de116e62c756c6802222cb1e7f0510b10d80c26f9229ce3eecf962"

URI_aarch64_syslog-ng-bpf = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-bpf-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-bpf;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-bpf}"
SRC_URI[aarch64_syslog-ng-bpf.sha256sum] = "f7f92c8c9e4decd517b416b2367f38777d3cca43e38a7de554b901ff7f161cfa"

URI_aarch64_syslog-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-devel-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-devel}"
SRC_URI[aarch64_syslog-ng-devel.sha256sum] = "ba05168fbd0790ba1f019d1c554f566426b0c56e8e86f1bb39388daf2e828d06"

URI_aarch64_syslog-ng-geoip = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-geoip-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-geoip;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-geoip}"
SRC_URI[aarch64_syslog-ng-geoip.sha256sum] = "4a5f8d20ade4d1234688277deeae36f5dc1acb36b4632d29a73e2db5586f7dd8"

URI_aarch64_syslog-ng-grpc = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-grpc-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-grpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-grpc}"
SRC_URI[aarch64_syslog-ng-grpc.sha256sum] = "0e6d462867475559c76d3df7a19cf49e3e6a7c9e2278c996844e99f0fee2ff3f"

URI_aarch64_syslog-ng-http = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-http-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-http}"
SRC_URI[aarch64_syslog-ng-http.sha256sum] = "d568eb09dfb9c21c04353b3f9bc887d6772e3d6b06c5b38fa2488a902c90f6ec"

URI_aarch64_syslog-ng-kafka = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-kafka-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-kafka;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-kafka}"
SRC_URI[aarch64_syslog-ng-kafka.sha256sum] = "2a6f508b5c35f8fbf3f7bd29dbe5e38e7e8ec89e538e815564fe358f5f985c01"

URI_aarch64_syslog-ng-loki = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-loki-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-loki;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-loki}"
SRC_URI[aarch64_syslog-ng-loki.sha256sum] = "edb52464e22baab3d83570015462ef317075a410a5a90542a2f6efb5fa193488"

URI_aarch64_syslog-ng-mongodb = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-mongodb-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-mongodb;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-mongodb}"
SRC_URI[aarch64_syslog-ng-mongodb.sha256sum] = "2a7d416d551f624d8180db0f9f57e8276e2b86a74e0492daafcd120e14018c5e"

URI_aarch64_syslog-ng-opentelemetry = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-opentelemetry-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-opentelemetry;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-opentelemetry}"
SRC_URI[aarch64_syslog-ng-opentelemetry.sha256sum] = "41bf2e282eeb9aa15df31edefef0f92d99e8d031497874417ca2df0b57441b10"

URI_aarch64_syslog-ng-python = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-python-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-python}"
SRC_URI[aarch64_syslog-ng-python.sha256sum] = "4eca6deaaa8140468c733b235545ef12e7db2b71d56f0dc485b720c52aa9e645"

URI_aarch64_syslog-ng-python-modules = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-python-modules-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-python-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-python-modules}"
SRC_URI[aarch64_syslog-ng-python-modules.sha256sum] = "571cedb6227849dc2724cbc2105732c60a1f4f0b1691a825f7cb56a1a72784ee"

URI_aarch64_syslog-ng-redis = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-redis-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-redis}"
SRC_URI[aarch64_syslog-ng-redis.sha256sum] = "2b57f76dd0ab9ae52afe642218902af4054598fee9405fb0f8725be1b270f721"

URI_aarch64_syslog-ng-riemann = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-riemann-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-riemann;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-riemann}"
SRC_URI[aarch64_syslog-ng-riemann.sha256sum] = "ec0bdd9f0d3f10311ce5e0afd20f11b11065121acbd9824a026dcb711420f14c"

URI_aarch64_syslog-ng-slog = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-slog-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-slog;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-slog}"
SRC_URI[aarch64_syslog-ng-slog.sha256sum] = "3acd66c7a7b7593e590bb8f375f8a86cd11512a54d1aa666e3d26fcc9a9db686"

URI_aarch64_syslog-ng-snmp = "${EPEL_MIRROR}/aarch64/Packages/s/syslog-ng-snmp-4.8.2-1.el10_1.aarch64.rpm;name=aarch64_syslog-ng-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslog-ng-snmp}"
SRC_URI[aarch64_syslog-ng-snmp.sha256sum] = "1b946c5e50269f7d6107a3729bfc1ffc315e1aa956f67a6b1f49c46f868ebe31"

RDEPENDS:syslog-ng = " \
 bash \
 gawk \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libcap \
 libgcc \
 libnet \
 libstdc++ \
 logrotate \
 openssl-libs \
 pcre2 \
 systemd \
 systemd-libs \
 "
RDEPENDS:syslog-ng-amqp = " \
 glibc \
 librabbitmq \
 syslog-ng \
 "
RDEPENDS:syslog-ng-bigquery = " \
 abseil-cpp \
 c-ares \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 ivykis \
 json-c \
 libcap \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcre2 \
 protobuf \
 re2 \
 syslog-ng \
 syslog-ng-grpc \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:syslog-ng-bpf = " \
 glibc \
 libbpf \
 syslog-ng \
 "
RDEPENDS:syslog-ng-devel = " \
 bash \
 glib2-devel \
 pkgconf-pkg-config \
 python3 \
 syslog-ng \
 "
RDEPENDS:syslog-ng-geoip = " \
 glibc \
 libmaxminddb \
 syslog-ng \
 "
RDEPENDS:syslog-ng-grpc = " \
 abseil-cpp \
 c-ares \
 glibc \
 grpc \
 grpc-cpp \
 libgcc \
 libstdc++ \
 openssl-libs \
 protobuf \
 re2 \
 syslog-ng \
 zlib-ng-compat \
 "
RDEPENDS:syslog-ng-http = " \
 glibc \
 syslog-ng \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:syslog-ng-kafka = " \
 glibc \
 librdkafka \
 syslog-ng \
 "
RDEPENDS:syslog-ng-loki = " \
 abseil-cpp \
 c-ares \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 ivykis \
 json-c \
 libcap \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcre2 \
 protobuf \
 re2 \
 syslog-ng \
 syslog-ng-grpc \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:syslog-ng-mongodb = " \
 glibc \
 libbson \
 mongo-c-driver-libs \
 syslog-ng \
 "
RDEPENDS:syslog-ng-opentelemetry = " \
 abseil-cpp \
 c-ares \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 ivykis \
 json-c \
 libcap \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcre2 \
 protobuf \
 re2 \
 syslog-ng \
 syslog-ng-grpc \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:syslog-ng-python = " \
 glibc \
 ivykis \
 python3-libs \
 syslog-ng \
 "
RDEPENDS:syslog-ng-python-modules = " \
 python3-cachetools \
 python3-certifi \
 python3-charset-normalizer \
 python3-dateutil \
 python3-google-auth \
 python3-idna \
 python3-kubernetes \
 python3-oauthlib \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-rsa \
 python3-six \
 python3-urllib3 \
 python3-websocket-client \
 syslog-ng \
 syslog-ng-python \
 "
RDEPENDS:syslog-ng-redis = " \
 glibc \
 hiredis \
 syslog-ng \
 "
RDEPENDS:syslog-ng-riemann = " \
 glibc \
 riemann-c-client \
 syslog-ng \
 "
RDEPENDS:syslog-ng-slog = " \
 glib2 \
 glibc \
 ivykis \
 json-c \
 libcap \
 openssl-libs \
 pcre2 \
 syslog-ng \
 systemd-libs \
 "
RDEPENDS:syslog-ng-snmp = " \
 glibc \
 net-snmp-libs \
 openssl-libs \
 syslog-ng \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/syslog"

PROVIDES:append:aarch64 = " rpm/virtual/syslog"
