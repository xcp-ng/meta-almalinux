# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xrootd"
PE = "1"
PV = "6.1.1"
PR = "1.el10_3"
PACKAGES = " \
 python3-xrootd \
 xrootd \
 xrootd-client \
 xrootd-client-devel \
 xrootd-client-libs \
 xrootd-devel \
 xrootd-doc \
 xrootd-fuse \
 xrootd-libs \
 xrootd-private-devel \
 xrootd-scitokens \
 xrootd-selinux \
 xrootd-server \
 xrootd-server-devel \
 xrootd-server-libs \
 xrootd-voms \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/x/xrootd-6.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6f386b1ff7408af3211f8405d3ace3463f534818ee7cef33417c0ab8aad73c1c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-xrootd-6.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-xrootd;unpack=0"
SRC_URI[x86_64_v2_python3-xrootd.sha256sum] = "ff061fbabaecd4f9eb2e07df1bafa2464260da62cdf4653f9a71305e3663dbc6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-6.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd;unpack=0"
SRC_URI[x86_64_v2_xrootd.sha256sum] = "0bc0f3ca9b4e23dba94caedef38a966f21985105e9b7b165a5cb611d38199eed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-client-6.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-client;unpack=0"
SRC_URI[x86_64_v2_xrootd-client.sha256sum] = "0a128bd01ff591c81ee82cb4baa7124aa767d78f3f92c499746095fe33170e14"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-client-devel-6.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-client-devel;unpack=0"
SRC_URI[x86_64_v2_xrootd-client-devel.sha256sum] = "345b14355f3056d4a166a123a68d83b2edb8ab1c90355d4ca6f470c9e5a6ae5c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-client-libs-6.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-client-libs;unpack=0"
SRC_URI[x86_64_v2_xrootd-client-libs.sha256sum] = "8f84023360884b33d2a62f360fad8258dbe6ae7a232dc3842e1b7d55fe783c00"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-devel-6.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-devel;unpack=0"
SRC_URI[x86_64_v2_xrootd-devel.sha256sum] = "2318db37bc506201a9bbca875df73790af5fbc8705fef151c2ecf0ba5d33a49a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-doc-6.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_xrootd-doc;unpack=0"
SRC_URI[x86_64_v2_xrootd-doc.sha256sum] = "f6b940e6938f1bb69c9a35992b161e70c83b8720f3cc020ad1be6abea08b682a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-fuse-6.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-fuse;unpack=0"
SRC_URI[x86_64_v2_xrootd-fuse.sha256sum] = "ead60a642e9e344bc6ae05e99a951a204f153d187677be2c352f8db46924c172"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-libs-6.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-libs;unpack=0"
SRC_URI[x86_64_v2_xrootd-libs.sha256sum] = "9ce6c4d41d04182199fb1c47225aa57ad268f85496b5e5874febb512ddfc5d9d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-private-devel-6.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-private-devel;unpack=0"
SRC_URI[x86_64_v2_xrootd-private-devel.sha256sum] = "d3108c85cc17b5c4fc611bae230d8428d5aed1a83c7e31e7a5440e9ecc6d6d57"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-scitokens-6.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-scitokens;unpack=0"
SRC_URI[x86_64_v2_xrootd-scitokens.sha256sum] = "69287f0d301929dd40e0f3081b2be82ae1807a639573c57fd149cd13c8fcd9d7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-selinux-6.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_xrootd-selinux;unpack=0"
SRC_URI[x86_64_v2_xrootd-selinux.sha256sum] = "0af1296b2173fddba2df75bf1a59c1a80187c554125550194c0f4963f35643e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-server-6.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-server;unpack=0"
SRC_URI[x86_64_v2_xrootd-server.sha256sum] = "e2a07ecb2c6698d5340d32b588a2aca56f6910e341ef5399ba9600cb1bf0d93d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-server-devel-6.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-server-devel;unpack=0"
SRC_URI[x86_64_v2_xrootd-server-devel.sha256sum] = "71b7116608fdb5a10f5bc4508e5dc7c65426786b8e8ab141b29a13ee71ec835a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-server-libs-6.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-server-libs;unpack=0"
SRC_URI[x86_64_v2_xrootd-server-libs.sha256sum] = "6e10e70b5bd913e40c6c1c5549ee3b71f40047b30e14c4d034ab7628aed72e86"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-voms-6.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-voms;unpack=0"
SRC_URI[x86_64_v2_xrootd-voms.sha256sum] = "a64aeed0b20d98575395aaf885ad270b90f17c89fb8d5e455a44aabcd9ca67eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-xrootd-6.1.1-1.el10_3.aarch64.rpm;name=aarch64_python3-xrootd;unpack=0"
SRC_URI[aarch64_python3-xrootd.sha256sum] = "cb42507d32a1ac4d7bdb7d92b527ba92e0b78984bf300e9fd385d1c6091fd943"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-6.1.1-1.el10_3.aarch64.rpm;name=aarch64_xrootd;unpack=0"
SRC_URI[aarch64_xrootd.sha256sum] = "c5a8cf201aab069ff89eb5f9e305609f8530969834c516ff5a722f6a95c1bf57"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-client-6.1.1-1.el10_3.aarch64.rpm;name=aarch64_xrootd-client;unpack=0"
SRC_URI[aarch64_xrootd-client.sha256sum] = "6a1872f0138b847e7b19189926cf0fa0461631a01be7f4be8251243fc1acea36"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-client-devel-6.1.1-1.el10_3.aarch64.rpm;name=aarch64_xrootd-client-devel;unpack=0"
SRC_URI[aarch64_xrootd-client-devel.sha256sum] = "ba1abb3d0f330b5743a7982442c9fc483927689f2c1f82e7bf60f21464d962a3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-client-libs-6.1.1-1.el10_3.aarch64.rpm;name=aarch64_xrootd-client-libs;unpack=0"
SRC_URI[aarch64_xrootd-client-libs.sha256sum] = "8aa468f815a517f0a2478c9fce8d6d63969b3c82ab49339111d07091347df36f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-devel-6.1.1-1.el10_3.aarch64.rpm;name=aarch64_xrootd-devel;unpack=0"
SRC_URI[aarch64_xrootd-devel.sha256sum] = "f9275bb8bf02b7e2ace7f5c9ed497c3b17b240f36ee7b9590d47a5c24c3af31d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-doc-6.1.1-1.el10_3.noarch.rpm;name=aarch64_xrootd-doc;unpack=0"
SRC_URI[aarch64_xrootd-doc.sha256sum] = "3b37edeebaa7bd4acb5b1399f343fbb45c76dfd586acd366a48cd55f4aa50d8b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-fuse-6.1.1-1.el10_3.aarch64.rpm;name=aarch64_xrootd-fuse;unpack=0"
SRC_URI[aarch64_xrootd-fuse.sha256sum] = "d2ac36232322bbf0fd0c3792e68b0596401855ea3f8d466fb3f4b850ce1b082c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-libs-6.1.1-1.el10_3.aarch64.rpm;name=aarch64_xrootd-libs;unpack=0"
SRC_URI[aarch64_xrootd-libs.sha256sum] = "1ea17a9830ea060f4a0558600aa7ab9d27849b2585c2922359e2c2b5c445ecc8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-private-devel-6.1.1-1.el10_3.aarch64.rpm;name=aarch64_xrootd-private-devel;unpack=0"
SRC_URI[aarch64_xrootd-private-devel.sha256sum] = "e85dd16f9ff30554dca011e860cd96f736e6a6aba1a6d4bd1d4d422ef51603be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-scitokens-6.1.1-1.el10_3.aarch64.rpm;name=aarch64_xrootd-scitokens;unpack=0"
SRC_URI[aarch64_xrootd-scitokens.sha256sum] = "1ee881578dc8844db7fabfd723b7c3811d892036adfce59819b3dd259ddae75e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-selinux-6.1.1-1.el10_3.noarch.rpm;name=aarch64_xrootd-selinux;unpack=0"
SRC_URI[aarch64_xrootd-selinux.sha256sum] = "a589f028970269e18e183249e2a82617b2bfd77f73926f17cbfe81195c0b2aa6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-server-6.1.1-1.el10_3.aarch64.rpm;name=aarch64_xrootd-server;unpack=0"
SRC_URI[aarch64_xrootd-server.sha256sum] = "a8f365dc6bb3bbe3a683c3dc924aaa30c446d1c188870e0c78c1ec2369759b02"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-server-devel-6.1.1-1.el10_3.aarch64.rpm;name=aarch64_xrootd-server-devel;unpack=0"
SRC_URI[aarch64_xrootd-server-devel.sha256sum] = "86ea0180c584a3364486d3df736c81bbe5b40e84bd43d530236ae433fd660a08"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-server-libs-6.1.1-1.el10_3.aarch64.rpm;name=aarch64_xrootd-server-libs;unpack=0"
SRC_URI[aarch64_xrootd-server-libs.sha256sum] = "cc6c79f4a748d4ab9c3329132cc6a0d521e9b65f15149be2963f0ecd4ee71b07"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-voms-6.1.1-1.el10_3.aarch64.rpm;name=aarch64_xrootd-voms;unpack=0"
SRC_URI[aarch64_xrootd-voms.sha256sum] = "c0c009fdfa60bb89b211c829a351b286523a9fc3c9edd7473b7bdb9ccf98caf8"

RDEPENDS:python3-xrootd = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:xrootd = " \
 xrootd-selinux \
 xrootd-server \
 "
RDEPENDS:xrootd-client = " \
 glibc \
 libgcc \
 libstdc++ \
 readline \
 xrootd-client-libs \
 xrootd-libs \
 zlib-ng-compat \
 "
RDEPENDS:xrootd-client-devel = " \
 xrootd-client-libs \
 xrootd-devel \
 "
RDEPENDS:xrootd-client-libs = " \
 glibc \
 isa-l \
 libgcc \
 libstdc++ \
 libuuid \
 openssl-libs \
 tinyxml \
 virtual/libcurl.so.4___64bit_ \
 xrootd-libs \
 zlib-ng-compat \
 "
RDEPENDS:xrootd-devel = " \
 bash \
 cmake-filesystem \
 xrootd-libs \
 "
RDEPENDS:xrootd-doc = " \
 "
RDEPENDS:xrootd-fuse = " \
 fuse \
 fuse-libs \
 glibc \
 libgcc \
 libstdc++ \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:xrootd-libs = " \
 glibc \
 krb5-libs \
 libcom_err \
 libgcc \
 libstdc++ \
 libxcrypt \
 libxml2 \
 openssl-libs \
 systemd-libs \
 tinyxml \
 zlib-ng-compat \
 "
RDEPENDS:xrootd-private-devel = " \
 xrootd-client-devel \
 xrootd-client-libs \
 xrootd-devel \
 xrootd-server-devel \
 "
RDEPENDS:xrootd-scitokens = " \
 glibc \
 libgcc \
 libstdc++ \
 scitokens-cpp \
 xrootd-libs \
 xrootd-server \
 "
RDEPENDS:xrootd-selinux = " \
 bash \
 policycoreutils \
 selinux-policy \
 "
RDEPENDS:xrootd-server = " \
 bash \
 expect \
 glibc \
 libgcc \
 libstdc++ \
 logrotate \
 perl-Exporter \
 perl-IO \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-Socket \
 perl-interpreter \
 readline \
 shadow-utils \
 systemd \
 xrootd-client-libs \
 xrootd-libs \
 xrootd-server-libs \
 "
RDEPENDS:xrootd-server-devel = " \
 xrootd-client-devel \
 xrootd-devel \
 xrootd-server-libs \
 "
RDEPENDS:xrootd-server-libs = " \
 glibc \
 json-c \
 libgcc \
 libmacaroons \
 libstdc++ \
 libuuid \
 libzip \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:xrootd-voms = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 voms \
 xrootd-libs \
 "
