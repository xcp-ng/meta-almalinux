# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf"
PV = "0.11.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-phf+default-devel \
 rust-phf+macros-devel \
 rust-phf+phf_macros-devel \
 rust-phf+serde-devel \
 rust-phf+std-devel \
 rust-phf+uncased-devel \
 rust-phf+unicase-devel \
 rust-phf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf-0.11.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9d6b59edcd0256f34ec47c29dee2bd4891a614dbe3b4f6afb55f61afa702c54"

URI_x86_64_v2_rust-phf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+default-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+default-devel}"
SRC_URI[x86_64_v2_rust-phf+default-devel.sha256sum] = "73e3d45aa68d66b70c40f10997c7e41240b3de6b8f9dc47dabd1a64195097e15"

URI_x86_64_v2_rust-phf+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+macros-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+macros-devel}"
SRC_URI[x86_64_v2_rust-phf+macros-devel.sha256sum] = "ae1129f0a854135dc07afb60b401bee00ff609ddd2cb5217e42d4bdfe09cbb25"

URI_x86_64_v2_rust-phf+phf_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+phf_macros-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+phf_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+phf_macros-devel}"
SRC_URI[x86_64_v2_rust-phf+phf_macros-devel.sha256sum] = "ba17a80ecf4fd79845d77beff9c4b87546af3f52f594c58596c6e3671c1190c9"

URI_x86_64_v2_rust-phf+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+serde-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+serde-devel}"
SRC_URI[x86_64_v2_rust-phf+serde-devel.sha256sum] = "42ed182b533f0e5d4f5ede58808bf743e23186629b2106a1fe752296394828c5"

URI_x86_64_v2_rust-phf+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+std-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+std-devel}"
SRC_URI[x86_64_v2_rust-phf+std-devel.sha256sum] = "7439b7b34e6a3f0631b16876e6a2e704c881beaee432c7e198a0b1ac54228fd5"

URI_x86_64_v2_rust-phf+uncased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+uncased-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+uncased-devel}"
SRC_URI[x86_64_v2_rust-phf+uncased-devel.sha256sum] = "f942622b1a7cb796b751513dc907205cc09dd8cf15c6c2393bddea8375ed1278"

URI_x86_64_v2_rust-phf+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+unicase-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+unicase-devel}"
SRC_URI[x86_64_v2_rust-phf+unicase-devel.sha256sum] = "7b1b8d3edd8838bd8c57ac9e9641409d1fb74030e97e1bca222c0fc0d6ae9945"

URI_x86_64_v2_rust-phf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf-devel}"
SRC_URI[x86_64_v2_rust-phf-devel.sha256sum] = "116d467721630039079be525b71119f4307550d529ecd1bf622a875db748effc"

URI_aarch64_rust-phf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+default-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+default-devel}"
SRC_URI[aarch64_rust-phf+default-devel.sha256sum] = "a425ec4e98045e19b461ad32fe95dbb469041e4a5308b6057a28e7e499f5af30"

URI_aarch64_rust-phf+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+macros-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+macros-devel}"
SRC_URI[aarch64_rust-phf+macros-devel.sha256sum] = "9f7721d3669245ff566b091db6efe6a4022f8be28b859b95e7b33833b6e1e559"

URI_aarch64_rust-phf+phf_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+phf_macros-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf+phf_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+phf_macros-devel}"
SRC_URI[aarch64_rust-phf+phf_macros-devel.sha256sum] = "a8a6fa802c0ea054d4eee814a9ae2d4abd68efcf5180f23a417b5f17867bb59e"

URI_aarch64_rust-phf+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+serde-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+serde-devel}"
SRC_URI[aarch64_rust-phf+serde-devel.sha256sum] = "e806163fa3f4253ba286afc47bf0466a1712d454a125abefdce8318deebcb789"

URI_aarch64_rust-phf+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+std-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+std-devel}"
SRC_URI[aarch64_rust-phf+std-devel.sha256sum] = "1f3a085a709d89c363162d9f5822363dc47e84de672013f3cad8e6bcd2890dc3"

URI_aarch64_rust-phf+uncased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+uncased-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+uncased-devel}"
SRC_URI[aarch64_rust-phf+uncased-devel.sha256sum] = "8efbba534675a88112e7234ae3840cece19944b4413e6f0f673acf5299eecea1"

URI_aarch64_rust-phf+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+unicase-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+unicase-devel}"
SRC_URI[aarch64_rust-phf+unicase-devel.sha256sum] = "4cb08fca4259b13f9f6a0883d69750bbe6ca905b9333b745b613a09b83ba4792"

URI_aarch64_rust-phf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf-devel}"
SRC_URI[aarch64_rust-phf-devel.sha256sum] = "226f3e1ae68ef5a0015222453753b4e341069235eec0ce9f673a30d9dbc06393"

RDEPENDS:rust-phf+default-devel = " \
 cargo \
 rust-phf+std-devel \
 rust-phf-devel \
 "
RDEPENDS:rust-phf+macros-devel = " \
 cargo \
 rust-phf+phf_macros-devel \
 rust-phf-devel \
 "
RDEPENDS:rust-phf+phf_macros-devel = " \
 cargo \
 rust-phf-devel \
 rust-phf_macros+default-devel \
 "
RDEPENDS:rust-phf+serde-devel = " \
 cargo \
 rust-phf-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-phf+std-devel = " \
 cargo \
 rust-phf-devel \
 rust-phf_shared+std-devel \
 "
RDEPENDS:rust-phf+uncased-devel = " \
 cargo \
 rust-phf-devel \
 rust-phf_shared+uncased-devel \
 "
RDEPENDS:rust-phf+unicase-devel = " \
 cargo \
 rust-phf-devel \
 rust-phf_macros+default-devel \
 rust-phf_macros+unicase-devel \
 rust-phf_shared+unicase-devel \
 "
RDEPENDS:rust-phf-devel = " \
 cargo \
 rust \
 rust-phf_shared-devel \
 "
