# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firejail"
PV = "0.9.76"
PR = "1.el10_0"
PACKAGES = " \
 firejail \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/firejail-0.9.76-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "960127ad46ea618e709197ba0b5d955538cb000dfc931a4512cab85a6a9fb390"

URI_x86_64_v2_firejail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/firejail-0.9.76-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_firejail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firejail}"
SRC_URI[x86_64_v2_firejail.sha256sum] = "9291c453c7e1acdef5cd18dd6d82bbdf407c91d5a13c9202a1e69bd71a6ca495"

URI_aarch64_firejail = "${EPEL_MIRROR}/aarch64/Packages/f/firejail-0.9.76-1.el10_0.aarch64.rpm;name=aarch64_firejail;unpack=0"
SRC_URI:append = " ${URI_aarch64_firejail}"
SRC_URI[aarch64_firejail.sha256sum] = "ee2cead07b0191742b07f4b15ea8fa7cf6313904d2be37823b21d4f48e95febb"

RDEPENDS:firejail = " \
 bash \
 glibc \
 libselinux \
 python3 \
 xdg-dbus-proxy \
 "
