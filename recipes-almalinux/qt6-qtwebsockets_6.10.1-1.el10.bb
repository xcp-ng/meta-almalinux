# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtwebsockets"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtwebsockets \
 qt6-qtwebsockets-devel \
 qt6-qtwebsockets-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtwebsockets-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e52bf773747e53cd30913e6308d0db482965bb53e524e0a7ab4dd216b05eef3f"

URI_x86_64_v2_qt6-qtwebsockets = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwebsockets-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebsockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebsockets}"
SRC_URI[x86_64_v2_qt6-qtwebsockets.sha256sum] = "1f60b99dc2d3a1fc3833492358862828aebfd8c03694f2077fd82e8d2beeaaab"

URI_x86_64_v2_qt6-qtwebsockets-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwebsockets-devel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebsockets-devel}"
SRC_URI[x86_64_v2_qt6-qtwebsockets-devel.sha256sum] = "23150374606d3a188cf649eedac144ad60b1b8fbbbc468ae50333427952af387"

URI_x86_64_v2_qt6-qtwebsockets-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtwebsockets-examples-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebsockets-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebsockets-examples}"
SRC_URI[x86_64_v2_qt6-qtwebsockets-examples.sha256sum] = "2dda9c64de2214a0335ce23869e0780eb94c5372cc7979e984dd9550d3720159"

URI_aarch64_qt6-qtwebsockets = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwebsockets-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtwebsockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebsockets}"
SRC_URI[aarch64_qt6-qtwebsockets.sha256sum] = "9e911057fd6d7e2f86da9a097a6fd0742d8ef45cd55e450ddfb80f0afcf31b20"

URI_aarch64_qt6-qtwebsockets-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwebsockets-devel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebsockets-devel}"
SRC_URI[aarch64_qt6-qtwebsockets-devel.sha256sum] = "d46b4fdfcacfab59fd7300d67adaa514f48b959bc9e1d42baf636290eefcc5bc"

URI_aarch64_qt6-qtwebsockets-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtwebsockets-examples-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtwebsockets-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebsockets-examples}"
SRC_URI[aarch64_qt6-qtwebsockets-examples.sha256sum] = "5570228fa156f3568731883d263b6e637b82b9367ce75f2df54d1e08ede2eda5"

RDEPENDS:qt6-qtwebsockets = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtwebsockets-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 "
RDEPENDS:qt6-qtwebsockets-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 "
