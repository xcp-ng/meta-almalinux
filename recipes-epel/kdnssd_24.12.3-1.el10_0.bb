# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdnssd"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kdnssd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdnssd-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc57fbe299f82398cd8bcc64bc12dfb06a2c5812063c0f4bccd9a8fef21961c6"

URI_x86_64_v2_kdnssd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdnssd-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdnssd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdnssd}"
SRC_URI[x86_64_v2_kdnssd.sha256sum] = "333cf60c52b6bc041aedbec97ab1494bc485d5b888d8ca43a6f38416ec98ee61"

URI_aarch64_kdnssd = "${EPEL_MIRROR}/aarch64/Packages/k/kdnssd-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kdnssd;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdnssd}"
SRC_URI[aarch64_kdnssd.sha256sum] = "c1e036add1a2d64dfba9f9476ca50468e60ba156af7480d1ea312c35fa028fb4"

RDEPENDS:kdnssd = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 "
