# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "khealthcertificate"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 khealthcertificate \
 khealthcertificate-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/khealthcertificate-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9f32a02ee07ca41c10ee5a88b25b4cee3841a0676519c51974e73272b02ae094"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khealthcertificate-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khealthcertificate;unpack=0"
SRC_URI[x86_64_v2_khealthcertificate.sha256sum] = "127c22a0b602e784ab2a92ddffa3b90dac7c150b235bd6e315589eccb4bb5ed5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khealthcertificate-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khealthcertificate-devel;unpack=0"
SRC_URI[x86_64_v2_khealthcertificate-devel.sha256sum] = "80e7d48946a4f2f9bc093680c2bb1e2f1d040f13be0f974f75d40c5d76968634"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/khealthcertificate-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_khealthcertificate;unpack=0"
SRC_URI[aarch64_khealthcertificate.sha256sum] = "0d04e377fc4acf55a7da8a7185245d7831e0b315df101167558e62c71fdf5445"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/khealthcertificate-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_khealthcertificate-devel;unpack=0"
SRC_URI[aarch64_khealthcertificate-devel.sha256sum] = "bdf78d1f4af68b5c59d26a2afdaaa053936a93c5ff032253909dc950d7a78be6"

RDEPENDS:khealthcertificate = " \
 glibc \
 kf6-karchive \
 kf6-kcodecs \
 kf6-ki18n \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtdeclarative \
 zlib-ng-compat \
 "
RDEPENDS:khealthcertificate-devel = " \
 cmake-filesystem \
 khealthcertificate \
 "
