# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ragel"
PV = "7.0.4"
PR = "8.el10_2"
PACKAGES = " \
 ragel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/ragel-7.0.4-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78363844f6375c921484f109d776b283295a8ec8835273828c4177ee69686ec3"

URI_x86_64_v2_ragel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ragel-7.0.4-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ragel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ragel}"
SRC_URI[x86_64_v2_ragel.sha256sum] = "269959d7d9fbe514ee2e3539c8747133d371886695ca52f277797b99d073203a"

URI_aarch64_ragel = "${EPEL_MIRROR}/aarch64/Packages/r/ragel-7.0.4-8.el10_2.aarch64.rpm;name=aarch64_ragel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ragel}"
SRC_URI[aarch64_ragel.sha256sum] = "01a55822e2094574d62079d695a49adfa68a1662a21e294a7fb6c250cac13f94"

RDEPENDS:ragel = " \
 colm \
 colm-devel \
 glibc \
 libgcc \
 libstdc++ \
 "
