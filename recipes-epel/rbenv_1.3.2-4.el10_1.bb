# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rbenv"
PV = "1.3.2"
PR = "4.el10_1"
PACKAGES = " \
 rbenv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rbenv-1.3.2-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c774dbb48fdc0c9e3ac3b40854a6cd56407f6fb3e0c65cb2bf622fc514e66d1"

URI_x86_64_v2_rbenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rbenv-1.3.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rbenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rbenv}"
SRC_URI[x86_64_v2_rbenv.sha256sum] = "294e2c0ebafec7c202600fbc26eb91b2629698da241183310860bb84af0d502f"

URI_aarch64_rbenv = "${EPEL_MIRROR}/aarch64/Packages/r/rbenv-1.3.2-4.el10_1.noarch.rpm;name=aarch64_rbenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_rbenv}"
SRC_URI[aarch64_rbenv.sha256sum] = "717f09032d6be8fa9997d13e7b2200697c364d547ea6207b46fb6b8dd31e58cc"

RDEPENDS:rbenv = " \
 bash \
 gawk \
 "
