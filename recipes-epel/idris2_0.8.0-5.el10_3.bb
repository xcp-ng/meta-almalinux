# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "idris2"
PV = "0.8.0"
PR = "5.el10_3"
PACKAGES = " \
 idris2 \
 idris2-doc \
 idris2-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/idris2-0.8.0-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78efc7b60f2786f6060fb8704abaaba540baf940893a5b292090bec4dc31b0c1"

URI_x86_64_v2_idris2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/idris2-0.8.0-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_idris2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idris2}"
SRC_URI[x86_64_v2_idris2.sha256sum] = "83a329ac586a6219e73a84446a61eccff1d95463f313ab84416625873a1048a1"

URI_x86_64_v2_idris2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/idris2-doc-0.8.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_idris2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idris2-doc}"
SRC_URI[x86_64_v2_idris2-doc.sha256sum] = "bc074333ca2bf3c90385d7c15e56396b2c46c767408d1ca3a2b21b3c31c7205e"

URI_x86_64_v2_idris2-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/idris2-libs-0.8.0-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_idris2-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idris2-libs}"
SRC_URI[x86_64_v2_idris2-libs.sha256sum] = "d2adc1117d736a7ac5f3f9696062cd60ccd2414e1ed3b92fdec819a8efe2d261"

URI_aarch64_idris2 = "${EPEL_MIRROR}/aarch64/Packages/i/idris2-0.8.0-5.el10_3.aarch64.rpm;name=aarch64_idris2;unpack=0"
SRC_URI:append = " ${URI_aarch64_idris2}"
SRC_URI[aarch64_idris2.sha256sum] = "95aeceea35ead08ba81f9b328eea437f69fd5a8d96ecec8c2d9797a62e58d8a9"

URI_aarch64_idris2-doc = "${EPEL_MIRROR}/aarch64/Packages/i/idris2-doc-0.8.0-5.el10_3.noarch.rpm;name=aarch64_idris2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_idris2-doc}"
SRC_URI[aarch64_idris2-doc.sha256sum] = "89bbd2490c154fddcb013ef3fbda9614a5f21dd8067691c23bd0e680b2769a18"

URI_aarch64_idris2-libs = "${EPEL_MIRROR}/aarch64/Packages/i/idris2-libs-0.8.0-5.el10_3.aarch64.rpm;name=aarch64_idris2-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_idris2-libs}"
SRC_URI[aarch64_idris2-libs.sha256sum] = "035b756ee29532b181866aa6e805f2049649d51dbeb59997262d2be470a8ad87"

RDEPENDS:idris2 = " \
 chez-scheme \
 idris2-libs \
 "
RDEPENDS:idris2-doc = " \
 fontawesome4-fonts \
 "
RDEPENDS:idris2-libs = " \
 glibc \
 "
