# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-probe"
PV = "0.5.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-probe+default-devel \
 rust-probe-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-probe-0.5.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0924d31338da38ed0f3e7e1d2e0656e3aee7fbb56ce5a09ec4a5a9334cd135d"

URI_x86_64_v2_rust-probe+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-probe+default-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-probe+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-probe+default-devel}"
SRC_URI[x86_64_v2_rust-probe+default-devel.sha256sum] = "1d3f55ee17092892731f3dc455873f3ed347a686034cbd40b7dba349ea311627"

URI_x86_64_v2_rust-probe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-probe-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-probe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-probe-devel}"
SRC_URI[x86_64_v2_rust-probe-devel.sha256sum] = "ca7b6cd4a17431db6bf08eae6dc8bd8a7a981d9b5c37c17fcc8c59d01b45ccb0"

URI_aarch64_rust-probe+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-probe+default-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-probe+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-probe+default-devel}"
SRC_URI[aarch64_rust-probe+default-devel.sha256sum] = "8ffa4e6626751c0523b3a788ec6726c2410bfcc4e8f13ddd9fc38abc6d786cff"

URI_aarch64_rust-probe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-probe-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-probe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-probe-devel}"
SRC_URI[aarch64_rust-probe-devel.sha256sum] = "ce9ba22ff37ca15ec280ce47f53095eb9ed96253baea79f32294f73cfe21fdf7"

RDEPENDS:rust-probe+default-devel = " \
 cargo \
 rust-probe-devel \
 "
RDEPENDS:rust-probe-devel = " \
 cargo \
 rust \
 "
