# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linkchecker"
PV = "10.5.0"
PR = "1.el10_0"
PACKAGES = " \
 linkchecker \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/linkchecker-10.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a90651d65fdd59afb7ec8446d74a6078ba40f3ff9da3c3d193d01d00d6cd9254"

URI_x86_64_v2_linkchecker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/linkchecker-10.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_linkchecker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linkchecker}"
SRC_URI[x86_64_v2_linkchecker.sha256sum] = "930e6fe4a2ad8366c602373652f2184c4ae31aae66f788e2acc68cc51dc17641"

URI_aarch64_linkchecker = "${EPEL_MIRROR}/aarch64/Packages/l/linkchecker-10.5.0-1.el10_0.noarch.rpm;name=aarch64_linkchecker;unpack=0"
SRC_URI:append = " ${URI_aarch64_linkchecker}"
SRC_URI[aarch64_linkchecker.sha256sum] = "682774c27e57ef75391940b9ffadd5cef0d96c471d8c8596ba4765d76e4f7812"

RDEPENDS:linkchecker = " \
 bash \
 python3 \
 python3-beautifulsoup4 \
 python3-dns \
 python3-requests \
 "
