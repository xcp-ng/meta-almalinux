# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mitchellh-copystructure"
PV = "1.2.0"
PR = "4.el10_0"
PACKAGES = " \
 golang-github-mitchellh-copystructure-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-mitchellh-copystructure-1.2.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d5f53b7a43809c4cc6249b374d2e4c26566549d23d93bc7c74eaf08288dd336"

URI_x86_64_v2_golang-github-mitchellh-copystructure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-mitchellh-copystructure-devel-1.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-mitchellh-copystructure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-mitchellh-copystructure-devel}"
SRC_URI[x86_64_v2_golang-github-mitchellh-copystructure-devel.sha256sum] = "dddc0b6901ee52f7592285a5433f077af3c7f9fc7c79434f0b3c6ebfc828417a"

URI_aarch64_golang-github-mitchellh-copystructure-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mitchellh-copystructure-devel-1.2.0-4.el10_0.noarch.rpm;name=aarch64_golang-github-mitchellh-copystructure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mitchellh-copystructure-devel}"
SRC_URI[aarch64_golang-github-mitchellh-copystructure-devel.sha256sum] = "e9ed8366e2fc54e065b47e06c20dc5111c6c88b6623e6ae67ae708f4c41f4537"

RDEPENDS:golang-github-mitchellh-copystructure-devel = " \
 go-filesystem \
 golang-github-mitchellh-reflectwalk-devel \
 "
