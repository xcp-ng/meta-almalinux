# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-get-size-derive2"
PV = "0.7.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-get-size-derive2+default-devel \
 rust-get-size-derive2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-get-size-derive2-0.7.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eda8f17b2ba243dd710c2d604e74ade0d38b6bd8f6c726d7c1bab70a6a32ac66"

URI_x86_64_v2_rust-get-size-derive2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size-derive2+default-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size-derive2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size-derive2+default-devel}"
SRC_URI[x86_64_v2_rust-get-size-derive2+default-devel.sha256sum] = "17b87e269ce4f29c225c80846e075ae0a9ead512389a278966a26335a353a891"

URI_x86_64_v2_rust-get-size-derive2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size-derive2-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size-derive2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size-derive2-devel}"
SRC_URI[x86_64_v2_rust-get-size-derive2-devel.sha256sum] = "6754603e32c06dbb6749c639665fe510e467df90514a1ba0c654385cf31a7de1"

URI_aarch64_rust-get-size-derive2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size-derive2+default-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size-derive2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size-derive2+default-devel}"
SRC_URI[aarch64_rust-get-size-derive2+default-devel.sha256sum] = "14406e1ea1e58ed474d661152b3cc80fd808006e4fe1b603f3200bc2dce6ea3a"

URI_aarch64_rust-get-size-derive2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size-derive2-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size-derive2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size-derive2-devel}"
SRC_URI[aarch64_rust-get-size-derive2-devel.sha256sum] = "d6e6e13fb9a4f40950ebeda222f64ac9d298f4ff2de44173fdfa5003f1600dac"

RDEPENDS:rust-get-size-derive2+default-devel = " \
 cargo \
 rust-get-size-derive2-devel \
 "
RDEPENDS:rust-get-size-derive2-devel = " \
 cargo \
 rust-attribute-derive+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 "
