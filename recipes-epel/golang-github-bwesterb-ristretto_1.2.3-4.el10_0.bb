# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-bwesterb-ristretto"
PV = "1.2.3"
PR = "4.el10_0"
PACKAGES = " \
 golang-github-bwesterb-ristretto-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-bwesterb-ristretto-1.2.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6115d8f36583f8fbb29a60d2552c602e34ba1c8f786f3a4cd52bbd04dc445c7"

URI_x86_64_v2_golang-github-bwesterb-ristretto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-bwesterb-ristretto-devel-1.2.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-bwesterb-ristretto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-bwesterb-ristretto-devel}"
SRC_URI[x86_64_v2_golang-github-bwesterb-ristretto-devel.sha256sum] = "d4197a476214728a2036c8c221c0b2a922e3b1e65087c1ed551fc8751e9f40c7"

URI_aarch64_golang-github-bwesterb-ristretto-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-bwesterb-ristretto-devel-1.2.3-4.el10_0.noarch.rpm;name=aarch64_golang-github-bwesterb-ristretto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-bwesterb-ristretto-devel}"
SRC_URI[aarch64_golang-github-bwesterb-ristretto-devel.sha256sum] = "57b809365aaa22ca283868e63993daa23b09706094a5555d492f5045ac124d2d"

RDEPENDS:golang-github-bwesterb-ristretto-devel = " \
 go-filesystem \
 "
