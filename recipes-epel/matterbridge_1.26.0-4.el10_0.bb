# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "matterbridge"
PV = "1.26.0"
PR = "4.el10_0"
PACKAGES = " \
 matterbridge \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/matterbridge-1.26.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e154fb09712b077940dd47033e44c47ba794ec01bb0d0d7c7cf2479caca384ad"

URI_x86_64_v2_matterbridge = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/matterbridge-1.26.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_matterbridge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_matterbridge}"
SRC_URI[x86_64_v2_matterbridge.sha256sum] = "b7be5afa2df613363eb1804d1ccc600da255183f642a5f3be9f476969680da97"

URI_aarch64_matterbridge = "${EPEL_MIRROR}/aarch64/Packages/m/matterbridge-1.26.0-4.el10_0.aarch64.rpm;name=aarch64_matterbridge;unpack=0"
SRC_URI:append = " ${URI_aarch64_matterbridge}"
SRC_URI[aarch64_matterbridge.sha256sum] = "0a77595221e5739a2f90d438c933593b14e466ed6e276f5bf2fbf8e327cfd48f"

RDEPENDS:matterbridge = " \
 bash \
 glibc \
 "
