# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "s3cmd"
PV = "2.4.0"
PR = "5.el10_1"
PACKAGES = " \
 s3cmd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/s3cmd-2.4.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6cd43a47c601fd73c35c936340ee4ce5763d438174b634208c145b85196a6d1"

URI_x86_64_v2_s3cmd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/s3cmd-2.4.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_s3cmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_s3cmd}"
SRC_URI[x86_64_v2_s3cmd.sha256sum] = "c747202a327f3a348c80b44d0792a8f6dc15fd6eb91b48945a9ddfc6330d099d"

URI_aarch64_s3cmd = "${EPEL_MIRROR}/aarch64/Packages/s/s3cmd-2.4.0-5.el10_1.noarch.rpm;name=aarch64_s3cmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_s3cmd}"
SRC_URI[aarch64_s3cmd.sha256sum] = "7a4ee50db02047dde31d32485bff8acb9ae205f5cb512859ac13c39266d3f5ce"

RDEPENDS:s3cmd = " \
 python3 \
 python3-dateutil \
 python3-file-magic \
 "
