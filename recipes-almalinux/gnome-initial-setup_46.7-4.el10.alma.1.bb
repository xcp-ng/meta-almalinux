# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-initial-setup"
PV = "46.7"
PR = "4.el10.alma.1"
PACKAGES = " \
 gnome-initial-setup \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-initial-setup-46.7-4.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8b70458f5f30f2bbfb10c4fe662c501c154b24874c2463c6bb4455400cbaf0e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-initial-setup-46.7-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gnome-initial-setup;unpack=0"
SRC_URI[x86_64_v2_gnome-initial-setup.sha256sum] = "f91d031327912f1b48342a68680d4297efe4b34beae694e3e20fd7b07cd87846"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-initial-setup-46.7-4.el10.alma.1.aarch64.rpm;name=aarch64_gnome-initial-setup;unpack=0"
SRC_URI[aarch64_gnome-initial-setup.sha256sum] = "4404c23688f0c4de7ac37cc1d83186a13e806a91003073fdff370243d6377f8c"

RDEPENDS:gnome-initial-setup = " \
 NetworkManager-libnm \
 accountsservice-libs \
 bash \
 fontconfig \
 gdk-pixbuf2 \
 gdm \
 geoclue2-libs \
 geocode-glib \
 glib2 \
 glibc \
 gnome-desktop4 \
 gtk4 \
 harfbuzz \
 ibus-libs \
 krb5-libs \
 libadwaita \
 libgcc \
 libgweather \
 libnma-gtk4 \
 libpwquality \
 libsecret \
 pango \
 polkit \
 polkit-libs \
 shadow-utils \
 tecla \
 "
