# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-freeipa"
PV = "1.0.8"
PR = "1.el10_3"
PACKAGES = " \
 python3-freeipa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-freeipa-1.0.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8fdb556314181757b725dc24b4f35d12fa3c64847051a861ce016cd14157b39"

URI_x86_64_v2_python3-freeipa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-freeipa-1.0.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-freeipa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-freeipa}"
SRC_URI[x86_64_v2_python3-freeipa.sha256sum] = "675314424e4e0c5db8f508daf66e4265fe45aeae54b7519adecf9f283c2b9ba5"

URI_aarch64_python3-freeipa = "${EPEL_MIRROR}/aarch64/Packages/p/python3-freeipa-1.0.8-1.el10_3.noarch.rpm;name=aarch64_python3-freeipa;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-freeipa}"
SRC_URI[aarch64_python3-freeipa.sha256sum] = "6b6203033a276c383f73f14b8cf5bfbe2925c66963737d3285c73e4dfdf673ff"

RDEPENDS:python3-freeipa = " \
 python3 \
 python3-requests \
 "
