# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snapd"
PV = "2.76"
PR = "0.el10_3"
PACKAGES = " \
 snap-confine \
 snapd \
 snapd-devel \
 snapd-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/snapd-2.76-0.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9398516f9744aebc5cc6d1264ecabf80c57ddccff9b5c946a9006321eb2e9b72"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - snap-confine: libcap.so.2()(64bit)

URI_x86_64_v2_snap-confine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snap-confine-2.76-0.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snap-confine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snap-confine}"
SRC_URI[x86_64_v2_snap-confine.sha256sum] = "3c64432ddfb5de546577b94a9e4d34d3e5ed75ec4223bb615f956bdef163aea7"

URI_x86_64_v2_snapd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-2.76-0.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd}"
SRC_URI[x86_64_v2_snapd.sha256sum] = "4d9887568117910d6b17b6d8e59a31d2c6845ee086299cd96597829ec53365ef"

URI_x86_64_v2_snapd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-devel-2.76-0.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_snapd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-devel}"
SRC_URI[x86_64_v2_snapd-devel.sha256sum] = "4eb93c1b7aaf00ff153516f0e39971e7ed59a024a3e35d883539f4592fe87efd"

URI_x86_64_v2_snapd-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-selinux-2.76-0.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_snapd-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-selinux}"
SRC_URI[x86_64_v2_snapd-selinux.sha256sum] = "31edc117afdadb2befcf770c2edbb896439362f05a31c88643a4430add51a1a1"

URI_aarch64_snap-confine = "${EPEL_MIRROR}/aarch64/Packages/s/snap-confine-2.76-0.el10_3.aarch64.rpm;name=aarch64_snap-confine;unpack=0"
SRC_URI:append = " ${URI_aarch64_snap-confine}"
SRC_URI[aarch64_snap-confine.sha256sum] = "c9a1258efd5be8624006714b56ba2108d4d12dc74ca1e3d6540f3d5980d9fac6"

URI_aarch64_snapd = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-2.76-0.el10_3.aarch64.rpm;name=aarch64_snapd;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd}"
SRC_URI[aarch64_snapd.sha256sum] = "a8f8efe26cd56a4fcc7bc8099b69df7cbb9d6ac9b3ff46b38a9b4043a59d337b"

URI_aarch64_snapd-devel = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-devel-2.76-0.el10_3.noarch.rpm;name=aarch64_snapd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-devel}"
SRC_URI[aarch64_snapd-devel.sha256sum] = "f3bd2c3c06c8824655d257949759baf25c2cc11393631c693272ab9020d3e76c"

URI_aarch64_snapd-selinux = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-selinux-2.76-0.el10_3.noarch.rpm;name=aarch64_snapd-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-selinux}"
SRC_URI[aarch64_snapd-selinux.sha256sum] = "b58747a41c131571166a3d2189b789e39ab76657decb0d23b805c10095ca69b7"

RDEPENDS:snap-confine:x86_64_v2 = " \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 systemd-libs \
"
RDEPENDS:snap-confine:aarch64 = " \
 glibc \
 libgcc \
 libseccomp \
 libselinux \
 systemd-libs \
"
RDEPENDS:snapd = " \
 bash \
 bash-completion \
 glibc \
 snap-confine \
 snapd-selinux \
 squashfs-tools \
 systemd \
 virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_ \
 xdelta \
 "
RDEPENDS:snapd-devel = " \
 "
RDEPENDS:snapd-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
