# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.13-pip"
PV = "25.1.1"
PR = "1.el10_1"
PACKAGES = " \
 python3.13-pip \
 python3.13-pip-wheel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3.13-pip-25.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae6632256d1002b9614be68e7a8f720158bf45ac72cd0f6ac6b66874afe74dcd"

URI_x86_64_v2_python3.13-pip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-pip-25.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3.13-pip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-pip}"
SRC_URI[x86_64_v2_python3.13-pip.sha256sum] = "4c626f7b34c320de7206fbddba393ea6dd827d86fa2eeaa1e2299cec88450d7c"

URI_x86_64_v2_python3.13-pip-wheel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-pip-wheel-25.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3.13-pip-wheel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-pip-wheel}"
SRC_URI[x86_64_v2_python3.13-pip-wheel.sha256sum] = "9c1d616c4b37146fda553adb386b6fbd5780f87614524d0b8fa6af8a4f30f276"

URI_aarch64_python3.13-pip = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-pip-25.1.1-1.el10_1.noarch.rpm;name=aarch64_python3.13-pip;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-pip}"
SRC_URI[aarch64_python3.13-pip.sha256sum] = "39f1d2f613a0b1255f29c0624a67fb2ccc31f2dc4fdfbbe6d536434ddfeb32eb"

URI_aarch64_python3.13-pip-wheel = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-pip-wheel-25.1.1-1.el10_1.noarch.rpm;name=aarch64_python3.13-pip-wheel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-pip-wheel}"
SRC_URI[aarch64_python3.13-pip-wheel.sha256sum] = "d78598f43cb475338bb4bc8bc7f3b4dc470873cabd914d69d1b81c8920b923e1"

RDEPENDS:python3.13-pip = " \
 ca-certificates \
 python3.13 \
 "
RDEPENDS:python3.13-pip-wheel = " \
 ca-certificates \
 "
