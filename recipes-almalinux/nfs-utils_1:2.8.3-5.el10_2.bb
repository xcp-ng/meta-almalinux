# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nfs-utils"
PE = "1"
PV = "2.8.3"
PR = "5.el10_2"
PACKAGES = " \
 libnfsidmap \
 libnfsidmap-devel \
 nfs-utils \
 nfs-utils-coreos \
 nfsv4-client-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nfs-utils-2.8.3-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "364d32203346acd60c85cd0f22b225ac24ce20066117e5b6d45d7fa34a39c0f8"

URI_x86_64_v2_libnfsidmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnfsidmap-2.8.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_libnfsidmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfsidmap}"
SRC_URI[x86_64_v2_libnfsidmap.sha256sum] = "f6ec683a9a03ceb6e83b354d54b2fb626e659d6a3617e25c64ae41899f2ea002"

URI_x86_64_v2_libnfsidmap-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnfsidmap-devel-2.8.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_libnfsidmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfsidmap-devel}"
SRC_URI[x86_64_v2_libnfsidmap-devel.sha256sum] = "81e5eb8c6e0875177d8896233b8d0735ac936d5742650a28a9ae35bf7484bf52"

URI_x86_64_v2_nfs-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nfs-utils-2.8.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_nfs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfs-utils}"
SRC_URI[x86_64_v2_nfs-utils.sha256sum] = "e1a85fcb442e27d3b3db431a137d2fec65e3a7197a1537a7d9fd4976f44d4dec"
RPROVIDES:nfs-utils:x86_64_v2 = "virtual/nfs-utils_or_nfsv4-client-utils"

URI_x86_64_v2_nfs-utils-coreos = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nfs-utils-coreos-2.8.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_nfs-utils-coreos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfs-utils-coreos}"
SRC_URI[x86_64_v2_nfs-utils-coreos.sha256sum] = "6bb4771e43a581fc65c5ff41710031e8421ac99140fe48add3385f6f8108d742"

URI_x86_64_v2_nfsv4-client-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nfsv4-client-utils-2.8.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_nfsv4-client-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfsv4-client-utils}"
SRC_URI[x86_64_v2_nfsv4-client-utils.sha256sum] = "a90e531718deac52862bcdce52e71123bf02d5102e4ba755361ef5bca9b7664b"
RPROVIDES:nfsv4-client-utils:x86_64_v2 = "virtual/nfs-utils_or_nfsv4-client-utils"

URI_aarch64_libnfsidmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnfsidmap-2.8.3-5.el10_2.aarch64.rpm;name=aarch64_libnfsidmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfsidmap}"
SRC_URI[aarch64_libnfsidmap.sha256sum] = "24011fb8050ab371f068c9ada96b62652f70eb181b6df4e8612dab1de1eba9e5"

URI_aarch64_libnfsidmap-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnfsidmap-devel-2.8.3-5.el10_2.aarch64.rpm;name=aarch64_libnfsidmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfsidmap-devel}"
SRC_URI[aarch64_libnfsidmap-devel.sha256sum] = "d3847458874675216e1c52b7acf4cceafd1d5efd14b1f164f152bcc8ce3de54a"

URI_aarch64_nfs-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nfs-utils-2.8.3-5.el10_2.aarch64.rpm;name=aarch64_nfs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfs-utils}"
SRC_URI[aarch64_nfs-utils.sha256sum] = "f240a57ae9229c23b0df12aac44274f6328ac7b781c0d793fde13a4bc26ab5c0"
RPROVIDES:nfs-utils:aarch64 = "virtual/nfs-utils_or_nfsv4-client-utils"

URI_aarch64_nfs-utils-coreos = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nfs-utils-coreos-2.8.3-5.el10_2.aarch64.rpm;name=aarch64_nfs-utils-coreos;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfs-utils-coreos}"
SRC_URI[aarch64_nfs-utils-coreos.sha256sum] = "4c18eb7cad040346248b3f63b03174d221accb6c1bc4a3804b17fbe72a06a5d7"

URI_aarch64_nfsv4-client-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nfsv4-client-utils-2.8.3-5.el10_2.aarch64.rpm;name=aarch64_nfsv4-client-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfsv4-client-utils}"
SRC_URI[aarch64_nfsv4-client-utils.sha256sum] = "805c8f3ce8ad35a118611f3574c3a1da0677f1b5ba4df9f3bb81fee176adfb54"
RPROVIDES:nfsv4-client-utils:aarch64 = "virtual/nfs-utils_or_nfsv4-client-utils"

RDEPENDS:libnfsidmap = " \
 glibc \
 krb5-libs \
 openldap \
 "
RDEPENDS:libnfsidmap-devel = " \
 libnfsidmap \
 pkgconf-pkg-config \
 "
RDEPENDS:nfs-utils = " \
 bash \
 device-mapper-libs \
 gawk \
 glibc \
 grep \
 gssproxy \
 keyutils \
 keyutils-libs \
 kmod \
 krb5-libs \
 libblkid \
 libcap \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libnl3 \
 libtirpc \
 libuuid \
 libxml2 \
 python3 \
 quota \
 readline \
 rpcbind \
 sed \
 selinux-policy \
 shadow-utils \
 sqlite-libs \
 systemd \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:nfs-utils-coreos = " \
 bash \
 glibc \
 keyutils-libs \
 krb5-libs \
 libcap \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libtirpc \
 rpcbind \
 systemd \
 "
RDEPENDS:nfsv4-client-utils = " \
 glibc \
 gssproxy \
 keyutils-libs \
 krb5-libs \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libtirpc \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/nfs-utils_or_nfsv4-client-utils"

PROVIDES:append:aarch64 = " rpm/virtual/nfs-utils_or_nfsv4-client-utils"
