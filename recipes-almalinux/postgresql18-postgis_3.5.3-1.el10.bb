# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql18-postgis"
PV = "3.5.3"
PR = "1.el10"
PACKAGES = " \
 postgresql18-postgis \
 postgresql18-postgis-client \
 postgresql18-postgis-docs \
 postgresql18-postgis-upgrade \
 postgresql18-postgis-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql18-postgis-3.5.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6f4676e9f3efa7b4ef0a7bb24192be73454b1622bebcbf4260f7e342d32bcdb"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - postgresql18-postgis-client: libgeos_c.so.1()(64bit)
# - postgresql18-postgis-upgrade: libgeos_c.so.1()(64bit)
# - postgresql18-postgis: libgeos_c.so.1()(64bit)

URI_x86_64_v2_postgresql18-postgis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-postgis-3.5.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-postgis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-postgis}"
SRC_URI[x86_64_v2_postgresql18-postgis.sha256sum] = "69b0b15c9897e324c615b8f925ece2ac61e4aae511b5783811d85c1a9848361d"

URI_x86_64_v2_postgresql18-postgis-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-postgis-client-3.5.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-postgis-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-postgis-client}"
SRC_URI[x86_64_v2_postgresql18-postgis-client.sha256sum] = "84201f2fac22bfdbf1f55a36df8de5153937514ca802770a55a58b7f5b7f4948"

URI_x86_64_v2_postgresql18-postgis-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-postgis-docs-3.5.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-postgis-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-postgis-docs}"
SRC_URI[x86_64_v2_postgresql18-postgis-docs.sha256sum] = "4f5072891566f9017dc4d8d14d4fc4f8e7faaad34d4c458db0786a4f17d3dd4d"

URI_x86_64_v2_postgresql18-postgis-upgrade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-postgis-upgrade-3.5.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-postgis-upgrade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-postgis-upgrade}"
SRC_URI[x86_64_v2_postgresql18-postgis-upgrade.sha256sum] = "f098b5e6ece3c7f0073460cd19ca60193fb8148bff95b81974a2c27d1ef6ffb1"

URI_x86_64_v2_postgresql18-postgis-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-postgis-utils-3.5.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-postgis-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-postgis-utils}"
SRC_URI[x86_64_v2_postgresql18-postgis-utils.sha256sum] = "a4fcaf00d2f79b6b78250e5153837d187b91c34aee2c0c3117276a219b2d00a6"

URI_aarch64_postgresql18-postgis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-postgis-3.5.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-postgis;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-postgis}"
SRC_URI[aarch64_postgresql18-postgis.sha256sum] = "354fc2dc69ba96ffdac4bb7a05f5cac8d1dd38906a8683bb0e48249dedae84e5"

URI_aarch64_postgresql18-postgis-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-postgis-client-3.5.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-postgis-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-postgis-client}"
SRC_URI[aarch64_postgresql18-postgis-client.sha256sum] = "48c763c0bba08b6897726e4279a86181addf3041ea1175d8e1dc0e191e844f73"

URI_aarch64_postgresql18-postgis-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-postgis-docs-3.5.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-postgis-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-postgis-docs}"
SRC_URI[aarch64_postgresql18-postgis-docs.sha256sum] = "92ff19a9e5312df4c21ff2dbfb8bc588a5c70987566fab975d7395292cd07d51"

URI_aarch64_postgresql18-postgis-upgrade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-postgis-upgrade-3.5.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-postgis-upgrade;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-postgis-upgrade}"
SRC_URI[aarch64_postgresql18-postgis-upgrade.sha256sum] = "5aea9bf463cd3c64f064b5647765e1e7ca83216c77947bb1edf8b6cedb4720b4"

URI_aarch64_postgresql18-postgis-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-postgis-utils-3.5.3-1.el10.aarch64.rpm;name=aarch64_postgresql18-postgis-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-postgis-utils}"
SRC_URI[aarch64_postgresql18-postgis-utils.sha256sum] = "2283c4e8d39259e5474f607bbd591c402784c34d31a50e049da82881297c59d0"

RDEPENDS:postgresql18-postgis:x86_64_v2 = " \
 gdal-libs \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 proj \
 protobuf-c \
"
RDEPENDS:postgresql18-postgis:aarch64 = " \
 gdal-libs \
 geos \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 proj \
 protobuf-c \
"
RDEPENDS:postgresql18-postgis-client:x86_64_v2 = " \
 bash \
 gdal-libs \
 glibc \
 perl-File-Basename \
 perl-interpreter \
 perl-libs \
 postgresql18-postgis \
 postgresql18-private-libs \
 proj \
"
RDEPENDS:postgresql18-postgis-client:aarch64 = " \
 bash \
 gdal-libs \
 geos \
 glibc \
 perl-File-Basename \
 perl-interpreter \
 perl-libs \
 postgresql18-postgis \
 postgresql18-private-libs \
 proj \
"
RDEPENDS:postgresql18-postgis-docs = " \
 "
RDEPENDS:postgresql18-postgis-upgrade:x86_64_v2 = " \
 gdal-libs \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 postgresql-upgrade \
 postgresql18-postgis \
 proj \
 protobuf-c \
"
RDEPENDS:postgresql18-postgis-upgrade:aarch64 = " \
 gdal-libs \
 geos \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 postgresql-upgrade \
 postgresql18-postgis \
 proj \
 protobuf-c \
"
RDEPENDS:postgresql18-postgis-utils = " \
 perl-DBD-Pg \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 postgresql18-postgis \
 "
