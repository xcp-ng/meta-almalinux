# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "image-builder"
PV = "31"
PR = "5.el10_1"
PACKAGES = " \
 image-builder \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/image-builder-31-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf575c9146704cb21e6530f69b773535367f85e340f1d22b9cb53e1fb8a3c27e"

URI_x86_64_v2_image-builder = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/image-builder-31-5.el10_1.x86_64_v2.rpm;name=x86_64_v2_image-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_image-builder}"
SRC_URI[x86_64_v2_image-builder.sha256sum] = "9155128753313b874160400653c20fe07dff1aeb12a7474dcaf01f84d92e5127"

URI_aarch64_image-builder = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/image-builder-31-5.el10_1.aarch64.rpm;name=aarch64_image-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_image-builder}"
SRC_URI[aarch64_image-builder.sha256sum] = "e4b4dc6717f9c2227f01259e8fa70840364ccd08cc8db7a05035d28286354da5"

RDEPENDS:image-builder = " \
 glibc \
 gpgme \
 libxcrypt \
 osbuild \
 osbuild-depsolve-dnf \
 osbuild-luks2 \
 osbuild-lvm2 \
 osbuild-ostree \
 "
