# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-error"
PV = "0.2.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-error+anyhow-devel \
 rust-gix-error+auto-chain-error-devel \
 rust-gix-error+default-devel \
 rust-gix-error+document-features-devel \
 rust-gix-error+tree-error-devel \
 rust-gix-error-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-error-0.2.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79b24a56f9b7bf450c27d4ac957e4071f12ac36c1b350cf98827490f6e13e72e"

URI_x86_64_v2_rust-gix-error+anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-error+anyhow-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-error+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-error+anyhow-devel}"
SRC_URI[x86_64_v2_rust-gix-error+anyhow-devel.sha256sum] = "1ecceef9d0b44a57f4b8ae3bf04df5a30fdb33f689d92466c284857b22ec3dad"

URI_x86_64_v2_rust-gix-error+auto-chain-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-error+auto-chain-error-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-error+auto-chain-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-error+auto-chain-error-devel}"
SRC_URI[x86_64_v2_rust-gix-error+auto-chain-error-devel.sha256sum] = "0986f29aae86d4ed703d96ba3a2b81aad5cdf139db7be05b42b3d2e7063e0f54"

URI_x86_64_v2_rust-gix-error+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-error+default-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-error+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-error+default-devel}"
SRC_URI[x86_64_v2_rust-gix-error+default-devel.sha256sum] = "2a21067dbb140e14d16a7918ea26dcf374f1319ff803b8b7f17a34ff477c020e"

URI_x86_64_v2_rust-gix-error+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-error+document-features-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-error+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-error+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-error+document-features-devel.sha256sum] = "37880cc148df3b1d31298c4902f1894d10008dfd3297c1d291c3a984fe407542"

URI_x86_64_v2_rust-gix-error+tree-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-error+tree-error-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-error+tree-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-error+tree-error-devel}"
SRC_URI[x86_64_v2_rust-gix-error+tree-error-devel.sha256sum] = "e993f6ab201592d805b93af9ed78c80b535c9e3d84bd818c608fe1188f402559"

URI_x86_64_v2_rust-gix-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-error-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-error-devel}"
SRC_URI[x86_64_v2_rust-gix-error-devel.sha256sum] = "8fe5570b3e05204ea9aba4d855feaa1898403f3ada5613f90018146107a879c8"

URI_aarch64_rust-gix-error+anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-error+anyhow-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-gix-error+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-error+anyhow-devel}"
SRC_URI[aarch64_rust-gix-error+anyhow-devel.sha256sum] = "c92e4fe207c77c7f037337fb63c74c9dd8e1227b7bdc16bbd6d5bfb63c3e18ae"

URI_aarch64_rust-gix-error+auto-chain-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-error+auto-chain-error-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-gix-error+auto-chain-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-error+auto-chain-error-devel}"
SRC_URI[aarch64_rust-gix-error+auto-chain-error-devel.sha256sum] = "c642993d3e067b2b3c09988c309c4668dabbec52f1adce81a881e7cd3bf9de87"

URI_aarch64_rust-gix-error+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-error+default-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-gix-error+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-error+default-devel}"
SRC_URI[aarch64_rust-gix-error+default-devel.sha256sum] = "8f21a93fff407c43574bdd174c87d2646208d2fd3bcb1354623b4130dadfa8d4"

URI_aarch64_rust-gix-error+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-error+document-features-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-gix-error+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-error+document-features-devel}"
SRC_URI[aarch64_rust-gix-error+document-features-devel.sha256sum] = "b70275a75e5623a57e10d3deb14924f9034ad0622e1bd14226c457b18b6c4c36"

URI_aarch64_rust-gix-error+tree-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-error+tree-error-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-gix-error+tree-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-error+tree-error-devel}"
SRC_URI[aarch64_rust-gix-error+tree-error-devel.sha256sum] = "60cd2a856b2fce9748de4e7eb150bc9fccc44d5102fdf0aeff214ed69fab5b0a"

URI_aarch64_rust-gix-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-error-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-gix-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-error-devel}"
SRC_URI[aarch64_rust-gix-error-devel.sha256sum] = "2331a2bc5edd488c1bf673ddb99e3001e42fc48e5531cfb0e2ca75a291d793ea"

RDEPENDS:rust-gix-error+anyhow-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-gix-error-devel \
 "
RDEPENDS:rust-gix-error+auto-chain-error-devel = " \
 cargo \
 rust-gix-error-devel \
 "
RDEPENDS:rust-gix-error+default-devel = " \
 cargo \
 rust-gix-error-devel \
 "
RDEPENDS:rust-gix-error+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-error-devel \
 "
RDEPENDS:rust-gix-error+tree-error-devel = " \
 cargo \
 rust-gix-error-devel \
 "
RDEPENDS:rust-gix-error-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 "
