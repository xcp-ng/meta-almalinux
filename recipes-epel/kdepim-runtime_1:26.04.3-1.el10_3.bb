# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdepim-runtime"
PE = "1"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdepim-runtime \
 kdepim-runtime-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdepim-runtime-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ecc63374df256f0d3351c90f2ee8b05bd0b4d86d9cdae15095d254af0ae931bf"

URI_x86_64_v2_kdepim-runtime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdepim-runtime-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdepim-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdepim-runtime}"
SRC_URI[x86_64_v2_kdepim-runtime.sha256sum] = "ca77b804a7a6818e79e7476943f9a23b9a50f022506915b1aa9c1fcff7986322"

URI_x86_64_v2_kdepim-runtime-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdepim-runtime-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdepim-runtime-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdepim-runtime-libs}"
SRC_URI[x86_64_v2_kdepim-runtime-libs.sha256sum] = "b9fb186a12268b0dab936e4efa35dc32413f217f79529784d578a65c14726f2a"

URI_aarch64_kdepim-runtime = "${EPEL_MIRROR}/aarch64/Packages/k/kdepim-runtime-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdepim-runtime;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdepim-runtime}"
SRC_URI[aarch64_kdepim-runtime.sha256sum] = "043df73cec8fc9bd48b0214264055dac7af36c55b7c8a6ac87723f8bda675e49"

URI_aarch64_kdepim-runtime-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kdepim-runtime-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdepim-runtime-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdepim-runtime-libs}"
SRC_URI[aarch64_kdepim-runtime-libs.sha256sum] = "8fa60d7bf8e6dd9a4ab2c7c91142706aa715bbdb501147fd4dda6167f75445e3"

RDEPENDS:kdepim-runtime = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 cyrus-sasl-lib \
 glibc \
 kdepim-runtime-libs \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kdav \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kidentitymanagement \
 kimap \
 kmailtransport \
 kmbox \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libkgapi \
 libstdc++ \
 pimcommon \
 qca-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtnetworkauth \
 qt6-qtspeech \
 qt6-qtwebengine \
 qtkeychain-qt6 \
 "
RDEPENDS:kdepim-runtime-libs = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kdav \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 kimap \
 kldap \
 kmailtransport \
 kmbox \
 kmime \
 libgcc \
 libkgapi \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
