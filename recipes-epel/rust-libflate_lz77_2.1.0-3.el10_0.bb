# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libflate_lz77"
PV = "2.1.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-libflate_lz77+default-devel \
 rust-libflate_lz77+std-devel \
 rust-libflate_lz77-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libflate_lz77-2.1.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ed0557bf923959f9533b0710558d5f90fe07129688b7f487f84679794f5c560"

URI_x86_64_v2_rust-libflate_lz77+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libflate_lz77+default-devel-2.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libflate_lz77+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libflate_lz77+default-devel}"
SRC_URI[x86_64_v2_rust-libflate_lz77+default-devel.sha256sum] = "d6a28ee1b76e01a566fd1de6772729b568af88557f0473ffa1444c4542e4841f"

URI_x86_64_v2_rust-libflate_lz77+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libflate_lz77+std-devel-2.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libflate_lz77+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libflate_lz77+std-devel}"
SRC_URI[x86_64_v2_rust-libflate_lz77+std-devel.sha256sum] = "526f4a79461093749520504c5881010a58944742d19823ffe3afa05d04f01f6d"

URI_x86_64_v2_rust-libflate_lz77-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libflate_lz77-devel-2.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libflate_lz77-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libflate_lz77-devel}"
SRC_URI[x86_64_v2_rust-libflate_lz77-devel.sha256sum] = "a6a382e6d3212dccba75f53b7e3cab8046c02651983fa6dec1f9aa1929f1420b"

URI_aarch64_rust-libflate_lz77+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libflate_lz77+default-devel-2.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-libflate_lz77+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libflate_lz77+default-devel}"
SRC_URI[aarch64_rust-libflate_lz77+default-devel.sha256sum] = "68896241ba9517f4054eade09dae0e5ac5ba455b3a69c20be9176707cfc91571"

URI_aarch64_rust-libflate_lz77+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libflate_lz77+std-devel-2.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-libflate_lz77+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libflate_lz77+std-devel}"
SRC_URI[aarch64_rust-libflate_lz77+std-devel.sha256sum] = "91ee8826521261943389fa1e5063964c4ac23eb79d02cdb7fb7eacb578f422a8"

URI_aarch64_rust-libflate_lz77-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libflate_lz77-devel-2.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-libflate_lz77-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libflate_lz77-devel}"
SRC_URI[aarch64_rust-libflate_lz77-devel.sha256sum] = "1802bee83348a7f1d9a49da42717eccf24d252a36552ac28bc4b307c6244e320"

RDEPENDS:rust-libflate_lz77+default-devel = " \
 cargo \
 rust-libflate_lz77+std-devel \
 rust-libflate_lz77-devel \
 "
RDEPENDS:rust-libflate_lz77+std-devel = " \
 cargo \
 rust-core2+std-devel \
 rust-libflate_lz77-devel \
 "
RDEPENDS:rust-libflate_lz77-devel = " \
 cargo \
 rust-core2+alloc-devel \
 rust-core2-devel \
 rust-hashbrown0.14+default-devel \
 rust-rle-decode-fast+default-devel \
 "
