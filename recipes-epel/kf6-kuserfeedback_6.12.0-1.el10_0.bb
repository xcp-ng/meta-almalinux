# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kuserfeedback"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kuserfeedback \
 kf6-kuserfeedback-console \
 kf6-kuserfeedback-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kuserfeedback-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc15716a0d6a1cb26f8b7f90a7656adafea83a43774d0c0306e06f9b8c103c39"

URI_x86_64_v2_kf6-kuserfeedback = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kuserfeedback;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback}"
SRC_URI[x86_64_v2_kf6-kuserfeedback.sha256sum] = "08321db34bb2011c924eaea3144c33c1c700e40922eb266b15711546aeef17a2"

URI_x86_64_v2_kf6-kuserfeedback-console = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-console-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kuserfeedback-console;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback-console}"
SRC_URI[x86_64_v2_kf6-kuserfeedback-console.sha256sum] = "e3b8dd18f97f1add2a0b4b8fc3fd6046b2f8d0264f5de66298e11245e4ad644d"

URI_x86_64_v2_kf6-kuserfeedback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kuserfeedback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback-devel}"
SRC_URI[x86_64_v2_kf6-kuserfeedback-devel.sha256sum] = "100b0084c8b7db9bcd11111f5b8da0df6b93c09faa172bb3cb0a33e79640f764"

URI_aarch64_kf6-kuserfeedback = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kuserfeedback;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback}"
SRC_URI[aarch64_kf6-kuserfeedback.sha256sum] = "d60c8ca738ba9554b28df2ce1d4fb61d6f1f40897c6e68fcb477fd217924e6a2"

URI_aarch64_kf6-kuserfeedback-console = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-console-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kuserfeedback-console;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback-console}"
SRC_URI[aarch64_kf6-kuserfeedback-console.sha256sum] = "ad52eca1bf251246392b3dc1b954d65cce1b86cc9f42037b94440f4ee5f8a22f"

URI_aarch64_kf6-kuserfeedback-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kuserfeedback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback-devel}"
SRC_URI[aarch64_kf6-kuserfeedback-devel.sha256sum] = "8b52648f78cf47b229168b7cc34be775f66dbe8fd385c0595cb27726bfedae91"

RDEPENDS:kf6-kuserfeedback = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kuserfeedback-console = " \
 glibc \
 kf6-kuserfeedback \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtsvg \
 "
RDEPENDS:kf6-kuserfeedback-devel = " \
 cmake-filesystem \
 kf6-kuserfeedback \
 qt6-qtbase-devel \
 "
