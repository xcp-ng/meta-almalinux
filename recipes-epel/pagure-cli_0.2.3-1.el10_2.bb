# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pagure-cli"
PV = "0.2.3"
PR = "1.el10_2"
PACKAGES = " \
 pagure-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pagure-cli-0.2.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5011a8dfba2ad3cc1305bcd9355d5ec007d758d55b9c2444f3732be6c0979645"

URI_x86_64_v2_pagure-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pagure-cli-0.2.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pagure-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pagure-cli}"
SRC_URI[x86_64_v2_pagure-cli.sha256sum] = "32280d6fbae1c6d270f2fd3d6b6e2d2fa745c44ed7e78c85d47bd1af73ae2fe8"

URI_aarch64_pagure-cli = "${EPEL_MIRROR}/aarch64/Packages/p/pagure-cli-0.2.3-1.el10_2.aarch64.rpm;name=aarch64_pagure-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_pagure-cli}"
SRC_URI[aarch64_pagure-cli.sha256sum] = "d309ea21253becf7d066f197727e690a54f4440760ded7edddc9cdec853c4902"

RDEPENDS:pagure-cli = " \
 glibc \
 gmp \
 libffi \
 libyaml \
 zlib-ng-compat \
 "
