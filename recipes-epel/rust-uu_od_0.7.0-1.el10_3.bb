# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_od"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_od+default-devel \
 rust-uu_od-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_od-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66f72930655d75859e994b53f7b0838ed648b2d76835474ebf9143d30f954a09"

URI_x86_64_v2_rust-uu_od+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_od+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_od+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_od+default-devel}"
SRC_URI[x86_64_v2_rust-uu_od+default-devel.sha256sum] = "3a7093f44a8fe3f506d13b8f763dd962fc822689472673023381c7719b406f63"

URI_x86_64_v2_rust-uu_od-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_od-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_od-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_od-devel}"
SRC_URI[x86_64_v2_rust-uu_od-devel.sha256sum] = "dad41a1c9786ca467817cfb2b38840e7d7d4d98c459be1e14ea8712788710cf7"

URI_aarch64_rust-uu_od+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_od+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_od+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_od+default-devel}"
SRC_URI[aarch64_rust-uu_od+default-devel.sha256sum] = "135549ef275fd8b3412e689f8dc65895d8e1a537a490461462e5b7a6f4609c40"

URI_aarch64_rust-uu_od-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_od-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_od-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_od-devel}"
SRC_URI[aarch64_rust-uu_od-devel.sha256sum] = "0975ddb6f432e266d324878bd555e1f3280b18f570279ee9a2696b5129adf064"

RDEPENDS:rust-uu_od+default-devel = " \
 cargo \
 rust-uu_od-devel \
 "
RDEPENDS:rust-uu_od-devel = " \
 cargo \
 rust \
 rust-byteorder+default-devel \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-half+default-devel \
 rust-libc+default-devel \
 rust-uucore+default-devel \
 rust-uucore+parser-size-devel \
 "
