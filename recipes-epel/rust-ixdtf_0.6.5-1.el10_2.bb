# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ixdtf"
PV = "0.6.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-ixdtf+default-devel \
 rust-ixdtf+duration-devel \
 rust-ixdtf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ixdtf-0.6.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab2b2d7e2b1726dd4736577a5ef9f457588177cdcb9ec5ac19629b093a8c83d1"

URI_x86_64_v2_rust-ixdtf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ixdtf+default-devel-0.6.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ixdtf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ixdtf+default-devel}"
SRC_URI[x86_64_v2_rust-ixdtf+default-devel.sha256sum] = "3255a2865e9b2ffc03cbb37a27ec87183a0a3da576eac39bbd514dee3b018bf3"

URI_x86_64_v2_rust-ixdtf+duration-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ixdtf+duration-devel-0.6.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ixdtf+duration-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ixdtf+duration-devel}"
SRC_URI[x86_64_v2_rust-ixdtf+duration-devel.sha256sum] = "f0fb1b29723673ffbcbebb6a2375739f9feac7dcdb06e73e34ed270b281b6e94"

URI_x86_64_v2_rust-ixdtf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ixdtf-devel-0.6.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ixdtf-devel}"
SRC_URI[x86_64_v2_rust-ixdtf-devel.sha256sum] = "9eb6cfb9aff477228e8d75a95d8e3853baddaa39f06c0122fd784c6e16437762"

URI_aarch64_rust-ixdtf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ixdtf+default-devel-0.6.5-1.el10_2.noarch.rpm;name=aarch64_rust-ixdtf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ixdtf+default-devel}"
SRC_URI[aarch64_rust-ixdtf+default-devel.sha256sum] = "fbabc825456e120a27cf21ec2977e541d9f05bab6ffb02ec07d2fa1459f3a6f7"

URI_aarch64_rust-ixdtf+duration-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ixdtf+duration-devel-0.6.5-1.el10_2.noarch.rpm;name=aarch64_rust-ixdtf+duration-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ixdtf+duration-devel}"
SRC_URI[aarch64_rust-ixdtf+duration-devel.sha256sum] = "f5ab6c639dba168da413e01b10fff53d22d650740d8214f732615c3f7087b57d"

URI_aarch64_rust-ixdtf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ixdtf-devel-0.6.5-1.el10_2.noarch.rpm;name=aarch64_rust-ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ixdtf-devel}"
SRC_URI[aarch64_rust-ixdtf-devel.sha256sum] = "a67e28d89cd2eee1ae3860be99b8c3399128bd38de6ac35b6a8827d14c5a811a"

RDEPENDS:rust-ixdtf+default-devel = " \
 cargo \
 rust-ixdtf+duration-devel \
 rust-ixdtf-devel \
 "
RDEPENDS:rust-ixdtf+duration-devel = " \
 cargo \
 rust-ixdtf-devel \
 "
RDEPENDS:rust-ixdtf-devel = " \
 cargo \
 rust \
 "
