# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pygraphviz"
PV = "1.14"
PR = "4.el10_0"
PACKAGES = " \
 python3-pygraphviz \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pygraphviz-1.14-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2dcd88e053bc53e1efe08e20a5e97f12d9dea97b70d7b555a5ea3441f40a500"

URI_x86_64_v2_python3-pygraphviz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pygraphviz-1.14-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pygraphviz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pygraphviz}"
SRC_URI[x86_64_v2_python3-pygraphviz.sha256sum] = "167e3787fefff8a5552a4101b8a4b1d1cc7950ae4708599c3929f4f8ac723947"

URI_aarch64_python3-pygraphviz = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pygraphviz-1.14-4.el10_0.aarch64.rpm;name=aarch64_python3-pygraphviz;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pygraphviz}"
SRC_URI[aarch64_python3-pygraphviz.sha256sum] = "cf841322b9213bd1e70736ed5723a77fba6e348aec0e000835d9cb409215252c"

RDEPENDS:python3-pygraphviz = " \
 glibc \
 graphviz \
 python3 \
 "
