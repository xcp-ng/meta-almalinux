# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crypto-common"
PV = "0.1.7"
PR = "1.el10_1"
PACKAGES = " \
 rust-crypto-common+default-devel \
 rust-crypto-common+getrandom-devel \
 rust-crypto-common+rand_core-devel \
 rust-crypto-common+std-devel \
 rust-crypto-common-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crypto-common-0.1.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cfe1f8ea818e5794685d65a64e29206d12d91849b87347056ecf2b4f43a9655"

URI_x86_64_v2_rust-crypto-common+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+default-devel-0.1.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+default-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+default-devel.sha256sum] = "744dc953c268edadaa68ef8d0938d17cacd7a6e6fd058943e8036bc418710c67"

URI_x86_64_v2_rust-crypto-common+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+getrandom-devel-0.1.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+getrandom-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+getrandom-devel.sha256sum] = "e6045fbbd0b58c6b26893dc8e3bd8fbee18dfba3234005ec942e30bda0614d69"

URI_x86_64_v2_rust-crypto-common+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+rand_core-devel-0.1.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+rand_core-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+rand_core-devel.sha256sum] = "3276005cba0ee26fc6ce3348f21a3278ae1212ea987d230974e0f777b317005c"

URI_x86_64_v2_rust-crypto-common+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+std-devel-0.1.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+std-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+std-devel.sha256sum] = "1c1d9df971d65b79db45946efe7b799378994d08e1a80ea6e366170a5bfc5731"

URI_x86_64_v2_rust-crypto-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common-devel-0.1.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common-devel}"
SRC_URI[x86_64_v2_rust-crypto-common-devel.sha256sum] = "83d1561954f3b99d122110d0524995e652c173f775e30d7ee79e649614562b42"

URI_aarch64_rust-crypto-common+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+default-devel-0.1.7-1.el10_1.noarch.rpm;name=aarch64_rust-crypto-common+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+default-devel}"
SRC_URI[aarch64_rust-crypto-common+default-devel.sha256sum] = "f70c5d4509b723eaf0a880c080297e3c526718cb340a32984fdb4bea42102af9"

URI_aarch64_rust-crypto-common+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+getrandom-devel-0.1.7-1.el10_1.noarch.rpm;name=aarch64_rust-crypto-common+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+getrandom-devel}"
SRC_URI[aarch64_rust-crypto-common+getrandom-devel.sha256sum] = "c6fd4a87b09dc7b23839ca06f2ef73fc0e1c86f53998eb2ad1be33c129615b77"

URI_aarch64_rust-crypto-common+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+rand_core-devel-0.1.7-1.el10_1.noarch.rpm;name=aarch64_rust-crypto-common+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+rand_core-devel}"
SRC_URI[aarch64_rust-crypto-common+rand_core-devel.sha256sum] = "0f0173073233c59a386a60738fc5c1307dc2e3413d975ca2cf7a855f9611b0a6"

URI_aarch64_rust-crypto-common+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+std-devel-0.1.7-1.el10_1.noarch.rpm;name=aarch64_rust-crypto-common+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+std-devel}"
SRC_URI[aarch64_rust-crypto-common+std-devel.sha256sum] = "d84d730d62fb8bd87a8b6eddd7f768e0bffdba294e8949d33376dacd0c89b88e"

URI_aarch64_rust-crypto-common-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common-devel-0.1.7-1.el10_1.noarch.rpm;name=aarch64_rust-crypto-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common-devel}"
SRC_URI[aarch64_rust-crypto-common-devel.sha256sum] = "69a8b074e541b474571724fa121d522a2670f865ac50922e3644097d5b9fb3df"

RDEPENDS:rust-crypto-common+default-devel = " \
 cargo \
 rust-crypto-common-devel \
 "
RDEPENDS:rust-crypto-common+getrandom-devel = " \
 cargo \
 rust-crypto-common-devel \
 rust-rand_core0.6+default-devel \
 rust-rand_core0.6+getrandom-devel \
 "
RDEPENDS:rust-crypto-common+rand_core-devel = " \
 cargo \
 rust-crypto-common-devel \
 rust-rand_core0.6+default-devel \
 "
RDEPENDS:rust-crypto-common+std-devel = " \
 cargo \
 rust-crypto-common-devel \
 "
RDEPENDS:rust-crypto-common-devel = " \
 cargo \
 rust-generic-array+default-devel \
 rust-generic-array+more_lengths-devel \
 rust-typenum+default-devel \
 "
