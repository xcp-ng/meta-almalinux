# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cgreen"
PV = "1.6.5"
PR = "2.el10_2"
PACKAGES = " \
 cgreen \
 cgreen-devel \
 cgreen-runner \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cgreen-1.6.5-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1592a8a4fa3b5705c948a72abefab3e022da13114ee47794722a8e8bab64cfa"

URI_x86_64_v2_cgreen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgreen-1.6.5-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgreen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgreen}"
SRC_URI[x86_64_v2_cgreen.sha256sum] = "53d3ba5685ae075911b6908d207739f26e915054c25977edaea174f5b6187e70"

URI_x86_64_v2_cgreen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgreen-devel-1.6.5-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgreen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgreen-devel}"
SRC_URI[x86_64_v2_cgreen-devel.sha256sum] = "e6f81279455012a8aaaefff6caf7272ea4aad36601ac9d870d6dac816e48b841"

URI_x86_64_v2_cgreen-runner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgreen-runner-1.6.5-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgreen-runner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgreen-runner}"
SRC_URI[x86_64_v2_cgreen-runner.sha256sum] = "2350dc60e4fe5309af5d97058e37c91b762e6ed99c4dae65a5f53d05b5fac9ea"

URI_aarch64_cgreen = "${EPEL_MIRROR}/aarch64/Packages/c/cgreen-1.6.5-2.el10_2.aarch64.rpm;name=aarch64_cgreen;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgreen}"
SRC_URI[aarch64_cgreen.sha256sum] = "93ccc8ea2e0a9622ec4352707a279388fd5336ec23f4ef1acad8f27085a7f5c7"

URI_aarch64_cgreen-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cgreen-devel-1.6.5-2.el10_2.aarch64.rpm;name=aarch64_cgreen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgreen-devel}"
SRC_URI[aarch64_cgreen-devel.sha256sum] = "88db1dee9861b0aff5823b846f88d31697b426f90a444c9e53dcc7e4efc7408e"

URI_aarch64_cgreen-runner = "${EPEL_MIRROR}/aarch64/Packages/c/cgreen-runner-1.6.5-2.el10_2.aarch64.rpm;name=aarch64_cgreen-runner;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgreen-runner}"
SRC_URI[aarch64_cgreen-runner.sha256sum] = "4bc7fa073217f9ad871b75786280eb8bb488d0fa817f41873723f62679e1c6ff"

RDEPENDS:cgreen = " \
 glibc \
 libxml2 \
 "
RDEPENDS:cgreen-devel = " \
 cgreen \
 cmake-filesystem \
 "
RDEPENDS:cgreen-runner = " \
 cgreen \
 glibc \
 "
