# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmailtransport"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kmailtransport \
 kmailtransport-devel \
 kmailtransport-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmailtransport-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b5b4ece123ef628c07e546f1527738a1c5c75051ffd985ccefd6d841f357c1a"

URI_x86_64_v2_kmailtransport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmailtransport-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmailtransport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmailtransport}"
SRC_URI[x86_64_v2_kmailtransport.sha256sum] = "cda65049a284d4a4f8c06df122c91f584a82ee0f1f054f3bf9513ef1fb0d4d13"

URI_x86_64_v2_kmailtransport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmailtransport-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmailtransport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmailtransport-devel}"
SRC_URI[x86_64_v2_kmailtransport-devel.sha256sum] = "97b3020a95daa523df20264815be1b67c34b40cc95c416e568c377a013d805e0"

URI_x86_64_v2_kmailtransport-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmailtransport-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kmailtransport-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmailtransport-doc}"
SRC_URI[x86_64_v2_kmailtransport-doc.sha256sum] = "73d35610c5f507d8bb9263a003c7d508d17615e068e3070fa992d3d168fd79a6"

URI_aarch64_kmailtransport = "${EPEL_MIRROR}/aarch64/Packages/k/kmailtransport-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmailtransport;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmailtransport}"
SRC_URI[aarch64_kmailtransport.sha256sum] = "70201b4ce4af1ad77561437b97e29b6ce269589db290c5ba5dccf3d26a24021e"

URI_aarch64_kmailtransport-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kmailtransport-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmailtransport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmailtransport-devel}"
SRC_URI[aarch64_kmailtransport-devel.sha256sum] = "914080bfa797084c9edbddfc6d25571ff7287137ee901054a7e1e216021c5bb9"

URI_aarch64_kmailtransport-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kmailtransport-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kmailtransport-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmailtransport-doc}"
SRC_URI[aarch64_kmailtransport-doc.sha256sum] = "e16a36da96786c5cd129654a4bb129a6b87297dd719acd75cae71267025dd309"

RDEPENDS:kmailtransport = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 ksmtp \
 libkgapi \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:kmailtransport-devel = " \
 akonadi-mime-devel \
 cmake-filesystem \
 kmailtransport \
 kmime-devel \
 "
RDEPENDS:kmailtransport-doc = " \
 "
