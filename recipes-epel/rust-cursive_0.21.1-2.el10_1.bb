# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cursive"
PV = "0.21.1"
PR = "2.el10_1"
PACKAGES = " \
 rust-cursive+builder-devel \
 rust-cursive+crossterm-backend-devel \
 rust-cursive+default-devel \
 rust-cursive+doc-cfg-devel \
 rust-cursive+termion-backend-devel \
 rust-cursive+toml-devel \
 rust-cursive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cursive-0.21.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e79530d04070cdf0789f5172894a5b9ec058f9da1a6b80d6f4a7e575edfa267"

URI_x86_64_v2_rust-cursive+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive+builder-devel-0.21.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive+builder-devel}"
SRC_URI[x86_64_v2_rust-cursive+builder-devel.sha256sum] = "8afe81af8c0567e2909a31bb590d25769f961cc31dbddabadfa1cdc3cbf214f8"

URI_x86_64_v2_rust-cursive+crossterm-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive+crossterm-backend-devel-0.21.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive+crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive+crossterm-backend-devel}"
SRC_URI[x86_64_v2_rust-cursive+crossterm-backend-devel.sha256sum] = "4a0af5edd284412449a07c1c4110fecb402d6effd607fcfa3a3248bce9da7c13"

URI_x86_64_v2_rust-cursive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive+default-devel-0.21.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive+default-devel}"
SRC_URI[x86_64_v2_rust-cursive+default-devel.sha256sum] = "c969632b039c5fdf0f4587f1ec545fab8c9cf36b5ffcde2132379f9f9d7cd5b0"

URI_x86_64_v2_rust-cursive+doc-cfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive+doc-cfg-devel-0.21.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive+doc-cfg-devel}"
SRC_URI[x86_64_v2_rust-cursive+doc-cfg-devel.sha256sum] = "44892515d8862c5e3f9f9e25e3f35026238f775e303ad09133d78a0843a49ba5"

URI_x86_64_v2_rust-cursive+termion-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive+termion-backend-devel-0.21.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive+termion-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive+termion-backend-devel}"
SRC_URI[x86_64_v2_rust-cursive+termion-backend-devel.sha256sum] = "2844c35d3d38ffd2312df360529f009b6dacf433618d9bbfeb50109d6015b572"

URI_x86_64_v2_rust-cursive+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive+toml-devel-0.21.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive+toml-devel}"
SRC_URI[x86_64_v2_rust-cursive+toml-devel.sha256sum] = "fbc93c3f618579b57d38175e19510959de641dd65a9c11c473659413080a62e2"

URI_x86_64_v2_rust-cursive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive-devel-0.21.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive-devel}"
SRC_URI[x86_64_v2_rust-cursive-devel.sha256sum] = "5d97e330036269bf64e15d1adc72bf76d32dc126c25ea4c09667e4241b6d41a6"

URI_aarch64_rust-cursive+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive+builder-devel-0.21.1-2.el10_1.noarch.rpm;name=aarch64_rust-cursive+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive+builder-devel}"
SRC_URI[aarch64_rust-cursive+builder-devel.sha256sum] = "d6e392dfcae96b44e58a8a715b3266dc77f68fd9fa973bc3cfb8c38794fdadce"

URI_aarch64_rust-cursive+crossterm-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive+crossterm-backend-devel-0.21.1-2.el10_1.noarch.rpm;name=aarch64_rust-cursive+crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive+crossterm-backend-devel}"
SRC_URI[aarch64_rust-cursive+crossterm-backend-devel.sha256sum] = "409a7f26c47df735fcf2f697c57e016294f1152bd28478dca7b7119209bbd7e5"

URI_aarch64_rust-cursive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive+default-devel-0.21.1-2.el10_1.noarch.rpm;name=aarch64_rust-cursive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive+default-devel}"
SRC_URI[aarch64_rust-cursive+default-devel.sha256sum] = "0d099194b818222a3447fecee50bdc575867cffc2c961e85de0b99a38b5f083f"

URI_aarch64_rust-cursive+doc-cfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive+doc-cfg-devel-0.21.1-2.el10_1.noarch.rpm;name=aarch64_rust-cursive+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive+doc-cfg-devel}"
SRC_URI[aarch64_rust-cursive+doc-cfg-devel.sha256sum] = "beca1ea0b0e662a300e71ff058039ada4f8c121efafbb5941893be98d5688e57"

URI_aarch64_rust-cursive+termion-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive+termion-backend-devel-0.21.1-2.el10_1.noarch.rpm;name=aarch64_rust-cursive+termion-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive+termion-backend-devel}"
SRC_URI[aarch64_rust-cursive+termion-backend-devel.sha256sum] = "2037d6faeb64a7901a0a232d231847a0b5e8c572aa1be8e5e0e8fa22aaf3c423"

URI_aarch64_rust-cursive+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive+toml-devel-0.21.1-2.el10_1.noarch.rpm;name=aarch64_rust-cursive+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive+toml-devel}"
SRC_URI[aarch64_rust-cursive+toml-devel.sha256sum] = "0476a1a2c08bf6ee8c3503d2b1942734013593f99f5ca55a54c28ee2df5901a9"

URI_aarch64_rust-cursive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive-devel-0.21.1-2.el10_1.noarch.rpm;name=aarch64_rust-cursive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive-devel}"
SRC_URI[aarch64_rust-cursive-devel.sha256sum] = "4ae9473b46a8490f37d9374f0004c8e737def098b194dde04a719cbd9e4d9305"

RDEPENDS:rust-cursive+builder-devel = " \
 cargo \
 rust-cursive-devel \
 rust-cursive_core+builder-devel \
 "
RDEPENDS:rust-cursive+crossterm-backend-devel = " \
 cargo \
 rust-crossterm0.28+default-devel \
 rust-cursive-devel \
 "
RDEPENDS:rust-cursive+default-devel = " \
 cargo \
 rust-cursive+crossterm-backend-devel \
 rust-cursive-devel \
 "
RDEPENDS:rust-cursive+doc-cfg-devel = " \
 cargo \
 rust-cursive-devel \
 rust-cursive_core+doc-cfg-devel \
 "
RDEPENDS:rust-cursive+termion-backend-devel = " \
 cargo \
 rust-cursive-devel \
 rust-termion+default-devel \
 "
RDEPENDS:rust-cursive+toml-devel = " \
 cargo \
 rust-cursive-devel \
 rust-cursive_core+toml-devel \
 "
RDEPENDS:rust-cursive-devel = " \
 cargo \
 rust-ahash+default-devel \
 rust-cfg-if+default-devel \
 rust-crossbeam-channel+default-devel \
 rust-cursive_core+default-devel \
 rust-lazy_static+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-signal-hook0.3+default-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width0.1+default-devel \
 "
