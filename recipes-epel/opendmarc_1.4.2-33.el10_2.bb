# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opendmarc"
PV = "1.4.2"
PR = "33.el10_2"
PACKAGES = " \
 libopendmarc \
 libopendmarc-devel \
 opendmarc \
 opendmarc-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opendmarc-1.4.2-33.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20a0d4ebba4985db54db5c973043f14a8e8401b30ebcb2c8ca5f37811cb11913"

URI_x86_64_v2_libopendmarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopendmarc-1.4.2-33.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopendmarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopendmarc}"
SRC_URI[x86_64_v2_libopendmarc.sha256sum] = "e5e899116416a42e7a4c787f80ad9d55f6962c39649e008879255ab678758469"

URI_x86_64_v2_libopendmarc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopendmarc-devel-1.4.2-33.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopendmarc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopendmarc-devel}"
SRC_URI[x86_64_v2_libopendmarc-devel.sha256sum] = "4be868b207336daff434d2cf55e936271a85c4f97d7bd183b22d5d485b549931"

URI_x86_64_v2_opendmarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendmarc-1.4.2-33.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendmarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendmarc}"
SRC_URI[x86_64_v2_opendmarc.sha256sum] = "9d3bcc5b0966b47b256becc05d31d97099a6f8c051f88c29233b74319c75dadb"

URI_x86_64_v2_opendmarc-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendmarc-tools-1.4.2-33.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendmarc-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendmarc-tools}"
SRC_URI[x86_64_v2_opendmarc-tools.sha256sum] = "379a12819b58075f068d3dbd251b0ff446aff67051eae16e2d1627218a21943b"

URI_aarch64_libopendmarc = "${EPEL_MIRROR}/aarch64/Packages/l/libopendmarc-1.4.2-33.el10_2.aarch64.rpm;name=aarch64_libopendmarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopendmarc}"
SRC_URI[aarch64_libopendmarc.sha256sum] = "b6741c0c7b550583bfdf3f1c47e2c0d0849b97b45b3089447a6869bf090f0df3"

URI_aarch64_libopendmarc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libopendmarc-devel-1.4.2-33.el10_2.aarch64.rpm;name=aarch64_libopendmarc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopendmarc-devel}"
SRC_URI[aarch64_libopendmarc-devel.sha256sum] = "fe0088f43b90c9f9a1965b62cb1e6934156f44eb8dbf16506d552d63f70dcc01"

URI_aarch64_opendmarc = "${EPEL_MIRROR}/aarch64/Packages/o/opendmarc-1.4.2-33.el10_2.aarch64.rpm;name=aarch64_opendmarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendmarc}"
SRC_URI[aarch64_opendmarc.sha256sum] = "e93996302c3532d3817d4a3d8ab9f92711f4cac07d180ba8b011a38438e8cd70"

URI_aarch64_opendmarc-tools = "${EPEL_MIRROR}/aarch64/Packages/o/opendmarc-tools-1.4.2-33.el10_2.aarch64.rpm;name=aarch64_opendmarc-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendmarc-tools}"
SRC_URI[aarch64_opendmarc-tools.sha256sum] = "969b401764a4c253e42fcc3db59d6440251bfbb3a5646db264470f13848625a1"

RDEPENDS:libopendmarc = " \
 glibc \
 libspf2 \
 "
RDEPENDS:libopendmarc-devel = " \
 libopendmarc \
 "
RDEPENDS:opendmarc = " \
 bash \
 glibc \
 libopendmarc \
 sendmail-milter \
 shadow-utils \
 "
RDEPENDS:opendmarc-tools = " \
 bash \
 libopendmarc \
 perl-DBD-MySQL \
 perl-DBI \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Compress \
 perl-JSON \
 perl-MIME-Base64 \
 perl-POSIX \
 perl-Switch \
 perl-Time-Local \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 "
