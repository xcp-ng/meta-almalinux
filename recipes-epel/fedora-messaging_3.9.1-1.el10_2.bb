# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-messaging"
PV = "3.9.1"
PR = "1.el10_2"
PACKAGES = " \
 fedora-messaging \
 python3-fedora-messaging \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-messaging-3.9.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59e15ca8b6a67002b8448000e9635fe297858d2804185bd13300be1adbd004f8"

URI_x86_64_v2_fedora-messaging = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-messaging-3.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-messaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-messaging}"
SRC_URI[x86_64_v2_fedora-messaging.sha256sum] = "93c220938753b661e0311fa0445449faf15945c60adf6d669effede78d2c10a7"

URI_x86_64_v2_python3-fedora-messaging = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fedora-messaging-3.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fedora-messaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fedora-messaging}"
SRC_URI[x86_64_v2_python3-fedora-messaging.sha256sum] = "5cfdf992b4764768960af33470f4774cf9af4361d190af4e0258ff7ad8b8990c"

URI_aarch64_fedora-messaging = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-messaging-3.9.1-1.el10_2.noarch.rpm;name=aarch64_fedora-messaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-messaging}"
SRC_URI[aarch64_fedora-messaging.sha256sum] = "3313fda49701d516cc3c6c9a481259f57d009b5a3ae0e19fb27bc45d70cd80ed"

URI_aarch64_python3-fedora-messaging = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fedora-messaging-3.9.1-1.el10_2.noarch.rpm;name=aarch64_python3-fedora-messaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fedora-messaging}"
SRC_URI[aarch64_python3-fedora-messaging.sha256sum] = "705f6742b3e0f70c5d0d8fd7a72f14cd930d9dfaca3f4015b45eccc4d208010c"

RDEPENDS:fedora-messaging = " \
 python3 \
 python3-fedora-messaging \
 "
RDEPENDS:python3-fedora-messaging = " \
 python3 \
 python3-blinker \
 python3-click \
 python3-crochet \
 python3-jsonschema \
 python3-pika \
 python3-pyOpenSSL \
 python3-requests \
 python3-service-identity \
 python3-tomli \
 python3-twisted \
 "
