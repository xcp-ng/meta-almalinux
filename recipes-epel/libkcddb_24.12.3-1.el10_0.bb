# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkcddb"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 libkcddb \
 libkcddb-devel \
 libkcddb-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkcddb-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bab0ca85c31d72ef28a4bc937b2e6834f9458231f335cf97842869f8876e7a8"

URI_x86_64_v2_libkcddb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcddb-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcddb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcddb}"
SRC_URI[x86_64_v2_libkcddb.sha256sum] = "f1cc6e7b9fc14ea67997dc862b0f2028740adf083822c914a2376520a697c53a"

URI_x86_64_v2_libkcddb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcddb-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcddb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcddb-devel}"
SRC_URI[x86_64_v2_libkcddb-devel.sha256sum] = "e552dc8fa529c2ee4cbdc2cb7bbb1078d8569656f1f216a5876392f8c8891c93"

URI_x86_64_v2_libkcddb-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcddb-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libkcddb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcddb-doc}"
SRC_URI[x86_64_v2_libkcddb-doc.sha256sum] = "87e1f07789977c8d954954aac4f2e105ab6a5507b293c5226c226324e7cbfa42"

URI_aarch64_libkcddb = "${EPEL_MIRROR}/aarch64/Packages/l/libkcddb-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkcddb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcddb}"
SRC_URI[aarch64_libkcddb.sha256sum] = "6459c03a735d264484ba354777bbbcacd891267a6dabede0a4ee2465a3d0904a"

URI_aarch64_libkcddb-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkcddb-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkcddb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcddb-devel}"
SRC_URI[aarch64_libkcddb-devel.sha256sum] = "b772c25e56234dac75e74e85dbc90e7fe2f0c8d05702ba647dbdc848bce65d62"

URI_aarch64_libkcddb-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkcddb-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_libkcddb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcddb-doc}"
SRC_URI[aarch64_libkcddb-doc.sha256sum] = "0279bedfdb42d0af1bf609722b085abf72e8db3b966fa239932b66a319d00eb3"

RDEPENDS:libkcddb = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 libgcc \
 libkcddb-doc \
 libmusicbrainz5 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkcddb-devel = " \
 cmake-filesystem \
 libkcddb \
 "
RDEPENDS:libkcddb-doc = " \
 libkcddb \
 "
