# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "s3cmd"
PV = "2.4.0"
PR = "14.el10_3"
PACKAGES = " \
 s3cmd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/s3cmd-2.4.0-14.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23529d3948b325c37a33a9135c8912fc2bdb0e496f9fc4d6e6a2ff38bcd9f95f"

URI_x86_64_v2_s3cmd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/s3cmd-2.4.0-14.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_s3cmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_s3cmd}"
SRC_URI[x86_64_v2_s3cmd.sha256sum] = "df857c3dbc29716c1d9a2f5c7df1e44c7adbab1695bd7f45cb9353dd39d00e63"

URI_aarch64_s3cmd = "${EPEL_MIRROR}/aarch64/Packages/s/s3cmd-2.4.0-14.el10_3.noarch.rpm;name=aarch64_s3cmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_s3cmd}"
SRC_URI[aarch64_s3cmd.sha256sum] = "1b6327c9c871987d75a378a7ca673dffbf385d310ca2dfece328f218e765f11d"

RDEPENDS:s3cmd = " \
 python3 \
 python3-dateutil \
 python3-file-magic \
 "
