# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_basename"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_basename+default-devel \
 rust-uu_basename-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_basename-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba202892ec15832f3de85e9a4b2323b17c51c570bda874ea7a679b685fc82a23"

URI_x86_64_v2_rust-uu_basename+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_basename+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_basename+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_basename+default-devel}"
SRC_URI[x86_64_v2_rust-uu_basename+default-devel.sha256sum] = "a392749e03da7dbc47eb006f9dc5cf12d050d6848089b2ba0796d81c0ed0ffe8"

URI_x86_64_v2_rust-uu_basename-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_basename-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_basename-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_basename-devel}"
SRC_URI[x86_64_v2_rust-uu_basename-devel.sha256sum] = "a374dbba7d6c91badd500dbadbb2543ecbe63e9488c0a32c71172a202a96f019"

URI_aarch64_rust-uu_basename+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_basename+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_basename+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_basename+default-devel}"
SRC_URI[aarch64_rust-uu_basename+default-devel.sha256sum] = "53ed4fb185d1c7215651649b950a3a2eea75a9e9ad6946e044f798eb44f40daa"

URI_aarch64_rust-uu_basename-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_basename-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_basename-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_basename-devel}"
SRC_URI[aarch64_rust-uu_basename-devel.sha256sum] = "2ae0b1ba4eba0ea21ef699df1b5caeb742717901452a7151efc8838bcdc300d7"

RDEPENDS:rust-uu_basename+default-devel = " \
 cargo \
 rust-uu_basename-devel \
 "
RDEPENDS:rust-uu_basename-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 "
