# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ammonia"
PV = "4.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-ammonia+default-devel \
 rust-ammonia-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ammonia-4.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de157d3bc414be299015470b56c64a7e075d7e12c07e92a51ebf1cc72a796695"

URI_x86_64_v2_rust-ammonia+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ammonia+default-devel-4.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ammonia+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ammonia+default-devel}"
SRC_URI[x86_64_v2_rust-ammonia+default-devel.sha256sum] = "1d53fcf57ac0c42f209d86a563218cbfbe21e055a967b5e8aa7b66941e02eb57"

URI_x86_64_v2_rust-ammonia-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ammonia-devel-4.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ammonia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ammonia-devel}"
SRC_URI[x86_64_v2_rust-ammonia-devel.sha256sum] = "cc9792304e33ce4548123cec6c1195b0b4059ebcf8399b73eef1bb279d06386b"

URI_aarch64_rust-ammonia+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ammonia+default-devel-4.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-ammonia+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ammonia+default-devel}"
SRC_URI[aarch64_rust-ammonia+default-devel.sha256sum] = "c3961854dda6604ec29df45615824e14e98baee1559bbcb95d5a10f0c6b9ad29"

URI_aarch64_rust-ammonia-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ammonia-devel-4.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-ammonia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ammonia-devel}"
SRC_URI[aarch64_rust-ammonia-devel.sha256sum] = "6f2d970b636105cb1ada75042a39c6ab022b7578b7ba4006b7ee3a9826269783"

RDEPENDS:rust-ammonia+default-devel = " \
 cargo \
 rust-ammonia-devel \
 "
RDEPENDS:rust-ammonia-devel = " \
 cargo \
 rust \
 rust-html5ever+default-devel \
 rust-maplit+default-devel \
 rust-once_cell+default-devel \
 rust-tendril+default-devel \
 rust-url+default-devel \
 "
