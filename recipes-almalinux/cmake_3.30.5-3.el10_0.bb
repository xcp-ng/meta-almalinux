# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cmake"
PV = "3.30.5"
PR = "3.el10_0"
PACKAGES = " \
 cmake \
 cmake-data \
 cmake-doc \
 cmake-filesystem \
 cmake-gui \
 cmake-rpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cmake-3.30.5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f5c69fc9dd081be8bd4349d83caaf40438d417d281f31d64ca963c21d47fbf0"

URI_x86_64_v2_cmake = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cmake-3.30.5-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_cmake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmake}"
SRC_URI[x86_64_v2_cmake.sha256sum] = "6df31a40956d5b80fbd1d3f32f13bd632c5101931d05a15ff12fc49dc04cc6d8"

URI_x86_64_v2_cmake-data = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cmake-data-3.30.5-3.el10_0.noarch.rpm;name=x86_64_v2_cmake-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmake-data}"
SRC_URI[x86_64_v2_cmake-data.sha256sum] = "8a325779b601baf5c11cf97966d584e6c3461c519f83db02c048aed42d72046d"

URI_x86_64_v2_cmake-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cmake-doc-3.30.5-3.el10_0.noarch.rpm;name=x86_64_v2_cmake-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmake-doc}"
SRC_URI[x86_64_v2_cmake-doc.sha256sum] = "ede5fd77c8ff7676cce538df71ed06649a06ffb461c2ae9a832b1dc8d9c8753a"

URI_x86_64_v2_cmake-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cmake-filesystem-3.30.5-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_cmake-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmake-filesystem}"
SRC_URI[x86_64_v2_cmake-filesystem.sha256sum] = "4cfb6f62506c5de0e18c538448fac1e332c863555f733bd3141cb0f87b90e225"

URI_x86_64_v2_cmake-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cmake-gui-3.30.5-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_cmake-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmake-gui}"
SRC_URI[x86_64_v2_cmake-gui.sha256sum] = "01d9ab1972a6d9fbe4e397c8a28f51c02619836148a25e6aa88526915c3f003b"

URI_x86_64_v2_cmake-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cmake-rpm-macros-3.30.5-3.el10_0.noarch.rpm;name=x86_64_v2_cmake-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmake-rpm-macros}"
SRC_URI[x86_64_v2_cmake-rpm-macros.sha256sum] = "fbff46632b94941136186b03331c1137170e16f91812331d974923cc6b344c22"

URI_aarch64_cmake = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cmake-3.30.5-3.el10_0.aarch64.rpm;name=aarch64_cmake;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmake}"
SRC_URI[aarch64_cmake.sha256sum] = "9844d16d3122e310ebea4e7e525cb6db4a96478c589e0bd97e8e81b28172e0f1"

URI_aarch64_cmake-data = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cmake-data-3.30.5-3.el10_0.noarch.rpm;name=aarch64_cmake-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmake-data}"
SRC_URI[aarch64_cmake-data.sha256sum] = "8a325779b601baf5c11cf97966d584e6c3461c519f83db02c048aed42d72046d"

URI_aarch64_cmake-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cmake-doc-3.30.5-3.el10_0.noarch.rpm;name=aarch64_cmake-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmake-doc}"
SRC_URI[aarch64_cmake-doc.sha256sum] = "ede5fd77c8ff7676cce538df71ed06649a06ffb461c2ae9a832b1dc8d9c8753a"

URI_aarch64_cmake-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cmake-filesystem-3.30.5-3.el10_0.aarch64.rpm;name=aarch64_cmake-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmake-filesystem}"
SRC_URI[aarch64_cmake-filesystem.sha256sum] = "bddd40168bc67570b31203a4808291374df9207e48c9248405d1ed615f7c66d2"

URI_aarch64_cmake-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cmake-gui-3.30.5-3.el10_0.aarch64.rpm;name=aarch64_cmake-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmake-gui}"
SRC_URI[aarch64_cmake-gui.sha256sum] = "84ece7ef81127ef98a17da36800d1c71fcab183611bfd970fa4d643634ff027d"

URI_aarch64_cmake-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cmake-rpm-macros-3.30.5-3.el10_0.noarch.rpm;name=aarch64_cmake-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmake-rpm-macros}"
SRC_URI[aarch64_cmake-rpm-macros.sha256sum] = "fbff46632b94941136186b03331c1137170e16f91812331d974923cc6b344c22"

RDEPENDS:cmake = " \
 cmake-data \
 cmake-filesystem \
 cmake-rpm-macros \
 expat \
 glibc \
 libarchive \
 libgcc \
 libstdc++ \
 libuv \
 make \
 ncurses-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:cmake-data = " \
 cmake \
 cmake-filesystem \
 cmake-rpm-macros \
 emacs-filesystem \
 vim-filesystem \
 "
RDEPENDS:cmake-doc = " \
 "
RDEPENDS:cmake-filesystem = " \
 "
RDEPENDS:cmake-gui = " \
 cmake \
 glibc \
 hicolor-icon-theme \
 libarchive \
 libgcc \
 libstdc++ \
 libuv \
 qt6-qtbase \
 qt6-qtbase-gui \
 shared-mime-info \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:cmake-rpm-macros = " \
 python3 \
 rpm \
 "
