# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Spellunker"
PV = "0.4.0"
PR = "27.el10_0"
PACKAGES = " \
 perl-Spellunker \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Spellunker-0.4.0-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "412974b4bc50a22edce85a6c8159a7861a8bb8820a59fb89113590e17f8efd8e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Spellunker-0.4.0-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Spellunker;unpack=0"
SRC_URI[x86_64_v2_perl-Spellunker.sha256sum] = "a7cfdcd802a29d54ef181e04ab5c3b845b27eaf6beea9e0b632d9580d3181c9b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Spellunker-0.4.0-27.el10_0.noarch.rpm;name=aarch64_perl-Spellunker;unpack=0"
SRC_URI[aarch64_perl-Spellunker.sha256sum] = "b93bbf4b11329eef78ccb3e096a5c036927f6dea930b4e3baecb291151e64820"

RDEPENDS:perl-Spellunker = " \
 perl-Carp \
 perl-Exporter \
 perl-File-ShareDir \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Simple \
 perl-Regexp-Common \
 perl-Scalar-List-Utils \
 perl-Spellunker \
 perl-Term-ANSIColor \
 perl-Test-Simple \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-parent \
 perl-version \
 "
