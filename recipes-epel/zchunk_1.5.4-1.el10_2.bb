# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zchunk"
PV = "1.5.4"
PR = "1.el10_2"
PACKAGES = " \
 zchunk \
 zchunk-devel \
 zchunk-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zchunk-1.5.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f33176e77022d6b65f5f1e7973b7d26ae4171d143a8c3981ae3958616a34a6b3"

URI_x86_64_v2_zchunk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zchunk-1.5.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zchunk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zchunk}"
SRC_URI[x86_64_v2_zchunk.sha256sum] = "e5a07020ce071494b3efcfb5ba4bfe23e7b47a4b2b80260308aeda6a0663cee5"

URI_x86_64_v2_zchunk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zchunk-devel-1.5.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zchunk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zchunk-devel}"
SRC_URI[x86_64_v2_zchunk-devel.sha256sum] = "8244481b2c81d8a8a3b65695611d3be09b368ea4ecf0daed045e7c2a0e2897e2"

URI_x86_64_v2_zchunk-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zchunk-libs-1.5.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zchunk-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zchunk-libs}"
SRC_URI[x86_64_v2_zchunk-libs.sha256sum] = "94cd23e1a61fadfcede0284f5ce72a5d4a041f0fe807eda7160b3f2297bf5547"

URI_aarch64_zchunk = "${EPEL_MIRROR}/aarch64/Packages/z/zchunk-1.5.4-1.el10_2.aarch64.rpm;name=aarch64_zchunk;unpack=0"
SRC_URI:append = " ${URI_aarch64_zchunk}"
SRC_URI[aarch64_zchunk.sha256sum] = "401972d51dc9b781ba10792ec990bfa7cbfb204e65f18523fb0be4cef1fc8824"

URI_aarch64_zchunk-devel = "${EPEL_MIRROR}/aarch64/Packages/z/zchunk-devel-1.5.4-1.el10_2.aarch64.rpm;name=aarch64_zchunk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zchunk-devel}"
SRC_URI[aarch64_zchunk-devel.sha256sum] = "b29aff075a97fca195bee866b663d4104cfa10523696470d0ec99c2693defc46"

URI_aarch64_zchunk-libs = "${EPEL_MIRROR}/aarch64/Packages/z/zchunk-libs-1.5.4-1.el10_2.aarch64.rpm;name=aarch64_zchunk-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_zchunk-libs}"
SRC_URI[aarch64_zchunk-libs.sha256sum] = "76a068290b1a39bf9b367974b5aed211e08092b229b39a10aee155cd777bd1f9"

RDEPENDS:zchunk = " \
 glibc \
 python3 \
 virtual/libcurl.so.4___64bit_ \
 zchunk-libs \
 "
RDEPENDS:zchunk-devel = " \
 libzstd-devel \
 openssl-devel \
 pkgconf-pkg-config \
 zchunk-libs \
 "
RDEPENDS:zchunk-libs = " \
 glibc \
 libzstd \
 openssl-libs \
 "
