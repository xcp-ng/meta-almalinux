# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc9.2"
PV = "9.2.8"
PR = "28.el10_0"
PACKAGES = " \
 ghc9.2 \
 ghc9.2-Cabal \
 ghc9.2-Cabal-devel \
 ghc9.2-Cabal-doc \
 ghc9.2-Cabal-prof \
 ghc9.2-array \
 ghc9.2-array-devel \
 ghc9.2-array-doc \
 ghc9.2-array-prof \
 ghc9.2-base \
 ghc9.2-base-devel \
 ghc9.2-base-doc \
 ghc9.2-base-prof \
 ghc9.2-binary \
 ghc9.2-binary-devel \
 ghc9.2-binary-doc \
 ghc9.2-binary-prof \
 ghc9.2-bytestring \
 ghc9.2-bytestring-devel \
 ghc9.2-bytestring-doc \
 ghc9.2-bytestring-prof \
 ghc9.2-compiler \
 ghc9.2-compiler-default \
 ghc9.2-containers \
 ghc9.2-containers-devel \
 ghc9.2-containers-doc \
 ghc9.2-containers-prof \
 ghc9.2-deepseq \
 ghc9.2-deepseq-devel \
 ghc9.2-deepseq-doc \
 ghc9.2-deepseq-prof \
 ghc9.2-devel \
 ghc9.2-directory \
 ghc9.2-directory-devel \
 ghc9.2-directory-doc \
 ghc9.2-directory-prof \
 ghc9.2-doc \
 ghc9.2-doc-index \
 ghc9.2-exceptions \
 ghc9.2-exceptions-devel \
 ghc9.2-exceptions-doc \
 ghc9.2-exceptions-prof \
 ghc9.2-filepath \
 ghc9.2-filepath-devel \
 ghc9.2-filepath-doc \
 ghc9.2-filepath-prof \
 ghc9.2-filesystem \
 ghc9.2-ghc \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-bignum-devel \
 ghc9.2-ghc-bignum-doc \
 ghc9.2-ghc-bignum-prof \
 ghc9.2-ghc-boot \
 ghc9.2-ghc-boot-devel \
 ghc9.2-ghc-boot-doc \
 ghc9.2-ghc-boot-prof \
 ghc9.2-ghc-boot-th \
 ghc9.2-ghc-boot-th-devel \
 ghc9.2-ghc-boot-th-doc \
 ghc9.2-ghc-boot-th-prof \
 ghc9.2-ghc-compact \
 ghc9.2-ghc-compact-devel \
 ghc9.2-ghc-compact-doc \
 ghc9.2-ghc-compact-prof \
 ghc9.2-ghc-devel \
 ghc9.2-ghc-doc \
 ghc9.2-ghc-heap \
 ghc9.2-ghc-heap-devel \
 ghc9.2-ghc-heap-doc \
 ghc9.2-ghc-heap-prof \
 ghc9.2-ghc-prof \
 ghc9.2-ghci \
 ghc9.2-ghci-devel \
 ghc9.2-ghci-doc \
 ghc9.2-ghci-prof \
 ghc9.2-hadrian \
 ghc9.2-haskeline \
 ghc9.2-haskeline-devel \
 ghc9.2-haskeline-doc \
 ghc9.2-haskeline-prof \
 ghc9.2-hpc \
 ghc9.2-hpc-devel \
 ghc9.2-hpc-doc \
 ghc9.2-hpc-prof \
 ghc9.2-libiserv \
 ghc9.2-libiserv-devel \
 ghc9.2-libiserv-doc \
 ghc9.2-libiserv-prof \
 ghc9.2-manual \
 ghc9.2-mtl \
 ghc9.2-mtl-devel \
 ghc9.2-mtl-doc \
 ghc9.2-mtl-prof \
 ghc9.2-parsec \
 ghc9.2-parsec-devel \
 ghc9.2-parsec-doc \
 ghc9.2-parsec-prof \
 ghc9.2-pretty \
 ghc9.2-pretty-devel \
 ghc9.2-pretty-doc \
 ghc9.2-pretty-prof \
 ghc9.2-process \
 ghc9.2-process-devel \
 ghc9.2-process-doc \
 ghc9.2-process-prof \
 ghc9.2-prof \
 ghc9.2-stm \
 ghc9.2-stm-devel \
 ghc9.2-stm-doc \
 ghc9.2-stm-prof \
 ghc9.2-template-haskell \
 ghc9.2-template-haskell-devel \
 ghc9.2-template-haskell-doc \
 ghc9.2-template-haskell-prof \
 ghc9.2-terminfo \
 ghc9.2-terminfo-devel \
 ghc9.2-terminfo-doc \
 ghc9.2-terminfo-prof \
 ghc9.2-text \
 ghc9.2-text-devel \
 ghc9.2-text-doc \
 ghc9.2-text-prof \
 ghc9.2-time \
 ghc9.2-time-devel \
 ghc9.2-time-doc \
 ghc9.2-time-prof \
 ghc9.2-transformers \
 ghc9.2-transformers-devel \
 ghc9.2-transformers-doc \
 ghc9.2-transformers-prof \
 ghc9.2-unix \
 ghc9.2-unix-devel \
 ghc9.2-unix-doc \
 ghc9.2-unix-prof \
 ghc9.2-xhtml \
 ghc9.2-xhtml-devel \
 ghc9.2-xhtml-doc \
 ghc9.2-xhtml-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc9.2-9.2.8-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35884a5339404869dedfbf889e7a32af332cd403f23b6063b29ff077f468794c"

URI_x86_64_v2_ghc9.2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2}"
SRC_URI[x86_64_v2_ghc9.2.sha256sum] = "b5ef443e45473c13500bd9c75de6610d477ff1c610c457b4843c84bf352afb29"

URI_x86_64_v2_ghc9.2-Cabal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-Cabal-3.6.3.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-Cabal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-Cabal}"
SRC_URI[x86_64_v2_ghc9.2-Cabal.sha256sum] = "aacdb00528b1da8e95411f0e9c95c1b924ecd4125b672daefbabaf8b608ab65f"

URI_x86_64_v2_ghc9.2-Cabal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-Cabal-devel-3.6.3.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-Cabal-devel}"
SRC_URI[x86_64_v2_ghc9.2-Cabal-devel.sha256sum] = "cfedb6dc105424f2038c2d1c2baf362031f36c038081762e7f239ac5a62732e6"

URI_x86_64_v2_ghc9.2-Cabal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-Cabal-doc-3.6.3.0-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-Cabal-doc}"
SRC_URI[x86_64_v2_ghc9.2-Cabal-doc.sha256sum] = "1fc457be283502b0c229c7e646d1df1b45ae6c54618535e42f2eec67048c48b8"

URI_x86_64_v2_ghc9.2-Cabal-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-Cabal-prof-3.6.3.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-Cabal-prof}"
SRC_URI[x86_64_v2_ghc9.2-Cabal-prof.sha256sum] = "c3b391196534ea88592581385f6a2d3ceeefb9f386dbe2962c9b8500357d10b6"

URI_x86_64_v2_ghc9.2-array = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-array-0.5.4.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-array}"
SRC_URI[x86_64_v2_ghc9.2-array.sha256sum] = "7e3d80ae492b87214dca26685a5c0776346a48a7e40e9e3f762da3df44b90a30"

URI_x86_64_v2_ghc9.2-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-array-devel-0.5.4.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-array-devel}"
SRC_URI[x86_64_v2_ghc9.2-array-devel.sha256sum] = "23324ede17c2cfddc7631550026cada192559d080b1316fc6c6ed33257a32c06"

URI_x86_64_v2_ghc9.2-array-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-array-doc-0.5.4.0-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-array-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-array-doc}"
SRC_URI[x86_64_v2_ghc9.2-array-doc.sha256sum] = "b4897f63a4fe01d23c761f0c31d14e9598e167b53f1a36d966b4f1b922cd3c30"

URI_x86_64_v2_ghc9.2-array-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-array-prof-0.5.4.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-array-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-array-prof}"
SRC_URI[x86_64_v2_ghc9.2-array-prof.sha256sum] = "08252d6e51082f58af944c244099fccf005c575d8246e5b3a37b3dd6c33a9646"

URI_x86_64_v2_ghc9.2-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-base-4.16.4.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-base}"
SRC_URI[x86_64_v2_ghc9.2-base.sha256sum] = "2bb297ca8a49bbcc8e7f92b1eea9254df7e15e4a091d31ca6bfb2971a3bd70b8"

URI_x86_64_v2_ghc9.2-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-base-devel-4.16.4.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-base-devel}"
SRC_URI[x86_64_v2_ghc9.2-base-devel.sha256sum] = "6a3aed90c9a43d458a6a045693580c6f8383fbb10d638a1f5aa535cc94178684"

URI_x86_64_v2_ghc9.2-base-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-base-doc-4.16.4.0-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-base-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-base-doc}"
SRC_URI[x86_64_v2_ghc9.2-base-doc.sha256sum] = "3719fc09e7a877860d108850972ebaac98c23f3a5376a09f521650dd371d7f4d"

URI_x86_64_v2_ghc9.2-base-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-base-prof-4.16.4.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-base-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-base-prof}"
SRC_URI[x86_64_v2_ghc9.2-base-prof.sha256sum] = "97e7891f13b9a4797d756b19cdc93e4ac7228d972cd5232c3ac49b8ac8071e64"

URI_x86_64_v2_ghc9.2-binary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-binary-0.8.9.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-binary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-binary}"
SRC_URI[x86_64_v2_ghc9.2-binary.sha256sum] = "6ce52d84c8ed672de9348294aed881296754beb66e105d95acc461409cd74a13"

URI_x86_64_v2_ghc9.2-binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-binary-devel-0.8.9.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-binary-devel}"
SRC_URI[x86_64_v2_ghc9.2-binary-devel.sha256sum] = "9a26fea359b13e2a20a11805880a4ef96c4dacef312495766fe0bbd99c1e826b"

URI_x86_64_v2_ghc9.2-binary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-binary-doc-0.8.9.0-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-binary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-binary-doc}"
SRC_URI[x86_64_v2_ghc9.2-binary-doc.sha256sum] = "d1b1e0ded799ec8747fa21eda4e5cf00f6b71dd240f68442bfbb724eb10dad70"

URI_x86_64_v2_ghc9.2-binary-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-binary-prof-0.8.9.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-binary-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-binary-prof}"
SRC_URI[x86_64_v2_ghc9.2-binary-prof.sha256sum] = "8da58d4d2121122bb7e2110de755aaddb0c3944bf1f663daa151678b08d404d9"

URI_x86_64_v2_ghc9.2-bytestring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-bytestring-0.11.4.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-bytestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-bytestring}"
SRC_URI[x86_64_v2_ghc9.2-bytestring.sha256sum] = "2e366c0d973280080e885bea1b030fc0e0f976a382168348b00d4474173d9ff1"

URI_x86_64_v2_ghc9.2-bytestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-bytestring-devel-0.11.4.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-bytestring-devel}"
SRC_URI[x86_64_v2_ghc9.2-bytestring-devel.sha256sum] = "00d30cf71ccfdd4ad4af255946aeb2558b5820f17dfc175db27e0e17723e4f47"

URI_x86_64_v2_ghc9.2-bytestring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-bytestring-doc-0.11.4.0-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-bytestring-doc}"
SRC_URI[x86_64_v2_ghc9.2-bytestring-doc.sha256sum] = "90d8b04b5b7c72756de37e4759e725a088d6f34c732f238b295f4f5ea966ba41"

URI_x86_64_v2_ghc9.2-bytestring-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-bytestring-prof-0.11.4.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-bytestring-prof}"
SRC_URI[x86_64_v2_ghc9.2-bytestring-prof.sha256sum] = "bd312928d8b24beb23945897ac74717010b7e4bfef281fc460c74c1cb6bd7ded"

URI_x86_64_v2_ghc9.2-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-compiler-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-compiler}"
SRC_URI[x86_64_v2_ghc9.2-compiler.sha256sum] = "5e531a182e6a024675959479324e9864876fe35f27daf21cd10180621ad91af1"

URI_x86_64_v2_ghc9.2-compiler-default = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-compiler-default-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-compiler-default;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-compiler-default}"
SRC_URI[x86_64_v2_ghc9.2-compiler-default.sha256sum] = "c2b2b625bf52deffaa00104e2cce54df7a20de96c077e739885ec9ccbe6c011f"

URI_x86_64_v2_ghc9.2-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-containers-0.6.5.1-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-containers}"
SRC_URI[x86_64_v2_ghc9.2-containers.sha256sum] = "c9ee3235c4a7bf63f7449ad5f6d66ccd23b769a68b54254fe84b36af66aba057"

URI_x86_64_v2_ghc9.2-containers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-containers-devel-0.6.5.1-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-containers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-containers-devel}"
SRC_URI[x86_64_v2_ghc9.2-containers-devel.sha256sum] = "52bdb34e344b15570ebe0d661a44477ef0abe8b5335d1d2cf1aade8bbfcda9a8"

URI_x86_64_v2_ghc9.2-containers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-containers-doc-0.6.5.1-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-containers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-containers-doc}"
SRC_URI[x86_64_v2_ghc9.2-containers-doc.sha256sum] = "9899d96ea111cf0b3d724f931a0db5e3572aac5be20d46e3b61f6f53b6051ff3"

URI_x86_64_v2_ghc9.2-containers-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-containers-prof-0.6.5.1-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-containers-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-containers-prof}"
SRC_URI[x86_64_v2_ghc9.2-containers-prof.sha256sum] = "68dc1bb070a1b49d4e2bba6a618af2840623f2229b43634e093cd1da36aeb925"

URI_x86_64_v2_ghc9.2-deepseq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-deepseq-1.4.6.1-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-deepseq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-deepseq}"
SRC_URI[x86_64_v2_ghc9.2-deepseq.sha256sum] = "1cb0a1c9444e662e7f0b8b43fa06cfe197bc51b26ed6657d7a7d6f2f7c45d473"

URI_x86_64_v2_ghc9.2-deepseq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-deepseq-devel-1.4.6.1-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-deepseq-devel}"
SRC_URI[x86_64_v2_ghc9.2-deepseq-devel.sha256sum] = "561acf7141e2777ab6b20b61eea886037f4f1d2ea21292215bf13c620e84f8d0"

URI_x86_64_v2_ghc9.2-deepseq-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-deepseq-doc-1.4.6.1-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-deepseq-doc}"
SRC_URI[x86_64_v2_ghc9.2-deepseq-doc.sha256sum] = "e77cf4dfd2cb28a65c4f89aa2249383ce2eb947a71de5b61899a3ed27b5859f3"

URI_x86_64_v2_ghc9.2-deepseq-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-deepseq-prof-1.4.6.1-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-deepseq-prof}"
SRC_URI[x86_64_v2_ghc9.2-deepseq-prof.sha256sum] = "e809690465bfbf0bdf00261adc16c0458058db8a9b539595c44a7cb4d5c89f1e"

URI_x86_64_v2_ghc9.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-devel-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-devel}"
SRC_URI[x86_64_v2_ghc9.2-devel.sha256sum] = "00dac4a86eda45fe2f04412ef964404d0075a3807014fa2246ce09565c17134b"

URI_x86_64_v2_ghc9.2-directory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-directory-1.3.6.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-directory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-directory}"
SRC_URI[x86_64_v2_ghc9.2-directory.sha256sum] = "c4b79a972c0a5e813cde195fc5203c0737fa783fbaf4d58a7685aeb306c0a215"

URI_x86_64_v2_ghc9.2-directory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-directory-devel-1.3.6.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-directory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-directory-devel}"
SRC_URI[x86_64_v2_ghc9.2-directory-devel.sha256sum] = "e7c90d3133f700367a5175e819e6dfd848ca2c7c7b3240efd69be53c291c80fb"

URI_x86_64_v2_ghc9.2-directory-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-directory-doc-1.3.6.2-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-directory-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-directory-doc}"
SRC_URI[x86_64_v2_ghc9.2-directory-doc.sha256sum] = "69325c561c93da57583029d6104d10625d6df84239c542ee24e670a13c8e3851"

URI_x86_64_v2_ghc9.2-directory-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-directory-prof-1.3.6.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-directory-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-directory-prof}"
SRC_URI[x86_64_v2_ghc9.2-directory-prof.sha256sum] = "2251f0a63b61f6a5c41c2169699fcd5804dec411035df2677c437d081b0dd0a3"

URI_x86_64_v2_ghc9.2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-doc-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-doc}"
SRC_URI[x86_64_v2_ghc9.2-doc.sha256sum] = "78a75082f790ef5c55d4d302705d7d30dcf41c52ce5dc2e618d79224bee75aad"

URI_x86_64_v2_ghc9.2-doc-index = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-doc-index-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-doc-index;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-doc-index}"
SRC_URI[x86_64_v2_ghc9.2-doc-index.sha256sum] = "6a2cd62e6c9cc23a3569ba4d2a38ee03568c915e2e67f519175be7d79e0360b3"

URI_x86_64_v2_ghc9.2-exceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-exceptions-0.10.4-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-exceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-exceptions}"
SRC_URI[x86_64_v2_ghc9.2-exceptions.sha256sum] = "b093422ade52d855a48b7ae95e0bccb03217dfe9c922ce2dadc5d65253764a5b"

URI_x86_64_v2_ghc9.2-exceptions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-exceptions-devel-0.10.4-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-exceptions-devel}"
SRC_URI[x86_64_v2_ghc9.2-exceptions-devel.sha256sum] = "630b5bcbe2d3ee8535fe8c668f415315c54f3294f51a5beadae5d5dc9cb44fac"

URI_x86_64_v2_ghc9.2-exceptions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-exceptions-doc-0.10.4-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-exceptions-doc}"
SRC_URI[x86_64_v2_ghc9.2-exceptions-doc.sha256sum] = "7b20a33725599c5317e50df2912c2ef56eb309ed851a547c03ce359f1fb53c54"

URI_x86_64_v2_ghc9.2-exceptions-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-exceptions-prof-0.10.4-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-exceptions-prof}"
SRC_URI[x86_64_v2_ghc9.2-exceptions-prof.sha256sum] = "cba202d80a11f23571993610b3db01925532169e9e3e0d055dac6e99444f0649"

URI_x86_64_v2_ghc9.2-filepath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-filepath-1.4.2.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-filepath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-filepath}"
SRC_URI[x86_64_v2_ghc9.2-filepath.sha256sum] = "c9d94e9fd208bad9a182a42c6d158019e08d0bdc94736d5477ea6a58ff897aad"

URI_x86_64_v2_ghc9.2-filepath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-filepath-devel-1.4.2.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-filepath-devel}"
SRC_URI[x86_64_v2_ghc9.2-filepath-devel.sha256sum] = "21d9c041da5009fee14ad5c9310ce0dae1d779e9854edfb758cbc8fb211e8efe"

URI_x86_64_v2_ghc9.2-filepath-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-filepath-doc-1.4.2.2-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-filepath-doc}"
SRC_URI[x86_64_v2_ghc9.2-filepath-doc.sha256sum] = "f6f1063b1eee4c2a8fccc0d31450ce01ffd07ee5310ed3a9514cdb881c8a20a3"

URI_x86_64_v2_ghc9.2-filepath-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-filepath-prof-1.4.2.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-filepath-prof}"
SRC_URI[x86_64_v2_ghc9.2-filepath-prof.sha256sum] = "d84594172aaa9d395574f403ff1848e51da65d8fac7ac30b8c78ae3ee0ede6e3"

URI_x86_64_v2_ghc9.2-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-filesystem-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-filesystem}"
SRC_URI[x86_64_v2_ghc9.2-filesystem.sha256sum] = "90a38456218858edab7f6e8f13018daae46581cd3e612deaca75be4a52fb48c3"

URI_x86_64_v2_ghc9.2-ghc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc}"
SRC_URI[x86_64_v2_ghc9.2-ghc.sha256sum] = "2a6a7aedd2cfdb66ed12f8021bdbe5571288e19c71cc056f2b9008e27107d097"

URI_x86_64_v2_ghc9.2-ghc-bignum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-bignum-1.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-bignum}"
SRC_URI[x86_64_v2_ghc9.2-ghc-bignum.sha256sum] = "74bdb758c9b7c0dfa23d127f711b8d7121322fa1b393251f8d39d1c32c9a3d82"

URI_x86_64_v2_ghc9.2-ghc-bignum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-bignum-devel-1.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-bignum-devel}"
SRC_URI[x86_64_v2_ghc9.2-ghc-bignum-devel.sha256sum] = "72adef7306de9518fc8f07c7db4cd94ffaa4492f9bdf8170e73ccd9c16e55228"

URI_x86_64_v2_ghc9.2-ghc-bignum-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-bignum-doc-1.2-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-bignum-doc}"
SRC_URI[x86_64_v2_ghc9.2-ghc-bignum-doc.sha256sum] = "e07600baa4d06e6aa539cdf175d030d2aca706c2402b59a26bda84a014145e78"

URI_x86_64_v2_ghc9.2-ghc-bignum-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-bignum-prof-1.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-bignum-prof}"
SRC_URI[x86_64_v2_ghc9.2-ghc-bignum-prof.sha256sum] = "7510a0f2e85db5daf7259cbbb19a7c2d9e0989c5e0b3d9f8b9e99b196559a6fd"

URI_x86_64_v2_ghc9.2-ghc-boot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-boot-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-boot}"
SRC_URI[x86_64_v2_ghc9.2-ghc-boot.sha256sum] = "c296b2820da93ba48695be1addc2f44e15fc2817c72613ff0daa078309cb26b0"

URI_x86_64_v2_ghc9.2-ghc-boot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-boot-devel-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-boot-devel}"
SRC_URI[x86_64_v2_ghc9.2-ghc-boot-devel.sha256sum] = "53d215724e9e780bec04b56a59100f44a4ffca1f82f853b4656c43b1d28deea2"

URI_x86_64_v2_ghc9.2-ghc-boot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-boot-doc-9.2.8-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-boot-doc}"
SRC_URI[x86_64_v2_ghc9.2-ghc-boot-doc.sha256sum] = "e93572a7dbe032189a6f52fc9b0b91503eeb244112cac3c4f8601997d4d35154"

URI_x86_64_v2_ghc9.2-ghc-boot-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-boot-prof-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-boot-prof}"
SRC_URI[x86_64_v2_ghc9.2-ghc-boot-prof.sha256sum] = "0de8836e8c0a04ed0aca1f9d9e4accc9381018d494a02a9e65f697c71c92ab7b"

URI_x86_64_v2_ghc9.2-ghc-boot-th = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-boot-th-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-boot-th}"
SRC_URI[x86_64_v2_ghc9.2-ghc-boot-th.sha256sum] = "9c9deab74753ed663a6e4c58f7a25020a461dc97621d60f568be51797869eee2"

URI_x86_64_v2_ghc9.2-ghc-boot-th-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-boot-th-devel-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-boot-th-devel}"
SRC_URI[x86_64_v2_ghc9.2-ghc-boot-th-devel.sha256sum] = "46253146867f5d7499024f303285514825d4c07da58c8cc5f02dae55415d4778"

URI_x86_64_v2_ghc9.2-ghc-boot-th-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-boot-th-doc-9.2.8-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-boot-th-doc}"
SRC_URI[x86_64_v2_ghc9.2-ghc-boot-th-doc.sha256sum] = "3059251bbf90fb2de28ba95d26ebbe1d32fba179bf14cc9c3fb7deb158de9ca0"

URI_x86_64_v2_ghc9.2-ghc-boot-th-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-boot-th-prof-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-boot-th-prof}"
SRC_URI[x86_64_v2_ghc9.2-ghc-boot-th-prof.sha256sum] = "a9a6463b4c1f0f89d5b99e4afbe30b48585fcf9cfce00af5a88c994d45fc4d19"

URI_x86_64_v2_ghc9.2-ghc-compact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-compact-0.1.0.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-compact}"
SRC_URI[x86_64_v2_ghc9.2-ghc-compact.sha256sum] = "f337d71eb53ec2e4b08fae50e0e594e51dab7f24e127893e925ebf9876905c14"

URI_x86_64_v2_ghc9.2-ghc-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-compact-devel-0.1.0.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-compact-devel}"
SRC_URI[x86_64_v2_ghc9.2-ghc-compact-devel.sha256sum] = "9e337a6e7f60690a87ec450f160eb43f0ba5df314ae14e878cf2e734e59958fb"

URI_x86_64_v2_ghc9.2-ghc-compact-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-compact-doc-0.1.0.0-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-compact-doc}"
SRC_URI[x86_64_v2_ghc9.2-ghc-compact-doc.sha256sum] = "2a629a22fe5b9484853a92ab305d108d4d7dc6221592c170094d0efb4cf4cc1d"

URI_x86_64_v2_ghc9.2-ghc-compact-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-compact-prof-0.1.0.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-compact-prof}"
SRC_URI[x86_64_v2_ghc9.2-ghc-compact-prof.sha256sum] = "bc996b53d871006b3ca4827012a30475e0e0c753b120e64e712d6307e8b393c7"

URI_x86_64_v2_ghc9.2-ghc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-devel-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-devel}"
SRC_URI[x86_64_v2_ghc9.2-ghc-devel.sha256sum] = "2a3ad59a368bb49257f9128da105bc9c0593ca6c138aadb15312544772751898"

URI_x86_64_v2_ghc9.2-ghc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-doc-9.2.8-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-doc}"
SRC_URI[x86_64_v2_ghc9.2-ghc-doc.sha256sum] = "329ee941a46288e28fdc512afb3817e9564228b98c81c536792080910868ca4b"

URI_x86_64_v2_ghc9.2-ghc-heap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-heap-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-heap}"
SRC_URI[x86_64_v2_ghc9.2-ghc-heap.sha256sum] = "9051fe9b6a0c1fe3f594439ffa0552117121017e7b4266f155c2e342834776cd"

URI_x86_64_v2_ghc9.2-ghc-heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-heap-devel-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-heap-devel}"
SRC_URI[x86_64_v2_ghc9.2-ghc-heap-devel.sha256sum] = "7fa6b1341fd1858b5dd7cba2336c7aeff667fdf02c03b89b36670f7e4adafe81"

URI_x86_64_v2_ghc9.2-ghc-heap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-heap-doc-9.2.8-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-heap-doc}"
SRC_URI[x86_64_v2_ghc9.2-ghc-heap-doc.sha256sum] = "572b6045b6db723a869ebb657be3e997f7a6cda8265d926c47b150d7ad1c996d"

URI_x86_64_v2_ghc9.2-ghc-heap-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-heap-prof-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-heap-prof}"
SRC_URI[x86_64_v2_ghc9.2-ghc-heap-prof.sha256sum] = "7af9caafe307951f597e8a5ab276a76f3b46c7c0bebfba92e169410df95a7386"

URI_x86_64_v2_ghc9.2-ghc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghc-prof-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghc-prof}"
SRC_URI[x86_64_v2_ghc9.2-ghc-prof.sha256sum] = "585c223f9401da40b7752940771be9b1fe10dfe017107a1026c2475fedf51661"

URI_x86_64_v2_ghc9.2-ghci = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghci-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghci}"
SRC_URI[x86_64_v2_ghc9.2-ghci.sha256sum] = "e9d1aec333c808c54075932f924f717abede7da5ab2abd7b9d91ddfc3df413e7"

URI_x86_64_v2_ghc9.2-ghci-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghci-devel-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghci-devel}"
SRC_URI[x86_64_v2_ghc9.2-ghci-devel.sha256sum] = "34c695bb3b9777bf57ebc1d819cf41e0944784879ce34edde5f228adb419c5ed"

URI_x86_64_v2_ghc9.2-ghci-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghci-doc-9.2.8-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghci-doc}"
SRC_URI[x86_64_v2_ghc9.2-ghci-doc.sha256sum] = "08aae6ecc785407c5679b7a76e77d2434f48ae5610e7fb2ad9067d3b9ede07ea"

URI_x86_64_v2_ghc9.2-ghci-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-ghci-prof-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-ghci-prof}"
SRC_URI[x86_64_v2_ghc9.2-ghci-prof.sha256sum] = "775307b0af9330145bc4856f2ace385d234ca6cd46d903a3ed13d7bf30e5e62f"

URI_x86_64_v2_ghc9.2-hadrian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-hadrian-0.1.0.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-hadrian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-hadrian}"
SRC_URI[x86_64_v2_ghc9.2-hadrian.sha256sum] = "be691214ed8ec98a2132cf6cd0b0a963b49b4a20ae643ebb29df08f9f169688b"

URI_x86_64_v2_ghc9.2-haskeline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-haskeline-0.8.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-haskeline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-haskeline}"
SRC_URI[x86_64_v2_ghc9.2-haskeline.sha256sum] = "a8ad2f0065daee3a71a6f4fe5a1bb73f6b32611ecac19b6e8e5d285219cfda6d"

URI_x86_64_v2_ghc9.2-haskeline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-haskeline-devel-0.8.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-haskeline-devel}"
SRC_URI[x86_64_v2_ghc9.2-haskeline-devel.sha256sum] = "c48f086f6116edb17b11c559464a7bfc2aada8daa63c986703a367e6bb08631f"

URI_x86_64_v2_ghc9.2-haskeline-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-haskeline-doc-0.8.2-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-haskeline-doc}"
SRC_URI[x86_64_v2_ghc9.2-haskeline-doc.sha256sum] = "6dc00a1958dcbe27f4fc43512fe7868292b7df79a55f66faf646ca00c977208e"

URI_x86_64_v2_ghc9.2-haskeline-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-haskeline-prof-0.8.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-haskeline-prof}"
SRC_URI[x86_64_v2_ghc9.2-haskeline-prof.sha256sum] = "d72b05e45639325bddc695b6e29692dddb86c18a3a5cb0cf45eda71b08aa51dd"

URI_x86_64_v2_ghc9.2-hpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-hpc-0.6.1.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-hpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-hpc}"
SRC_URI[x86_64_v2_ghc9.2-hpc.sha256sum] = "6748ba9ecafb04c7e2f48b27d21e96cdecac1554bc0f6f6729c376790e1c5ee9"

URI_x86_64_v2_ghc9.2-hpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-hpc-devel-0.6.1.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-hpc-devel}"
SRC_URI[x86_64_v2_ghc9.2-hpc-devel.sha256sum] = "8ee263c0039272d896526dbb00cc0522bf1be0edbc516f574cc958fad7b09bf6"

URI_x86_64_v2_ghc9.2-hpc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-hpc-doc-0.6.1.0-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-hpc-doc}"
SRC_URI[x86_64_v2_ghc9.2-hpc-doc.sha256sum] = "3bdf74c18e556a3ca0ae865df741c690ebb890428c2791617a214c6b30958f25"

URI_x86_64_v2_ghc9.2-hpc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-hpc-prof-0.6.1.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-hpc-prof}"
SRC_URI[x86_64_v2_ghc9.2-hpc-prof.sha256sum] = "38fe3fc4a818f4bd7c82199c7d1d3f8f991a9d9fa59f79f1513d2303aa7bf752"

URI_x86_64_v2_ghc9.2-libiserv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-libiserv-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-libiserv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-libiserv}"
SRC_URI[x86_64_v2_ghc9.2-libiserv.sha256sum] = "4add58d27238ceabb2c3130b8ef7660b6fc24c2b0708bd8d141936ea1bbcc59c"

URI_x86_64_v2_ghc9.2-libiserv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-libiserv-devel-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-libiserv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-libiserv-devel}"
SRC_URI[x86_64_v2_ghc9.2-libiserv-devel.sha256sum] = "ebbf4c704aac8ec3905219acd4c334f6e0c7a4d5aca33ce795fc718544f0d5f1"

URI_x86_64_v2_ghc9.2-libiserv-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-libiserv-doc-9.2.8-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-libiserv-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-libiserv-doc}"
SRC_URI[x86_64_v2_ghc9.2-libiserv-doc.sha256sum] = "cad8288c530427449bc0d3e2c8049799adafc750c8c07eb8e81c5b3fa1d27b79"

URI_x86_64_v2_ghc9.2-libiserv-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-libiserv-prof-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-libiserv-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-libiserv-prof}"
SRC_URI[x86_64_v2_ghc9.2-libiserv-prof.sha256sum] = "4e378a59306aed3281c8107c9f26974e756519d53a105da6f9e8dde7f991afc4"

URI_x86_64_v2_ghc9.2-manual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-manual-9.2.8-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-manual}"
SRC_URI[x86_64_v2_ghc9.2-manual.sha256sum] = "cd8741348c1d23139ffc0a1eac83c8611b4b0e9756221970841b3ec2578b444a"

URI_x86_64_v2_ghc9.2-mtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-mtl-2.2.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-mtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-mtl}"
SRC_URI[x86_64_v2_ghc9.2-mtl.sha256sum] = "e40e34965ae5d29d9f6f4e8673f6d64f0a6eeabe36ce443ed6fdbd9642d755d5"

URI_x86_64_v2_ghc9.2-mtl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-mtl-devel-2.2.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-mtl-devel}"
SRC_URI[x86_64_v2_ghc9.2-mtl-devel.sha256sum] = "65eb87401da3e64ba69622106d202d9ae0fd4c48fb44c829d2f5a34533f205ab"

URI_x86_64_v2_ghc9.2-mtl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-mtl-doc-2.2.2-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-mtl-doc}"
SRC_URI[x86_64_v2_ghc9.2-mtl-doc.sha256sum] = "cd1fc37d21f67266601ed7df1e38c17c43fd1dd9357011d6c946fab98820e5c6"

URI_x86_64_v2_ghc9.2-mtl-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-mtl-prof-2.2.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-mtl-prof}"
SRC_URI[x86_64_v2_ghc9.2-mtl-prof.sha256sum] = "ccf26520c7ce3eb0227a0643cc8155b58a94576249391dad9b0ee54ef309df34"

URI_x86_64_v2_ghc9.2-parsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-parsec-3.1.15.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-parsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-parsec}"
SRC_URI[x86_64_v2_ghc9.2-parsec.sha256sum] = "dc5e4c82d147e5e67e3df84354085db8db9a24504395b45dc3a88387f58f8dd5"

URI_x86_64_v2_ghc9.2-parsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-parsec-devel-3.1.15.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-parsec-devel}"
SRC_URI[x86_64_v2_ghc9.2-parsec-devel.sha256sum] = "310f0ff41fe3a0461941cb612a6546354e66f8d80425c661e8a0edb173695910"

URI_x86_64_v2_ghc9.2-parsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-parsec-doc-3.1.15.0-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-parsec-doc}"
SRC_URI[x86_64_v2_ghc9.2-parsec-doc.sha256sum] = "0fe76fd96e9a19c52123e8016ac4dbadf11826d2dd79722275c7d25591f8be77"

URI_x86_64_v2_ghc9.2-parsec-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-parsec-prof-3.1.15.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-parsec-prof}"
SRC_URI[x86_64_v2_ghc9.2-parsec-prof.sha256sum] = "4339207517ad8626eb62dc9ef14febb779059c9cdeebb77062db61927d788eef"

URI_x86_64_v2_ghc9.2-pretty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-pretty-1.1.3.6-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-pretty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-pretty}"
SRC_URI[x86_64_v2_ghc9.2-pretty.sha256sum] = "f7b74b487931c5409dd277c50dff03f1523c22e3cf0f417fb2dba75709280be5"

URI_x86_64_v2_ghc9.2-pretty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-pretty-devel-1.1.3.6-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-pretty-devel}"
SRC_URI[x86_64_v2_ghc9.2-pretty-devel.sha256sum] = "9075eb2d1bbad8ad2e534a2e3b7d09ee4b8087fefc7ed527bb54a26c9f3dd538"

URI_x86_64_v2_ghc9.2-pretty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-pretty-doc-1.1.3.6-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-pretty-doc}"
SRC_URI[x86_64_v2_ghc9.2-pretty-doc.sha256sum] = "dd78afaab3deddce29a280d1a36d9a67d809462634745cdee9a5e8b95566004f"

URI_x86_64_v2_ghc9.2-pretty-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-pretty-prof-1.1.3.6-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-pretty-prof}"
SRC_URI[x86_64_v2_ghc9.2-pretty-prof.sha256sum] = "342569402c3abfc3b560539679ddcb5c25b37a4030b591975ef7e1627c4b899b"

URI_x86_64_v2_ghc9.2-process = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-process-1.6.16.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-process}"
SRC_URI[x86_64_v2_ghc9.2-process.sha256sum] = "05021dcd06a43587e36258ec191967a3dbc4be7a7f051d0bdf9a2f203a48735d"

URI_x86_64_v2_ghc9.2-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-process-devel-1.6.16.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-process-devel}"
SRC_URI[x86_64_v2_ghc9.2-process-devel.sha256sum] = "cdd4e6f30059dfece07ddb70be019feb69ada403356d60269c15f487c29e01e1"

URI_x86_64_v2_ghc9.2-process-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-process-doc-1.6.16.0-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-process-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-process-doc}"
SRC_URI[x86_64_v2_ghc9.2-process-doc.sha256sum] = "a1206554b325f9071022fdb8bdd876389a8e6712ea34367238d23d277c52da95"

URI_x86_64_v2_ghc9.2-process-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-process-prof-1.6.16.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-process-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-process-prof}"
SRC_URI[x86_64_v2_ghc9.2-process-prof.sha256sum] = "0f21cc8cb4c3c71aa669660173ce66c8b97ab5bc8287f0dd648f3d17bc649016"

URI_x86_64_v2_ghc9.2-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-prof-9.2.8-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-prof}"
SRC_URI[x86_64_v2_ghc9.2-prof.sha256sum] = "40829d6a4b8cf990ec7607bc754a2d707726aba84e63c135208b6fe5ffd8c42d"

URI_x86_64_v2_ghc9.2-stm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-stm-2.5.0.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-stm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-stm}"
SRC_URI[x86_64_v2_ghc9.2-stm.sha256sum] = "dd895aa6d4dd7a37216e14330e1def09fa977ced9b89dc5a7dfc148b911799e4"

URI_x86_64_v2_ghc9.2-stm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-stm-devel-2.5.0.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-stm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-stm-devel}"
SRC_URI[x86_64_v2_ghc9.2-stm-devel.sha256sum] = "cc62652964d3693974b00961ebfdc89d63277e2b3b557ad59014da8aca6dce73"

URI_x86_64_v2_ghc9.2-stm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-stm-doc-2.5.0.2-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-stm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-stm-doc}"
SRC_URI[x86_64_v2_ghc9.2-stm-doc.sha256sum] = "dab9b23b9013695794a8053ec05fde1dccd3b0861f8a1c55a33473294b5ff103"

URI_x86_64_v2_ghc9.2-stm-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-stm-prof-2.5.0.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-stm-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-stm-prof}"
SRC_URI[x86_64_v2_ghc9.2-stm-prof.sha256sum] = "0af2e9daa606aa52079973063964a302c16341ee94956ea261704263b9fae9c5"

URI_x86_64_v2_ghc9.2-template-haskell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-template-haskell-2.18.0.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-template-haskell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-template-haskell}"
SRC_URI[x86_64_v2_ghc9.2-template-haskell.sha256sum] = "b0e9a28836f324301bc94671f5f9c4e826b5724fa694914acde792384a1677a0"

URI_x86_64_v2_ghc9.2-template-haskell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-template-haskell-devel-2.18.0.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-template-haskell-devel}"
SRC_URI[x86_64_v2_ghc9.2-template-haskell-devel.sha256sum] = "eb7f83e4e996e29b64a7207d184bf41e248ec28a8d3b600183f0cc365a6c2454"

URI_x86_64_v2_ghc9.2-template-haskell-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-template-haskell-doc-2.18.0.0-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-template-haskell-doc}"
SRC_URI[x86_64_v2_ghc9.2-template-haskell-doc.sha256sum] = "df5db9f81eb9cdf99fce9986a0f4093fec4cfa9a16bfa1a43201cb97fa1fd0d2"

URI_x86_64_v2_ghc9.2-template-haskell-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-template-haskell-prof-2.18.0.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-template-haskell-prof}"
SRC_URI[x86_64_v2_ghc9.2-template-haskell-prof.sha256sum] = "c0da0a67c62f7bb6b8699f3007a3627e9ca569ab9c8fbfe88e3d2ca3b97b8dbb"

URI_x86_64_v2_ghc9.2-terminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-terminfo-0.4.1.5-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-terminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-terminfo}"
SRC_URI[x86_64_v2_ghc9.2-terminfo.sha256sum] = "5b91af0a9acd97af21d34e46b9f8267c971e61e272ac280bdc5c8dbd3251a7c9"

URI_x86_64_v2_ghc9.2-terminfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-terminfo-devel-0.4.1.5-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-terminfo-devel}"
SRC_URI[x86_64_v2_ghc9.2-terminfo-devel.sha256sum] = "5efceba581267bd9348f277fbaf202a865933adf11e1c540db2f7f3d517dc731"

URI_x86_64_v2_ghc9.2-terminfo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-terminfo-doc-0.4.1.5-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-terminfo-doc}"
SRC_URI[x86_64_v2_ghc9.2-terminfo-doc.sha256sum] = "c01d1cddce5e088628fa04feb6b5ae86137fc779ab01206d8dd5de1d86bc837b"

URI_x86_64_v2_ghc9.2-terminfo-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-terminfo-prof-0.4.1.5-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-terminfo-prof}"
SRC_URI[x86_64_v2_ghc9.2-terminfo-prof.sha256sum] = "5f6960a6d2d202a4e84b5853c3aad354d5ef9caf47972ef24c47bca0a9548c5c"

URI_x86_64_v2_ghc9.2-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-text-1.2.5.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-text}"
SRC_URI[x86_64_v2_ghc9.2-text.sha256sum] = "74e2b9d1848023125a94d410d2dc175e2b2bff8c79ef80547e79489fbafb4c63"

URI_x86_64_v2_ghc9.2-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-text-devel-1.2.5.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-text-devel}"
SRC_URI[x86_64_v2_ghc9.2-text-devel.sha256sum] = "cb81f5ee53feffc860659c9b30ef12d8b92f93d1c04ce5e2f2ae727ba3a2daa0"

URI_x86_64_v2_ghc9.2-text-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-text-doc-1.2.5.0-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-text-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-text-doc}"
SRC_URI[x86_64_v2_ghc9.2-text-doc.sha256sum] = "8751229a1c796b1e6aa8db762b6d07e9716c8b6217751fd2b38875e159d8a8c3"

URI_x86_64_v2_ghc9.2-text-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-text-prof-1.2.5.0-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-text-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-text-prof}"
SRC_URI[x86_64_v2_ghc9.2-text-prof.sha256sum] = "040dee8ce7f0289bb553c0bfb1efc8ddffc8000d0742b6b4d44172fc12b1287c"

URI_x86_64_v2_ghc9.2-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-time-1.11.1.1-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-time}"
SRC_URI[x86_64_v2_ghc9.2-time.sha256sum] = "e1cafb24474d69f2cd5f9697ae267a34e72daba778ec1897d94867a247a63893"

URI_x86_64_v2_ghc9.2-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-time-devel-1.11.1.1-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-time-devel}"
SRC_URI[x86_64_v2_ghc9.2-time-devel.sha256sum] = "3eff3c92cdbd4cfce81e46fd508d79f1dc9b1f47034d40c232d115f2cec230d2"

URI_x86_64_v2_ghc9.2-time-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-time-doc-1.11.1.1-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-time-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-time-doc}"
SRC_URI[x86_64_v2_ghc9.2-time-doc.sha256sum] = "86053b2954f37e8fd4fdee30b0fe71b7bec51214006a12853b3a52ae3786927b"

URI_x86_64_v2_ghc9.2-time-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-time-prof-1.11.1.1-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-time-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-time-prof}"
SRC_URI[x86_64_v2_ghc9.2-time-prof.sha256sum] = "1bea8f08f9ea3d1560e0b581a8cc5d15ab4efc130b715fc4cbe59c3d24334c68"

URI_x86_64_v2_ghc9.2-transformers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-transformers-0.5.6.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-transformers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-transformers}"
SRC_URI[x86_64_v2_ghc9.2-transformers.sha256sum] = "a5b090fecfa00d13558b4e21a7a8a6e5b340d5968939675f921ab5b22da12fd1"

URI_x86_64_v2_ghc9.2-transformers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-transformers-devel-0.5.6.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-transformers-devel}"
SRC_URI[x86_64_v2_ghc9.2-transformers-devel.sha256sum] = "2885810dbb0d5dd6c858e913207191fd8dea85d958f092f5e9af158c5ea09d0d"

URI_x86_64_v2_ghc9.2-transformers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-transformers-doc-0.5.6.2-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-transformers-doc}"
SRC_URI[x86_64_v2_ghc9.2-transformers-doc.sha256sum] = "89716f6d2d6a76d145f7c0241b61bb0066b41be676427fc4c25a57f883791db7"

URI_x86_64_v2_ghc9.2-transformers-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-transformers-prof-0.5.6.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-transformers-prof}"
SRC_URI[x86_64_v2_ghc9.2-transformers-prof.sha256sum] = "e4fb3d9472fa4e478fb8001e15f81164cce6534f1823b7ea4e5f46b04969da00"

URI_x86_64_v2_ghc9.2-unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-unix-2.7.2.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-unix}"
SRC_URI[x86_64_v2_ghc9.2-unix.sha256sum] = "13099bb4b16d1e67d69a5735dc8f7f40c64a92b6ce2c3fb0b65689171a1f9691"

URI_x86_64_v2_ghc9.2-unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-unix-devel-2.7.2.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-unix-devel}"
SRC_URI[x86_64_v2_ghc9.2-unix-devel.sha256sum] = "c62e83fcf11add9a51a099512f729d886306aeb8fb81d5f18c588a23e6a80c88"

URI_x86_64_v2_ghc9.2-unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-unix-doc-2.7.2.2-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-unix-doc}"
SRC_URI[x86_64_v2_ghc9.2-unix-doc.sha256sum] = "f81ab4317d76e17e2286d5501aab70a17f9524a00c15902a9c9d758432674e33"

URI_x86_64_v2_ghc9.2-unix-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-unix-prof-2.7.2.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-unix-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-unix-prof}"
SRC_URI[x86_64_v2_ghc9.2-unix-prof.sha256sum] = "3c2c56c390d974feb663c40125261dd69589303ec55c0d585ef276a6a8510838"

URI_x86_64_v2_ghc9.2-xhtml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-xhtml-3000.2.2.1-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-xhtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-xhtml}"
SRC_URI[x86_64_v2_ghc9.2-xhtml.sha256sum] = "c452cbebea57790b4a17dcbbb2992d248417b4f450808b71e894af1062257311"

URI_x86_64_v2_ghc9.2-xhtml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-xhtml-devel-3000.2.2.1-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-xhtml-devel}"
SRC_URI[x86_64_v2_ghc9.2-xhtml-devel.sha256sum] = "8bddd3685dcf86ff837334585a8121d4a6971b306c196a9bc4a01b114181c7e9"

URI_x86_64_v2_ghc9.2-xhtml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-xhtml-doc-3000.2.2.1-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.2-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-xhtml-doc}"
SRC_URI[x86_64_v2_ghc9.2-xhtml-doc.sha256sum] = "8ff9cd56a2ebc23750105bcca4e65b8a46f1661258e1f6cb654b39e96c1a108b"

URI_x86_64_v2_ghc9.2-xhtml-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.2-xhtml-prof-3000.2.2.1-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.2-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.2-xhtml-prof}"
SRC_URI[x86_64_v2_ghc9.2-xhtml-prof.sha256sum] = "b6ea14fc3070bcf23b04b2c9ef7b2586ffaf9c82c1b1d7e4bf453d4e761a5840"

URI_aarch64_ghc9.2 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2}"
SRC_URI[aarch64_ghc9.2.sha256sum] = "e7729d5e92c564b8d753e4d79b38169c293d062b7271d2f73c647fd6429149c9"

URI_aarch64_ghc9.2-Cabal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-Cabal-3.6.3.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-Cabal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-Cabal}"
SRC_URI[aarch64_ghc9.2-Cabal.sha256sum] = "47f46d29c2218881614ed04659af41d93e4a16e760724b8708726613724a50d7"

URI_aarch64_ghc9.2-Cabal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-Cabal-devel-3.6.3.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-Cabal-devel}"
SRC_URI[aarch64_ghc9.2-Cabal-devel.sha256sum] = "00bebd1ff0af4ec9e0a8c43a4b27aa08beb65a9cbb360ab05c09e365a9682e46"

URI_aarch64_ghc9.2-Cabal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-Cabal-doc-3.6.3.0-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-Cabal-doc}"
SRC_URI[aarch64_ghc9.2-Cabal-doc.sha256sum] = "a32aa7142b45c60b343d5f9a2593c090c9ba754ab25179d9d51daa701cbf9a7e"

URI_aarch64_ghc9.2-Cabal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-Cabal-prof-3.6.3.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-Cabal-prof}"
SRC_URI[aarch64_ghc9.2-Cabal-prof.sha256sum] = "cd2d4b4b2bb49b394838440b5a336c5485686a3f8123b04a2af3b591becba265"

URI_aarch64_ghc9.2-array = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-array-0.5.4.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-array;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-array}"
SRC_URI[aarch64_ghc9.2-array.sha256sum] = "52bb696e2f355b6d7197310ba8be3dedabfdcf79aff4a84786bd298497728b43"

URI_aarch64_ghc9.2-array-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-array-devel-0.5.4.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-array-devel}"
SRC_URI[aarch64_ghc9.2-array-devel.sha256sum] = "ef3d3d7c91dc13a8cabc52ba1ff5fc5cce99ca920ce479fdb955a64a3b72922a"

URI_aarch64_ghc9.2-array-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-array-doc-0.5.4.0-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-array-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-array-doc}"
SRC_URI[aarch64_ghc9.2-array-doc.sha256sum] = "f623f3a7d11eeb8419433793c356ee9e81beef57524f7a393911f36f037416b4"

URI_aarch64_ghc9.2-array-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-array-prof-0.5.4.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-array-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-array-prof}"
SRC_URI[aarch64_ghc9.2-array-prof.sha256sum] = "7c81d9cb216292bb1e35ac3bac750457ed73b079881b8a9e77e5f659ee8a4495"

URI_aarch64_ghc9.2-base = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-base-4.16.4.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-base}"
SRC_URI[aarch64_ghc9.2-base.sha256sum] = "62effb686910d4e44d7ff97a96f63cc5e2538582152e6ae235b18c9fcd80257f"

URI_aarch64_ghc9.2-base-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-base-devel-4.16.4.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-base-devel}"
SRC_URI[aarch64_ghc9.2-base-devel.sha256sum] = "5bce0120c808b20758264cb6d26b6a517a4d6af561a320edb87e3aa9c505b084"

URI_aarch64_ghc9.2-base-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-base-doc-4.16.4.0-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-base-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-base-doc}"
SRC_URI[aarch64_ghc9.2-base-doc.sha256sum] = "9350d04cf563ab1b511633c98705ff00d3945f407dc41c7bebb94a32f490db41"

URI_aarch64_ghc9.2-base-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-base-prof-4.16.4.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-base-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-base-prof}"
SRC_URI[aarch64_ghc9.2-base-prof.sha256sum] = "f517b72be793c9a4a118623cb8167a56190cbdd0b5d5c1533c5f1a96abdd198d"

URI_aarch64_ghc9.2-binary = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-binary-0.8.9.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-binary;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-binary}"
SRC_URI[aarch64_ghc9.2-binary.sha256sum] = "c8e57efe67d67e99895fa95e52485b1c3f2af292a80c02c0bc2e4cc87ce5b7f7"

URI_aarch64_ghc9.2-binary-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-binary-devel-0.8.9.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-binary-devel}"
SRC_URI[aarch64_ghc9.2-binary-devel.sha256sum] = "02f92fb030933c060efecb7e4e4edbd38a83210de1cb04ba671086154a9b6302"

URI_aarch64_ghc9.2-binary-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-binary-doc-0.8.9.0-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-binary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-binary-doc}"
SRC_URI[aarch64_ghc9.2-binary-doc.sha256sum] = "b7c1247eacaa5511201c6bb7cf14cf23f4e35fc722b44a95889824cc2fc03ee4"

URI_aarch64_ghc9.2-binary-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-binary-prof-0.8.9.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-binary-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-binary-prof}"
SRC_URI[aarch64_ghc9.2-binary-prof.sha256sum] = "2cc386b0a6ddeb89446e78cdea62d7138806e4692b82096b13ec0eef8d5750c3"

URI_aarch64_ghc9.2-bytestring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-bytestring-0.11.4.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-bytestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-bytestring}"
SRC_URI[aarch64_ghc9.2-bytestring.sha256sum] = "78e94e55193a0b537a9b873709d5e697df57bd79f59710ce90f8f9f096046753"

URI_aarch64_ghc9.2-bytestring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-bytestring-devel-0.11.4.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-bytestring-devel}"
SRC_URI[aarch64_ghc9.2-bytestring-devel.sha256sum] = "25ad347e3512b6205d646300ca14cd1f4056ab37329317b5da65fd164f816736"

URI_aarch64_ghc9.2-bytestring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-bytestring-doc-0.11.4.0-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-bytestring-doc}"
SRC_URI[aarch64_ghc9.2-bytestring-doc.sha256sum] = "bf37b7a257ea0f588712b0ac89bb32c0d167679abf68eef619b290f41c092174"

URI_aarch64_ghc9.2-bytestring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-bytestring-prof-0.11.4.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-bytestring-prof}"
SRC_URI[aarch64_ghc9.2-bytestring-prof.sha256sum] = "c5b95d7e1cf7988b131aee9562b7039632af7d1f2cc4565737301a253b5ca37a"

URI_aarch64_ghc9.2-compiler = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-compiler-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-compiler}"
SRC_URI[aarch64_ghc9.2-compiler.sha256sum] = "2e0682925b66f6f461a5a35b604d148bc55922b5eb78a0faa9de214f826bef15"

URI_aarch64_ghc9.2-compiler-default = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-compiler-default-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-compiler-default;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-compiler-default}"
SRC_URI[aarch64_ghc9.2-compiler-default.sha256sum] = "b26f4db28faf87cdf6a3e6e8dc5227866b862523c782570fc45c6a50bf9760b3"

URI_aarch64_ghc9.2-containers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-containers-0.6.5.1-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-containers}"
SRC_URI[aarch64_ghc9.2-containers.sha256sum] = "c6bdc9cf23376f67cabfa9442bb3d33f232f28ef422d43a7279cbaf6cd1525ee"

URI_aarch64_ghc9.2-containers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-containers-devel-0.6.5.1-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-containers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-containers-devel}"
SRC_URI[aarch64_ghc9.2-containers-devel.sha256sum] = "c1183ba6d58edc9d38ab6ab143e39c906512f611c71e2101c2f52224293335f1"

URI_aarch64_ghc9.2-containers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-containers-doc-0.6.5.1-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-containers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-containers-doc}"
SRC_URI[aarch64_ghc9.2-containers-doc.sha256sum] = "d8c39990d439173e77e6e19fc7b602afa0db8bb23ce04e905912dcccbcdef3b5"

URI_aarch64_ghc9.2-containers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-containers-prof-0.6.5.1-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-containers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-containers-prof}"
SRC_URI[aarch64_ghc9.2-containers-prof.sha256sum] = "424927fcfb028689f0e9de9791fc7aac27ffed6c8982f5992e2755905bae51df"

URI_aarch64_ghc9.2-deepseq = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-deepseq-1.4.6.1-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-deepseq;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-deepseq}"
SRC_URI[aarch64_ghc9.2-deepseq.sha256sum] = "c304b564b0baec605d9d6ce1cefc13fe79fa20de66cf50e84a4d5d92f49d7d30"

URI_aarch64_ghc9.2-deepseq-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-deepseq-devel-1.4.6.1-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-deepseq-devel}"
SRC_URI[aarch64_ghc9.2-deepseq-devel.sha256sum] = "bf8a4a108a7783e89c8c676c40cb0b3e167875394e991cd8c4f39723fe17ba46"

URI_aarch64_ghc9.2-deepseq-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-deepseq-doc-1.4.6.1-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-deepseq-doc}"
SRC_URI[aarch64_ghc9.2-deepseq-doc.sha256sum] = "e20031667530c6d65f96d0ff653ed3f8972f96d3fe7ddc6269db67e1ef51ba53"

URI_aarch64_ghc9.2-deepseq-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-deepseq-prof-1.4.6.1-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-deepseq-prof}"
SRC_URI[aarch64_ghc9.2-deepseq-prof.sha256sum] = "b02c2041f07aaf55eab7ce9dbafa15f35ad6482132a8f7ed15e1f7709e0b45e1"

URI_aarch64_ghc9.2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-devel-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-devel}"
SRC_URI[aarch64_ghc9.2-devel.sha256sum] = "17fa2524d91bc4fb7e7e83a56f201f5d73441d4a37d5ea9904a351fa50cd2cc6"

URI_aarch64_ghc9.2-directory = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-directory-1.3.6.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-directory;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-directory}"
SRC_URI[aarch64_ghc9.2-directory.sha256sum] = "32415bf08e6aa04579507a90f1b2db7751c2c7957c1c05d9309e8b202b4bf776"

URI_aarch64_ghc9.2-directory-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-directory-devel-1.3.6.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-directory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-directory-devel}"
SRC_URI[aarch64_ghc9.2-directory-devel.sha256sum] = "e68c790011a1e63dc1e8ed3a7f4ed161b83ce0e973be25d903e8c51498870fba"

URI_aarch64_ghc9.2-directory-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-directory-doc-1.3.6.2-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-directory-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-directory-doc}"
SRC_URI[aarch64_ghc9.2-directory-doc.sha256sum] = "fd0d490e0f992451da96747c88b9fdd842c0f9e9c02f28a6a46beeef50180f7d"

URI_aarch64_ghc9.2-directory-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-directory-prof-1.3.6.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-directory-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-directory-prof}"
SRC_URI[aarch64_ghc9.2-directory-prof.sha256sum] = "8f7cae2552d6f493da4a57f5ac2f549d131834e2491e0b58c70ea41cc1286413"

URI_aarch64_ghc9.2-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-doc-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-doc}"
SRC_URI[aarch64_ghc9.2-doc.sha256sum] = "e03b2e6271c340d8258e764768dd0bb552c96e1248668e233b3603ce10e77dd2"

URI_aarch64_ghc9.2-doc-index = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-doc-index-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-doc-index;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-doc-index}"
SRC_URI[aarch64_ghc9.2-doc-index.sha256sum] = "7f5e1faf6ba9b99e4a82313e9fb9c668439f1de07fcc4d446cbd180d96889511"

URI_aarch64_ghc9.2-exceptions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-exceptions-0.10.4-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-exceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-exceptions}"
SRC_URI[aarch64_ghc9.2-exceptions.sha256sum] = "289d8a61d8233533cd93b26793dd76bacbdcafedbf35b62e2b614e1a73e691ca"

URI_aarch64_ghc9.2-exceptions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-exceptions-devel-0.10.4-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-exceptions-devel}"
SRC_URI[aarch64_ghc9.2-exceptions-devel.sha256sum] = "c059fe78e56a7e37dd3137b01fcf016506237f7e2ca1f27fadf1461243abe59e"

URI_aarch64_ghc9.2-exceptions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-exceptions-doc-0.10.4-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-exceptions-doc}"
SRC_URI[aarch64_ghc9.2-exceptions-doc.sha256sum] = "93127b248dab40250df71c9a7bc67dbcf24a1c6d9a565c6a8e1445d70d4c3825"

URI_aarch64_ghc9.2-exceptions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-exceptions-prof-0.10.4-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-exceptions-prof}"
SRC_URI[aarch64_ghc9.2-exceptions-prof.sha256sum] = "5192ce3e058b591092816eaccd0d9453ef149015cdac9bcee0113df04683e45e"

URI_aarch64_ghc9.2-filepath = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-filepath-1.4.2.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-filepath;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-filepath}"
SRC_URI[aarch64_ghc9.2-filepath.sha256sum] = "ab10a3ac62dfea979e074a4f3fb836eadee55b952c1936e14a10bc4689018327"

URI_aarch64_ghc9.2-filepath-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-filepath-devel-1.4.2.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-filepath-devel}"
SRC_URI[aarch64_ghc9.2-filepath-devel.sha256sum] = "838b481461708701754804512d14c94457c5bae04697d9428d709edd9ede994a"

URI_aarch64_ghc9.2-filepath-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-filepath-doc-1.4.2.2-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-filepath-doc}"
SRC_URI[aarch64_ghc9.2-filepath-doc.sha256sum] = "eb599001aa5641dbe2c92afda2ca53cfa9754dc87c6417a15c9dc44b469c4985"

URI_aarch64_ghc9.2-filepath-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-filepath-prof-1.4.2.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-filepath-prof}"
SRC_URI[aarch64_ghc9.2-filepath-prof.sha256sum] = "4a3229baf23be300d3dfd8d1488128798a2f5506a1f5ed35c43d25f0a3b55d39"

URI_aarch64_ghc9.2-filesystem = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-filesystem-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-filesystem}"
SRC_URI[aarch64_ghc9.2-filesystem.sha256sum] = "b37369b33e9e4e49631bc3979c0b01c14968d0de1fd1edc69dcbeac70c563f25"

URI_aarch64_ghc9.2-ghc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc}"
SRC_URI[aarch64_ghc9.2-ghc.sha256sum] = "79a11de3c16a66982b57bd448e3e20a336349393aeaf2b4378af0b551c37a3f8"

URI_aarch64_ghc9.2-ghc-bignum = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-bignum-1.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-bignum}"
SRC_URI[aarch64_ghc9.2-ghc-bignum.sha256sum] = "1b451c9cb39f85c88558d84ff5417bd243dc0d9ae12ba48fa0c6769c434ac6da"

URI_aarch64_ghc9.2-ghc-bignum-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-bignum-devel-1.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-bignum-devel}"
SRC_URI[aarch64_ghc9.2-ghc-bignum-devel.sha256sum] = "f1c1606eb98b22c8ebab7b0b465cd36d1be870f15cdb1a3d3cee5aa6b7970d69"

URI_aarch64_ghc9.2-ghc-bignum-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-bignum-doc-1.2-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-bignum-doc}"
SRC_URI[aarch64_ghc9.2-ghc-bignum-doc.sha256sum] = "3d489443c0eb9c0b7105a8f74cfd8f5468cf9a1b0fa0fb98715a8e51242b5e1e"

URI_aarch64_ghc9.2-ghc-bignum-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-bignum-prof-1.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-bignum-prof}"
SRC_URI[aarch64_ghc9.2-ghc-bignum-prof.sha256sum] = "21f5723c0d768a89ff9ccb0c1a62095ab5f575d971fa64a6577ce6f8d9a9e657"

URI_aarch64_ghc9.2-ghc-boot = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-boot-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-boot}"
SRC_URI[aarch64_ghc9.2-ghc-boot.sha256sum] = "3984e85d161ba1bb9610a2a054fe433621d662336827c38ace9280a7b62f9089"

URI_aarch64_ghc9.2-ghc-boot-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-boot-devel-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-boot-devel}"
SRC_URI[aarch64_ghc9.2-ghc-boot-devel.sha256sum] = "13607c808ad24a7906d238281aca069787efcbd9d36e3834bb7c4416a2feda12"

URI_aarch64_ghc9.2-ghc-boot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-boot-doc-9.2.8-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-boot-doc}"
SRC_URI[aarch64_ghc9.2-ghc-boot-doc.sha256sum] = "8fd20eec2154ed16699a6a50d99b05440de264343465b6daba06606ba389c33a"

URI_aarch64_ghc9.2-ghc-boot-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-boot-prof-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-boot-prof}"
SRC_URI[aarch64_ghc9.2-ghc-boot-prof.sha256sum] = "4ee8acd125c73b14fd9558df7f48a65792e733d2bf8881e23a5d02c4c0d7f43b"

URI_aarch64_ghc9.2-ghc-boot-th = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-boot-th-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-boot-th}"
SRC_URI[aarch64_ghc9.2-ghc-boot-th.sha256sum] = "2a1f43492fb1bbd1a5b011cb9012200b8a713646ac8d49038857263dfd462eb6"

URI_aarch64_ghc9.2-ghc-boot-th-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-boot-th-devel-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-boot-th-devel}"
SRC_URI[aarch64_ghc9.2-ghc-boot-th-devel.sha256sum] = "7826d0a58385b9cc0cef54b5e79007fe7b9a018c63f582577cf057e25c4cb85b"

URI_aarch64_ghc9.2-ghc-boot-th-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-boot-th-doc-9.2.8-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-boot-th-doc}"
SRC_URI[aarch64_ghc9.2-ghc-boot-th-doc.sha256sum] = "e24b5e2f2f9074958b53db17584b17447fe3dad29e2d7dad396f4d4d6924698f"

URI_aarch64_ghc9.2-ghc-boot-th-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-boot-th-prof-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-boot-th-prof}"
SRC_URI[aarch64_ghc9.2-ghc-boot-th-prof.sha256sum] = "fef6c091fe8051f919af5d2b93f26243b11202f3ee923e889e953e0b9d5fc5a0"

URI_aarch64_ghc9.2-ghc-compact = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-compact-0.1.0.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-compact}"
SRC_URI[aarch64_ghc9.2-ghc-compact.sha256sum] = "0df3da7f15449c4b8a572e8dfc8bfa6956db4018fc788ca51b1c4cc1a3a14660"

URI_aarch64_ghc9.2-ghc-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-compact-devel-0.1.0.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-compact-devel}"
SRC_URI[aarch64_ghc9.2-ghc-compact-devel.sha256sum] = "d195dfa62dde9957aff9e2b0a4b92751dd3163b6c6461e820f90f08ec3d50396"

URI_aarch64_ghc9.2-ghc-compact-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-compact-doc-0.1.0.0-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-compact-doc}"
SRC_URI[aarch64_ghc9.2-ghc-compact-doc.sha256sum] = "db76ccaafe13a85d30add94ea0a4c37557dbf3d58a7707c29f05a16902c23b69"

URI_aarch64_ghc9.2-ghc-compact-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-compact-prof-0.1.0.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-compact-prof}"
SRC_URI[aarch64_ghc9.2-ghc-compact-prof.sha256sum] = "f94b5bb1fe82e6ad1053d2a2b959c8619cea9028282d322bcae6ae9940cf0964"

URI_aarch64_ghc9.2-ghc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-devel-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-devel}"
SRC_URI[aarch64_ghc9.2-ghc-devel.sha256sum] = "d98ef6fb7dada296618a4ab71ebd3bafa394e6ae0925babd07b3cc11560b5947"

URI_aarch64_ghc9.2-ghc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-doc-9.2.8-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-doc}"
SRC_URI[aarch64_ghc9.2-ghc-doc.sha256sum] = "4f40878768e4f5180304945adaa3ebf4944f31d878535c3bc05e4737816d83cf"

URI_aarch64_ghc9.2-ghc-heap = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-heap-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-heap}"
SRC_URI[aarch64_ghc9.2-ghc-heap.sha256sum] = "e001185962038a1ec16f7cb38fcb14022fd1534bf02f30582a365514d4afe10e"

URI_aarch64_ghc9.2-ghc-heap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-heap-devel-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-heap-devel}"
SRC_URI[aarch64_ghc9.2-ghc-heap-devel.sha256sum] = "19960d6b6eae5ab773c2546f302473ab7a26ff20ddcbf50b98af026f47ce54d0"

URI_aarch64_ghc9.2-ghc-heap-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-heap-doc-9.2.8-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-heap-doc}"
SRC_URI[aarch64_ghc9.2-ghc-heap-doc.sha256sum] = "591bc121db3d49d2708fbee497286e091e4f08e59c930786e743c14dbb6bad66"

URI_aarch64_ghc9.2-ghc-heap-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-heap-prof-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-heap-prof}"
SRC_URI[aarch64_ghc9.2-ghc-heap-prof.sha256sum] = "e1cb5b769faf7ab8ca7a7ba604d84991056318613fb165bd3b15c7f80305cbc6"

URI_aarch64_ghc9.2-ghc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghc-prof-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghc-prof}"
SRC_URI[aarch64_ghc9.2-ghc-prof.sha256sum] = "c6f6013e44b469f4bec1b1f8a26c4eb208129c2a6d851581d9884c0e3b56ff76"

URI_aarch64_ghc9.2-ghci = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghci-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghci;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghci}"
SRC_URI[aarch64_ghc9.2-ghci.sha256sum] = "f57023a17ecfb68b600aaae1f98b032eca25e52ed8b30d06eee317b103e55338"

URI_aarch64_ghc9.2-ghci-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghci-devel-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghci-devel}"
SRC_URI[aarch64_ghc9.2-ghci-devel.sha256sum] = "4c4ace1769879a42ea31d365b9d3506a4fcdd12b19e572aee9bc8e0b481b7ead"

URI_aarch64_ghc9.2-ghci-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghci-doc-9.2.8-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghci-doc}"
SRC_URI[aarch64_ghc9.2-ghci-doc.sha256sum] = "631afc2aab3685fc8306c9a017d8b9b943d96468f34ab7202c8e6f74296c3b48"

URI_aarch64_ghc9.2-ghci-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-ghci-prof-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-ghci-prof}"
SRC_URI[aarch64_ghc9.2-ghci-prof.sha256sum] = "674375c54dada0f014bcd4b9558e9f5d933a2ad4aa52b8af6c320889a3bddebc"

URI_aarch64_ghc9.2-hadrian = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-hadrian-0.1.0.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-hadrian;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-hadrian}"
SRC_URI[aarch64_ghc9.2-hadrian.sha256sum] = "57d389c7a73fc6297ba1116940c8151f6c9d531f16fe4766a13fa2d94a3832a3"

URI_aarch64_ghc9.2-haskeline = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-haskeline-0.8.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-haskeline;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-haskeline}"
SRC_URI[aarch64_ghc9.2-haskeline.sha256sum] = "9e1f726bc15b2686748f594826bd28e6c600e5ae9df5e30c330f1e6be2285746"

URI_aarch64_ghc9.2-haskeline-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-haskeline-devel-0.8.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-haskeline-devel}"
SRC_URI[aarch64_ghc9.2-haskeline-devel.sha256sum] = "393697c21e57f336d7fb389f22ca8d603742b322e8f4db98715c424cff90740a"

URI_aarch64_ghc9.2-haskeline-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-haskeline-doc-0.8.2-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-haskeline-doc}"
SRC_URI[aarch64_ghc9.2-haskeline-doc.sha256sum] = "9b5b0cc7f9bb9ebfecac04637467bff3bf9398aad22c4c15ca8651136332b1b9"

URI_aarch64_ghc9.2-haskeline-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-haskeline-prof-0.8.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-haskeline-prof}"
SRC_URI[aarch64_ghc9.2-haskeline-prof.sha256sum] = "fe9d854eebea42f9891ff086d02f66f8a12a369e8a4873448684049ce739a701"

URI_aarch64_ghc9.2-hpc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-hpc-0.6.1.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-hpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-hpc}"
SRC_URI[aarch64_ghc9.2-hpc.sha256sum] = "0a206c48a0f99f45639251b685f6e437c9a3eb8f2c6225cbf7ddaacb96e6332f"

URI_aarch64_ghc9.2-hpc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-hpc-devel-0.6.1.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-hpc-devel}"
SRC_URI[aarch64_ghc9.2-hpc-devel.sha256sum] = "f5d7410e099363dc978666a5b17471ce67160c066f1d9dcae51dd7f673dc3e9d"

URI_aarch64_ghc9.2-hpc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-hpc-doc-0.6.1.0-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-hpc-doc}"
SRC_URI[aarch64_ghc9.2-hpc-doc.sha256sum] = "395cb6a6a12495ca4a63a5d1d6a21bd78f9250aea7ae068176cd3aff3f041c6b"

URI_aarch64_ghc9.2-hpc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-hpc-prof-0.6.1.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-hpc-prof}"
SRC_URI[aarch64_ghc9.2-hpc-prof.sha256sum] = "ecee4c91f0865794c68930b68d0b7b0328f56af9ad9aab6c60a84048aba3beb6"

URI_aarch64_ghc9.2-libiserv = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-libiserv-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-libiserv;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-libiserv}"
SRC_URI[aarch64_ghc9.2-libiserv.sha256sum] = "3c89a37607ba211401882081c6bf4d4fa95b9e939793d28ea22691f5c98c9aeb"

URI_aarch64_ghc9.2-libiserv-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-libiserv-devel-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-libiserv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-libiserv-devel}"
SRC_URI[aarch64_ghc9.2-libiserv-devel.sha256sum] = "ac25c382de10289f85acf0189347ddf46bae4aa704b53454fb40071c67f433c3"

URI_aarch64_ghc9.2-libiserv-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-libiserv-doc-9.2.8-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-libiserv-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-libiserv-doc}"
SRC_URI[aarch64_ghc9.2-libiserv-doc.sha256sum] = "dcd3be6d9d0cd88551b48879ec11364da6a760a47f58de61291134076db21159"

URI_aarch64_ghc9.2-libiserv-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-libiserv-prof-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-libiserv-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-libiserv-prof}"
SRC_URI[aarch64_ghc9.2-libiserv-prof.sha256sum] = "55242d0d1a1482a37047cf74577b74c0ba988b4ea592df34857da4a855979e2b"

URI_aarch64_ghc9.2-manual = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-manual-9.2.8-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-manual}"
SRC_URI[aarch64_ghc9.2-manual.sha256sum] = "a08584fdc478b7da057169c21c7d9d09813f41e873335cf144135e722b5005a9"

URI_aarch64_ghc9.2-mtl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-mtl-2.2.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-mtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-mtl}"
SRC_URI[aarch64_ghc9.2-mtl.sha256sum] = "488e5b9a41c951b73f64d1de8e5dfc7445667842f25e67e2485f3304b9968300"

URI_aarch64_ghc9.2-mtl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-mtl-devel-2.2.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-mtl-devel}"
SRC_URI[aarch64_ghc9.2-mtl-devel.sha256sum] = "4894bf1e88bddf009d40acfe07ea35c90ff88770667b3911d7bc0b4352d66613"

URI_aarch64_ghc9.2-mtl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-mtl-doc-2.2.2-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-mtl-doc}"
SRC_URI[aarch64_ghc9.2-mtl-doc.sha256sum] = "27e987194740e1d8356bbffd01568710ed2185487d47cacdec3b13071bae4bfc"

URI_aarch64_ghc9.2-mtl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-mtl-prof-2.2.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-mtl-prof}"
SRC_URI[aarch64_ghc9.2-mtl-prof.sha256sum] = "8b836bcb992aac0c52fbc203e84b9f55765c118678b631fd49cf16337f0d4fff"

URI_aarch64_ghc9.2-parsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-parsec-3.1.15.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-parsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-parsec}"
SRC_URI[aarch64_ghc9.2-parsec.sha256sum] = "85dac341f84c4c8eb4b9f49b3fbda135c4de6af8efe225d42593674f25ff6fca"

URI_aarch64_ghc9.2-parsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-parsec-devel-3.1.15.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-parsec-devel}"
SRC_URI[aarch64_ghc9.2-parsec-devel.sha256sum] = "d3909a80a9b5f16cbad886097e497704f9ecdf48504fa163579fbad651137391"

URI_aarch64_ghc9.2-parsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-parsec-doc-3.1.15.0-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-parsec-doc}"
SRC_URI[aarch64_ghc9.2-parsec-doc.sha256sum] = "35cd53457433faea5b828e8adf381d189d013e646408ca9313dd193022750d9a"

URI_aarch64_ghc9.2-parsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-parsec-prof-3.1.15.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-parsec-prof}"
SRC_URI[aarch64_ghc9.2-parsec-prof.sha256sum] = "39fcfa329c0cd95f74e8df2c669b48d3e9235ad8730ee72096ae2feb3ddef33c"

URI_aarch64_ghc9.2-pretty = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-pretty-1.1.3.6-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-pretty;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-pretty}"
SRC_URI[aarch64_ghc9.2-pretty.sha256sum] = "8ca75fbc8346556dad2c513fe496cbcd252e53d1718a4c73a0450877d72807ba"

URI_aarch64_ghc9.2-pretty-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-pretty-devel-1.1.3.6-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-pretty-devel}"
SRC_URI[aarch64_ghc9.2-pretty-devel.sha256sum] = "be10c70a6506a754740a4ae23c3cd0dc3e571143196ad52d6f7b6dbc08cfb440"

URI_aarch64_ghc9.2-pretty-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-pretty-doc-1.1.3.6-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-pretty-doc}"
SRC_URI[aarch64_ghc9.2-pretty-doc.sha256sum] = "63d40486b887c9507f2c88889ccec6efaf770373532893e8589490125e19f690"

URI_aarch64_ghc9.2-pretty-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-pretty-prof-1.1.3.6-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-pretty-prof}"
SRC_URI[aarch64_ghc9.2-pretty-prof.sha256sum] = "f7c8153a6b0c79447ab407cae8e72f43e2c9a986c45ac9f30be29829723d93de"

URI_aarch64_ghc9.2-process = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-process-1.6.16.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-process}"
SRC_URI[aarch64_ghc9.2-process.sha256sum] = "2786f6de836ab4ee8636341a3df278285b2c0158ae696576f570b19e34dbcc9a"

URI_aarch64_ghc9.2-process-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-process-devel-1.6.16.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-process-devel}"
SRC_URI[aarch64_ghc9.2-process-devel.sha256sum] = "6ad8558d7212f4d683ef6e4e43bd085d51344d093c89462655e5579b332f1a58"

URI_aarch64_ghc9.2-process-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-process-doc-1.6.16.0-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-process-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-process-doc}"
SRC_URI[aarch64_ghc9.2-process-doc.sha256sum] = "06b41f1acdc0ca340efc74b8e184a23e3a0b35478f7b897a0ff4049b89b9ee5c"

URI_aarch64_ghc9.2-process-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-process-prof-1.6.16.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-process-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-process-prof}"
SRC_URI[aarch64_ghc9.2-process-prof.sha256sum] = "bd5aeafafbf361cfb1659b1248ae8f7f446041060228447e93f9bad56ee08af8"

URI_aarch64_ghc9.2-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-prof-9.2.8-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-prof}"
SRC_URI[aarch64_ghc9.2-prof.sha256sum] = "5082df54bc9fe31ebadf3ccc778fa0d148f192c89c03b53fe7ec69b9f3e6dcf7"

URI_aarch64_ghc9.2-stm = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-stm-2.5.0.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-stm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-stm}"
SRC_URI[aarch64_ghc9.2-stm.sha256sum] = "d1c53803e34455fdca519493f21e6d75c40ad36a09dd74872ad3f7c642a1a6b5"

URI_aarch64_ghc9.2-stm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-stm-devel-2.5.0.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-stm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-stm-devel}"
SRC_URI[aarch64_ghc9.2-stm-devel.sha256sum] = "5a6bccbd14926482651a3e668ecbb00da30c9c5063ea16224eb1c35b016be2e0"

URI_aarch64_ghc9.2-stm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-stm-doc-2.5.0.2-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-stm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-stm-doc}"
SRC_URI[aarch64_ghc9.2-stm-doc.sha256sum] = "a0e12836463f6244e13d95a48f227a8b788503659e495e7fb0aa22e5712d800c"

URI_aarch64_ghc9.2-stm-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-stm-prof-2.5.0.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-stm-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-stm-prof}"
SRC_URI[aarch64_ghc9.2-stm-prof.sha256sum] = "8a1f179221695d743dfec63315e3e8e4aa4c1e91a0cfe5cea38ce59041f29e70"

URI_aarch64_ghc9.2-template-haskell = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-template-haskell-2.18.0.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-template-haskell;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-template-haskell}"
SRC_URI[aarch64_ghc9.2-template-haskell.sha256sum] = "a06257c2124f76b3cd60bd5b8002460619976069078ee430325c89717f93d0cc"

URI_aarch64_ghc9.2-template-haskell-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-template-haskell-devel-2.18.0.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-template-haskell-devel}"
SRC_URI[aarch64_ghc9.2-template-haskell-devel.sha256sum] = "31f611d42229021183250934095d5b9fb850a332b88e236434994ddd4f0bd27d"

URI_aarch64_ghc9.2-template-haskell-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-template-haskell-doc-2.18.0.0-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-template-haskell-doc}"
SRC_URI[aarch64_ghc9.2-template-haskell-doc.sha256sum] = "6c871379c860850aedc20ce325b1ae9d7435cdfb296b1e944231e679774612ca"

URI_aarch64_ghc9.2-template-haskell-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-template-haskell-prof-2.18.0.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-template-haskell-prof}"
SRC_URI[aarch64_ghc9.2-template-haskell-prof.sha256sum] = "c2bca4b7f4aefd4040088a2616da9985433384dee6228e48f3d54ca0d2b25d42"

URI_aarch64_ghc9.2-terminfo = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-terminfo-0.4.1.5-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-terminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-terminfo}"
SRC_URI[aarch64_ghc9.2-terminfo.sha256sum] = "6763cdc8cf4ace2603052d3ece0539e488083010bd9ab59da77c5e5468a4bbef"

URI_aarch64_ghc9.2-terminfo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-terminfo-devel-0.4.1.5-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-terminfo-devel}"
SRC_URI[aarch64_ghc9.2-terminfo-devel.sha256sum] = "f5349b72eed574caaf123972b9a41ece4206ea075404bc07c10ae64bf873f31c"

URI_aarch64_ghc9.2-terminfo-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-terminfo-doc-0.4.1.5-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-terminfo-doc}"
SRC_URI[aarch64_ghc9.2-terminfo-doc.sha256sum] = "f87a79fbb2b6c77cc1c7d7f9805143914efdca5618b697d9bf196a51e9dccf3d"

URI_aarch64_ghc9.2-terminfo-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-terminfo-prof-0.4.1.5-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-terminfo-prof}"
SRC_URI[aarch64_ghc9.2-terminfo-prof.sha256sum] = "3c19bcbf297ca49304b00a0b878bfddbbab99412ec9e1cad9e8831620fe3bccc"

URI_aarch64_ghc9.2-text = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-text-1.2.5.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-text}"
SRC_URI[aarch64_ghc9.2-text.sha256sum] = "f3d7cbb0202f54e1aae371c0720ed85521b67eb1c74961570d517f4b6231e5a7"

URI_aarch64_ghc9.2-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-text-devel-1.2.5.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-text-devel}"
SRC_URI[aarch64_ghc9.2-text-devel.sha256sum] = "a1845a026d16a4d928b37eb4ae1c1ce42f01090325861071f278e55ecb112d6e"

URI_aarch64_ghc9.2-text-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-text-doc-1.2.5.0-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-text-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-text-doc}"
SRC_URI[aarch64_ghc9.2-text-doc.sha256sum] = "8d1987dc7c072f9450e6087da96bfd4553313cc775ccbc905fbd746b74317f68"

URI_aarch64_ghc9.2-text-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-text-prof-1.2.5.0-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-text-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-text-prof}"
SRC_URI[aarch64_ghc9.2-text-prof.sha256sum] = "92d09113975952888d10a4db1ed68408115d46ca7ac18e8d50c52edb316a87db"

URI_aarch64_ghc9.2-time = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-time-1.11.1.1-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-time}"
SRC_URI[aarch64_ghc9.2-time.sha256sum] = "c3e3973284c9d641d6b0c3046ebc1cddb649bcec6135646e448d859dfa92ab38"

URI_aarch64_ghc9.2-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-time-devel-1.11.1.1-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-time-devel}"
SRC_URI[aarch64_ghc9.2-time-devel.sha256sum] = "1095ab7a8cae483f278153fbd3b1b0eb61783003bafbb73046e2e2317ea08b89"

URI_aarch64_ghc9.2-time-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-time-doc-1.11.1.1-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-time-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-time-doc}"
SRC_URI[aarch64_ghc9.2-time-doc.sha256sum] = "016374e6ac07b235d233c9319d6d28f9e45f6f95a0088b424ec109b0e72e3be2"

URI_aarch64_ghc9.2-time-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-time-prof-1.11.1.1-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-time-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-time-prof}"
SRC_URI[aarch64_ghc9.2-time-prof.sha256sum] = "020a7291b03f9682ba8da2bf859c351fea5d4ead96ceede2b979918a074788d2"

URI_aarch64_ghc9.2-transformers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-transformers-0.5.6.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-transformers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-transformers}"
SRC_URI[aarch64_ghc9.2-transformers.sha256sum] = "529e1ff5a03d298eacc84b59dbe3f0a2fa29e7ac547210d0d1a394d2f536caea"

URI_aarch64_ghc9.2-transformers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-transformers-devel-0.5.6.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-transformers-devel}"
SRC_URI[aarch64_ghc9.2-transformers-devel.sha256sum] = "1d0c7c8d02a43dd6ba8530400d2bc76bbd92106b2ff62264079c8b04d2adf59e"

URI_aarch64_ghc9.2-transformers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-transformers-doc-0.5.6.2-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-transformers-doc}"
SRC_URI[aarch64_ghc9.2-transformers-doc.sha256sum] = "503b1d603ea9e64ee94b803c05ed8273deebc477ae3eef15ee446974fbd34655"

URI_aarch64_ghc9.2-transformers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-transformers-prof-0.5.6.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-transformers-prof}"
SRC_URI[aarch64_ghc9.2-transformers-prof.sha256sum] = "2666a760a31e1bbb5cf222cc3d58556f30bee1e26eb645a6c284d3087a6048e1"

URI_aarch64_ghc9.2-unix = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-unix-2.7.2.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-unix}"
SRC_URI[aarch64_ghc9.2-unix.sha256sum] = "e0ae5ac72388d888821611bbdd8b0d8e08c115572e0f4e907cc87ee8d301c2d4"

URI_aarch64_ghc9.2-unix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-unix-devel-2.7.2.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-unix-devel}"
SRC_URI[aarch64_ghc9.2-unix-devel.sha256sum] = "5242fcdd09c9ff2740eee97018a86ef8a8a0682f656a9b1df930bcdeb74f321f"

URI_aarch64_ghc9.2-unix-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-unix-doc-2.7.2.2-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-unix-doc}"
SRC_URI[aarch64_ghc9.2-unix-doc.sha256sum] = "3da8e12af88b7093286c00bcd34343b700e6a97395d51d2d7b17aeabb16dfe0b"

URI_aarch64_ghc9.2-unix-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-unix-prof-2.7.2.2-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-unix-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-unix-prof}"
SRC_URI[aarch64_ghc9.2-unix-prof.sha256sum] = "8169a40bcb4231bfefd544335eb61e15345aa8a37e5fe7e37f352ab9c5eef077"

URI_aarch64_ghc9.2-xhtml = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-xhtml-3000.2.2.1-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-xhtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-xhtml}"
SRC_URI[aarch64_ghc9.2-xhtml.sha256sum] = "6dcbcf7e53d2eff72038ad0c2bcfc2d0166cdefc765bec77c2a444841b0f5c71"

URI_aarch64_ghc9.2-xhtml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-xhtml-devel-3000.2.2.1-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-xhtml-devel}"
SRC_URI[aarch64_ghc9.2-xhtml-devel.sha256sum] = "368f55b1a43c4cbe540ceebb96ed7fd3a2506fdfd0122d41cf0b03ad30801f40"

URI_aarch64_ghc9.2-xhtml-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-xhtml-doc-3000.2.2.1-28.el10_0.noarch.rpm;name=aarch64_ghc9.2-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-xhtml-doc}"
SRC_URI[aarch64_ghc9.2-xhtml-doc.sha256sum] = "c02cbebaa9baa222341052c3b9bf5af3d330aaa5a1a3f80582cc1383de1baa47"

URI_aarch64_ghc9.2-xhtml-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.2-xhtml-prof-3000.2.2.1-28.el10_0.aarch64.rpm;name=aarch64_ghc9.2-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.2-xhtml-prof}"
SRC_URI[aarch64_ghc9.2-xhtml-prof.sha256sum] = "b58572c92b62671971f6c09e044a70b906fbdb7afc9cfa1d18619ac944434163"

RDEPENDS:ghc9.2 = " \
 ghc9.2-compiler \
 ghc9.2-devel \
 ghc9.2-ghc-boot-devel \
 ghc9.2-ghc-compact-devel \
 ghc9.2-ghc-devel \
 ghc9.2-ghc-heap-devel \
 ghc9.2-ghci-devel \
 ghc9.2-hpc-devel \
 ghc9.2-libiserv-devel \
 "
RDEPENDS:ghc9.2-Cabal = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-binary \
 ghc9.2-bytestring \
 ghc9.2-containers \
 ghc9.2-deepseq \
 ghc9.2-directory \
 ghc9.2-filepath \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot-th \
 ghc9.2-mtl \
 ghc9.2-parsec \
 ghc9.2-pretty \
 ghc9.2-process \
 ghc9.2-template-haskell \
 ghc9.2-text \
 ghc9.2-time \
 ghc9.2-transformers \
 ghc9.2-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-Cabal-devel = " \
 ghc9.2-Cabal \
 ghc9.2-array-devel \
 ghc9.2-base-devel \
 ghc9.2-binary-devel \
 ghc9.2-bytestring-devel \
 ghc9.2-compiler \
 ghc9.2-containers-devel \
 ghc9.2-deepseq-devel \
 ghc9.2-directory-devel \
 ghc9.2-filepath-devel \
 ghc9.2-mtl-devel \
 ghc9.2-parsec-devel \
 ghc9.2-pretty-devel \
 ghc9.2-process-devel \
 ghc9.2-text-devel \
 ghc9.2-time-devel \
 ghc9.2-transformers-devel \
 ghc9.2-unix-devel \
 "
RDEPENDS:ghc9.2-Cabal-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-Cabal-prof = " \
 ghc9.2-Cabal-devel \
 ghc9.2-array-prof \
 ghc9.2-base-prof \
 ghc9.2-binary-prof \
 ghc9.2-bytestring-prof \
 ghc9.2-containers-prof \
 ghc9.2-deepseq-prof \
 ghc9.2-directory-prof \
 ghc9.2-filepath-prof \
 ghc9.2-mtl-prof \
 ghc9.2-parsec-prof \
 ghc9.2-pretty-prof \
 ghc9.2-process-prof \
 ghc9.2-text-prof \
 ghc9.2-time-prof \
 ghc9.2-transformers-prof \
 ghc9.2-unix-prof \
 "
RDEPENDS:ghc9.2-array = " \
 ghc9.2-base \
 ghc9.2-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-array-devel = " \
 ghc9.2-array \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 "
RDEPENDS:ghc9.2-array-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-array-prof = " \
 ghc9.2-array-devel \
 ghc9.2-base-prof \
 "
RDEPENDS:ghc9.2-base = " \
 ghc9.2-ghc-bignum \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.2-base-devel = " \
 ghc9.2-base \
 ghc9.2-compiler \
 ghc9.2-ghc-bignum-devel \
 gmp-devel \
 libffi-devel \
 "
RDEPENDS:ghc9.2-base-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-base-prof = " \
 ghc9.2-base-devel \
 ghc9.2-ghc-bignum-prof \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.2-binary = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-bytestring \
 ghc9.2-containers \
 ghc9.2-deepseq \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot-th \
 ghc9.2-pretty \
 ghc9.2-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-binary-devel = " \
 ghc9.2-array-devel \
 ghc9.2-base-devel \
 ghc9.2-binary \
 ghc9.2-bytestring-devel \
 ghc9.2-compiler \
 ghc9.2-containers-devel \
 "
RDEPENDS:ghc9.2-binary-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-binary-prof = " \
 ghc9.2-array-prof \
 ghc9.2-base-prof \
 ghc9.2-binary-devel \
 ghc9.2-bytestring-prof \
 ghc9.2-containers-prof \
 "
RDEPENDS:ghc9.2-bytestring = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-deepseq \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot-th \
 ghc9.2-pretty \
 ghc9.2-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-bytestring-devel = " \
 ghc9.2-base-devel \
 ghc9.2-bytestring \
 ghc9.2-compiler \
 ghc9.2-deepseq-devel \
 ghc9.2-template-haskell-devel \
 "
RDEPENDS:ghc9.2-bytestring-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-bytestring-prof = " \
 ghc9.2-base-prof \
 ghc9.2-bytestring-devel \
 ghc9.2-deepseq-prof \
 ghc9.2-template-haskell-prof \
 "
RDEPENDS:ghc9.2-compiler = " \
 bash \
 binutils-gold \
 gcc \
 ghc9.2-Cabal \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-base-devel \
 ghc9.2-binary \
 ghc9.2-bytestring \
 ghc9.2-containers \
 ghc9.2-deepseq \
 ghc9.2-directory \
 ghc9.2-exceptions \
 ghc9.2-filepath \
 ghc9.2-filesystem \
 ghc9.2-ghc \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot \
 ghc9.2-ghc-boot-th \
 ghc9.2-ghc-heap \
 ghc9.2-ghci \
 ghc9.2-haskeline \
 ghc9.2-hpc \
 ghc9.2-libiserv \
 ghc9.2-mtl \
 ghc9.2-parsec \
 ghc9.2-pretty \
 ghc9.2-process \
 ghc9.2-stm \
 ghc9.2-template-haskell \
 ghc9.2-terminfo \
 ghc9.2-text \
 ghc9.2-time \
 ghc9.2-transformers \
 ghc9.2-unix \
 ghc9.2-xhtml \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 "
RDEPENDS:ghc9.2-compiler-default = " \
 bash \
 ghc9.2-compiler \
 "
RDEPENDS:ghc9.2-containers = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-deepseq \
 ghc9.2-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-containers-devel = " \
 ghc9.2-array-devel \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-containers \
 ghc9.2-deepseq-devel \
 "
RDEPENDS:ghc9.2-containers-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-containers-prof = " \
 ghc9.2-array-prof \
 ghc9.2-base-prof \
 ghc9.2-containers-devel \
 ghc9.2-deepseq-prof \
 "
RDEPENDS:ghc9.2-deepseq = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-deepseq-devel = " \
 ghc9.2-array-devel \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-deepseq \
 "
RDEPENDS:ghc9.2-deepseq-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-deepseq-prof = " \
 ghc9.2-array-prof \
 ghc9.2-base-prof \
 ghc9.2-deepseq-devel \
 "
RDEPENDS:ghc9.2-devel = " \
 ghc9.2-Cabal-devel \
 ghc9.2-array-devel \
 ghc9.2-base-devel \
 ghc9.2-binary-devel \
 ghc9.2-bytestring-devel \
 ghc9.2-compiler \
 ghc9.2-containers-devel \
 ghc9.2-deepseq-devel \
 ghc9.2-directory-devel \
 ghc9.2-exceptions-devel \
 ghc9.2-filepath-devel \
 ghc9.2-ghc-boot-th-devel \
 ghc9.2-haskeline-devel \
 ghc9.2-mtl-devel \
 ghc9.2-parsec-devel \
 ghc9.2-pretty-devel \
 ghc9.2-process-devel \
 ghc9.2-stm-devel \
 ghc9.2-template-haskell-devel \
 ghc9.2-terminfo-devel \
 ghc9.2-text-devel \
 ghc9.2-time-devel \
 ghc9.2-transformers-devel \
 ghc9.2-unix-devel \
 ghc9.2-xhtml-devel \
 "
RDEPENDS:ghc9.2-directory = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-bytestring \
 ghc9.2-deepseq \
 ghc9.2-filepath \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot-th \
 ghc9.2-pretty \
 ghc9.2-template-haskell \
 ghc9.2-time \
 ghc9.2-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-directory-devel = " \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-directory \
 ghc9.2-filepath-devel \
 ghc9.2-time-devel \
 ghc9.2-unix-devel \
 "
RDEPENDS:ghc9.2-directory-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-directory-prof = " \
 ghc9.2-base-prof \
 ghc9.2-directory-devel \
 ghc9.2-filepath-prof \
 ghc9.2-time-prof \
 ghc9.2-unix-prof \
 "
RDEPENDS:ghc9.2-doc = " \
 "
RDEPENDS:ghc9.2-doc-index = " \
 ghc9.2-compiler \
 "
RDEPENDS:ghc9.2-exceptions = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-deepseq \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot-th \
 ghc9.2-mtl \
 ghc9.2-pretty \
 ghc9.2-stm \
 ghc9.2-template-haskell \
 ghc9.2-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-exceptions-devel = " \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-exceptions \
 ghc9.2-mtl-devel \
 ghc9.2-stm-devel \
 ghc9.2-template-haskell-devel \
 ghc9.2-transformers-devel \
 "
RDEPENDS:ghc9.2-exceptions-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-exceptions-prof = " \
 ghc9.2-base-prof \
 ghc9.2-exceptions-devel \
 ghc9.2-mtl-prof \
 ghc9.2-stm-prof \
 ghc9.2-template-haskell-prof \
 ghc9.2-transformers-prof \
 "
RDEPENDS:ghc9.2-filepath = " \
 ghc9.2-base \
 ghc9.2-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-filepath-devel = " \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-filepath \
 "
RDEPENDS:ghc9.2-filepath-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-filepath-prof = " \
 ghc9.2-base-prof \
 ghc9.2-filepath-devel \
 "
RDEPENDS:ghc9.2-filesystem = " \
 "
RDEPENDS:ghc9.2-ghc = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-binary \
 ghc9.2-bytestring \
 ghc9.2-containers \
 ghc9.2-deepseq \
 ghc9.2-directory \
 ghc9.2-exceptions \
 ghc9.2-filepath \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot \
 ghc9.2-ghc-boot-th \
 ghc9.2-ghc-heap \
 ghc9.2-ghci \
 ghc9.2-hpc \
 ghc9.2-mtl \
 ghc9.2-pretty \
 ghc9.2-process \
 ghc9.2-stm \
 ghc9.2-template-haskell \
 ghc9.2-terminfo \
 ghc9.2-time \
 ghc9.2-transformers \
 ghc9.2-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.2-ghc-bignum = " \
 ghc9.2-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-ghc-bignum-devel = " \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-ghc-bignum \
 "
RDEPENDS:ghc9.2-ghc-bignum-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-ghc-bignum-prof = " \
 ghc9.2-base-prof \
 ghc9.2-ghc-bignum-devel \
 "
RDEPENDS:ghc9.2-ghc-boot = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-binary \
 ghc9.2-bytestring \
 ghc9.2-containers \
 ghc9.2-deepseq \
 ghc9.2-directory \
 ghc9.2-filepath \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot-th \
 ghc9.2-pretty \
 ghc9.2-template-haskell \
 ghc9.2-time \
 ghc9.2-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-ghc-boot-devel = " \
 ghc9.2-base-devel \
 ghc9.2-binary-devel \
 ghc9.2-bytestring-devel \
 ghc9.2-compiler \
 ghc9.2-containers-devel \
 ghc9.2-deepseq-devel \
 ghc9.2-directory-devel \
 ghc9.2-filepath-devel \
 ghc9.2-ghc-boot \
 ghc9.2-ghc-boot-th-devel \
 ghc9.2-unix-devel \
 "
RDEPENDS:ghc9.2-ghc-boot-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-ghc-boot-prof = " \
 ghc9.2-base-prof \
 ghc9.2-binary-prof \
 ghc9.2-bytestring-prof \
 ghc9.2-containers-prof \
 ghc9.2-deepseq-prof \
 ghc9.2-directory-prof \
 ghc9.2-filepath-prof \
 ghc9.2-ghc-boot-devel \
 ghc9.2-ghc-boot-th-prof \
 ghc9.2-unix-prof \
 "
RDEPENDS:ghc9.2-ghc-boot-th = " \
 ghc9.2-base \
 ghc9.2-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-ghc-boot-th-devel = " \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-ghc-boot-th \
 "
RDEPENDS:ghc9.2-ghc-boot-th-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-ghc-boot-th-prof = " \
 ghc9.2-base-prof \
 ghc9.2-ghc-boot-th-devel \
 "
RDEPENDS:ghc9.2-ghc-compact = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-bytestring \
 ghc9.2-deepseq \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot-th \
 ghc9.2-pretty \
 ghc9.2-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-ghc-compact-devel = " \
 ghc9.2-base-devel \
 ghc9.2-bytestring-devel \
 ghc9.2-compiler \
 ghc9.2-ghc-compact \
 "
RDEPENDS:ghc9.2-ghc-compact-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-ghc-compact-prof = " \
 ghc9.2-base-prof \
 ghc9.2-bytestring-prof \
 ghc9.2-ghc-compact-devel \
 "
RDEPENDS:ghc9.2-ghc-devel = " \
 ghc9.2-array-devel \
 ghc9.2-base-devel \
 ghc9.2-binary-devel \
 ghc9.2-bytestring-devel \
 ghc9.2-compiler \
 ghc9.2-containers-devel \
 ghc9.2-deepseq-devel \
 ghc9.2-directory-devel \
 ghc9.2-exceptions-devel \
 ghc9.2-filepath-devel \
 ghc9.2-ghc \
 ghc9.2-ghc-boot-devel \
 ghc9.2-ghc-heap-devel \
 ghc9.2-ghci-devel \
 ghc9.2-hpc-devel \
 ghc9.2-process-devel \
 ghc9.2-template-haskell-devel \
 ghc9.2-terminfo-devel \
 ghc9.2-time-devel \
 ghc9.2-transformers-devel \
 ghc9.2-unix-devel \
 "
RDEPENDS:ghc9.2-ghc-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-ghc-heap = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-containers \
 ghc9.2-deepseq \
 ghc9.2-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-ghc-heap-devel = " \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-containers-devel \
 ghc9.2-ghc-heap \
 "
RDEPENDS:ghc9.2-ghc-heap-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-ghc-heap-prof = " \
 ghc9.2-base-prof \
 ghc9.2-containers-prof \
 ghc9.2-ghc-heap-devel \
 "
RDEPENDS:ghc9.2-ghc-prof = " \
 ghc9.2-array-prof \
 ghc9.2-base-prof \
 ghc9.2-binary-prof \
 ghc9.2-bytestring-prof \
 ghc9.2-containers-prof \
 ghc9.2-deepseq-prof \
 ghc9.2-directory-prof \
 ghc9.2-exceptions-prof \
 ghc9.2-filepath-prof \
 ghc9.2-ghc-boot-prof \
 ghc9.2-ghc-devel \
 ghc9.2-ghc-heap-prof \
 ghc9.2-ghci-prof \
 ghc9.2-hpc-prof \
 ghc9.2-process-prof \
 ghc9.2-template-haskell-prof \
 ghc9.2-terminfo-prof \
 ghc9.2-time-prof \
 ghc9.2-transformers-prof \
 ghc9.2-unix-prof \
 "
RDEPENDS:ghc9.2-ghci = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-binary \
 ghc9.2-bytestring \
 ghc9.2-containers \
 ghc9.2-deepseq \
 ghc9.2-directory \
 ghc9.2-filepath \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot \
 ghc9.2-ghc-boot-th \
 ghc9.2-ghc-heap \
 ghc9.2-pretty \
 ghc9.2-template-haskell \
 ghc9.2-time \
 ghc9.2-transformers \
 ghc9.2-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-ghci-devel = " \
 ghc9.2-array-devel \
 ghc9.2-base-devel \
 ghc9.2-binary-devel \
 ghc9.2-bytestring-devel \
 ghc9.2-compiler \
 ghc9.2-containers-devel \
 ghc9.2-deepseq-devel \
 ghc9.2-filepath-devel \
 ghc9.2-ghc-boot-devel \
 ghc9.2-ghc-heap-devel \
 ghc9.2-ghci \
 ghc9.2-template-haskell-devel \
 ghc9.2-transformers-devel \
 ghc9.2-unix-devel \
 "
RDEPENDS:ghc9.2-ghci-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-ghci-prof = " \
 ghc9.2-array-prof \
 ghc9.2-base-prof \
 ghc9.2-binary-prof \
 ghc9.2-bytestring-prof \
 ghc9.2-containers-prof \
 ghc9.2-deepseq-prof \
 ghc9.2-filepath-prof \
 ghc9.2-ghc-boot-prof \
 ghc9.2-ghc-heap-prof \
 ghc9.2-ghci-devel \
 ghc9.2-template-haskell-prof \
 ghc9.2-transformers-prof \
 ghc9.2-unix-prof \
 "
RDEPENDS:ghc9.2-hadrian = " \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.2-haskeline = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-bytestring \
 ghc9.2-containers \
 ghc9.2-deepseq \
 ghc9.2-directory \
 ghc9.2-exceptions \
 ghc9.2-filepath \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot-th \
 ghc9.2-mtl \
 ghc9.2-pretty \
 ghc9.2-process \
 ghc9.2-stm \
 ghc9.2-template-haskell \
 ghc9.2-terminfo \
 ghc9.2-time \
 ghc9.2-transformers \
 ghc9.2-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.2-haskeline-devel = " \
 ghc9.2-base-devel \
 ghc9.2-bytestring-devel \
 ghc9.2-compiler \
 ghc9.2-containers-devel \
 ghc9.2-directory-devel \
 ghc9.2-exceptions-devel \
 ghc9.2-filepath-devel \
 ghc9.2-haskeline \
 ghc9.2-process-devel \
 ghc9.2-stm-devel \
 ghc9.2-terminfo-devel \
 ghc9.2-transformers-devel \
 ghc9.2-unix-devel \
 "
RDEPENDS:ghc9.2-haskeline-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-haskeline-prof = " \
 ghc9.2-base-prof \
 ghc9.2-bytestring-prof \
 ghc9.2-containers-prof \
 ghc9.2-directory-prof \
 ghc9.2-exceptions-prof \
 ghc9.2-filepath-prof \
 ghc9.2-haskeline-devel \
 ghc9.2-process-prof \
 ghc9.2-stm-prof \
 ghc9.2-terminfo-prof \
 ghc9.2-transformers-prof \
 ghc9.2-unix-prof \
 "
RDEPENDS:ghc9.2-hpc = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-bytestring \
 ghc9.2-containers \
 ghc9.2-deepseq \
 ghc9.2-directory \
 ghc9.2-filepath \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot-th \
 ghc9.2-pretty \
 ghc9.2-template-haskell \
 ghc9.2-time \
 ghc9.2-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-hpc-devel = " \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-containers-devel \
 ghc9.2-deepseq-devel \
 ghc9.2-directory-devel \
 ghc9.2-filepath-devel \
 ghc9.2-hpc \
 ghc9.2-time-devel \
 "
RDEPENDS:ghc9.2-hpc-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-hpc-prof = " \
 ghc9.2-base-prof \
 ghc9.2-containers-prof \
 ghc9.2-deepseq-prof \
 ghc9.2-directory-prof \
 ghc9.2-filepath-prof \
 ghc9.2-hpc-devel \
 ghc9.2-time-prof \
 "
RDEPENDS:ghc9.2-libiserv = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-binary \
 ghc9.2-bytestring \
 ghc9.2-containers \
 ghc9.2-deepseq \
 ghc9.2-directory \
 ghc9.2-filepath \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot \
 ghc9.2-ghc-boot-th \
 ghc9.2-ghc-heap \
 ghc9.2-ghci \
 ghc9.2-pretty \
 ghc9.2-template-haskell \
 ghc9.2-time \
 ghc9.2-transformers \
 ghc9.2-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-libiserv-devel = " \
 ghc9.2-base-devel \
 ghc9.2-binary-devel \
 ghc9.2-bytestring-devel \
 ghc9.2-compiler \
 ghc9.2-containers-devel \
 ghc9.2-deepseq-devel \
 ghc9.2-ghci-devel \
 ghc9.2-libiserv \
 ghc9.2-unix-devel \
 "
RDEPENDS:ghc9.2-libiserv-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-libiserv-prof = " \
 ghc9.2-base-prof \
 ghc9.2-binary-prof \
 ghc9.2-bytestring-prof \
 ghc9.2-containers-prof \
 ghc9.2-deepseq-prof \
 ghc9.2-ghci-prof \
 ghc9.2-libiserv-devel \
 ghc9.2-unix-prof \
 "
RDEPENDS:ghc9.2-manual = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-mtl = " \
 ghc9.2-base \
 ghc9.2-ghc-bignum \
 ghc9.2-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-mtl-devel = " \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-mtl \
 ghc9.2-transformers-devel \
 "
RDEPENDS:ghc9.2-mtl-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-mtl-prof = " \
 ghc9.2-base-prof \
 ghc9.2-mtl-devel \
 ghc9.2-transformers-prof \
 "
RDEPENDS:ghc9.2-parsec = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-binary \
 ghc9.2-bytestring \
 ghc9.2-containers \
 ghc9.2-deepseq \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot-th \
 ghc9.2-mtl \
 ghc9.2-pretty \
 ghc9.2-template-haskell \
 ghc9.2-text \
 ghc9.2-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-parsec-devel = " \
 ghc9.2-base-devel \
 ghc9.2-bytestring-devel \
 ghc9.2-compiler \
 ghc9.2-mtl-devel \
 ghc9.2-parsec \
 ghc9.2-text-devel \
 "
RDEPENDS:ghc9.2-parsec-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-parsec-prof = " \
 ghc9.2-base-prof \
 ghc9.2-bytestring-prof \
 ghc9.2-mtl-prof \
 ghc9.2-parsec-devel \
 ghc9.2-text-prof \
 "
RDEPENDS:ghc9.2-pretty = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-deepseq \
 ghc9.2-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-pretty-devel = " \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-deepseq-devel \
 ghc9.2-pretty \
 "
RDEPENDS:ghc9.2-pretty-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-pretty-prof = " \
 ghc9.2-base-prof \
 ghc9.2-deepseq-prof \
 ghc9.2-pretty-devel \
 "
RDEPENDS:ghc9.2-process = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-bytestring \
 ghc9.2-deepseq \
 ghc9.2-directory \
 ghc9.2-filepath \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot-th \
 ghc9.2-pretty \
 ghc9.2-template-haskell \
 ghc9.2-time \
 ghc9.2-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-process-devel = " \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-deepseq-devel \
 ghc9.2-directory-devel \
 ghc9.2-filepath-devel \
 ghc9.2-process \
 ghc9.2-unix-devel \
 "
RDEPENDS:ghc9.2-process-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-process-prof = " \
 ghc9.2-base-prof \
 ghc9.2-deepseq-prof \
 ghc9.2-directory-prof \
 ghc9.2-filepath-prof \
 ghc9.2-process-devel \
 ghc9.2-unix-prof \
 "
RDEPENDS:ghc9.2-prof = " \
 ghc9.2-compiler \
 "
RDEPENDS:ghc9.2-stm = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-stm-devel = " \
 ghc9.2-array-devel \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-stm \
 "
RDEPENDS:ghc9.2-stm-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-stm-prof = " \
 ghc9.2-array-prof \
 ghc9.2-base-prof \
 ghc9.2-stm-devel \
 "
RDEPENDS:ghc9.2-template-haskell = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-deepseq \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot-th \
 ghc9.2-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-template-haskell-devel = " \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-ghc-boot-th-devel \
 ghc9.2-pretty-devel \
 ghc9.2-template-haskell \
 "
RDEPENDS:ghc9.2-template-haskell-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-template-haskell-prof = " \
 ghc9.2-base-prof \
 ghc9.2-ghc-boot-th-prof \
 ghc9.2-pretty-prof \
 ghc9.2-template-haskell-devel \
 "
RDEPENDS:ghc9.2-terminfo = " \
 ghc9.2-base \
 ghc9.2-ghc-bignum \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.2-terminfo-devel = " \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-terminfo \
 ncurses-devel \
 "
RDEPENDS:ghc9.2-terminfo-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-terminfo-prof = " \
 ghc9.2-base-prof \
 ghc9.2-terminfo-devel \
 "
RDEPENDS:ghc9.2-text = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-binary \
 ghc9.2-bytestring \
 ghc9.2-containers \
 ghc9.2-deepseq \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot-th \
 ghc9.2-pretty \
 ghc9.2-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-text-devel = " \
 ghc9.2-array-devel \
 ghc9.2-base-devel \
 ghc9.2-binary-devel \
 ghc9.2-bytestring-devel \
 ghc9.2-compiler \
 ghc9.2-deepseq-devel \
 ghc9.2-template-haskell-devel \
 ghc9.2-text \
 "
RDEPENDS:ghc9.2-text-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-text-prof = " \
 ghc9.2-array-prof \
 ghc9.2-base-prof \
 ghc9.2-binary-prof \
 ghc9.2-bytestring-prof \
 ghc9.2-deepseq-prof \
 ghc9.2-template-haskell-prof \
 ghc9.2-text-devel \
 "
RDEPENDS:ghc9.2-time = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-deepseq \
 ghc9.2-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-time-devel = " \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-deepseq-devel \
 ghc9.2-time \
 "
RDEPENDS:ghc9.2-time-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-time-prof = " \
 ghc9.2-base-prof \
 ghc9.2-deepseq-prof \
 ghc9.2-time-devel \
 "
RDEPENDS:ghc9.2-transformers = " \
 ghc9.2-base \
 ghc9.2-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-transformers-devel = " \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-transformers \
 "
RDEPENDS:ghc9.2-transformers-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-transformers-prof = " \
 ghc9.2-base-prof \
 ghc9.2-transformers-devel \
 "
RDEPENDS:ghc9.2-unix = " \
 ghc9.2-array \
 ghc9.2-base \
 ghc9.2-bytestring \
 ghc9.2-deepseq \
 ghc9.2-ghc-bignum \
 ghc9.2-ghc-boot-th \
 ghc9.2-pretty \
 ghc9.2-template-haskell \
 ghc9.2-time \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-unix-devel = " \
 ghc9.2-base-devel \
 ghc9.2-bytestring-devel \
 ghc9.2-compiler \
 ghc9.2-time-devel \
 ghc9.2-unix \
 "
RDEPENDS:ghc9.2-unix-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-unix-prof = " \
 ghc9.2-base-prof \
 ghc9.2-bytestring-prof \
 ghc9.2-time-prof \
 ghc9.2-unix-devel \
 "
RDEPENDS:ghc9.2-xhtml = " \
 ghc9.2-base \
 ghc9.2-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.2-xhtml-devel = " \
 ghc9.2-base-devel \
 ghc9.2-compiler \
 ghc9.2-xhtml \
 "
RDEPENDS:ghc9.2-xhtml-doc = " \
 ghc9.2-filesystem \
 "
RDEPENDS:ghc9.2-xhtml-prof = " \
 ghc9.2-base-prof \
 ghc9.2-xhtml-devel \
 "
