# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fs_extra"
PV = "1.3.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-fs_extra+default-devel \
 rust-fs_extra-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fs_extra-1.3.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92513958134ad08a37487968b02518f6644b3a7c986222c878a9cbff80a2d770"

URI_x86_64_v2_rust-fs_extra+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs_extra+default-devel-1.3.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs_extra+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs_extra+default-devel}"
SRC_URI[x86_64_v2_rust-fs_extra+default-devel.sha256sum] = "6beedca1dabf578278b333d80d2a4426321821ee0ee8b74611b1d2e65394fd00"

URI_x86_64_v2_rust-fs_extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs_extra-devel-1.3.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs_extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs_extra-devel}"
SRC_URI[x86_64_v2_rust-fs_extra-devel.sha256sum] = "59597d979a33f845794a28bf3b75637a298876d0bb9729cc68c18fc60ca143f6"

URI_aarch64_rust-fs_extra+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs_extra+default-devel-1.3.0-4.el10_0.noarch.rpm;name=aarch64_rust-fs_extra+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs_extra+default-devel}"
SRC_URI[aarch64_rust-fs_extra+default-devel.sha256sum] = "d9e92c1d93f015c5723436511eb24117eb02ee4ea671d6544548874c43f8b83a"

URI_aarch64_rust-fs_extra-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs_extra-devel-1.3.0-4.el10_0.noarch.rpm;name=aarch64_rust-fs_extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs_extra-devel}"
SRC_URI[aarch64_rust-fs_extra-devel.sha256sum] = "a40411b5a8f603b976e3633b978a722fcfa22e08a31339f1e3621304488c9fd4"

RDEPENDS:rust-fs_extra+default-devel = " \
 cargo \
 rust-fs_extra-devel \
 "
RDEPENDS:rust-fs_extra-devel = " \
 cargo \
 "
