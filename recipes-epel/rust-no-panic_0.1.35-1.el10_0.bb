# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-no-panic"
PV = "0.1.35"
PR = "1.el10_0"
PACKAGES = " \
 rust-no-panic+default-devel \
 rust-no-panic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-no-panic-0.1.35-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3f89e4f1be89a4e70161391ef0c84ba5945a7fd44d6dd05d9ba8d78055eda3a"

URI_x86_64_v2_rust-no-panic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-no-panic+default-devel-0.1.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-no-panic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-no-panic+default-devel}"
SRC_URI[x86_64_v2_rust-no-panic+default-devel.sha256sum] = "94af32306507eb555240a546a2be65aa2d0d39130495dbcfa787a80cdb86e4b6"

URI_x86_64_v2_rust-no-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-no-panic-devel-0.1.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-no-panic-devel}"
SRC_URI[x86_64_v2_rust-no-panic-devel.sha256sum] = "131af7dbafcf6543f2f869179f2442e326e2afbf7fad7f0427e0530a9a889334"

URI_aarch64_rust-no-panic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-no-panic+default-devel-0.1.35-1.el10_0.noarch.rpm;name=aarch64_rust-no-panic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-no-panic+default-devel}"
SRC_URI[aarch64_rust-no-panic+default-devel.sha256sum] = "078b879ae00f0cb989d737d9ee7460ed30748a623a5a1183725745558f8a90a8"

URI_aarch64_rust-no-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-no-panic-devel-0.1.35-1.el10_0.noarch.rpm;name=aarch64_rust-no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-no-panic-devel}"
SRC_URI[aarch64_rust-no-panic-devel.sha256sum] = "149d18124fbf02ddb15aff22fc31e7a301e7242b44c57f30daf974e462c103bc"

RDEPENDS:rust-no-panic+default-devel = " \
 cargo \
 rust-no-panic-devel \
 "
RDEPENDS:rust-no-panic-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
