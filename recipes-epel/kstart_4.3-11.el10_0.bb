# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kstart"
PV = "4.3"
PR = "11.el10_0"
PACKAGES = " \
 kstart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kstart-4.3-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9136f14ee3e03dbcc4fa709682ead64c9ce42c4e5813d547c9837a49064da8b3"

URI_x86_64_v2_kstart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kstart-4.3-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kstart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kstart}"
SRC_URI[x86_64_v2_kstart.sha256sum] = "fdf914432ad4ce65e242bb8defc0222a76fa1ed7286aafbab136535972d9ac3e"

URI_aarch64_kstart = "${EPEL_MIRROR}/aarch64/Packages/k/kstart-4.3-11.el10_0.aarch64.rpm;name=aarch64_kstart;unpack=0"
SRC_URI:append = " ${URI_aarch64_kstart}"
SRC_URI[aarch64_kstart.sha256sum] = "b5002436903f4fe9ccd4179459078b9bfa2f88e33322eac9dd7d7fe0e03dc08d"

RDEPENDS:kstart = " \
 bash \
 glibc \
 keyutils-libs \
 krb5-libs \
 "
