# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ndppd"
PV = "0.2.6"
PR = "1.el10_1"
PACKAGES = " \
 ndppd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ndppd-0.2.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba7281bcea850cf5b00729aff71521a0f59a3ca6c6e9fe720d6ab0084b66eccf"

URI_x86_64_v2_ndppd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ndppd-0.2.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ndppd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ndppd}"
SRC_URI[x86_64_v2_ndppd.sha256sum] = "b8eefb4b3a81a99882db859fab6d82a860fcd2abe3564391e180c82b1eb80e91"

URI_aarch64_ndppd = "${EPEL_MIRROR}/aarch64/Packages/n/ndppd-0.2.6-1.el10_1.aarch64.rpm;name=aarch64_ndppd;unpack=0"
SRC_URI:append = " ${URI_aarch64_ndppd}"
SRC_URI[aarch64_ndppd.sha256sum] = "c6f8fe7d07b9b85c8a7a630052f61809a08c437a9c756feacb77dc29dff7f9cf"

RDEPENDS:ndppd = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
