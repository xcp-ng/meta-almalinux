# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "klickety"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 klickety \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/klickety-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "624812b25b7cffdbef128c36580e42d889bb4d8d5087c2876a4201eb3ecd84a1"

URI_x86_64_v2_klickety = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/klickety-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_klickety;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_klickety}"
SRC_URI[x86_64_v2_klickety.sha256sum] = "fc01e78783c9a9984f8dfdbd417975e2e08fb5a322c4f97d8c6d2417a05b7f35"

URI_aarch64_klickety = "${EPEL_MIRROR}/aarch64/Packages/k/klickety-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_klickety;unpack=0"
SRC_URI:append = " ${URI_aarch64_klickety}"
SRC_URI[aarch64_klickety.sha256sum] = "71f39e57dfa6ce9d94983a19db9cc7fd3be017643efe13e90835764bc88f1752"

RDEPENDS:klickety = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 perl-interpreter \
 perl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
