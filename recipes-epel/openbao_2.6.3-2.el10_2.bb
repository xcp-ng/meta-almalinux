# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openbao"
PV = "2.6.3"
PR = "2.el10_2"
PACKAGES = " \
 openbao \
 openbao-vault-compat \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/openbao-2.6.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a056e901875551334351192a23ad7ce067f396682c6c0b518eac743a4312ce73"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbao-2.6.3-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbao;unpack=0"
SRC_URI[x86_64_v2_openbao.sha256sum] = "ebb90cc8f8aeaf7d51caf8967d08ed7acfdb70b32d0e2170e07ac65ce8b7f961"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbao-vault-compat-2.6.3-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbao-vault-compat;unpack=0"
SRC_URI[x86_64_v2_openbao-vault-compat.sha256sum] = "a5b3430807be6953391dff858f41ce881f9506736dceeed79a9cae7b86b41422"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openbao-2.6.3-2.el10_2.aarch64.rpm;name=aarch64_openbao;unpack=0"
SRC_URI[aarch64_openbao.sha256sum] = "9990501ca22130a3b5ff2fd2186ca6b431e44b7343269ed2bac267723321a5df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openbao-vault-compat-2.6.3-2.el10_2.aarch64.rpm;name=aarch64_openbao-vault-compat;unpack=0"
SRC_URI[aarch64_openbao-vault-compat.sha256sum] = "f6124b61705731b94602368b2dc9e371cd694be425c83566285043ffff367042"

RDEPENDS:openbao = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:openbao-vault-compat = " \
 openbao \
 "
