# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-core"
PE = "1"
PV = "2.16.16"
PR = "2.el10_2.1"
PACKAGES = " \
 ansible-core \
 ansible-test \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ansible-core-2.16.16-2.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c0e9d933c3fddb7924ecdada3d404503aa801331d744db84c7f5905dfb700850"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-core-2.16.16-2.el10_2.1.noarch.rpm;name=x86_64_v2_ansible-core;unpack=0"
SRC_URI[x86_64_v2_ansible-core.sha256sum] = "9e56e424dbf2c5ad2a45a0dfbe4d711e036865c0a60139679f71bec6f32d2897"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-test-2.16.16-2.el10_2.1.noarch.rpm;name=x86_64_v2_ansible-test;unpack=0"
SRC_URI[x86_64_v2_ansible-test.sha256sum] = "278ed7a9b385cb985f51b9a6e708b16d47cae71cb98ba0d3c8d13b7c71d3f0de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-core-2.16.16-2.el10_2.1.noarch.rpm;name=aarch64_ansible-core;unpack=0"
SRC_URI[aarch64_ansible-core.sha256sum] = "9e56e424dbf2c5ad2a45a0dfbe4d711e036865c0a60139679f71bec6f32d2897"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-test-2.16.16-2.el10_2.1.noarch.rpm;name=aarch64_ansible-test;unpack=0"
SRC_URI[aarch64_ansible-test.sha256sum] = "278ed7a9b385cb985f51b9a6e708b16d47cae71cb98ba0d3c8d13b7c71d3f0de"

RDEPENDS:ansible-core = " \
 git-core \
 python3 \
 python3-cryptography \
 python3-jinja2 \
 python3-packaging \
 python3-pyyaml \
 python3-resolvelib \
 "
RDEPENDS:ansible-test = " \
 ansible-core \
 python3 \
 "
