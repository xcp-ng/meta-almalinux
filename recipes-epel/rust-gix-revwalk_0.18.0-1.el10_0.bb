# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-revwalk"
PV = "0.18.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-revwalk+default-devel \
 rust-gix-revwalk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-revwalk-0.18.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "287342aee6c3e5d7c4f71b3f88008277d78d0c4bd18cecb02ff0df264749f576"

URI_x86_64_v2_rust-gix-revwalk+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revwalk+default-devel-0.18.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revwalk+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revwalk+default-devel}"
SRC_URI[x86_64_v2_rust-gix-revwalk+default-devel.sha256sum] = "d9ef1f59ff95211cc39fbfe062b570e2d021000a11037638f3d2c85254f73268"

URI_x86_64_v2_rust-gix-revwalk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revwalk-devel-0.18.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revwalk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revwalk-devel}"
SRC_URI[x86_64_v2_rust-gix-revwalk-devel.sha256sum] = "e8713fbe9cb4c3db75329aaceb5b3117e2459923491e235f842d2b3f3598825c"

URI_aarch64_rust-gix-revwalk+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revwalk+default-devel-0.18.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-revwalk+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revwalk+default-devel}"
SRC_URI[aarch64_rust-gix-revwalk+default-devel.sha256sum] = "4cc8a3ba42c36de6e61f0115b781966908cfeb22b1791b325e7b408aa2d3f578"

URI_aarch64_rust-gix-revwalk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revwalk-devel-0.18.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-revwalk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revwalk-devel}"
SRC_URI[aarch64_rust-gix-revwalk-devel.sha256sum] = "e3165b120d75d933e19a752217e73058305399079879393ef135461dfe59c395"

RDEPENDS:rust-gix-revwalk+default-devel = " \
 cargo \
 rust-gix-revwalk-devel \
 "
RDEPENDS:rust-gix-revwalk-devel = " \
 cargo \
 rust \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-object+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
