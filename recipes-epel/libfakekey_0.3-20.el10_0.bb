# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libfakekey"
PV = "0.3"
PR = "20.el10_0"
PACKAGES = " \
 libfakekey \
 libfakekey-devel \
 libfakekey-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libfakekey-0.3-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "463946450a76714c7d11eca6a6e5dae6b21c208c4d753e8371ce50781fb2e432"

URI_x86_64_v2_libfakekey = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfakekey-0.3-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libfakekey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfakekey}"
SRC_URI[x86_64_v2_libfakekey.sha256sum] = "e78c33ccdca7c09ea8cb6d02e0c83453f5b086b0977b11fe46e72133a5ce135a"

URI_x86_64_v2_libfakekey-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfakekey-devel-0.3-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libfakekey-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfakekey-devel}"
SRC_URI[x86_64_v2_libfakekey-devel.sha256sum] = "849f2cea436bf59e8bfbe57d74c55a2e2aab4a9fbed20406f1b15df1c042196d"

URI_x86_64_v2_libfakekey-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfakekey-doc-0.3-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libfakekey-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfakekey-doc}"
SRC_URI[x86_64_v2_libfakekey-doc.sha256sum] = "a2457bd4b63ccc30c210fb39cbf19802fabc8383d58d904f2469d7d1784a3422"

URI_aarch64_libfakekey = "${EPEL_MIRROR}/aarch64/Packages/l/libfakekey-0.3-20.el10_0.aarch64.rpm;name=aarch64_libfakekey;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfakekey}"
SRC_URI[aarch64_libfakekey.sha256sum] = "da751f7827b589f838b0877f0990a3e46b72feccb3fa9bf41fa12f34d1ed8dec"

URI_aarch64_libfakekey-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libfakekey-devel-0.3-20.el10_0.aarch64.rpm;name=aarch64_libfakekey-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfakekey-devel}"
SRC_URI[aarch64_libfakekey-devel.sha256sum] = "efcc73d6861ab55da627cba1f241aad6175de0cd977b335a95c2d0877873de60"

URI_aarch64_libfakekey-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libfakekey-doc-0.3-20.el10_0.noarch.rpm;name=aarch64_libfakekey-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfakekey-doc}"
SRC_URI[aarch64_libfakekey-doc.sha256sum] = "1fc9aef592582311762598b3a6a41d357bb29a379dc2e6dc827fe3de40525441"

RDEPENDS:libfakekey = " \
 glibc \
 libX11 \
 libXtst \
 "
RDEPENDS:libfakekey-devel = " \
 libX11-devel \
 libXtst-devel \
 libfakekey \
 pkgconf-pkg-config \
 "
RDEPENDS:libfakekey-doc = " \
 "
