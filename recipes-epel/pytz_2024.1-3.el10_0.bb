# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pytz"
PV = "2024.1"
PR = "3.el10_0"
PACKAGES = " \
 python3-pytz \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pytz-2024.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3af70ef19e2d929c30b1f7753afdf325450ff564ca86f6d3d33229022c561511"

URI_x86_64_v2_python3-pytz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytz-2024.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytz}"
SRC_URI[x86_64_v2_python3-pytz.sha256sum] = "5ca5030d032fabd86e377fb9bb8846dc7068db745b6de5ca208edd23cae8ba3b"

URI_aarch64_python3-pytz = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytz-2024.1-3.el10_0.noarch.rpm;name=aarch64_python3-pytz;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytz}"
SRC_URI[aarch64_python3-pytz.sha256sum] = "ce93f0b5470577698fe664b383279ad7752355db8ecab99fb4811d0c8b2d3d1f"

RDEPENDS:python3-pytz = " \
 python3 \
 tzdata \
 "
