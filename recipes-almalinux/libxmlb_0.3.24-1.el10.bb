# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxmlb"
PV = "0.3.24"
PR = "1.el10"
PACKAGES = " \
 libxmlb \
 libxmlb-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libxmlb-0.3.24-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea6e2fde26c14af81cb09264f8c0e6822cd444bf281de242bee9e3e4926ca972"

URI_x86_64_v2_libxmlb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libxmlb-0.3.24-1.el10.x86_64_v2.rpm;name=x86_64_v2_libxmlb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxmlb}"
SRC_URI[x86_64_v2_libxmlb.sha256sum] = "70ac2834be9b788d27da4ae6a56c0364878f7ccad5b57eb8208ed7c88f3f63be"

URI_x86_64_v2_libxmlb-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxmlb-devel-0.3.24-1.el10.x86_64_v2.rpm;name=x86_64_v2_libxmlb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxmlb-devel}"
SRC_URI[x86_64_v2_libxmlb-devel.sha256sum] = "2c99eaa3fecd821f43a132fdac3e7d85852882c511a2dfdd792a572748999835"

URI_aarch64_libxmlb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libxmlb-0.3.24-1.el10.aarch64.rpm;name=aarch64_libxmlb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxmlb}"
SRC_URI[aarch64_libxmlb.sha256sum] = "5f8c18778637ed0c143decf4566cae615ff7739dc64e805dc4e4d2d499f74d42"

URI_aarch64_libxmlb-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxmlb-devel-0.3.24-1.el10.aarch64.rpm;name=aarch64_libxmlb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxmlb-devel}"
SRC_URI[aarch64_libxmlb-devel.sha256sum] = "6ef9d19b754fdfff97eeceb0944c056ae641ac26472ef4772bf7c1ea407ea5e9"

RDEPENDS:libxmlb = " \
 glib2 \
 glibc \
 libgcc \
 libzstd \
 shared-mime-info \
 xz-libs \
 "
RDEPENDS:libxmlb-devel = " \
 glib2-devel \
 libxmlb \
 libzstd-devel \
 pkgconf-pkg-config \
 xz-devel \
 "
