# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet8.0"
PV = "8.0.126"
PR = "1.el10_1"
PACKAGES = " \
 aspnetcore-runtime-8.0 \
 aspnetcore-runtime-dbg-8.0 \
 aspnetcore-targeting-pack-8.0 \
 dotnet-apphost-pack-8.0 \
 dotnet-hostfxr-8.0 \
 dotnet-runtime-8.0 \
 dotnet-runtime-dbg-8.0 \
 dotnet-sdk-8.0 \
 dotnet-sdk-8.0-source-built-artifacts \
 dotnet-sdk-dbg-8.0 \
 dotnet-targeting-pack-8.0 \
 dotnet-templates-8.0 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet8.0-8.0.126-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7091326da43380cca27d4fa3537fb2db41d4efbfa18bdd273e5d9943f53399a"

URI_x86_64_v2_aspnetcore-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-8.0-8.0.26-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-8.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-8.0.sha256sum] = "c4ec69028313ca1656d8c9d97166c34b77a32dae82b515808d70c3790db5af5c"

URI_x86_64_v2_aspnetcore-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-8.0-8.0.26-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-dbg-8.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-8.0.sha256sum] = "2264324d66ecda5930bf4c34c84be87ef62654cd6ecf7324babcb590acfaed8e"

URI_x86_64_v2_aspnetcore-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-8.0-8.0.26-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-targeting-pack-8.0}"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-8.0.sha256sum] = "1249ef9ccce2ddfeac788fce74c3b363bf8b4ee29338faa78f947c58c2cb8324"

URI_x86_64_v2_dotnet-apphost-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-8.0-8.0.26-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-apphost-pack-8.0}"
SRC_URI[x86_64_v2_dotnet-apphost-pack-8.0.sha256sum] = "bff3fa8ea4b6c3516547af3bd5b05aae272716e1c0a69b700f267849802546c8"

URI_x86_64_v2_dotnet-hostfxr-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-8.0-8.0.26-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-hostfxr-8.0}"
SRC_URI[x86_64_v2_dotnet-hostfxr-8.0.sha256sum] = "9fb64b8b599d3a1270512c2326b93a105cdbc43d769355ac6340f5d70e1761e3"

URI_x86_64_v2_dotnet-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-8.0-8.0.26-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-8.0}"
SRC_URI[x86_64_v2_dotnet-runtime-8.0.sha256sum] = "0fd41177f13717c60c1b3f02edf22d813d65f802118fc8840bfff4b4f59d820b"

URI_x86_64_v2_dotnet-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-8.0-8.0.26-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-dbg-8.0}"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-8.0.sha256sum] = "25207f389977ef0236be037ab47813e94fc4137168bdb2b4e7c323d6b0f3ac0d"

URI_x86_64_v2_dotnet-sdk-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-8.0-8.0.126-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-8.0}"
SRC_URI[x86_64_v2_dotnet-sdk-8.0.sha256sum] = "cd73ac1e5c66302848d81e941ffe59667f635e4c5d5fbc904b43371246294341"

URI_x86_64_v2_dotnet-sdk-8.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-8.0-source-built-artifacts-8.0.126-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-8.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-8.0-source-built-artifacts}"
SRC_URI[x86_64_v2_dotnet-sdk-8.0-source-built-artifacts.sha256sum] = "023e61b8923169743842b389cfe7622088495b622949d4692f7fe8582e027afb"

URI_x86_64_v2_dotnet-sdk-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-8.0-8.0.126-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-dbg-8.0}"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-8.0.sha256sum] = "51f7c88ce3847c2d94ec2534b8ce2e97d7a3d5b0bd18d9c0ace874ee601f9f73"

URI_x86_64_v2_dotnet-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-8.0-8.0.26-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-targeting-pack-8.0}"
SRC_URI[x86_64_v2_dotnet-targeting-pack-8.0.sha256sum] = "f3dc436e0e3cbbabb0a97221aad2cab273576c404f8efd00e35680302cbaa79a"

URI_x86_64_v2_dotnet-templates-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-8.0-8.0.126-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-templates-8.0}"
SRC_URI[x86_64_v2_dotnet-templates-8.0.sha256sum] = "dfa10b49770f335b1ba8cd6c931c7d3ade03b1494041b2a7608842dcc6863809"

URI_aarch64_aspnetcore-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-8.0-8.0.26-1.el10_1.aarch64.rpm;name=aarch64_aspnetcore-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-8.0}"
SRC_URI[aarch64_aspnetcore-runtime-8.0.sha256sum] = "54f0a89cac4ff23e16a9953d5f827a0aa06be053b04cf140c3ba2383f70d4585"

URI_aarch64_aspnetcore-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-8.0-8.0.26-1.el10_1.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-dbg-8.0}"
SRC_URI[aarch64_aspnetcore-runtime-dbg-8.0.sha256sum] = "7d4712b6bcb8f95ebf25f2420d2cbea30eb7a005d1d3e803395f7eed5a69124e"

URI_aarch64_aspnetcore-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-8.0-8.0.26-1.el10_1.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-targeting-pack-8.0}"
SRC_URI[aarch64_aspnetcore-targeting-pack-8.0.sha256sum] = "26392d347f787cf77148c56a73b68217686c3aa0c662b47fd48d381e59284d91"

URI_aarch64_dotnet-apphost-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-8.0-8.0.26-1.el10_1.aarch64.rpm;name=aarch64_dotnet-apphost-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-apphost-pack-8.0}"
SRC_URI[aarch64_dotnet-apphost-pack-8.0.sha256sum] = "56cb26c5850f5e59558ede33980a1c0b311806ac974fcc9cc456993c93d3928a"

URI_aarch64_dotnet-hostfxr-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-8.0-8.0.26-1.el10_1.aarch64.rpm;name=aarch64_dotnet-hostfxr-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-hostfxr-8.0}"
SRC_URI[aarch64_dotnet-hostfxr-8.0.sha256sum] = "b7b0fc07dc8d54391a1dd4d4d75038ef9be74985b523ce9da281796ba98a3270"

URI_aarch64_dotnet-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-8.0-8.0.26-1.el10_1.aarch64.rpm;name=aarch64_dotnet-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-8.0}"
SRC_URI[aarch64_dotnet-runtime-8.0.sha256sum] = "2fc3597d2a909126e5a41fa71dac2dbd109f5e12940c218f3c904afc3f5c19d5"

URI_aarch64_dotnet-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-8.0-8.0.26-1.el10_1.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-dbg-8.0}"
SRC_URI[aarch64_dotnet-runtime-dbg-8.0.sha256sum] = "0f87ae62e954f0cc08ae0f9ca2edc4149a7d351df0a33bb3c605dee5df9bf69c"

URI_aarch64_dotnet-sdk-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-8.0-8.0.126-1.el10_1.aarch64.rpm;name=aarch64_dotnet-sdk-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-8.0}"
SRC_URI[aarch64_dotnet-sdk-8.0.sha256sum] = "c0dbacc440c6a13829d9f342310ef97bae00957db3838f4641200d818941902f"

URI_aarch64_dotnet-sdk-8.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-8.0-source-built-artifacts-8.0.126-1.el10_1.aarch64.rpm;name=aarch64_dotnet-sdk-8.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-8.0-source-built-artifacts}"
SRC_URI[aarch64_dotnet-sdk-8.0-source-built-artifacts.sha256sum] = "5e49ce46c25b94386c43e55e5ba75316bb7c2f49d7044159c3665a9b30e272a5"

URI_aarch64_dotnet-sdk-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-8.0-8.0.126-1.el10_1.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-dbg-8.0}"
SRC_URI[aarch64_dotnet-sdk-dbg-8.0.sha256sum] = "d67d3976f566ce91362801776f6b88c92e5e317ddfe54326db93300c2b44a1a1"

URI_aarch64_dotnet-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-8.0-8.0.26-1.el10_1.aarch64.rpm;name=aarch64_dotnet-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-targeting-pack-8.0}"
SRC_URI[aarch64_dotnet-targeting-pack-8.0.sha256sum] = "7dc12f758ffa8eee378fafad8eea73863b88cadc4dd1dcfa0c49c646d2b8ff15"

URI_aarch64_dotnet-templates-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-8.0-8.0.126-1.el10_1.aarch64.rpm;name=aarch64_dotnet-templates-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-templates-8.0}"
SRC_URI[aarch64_dotnet-templates-8.0.sha256sum] = "ba86f8a9e94e3dfcac3b64475b187cff7accc1975044cc6d6e3ff5cceb9ffb8f"

RDEPENDS:aspnetcore-runtime-8.0 = " \
 dotnet-runtime-8.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-8.0 = " \
 aspnetcore-runtime-8.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-8.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-8.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-hostfxr-8.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-8.0 = " \
 dotnet-hostfxr-8.0 \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-8.0 = " \
 dotnet-runtime-8.0 \
 "
RDEPENDS:dotnet-sdk-8.0 = " \
 aspnetcore-runtime-8.0 \
 aspnetcore-targeting-pack-8.0 \
 dotnet-apphost-pack-8.0 \
 dotnet-runtime-8.0 \
 dotnet-targeting-pack-8.0 \
 dotnet-templates-8.0 \
 glibc \
 libgcc \
 libstdc++ \
 netstandard-targeting-pack-2.1 \
 "
RDEPENDS:dotnet-sdk-8.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-dbg-8.0 = " \
 dotnet-sdk-8.0 \
 "
RDEPENDS:dotnet-targeting-pack-8.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-8.0 = " \
 dotnet-host \
 "
