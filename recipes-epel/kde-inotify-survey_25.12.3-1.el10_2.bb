# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-inotify-survey"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kde-inotify-survey \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-inotify-survey-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b038ef1585e88b83bddef17e274857955a7a8f04e11cea746abd696ecfc32408"

URI_x86_64_v2_kde-inotify-survey = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-inotify-survey-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-inotify-survey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-inotify-survey}"
SRC_URI[x86_64_v2_kde-inotify-survey.sha256sum] = "396787a15dbdadccecbc2e094144708ef021a3a8930c05ca9296f01aeae0a689"

URI_aarch64_kde-inotify-survey = "${EPEL_MIRROR}/aarch64/Packages/k/kde-inotify-survey-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kde-inotify-survey;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-inotify-survey}"
SRC_URI[aarch64_kde-inotify-survey.sha256sum] = "eaba5cbafa9cc4ae8fa3ae9ab84092c19aaab29550e659ab2d22220110d24dc1"

RDEPENDS:kde-inotify-survey = " \
 dbus-common \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kded \
 kf6-ki18n \
 kf6-knotifications \
 libstdc++ \
 polkit \
 qt6-qtbase \
 "
