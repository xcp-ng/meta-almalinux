# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wayland-protocols"
PV = "1.45"
PR = "1.el10"
PACKAGES = " \
 wayland-protocols-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wayland-protocols-1.45-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9f8cf6aae24588e78c5b1ba77475c440a6c4ba41fb69dbc77aca68431a466fa"

URI_x86_64_v2_wayland-protocols-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wayland-protocols-devel-1.45-1.el10.noarch.rpm;name=x86_64_v2_wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wayland-protocols-devel}"
SRC_URI[x86_64_v2_wayland-protocols-devel.sha256sum] = "de9fb86e9ad97d352b3a9f2f459a9a2773759322644e2ddc4bda827be71cce58"

URI_aarch64_wayland-protocols-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wayland-protocols-devel-1.45-1.el10.noarch.rpm;name=aarch64_wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wayland-protocols-devel}"
SRC_URI[aarch64_wayland-protocols-devel.sha256sum] = "de9fb86e9ad97d352b3a9f2f459a9a2773759322644e2ddc4bda827be71cce58"

RDEPENDS:wayland-protocols-devel = " \
 pkgconf-pkg-config \
 "
