# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-kardianos-osext"
PV = "0"
PR = "19.20190626git2bc1f35.el10_0"
PACKAGES = " \
 compat-golang-bitbucket-kardianos-osext-devel \
 golang-github-kardianos-osext-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-kardianos-osext-0-19.20190626git2bc1f35.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4d8c95a9bb7868046c95eeeb6a749ada1b356c72ce73d18f11e21bedab68f80"

URI_aarch64_compat-golang-bitbucket-kardianos-osext-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-bitbucket-kardianos-osext-devel-0-19.20190626git2bc1f35.el10_0.noarch.rpm;name=aarch64_compat-golang-bitbucket-kardianos-osext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-bitbucket-kardianos-osext-devel}"
SRC_URI[aarch64_compat-golang-bitbucket-kardianos-osext-devel.sha256sum] = "1b5d1acd8e4ddb5fbb88b904e336d28481cdb42e177ef34cdb0a95c8cda2c6f0"

URI_aarch64_golang-github-kardianos-osext-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-kardianos-osext-devel-0-19.20190626git2bc1f35.el10_0.noarch.rpm;name=aarch64_golang-github-kardianos-osext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-kardianos-osext-devel}"
SRC_URI[aarch64_golang-github-kardianos-osext-devel.sha256sum] = "7341edf50cb8edcefd53ee0660f4a478821c9c1e1f721584e1a05f951a0299ad"

RDEPENDS:compat-golang-bitbucket-kardianos-osext-devel = " \
 go-filesystem \
 golang-github-kardianos-osext-devel \
 "
RDEPENDS:golang-github-kardianos-osext-devel = " \
 go-filesystem \
 "
