# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-lock"
PV = "11.0.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-cargo-lock+default-devel \
 rust-cargo-lock+dependency-tree-devel \
 rust-cargo-lock+petgraph-devel \
 rust-cargo-lock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-lock-11.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f982d17e62912ca4b99755d5d46a3e82b1105e81040734db55c6643570a61df9"

URI_x86_64_v2_rust-cargo-lock+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-lock+default-devel-11.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-lock+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-lock+default-devel.sha256sum] = "62ccb9480102179fe2f4cdd97ab56c8874a3ef2bca51d22d41c14ececab421d3"

URI_x86_64_v2_rust-cargo-lock+dependency-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-lock+dependency-tree-devel-11.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-lock+dependency-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-lock+dependency-tree-devel}"
SRC_URI[x86_64_v2_rust-cargo-lock+dependency-tree-devel.sha256sum] = "3809ca13c5efda77acbade7cbe8de6b4f373da0c96951ef86ada37212a2205dc"

URI_x86_64_v2_rust-cargo-lock+petgraph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-lock+petgraph-devel-11.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-lock+petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-lock+petgraph-devel}"
SRC_URI[x86_64_v2_rust-cargo-lock+petgraph-devel.sha256sum] = "92a00e9e08a303ce8b1d1fb5e9b611980bdce3192381a6d5cab44540aed46101"

URI_x86_64_v2_rust-cargo-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-lock-devel-11.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-lock-devel}"
SRC_URI[x86_64_v2_rust-cargo-lock-devel.sha256sum] = "924ff1950663e8e4e2a461a9c9a5e93b4f3d07dd8c20b7fcef9054dd2b323469"

URI_aarch64_rust-cargo-lock+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-lock+default-devel-11.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-lock+default-devel}"
SRC_URI[aarch64_rust-cargo-lock+default-devel.sha256sum] = "9eb79e1bd2f5836203236d202d669c3dd4f3c03b453eaaa17909dc68dd22fdf1"

URI_aarch64_rust-cargo-lock+dependency-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-lock+dependency-tree-devel-11.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-lock+dependency-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-lock+dependency-tree-devel}"
SRC_URI[aarch64_rust-cargo-lock+dependency-tree-devel.sha256sum] = "d6dc5bae49650c48f9d30234c7abe82b48df7c622dc97c31b64c487c085124a9"

URI_aarch64_rust-cargo-lock+petgraph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-lock+petgraph-devel-11.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-lock+petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-lock+petgraph-devel}"
SRC_URI[aarch64_rust-cargo-lock+petgraph-devel.sha256sum] = "1e413bd11eae5f95bc6d46574d5f5f0d0e6ad747d7c643101bcf6f98173167fb"

URI_aarch64_rust-cargo-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-lock-devel-11.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-lock-devel}"
SRC_URI[aarch64_rust-cargo-lock-devel.sha256sum] = "6aa8707ee8c52f831300a8e5560a51567d28cec3b35bd380c5288776cbbbd3f5"

RDEPENDS:rust-cargo-lock+default-devel = " \
 cargo \
 rust-cargo-lock-devel \
 "
RDEPENDS:rust-cargo-lock+dependency-tree-devel = " \
 cargo \
 rust-cargo-lock+petgraph-devel \
 rust-cargo-lock-devel \
 "
RDEPENDS:rust-cargo-lock+petgraph-devel = " \
 cargo \
 rust-cargo-lock-devel \
 rust-petgraph+default-devel \
 "
RDEPENDS:rust-cargo-lock-devel = " \
 cargo \
 rust \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+serde_derive-devel \
 rust-toml0.9+default-devel \
 rust-url+default-devel \
 "
