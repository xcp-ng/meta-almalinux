# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrow-csv"
PV = "57.3.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-arrow-csv+default-devel \
 rust-arrow-csv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrow-csv-57.3.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ba79521676661458f1b1b16c602e56e91ad90f2deac1588f35433e64e6fc5e0"

URI_x86_64_v2_rust-arrow-csv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-csv+default-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-csv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-csv+default-devel}"
SRC_URI[x86_64_v2_rust-arrow-csv+default-devel.sha256sum] = "4da3690a40773b866aa076a475c70bdbb7749ef0dd067e27ec3dbaf2da2f86bb"

URI_x86_64_v2_rust-arrow-csv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-csv-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-csv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-csv-devel}"
SRC_URI[x86_64_v2_rust-arrow-csv-devel.sha256sum] = "c138933a401ba8028c1224a0e80e72fc52ec57495ac6c676ca7d1906eb3e499e"

URI_aarch64_rust-arrow-csv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-csv+default-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-csv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-csv+default-devel}"
SRC_URI[aarch64_rust-arrow-csv+default-devel.sha256sum] = "2a754dfaad3d8e59ac5a804c24fe5c3b40f3937b9a6c78e996fac2d234cf9939"

URI_aarch64_rust-arrow-csv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-csv-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-csv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-csv-devel}"
SRC_URI[aarch64_rust-arrow-csv-devel.sha256sum] = "ea003e19ddd13b26b6b1e3400b5fcb35b5d2b703a27b80a5481b986b73b691df"

RDEPENDS:rust-arrow-csv+default-devel = " \
 cargo \
 rust-arrow-csv-devel \
 "
RDEPENDS:rust-arrow-csv-devel = " \
 cargo \
 rust \
 rust-arrow-array+default-devel \
 rust-arrow-cast+default-devel \
 rust-arrow-schema+default-devel \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-csv-core+default-devel \
 rust-csv-devel \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 "
