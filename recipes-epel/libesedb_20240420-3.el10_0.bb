# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libesedb"
PV = "20240420"
PR = "3.el10_0"
PACKAGES = " \
 libesedb \
 libesedb-devel \
 python3-pyesedb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libesedb-20240420-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a1813ed0d9daf2ef00ddf4ed2ae523902363e99130253c8830379fc6acf3635"

URI_x86_64_v2_libesedb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libesedb-20240420-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libesedb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libesedb}"
SRC_URI[x86_64_v2_libesedb.sha256sum] = "10ba1975475e73cf0d75052826ef05ab98fb88f66541c4cc89d838276f841406"

URI_x86_64_v2_libesedb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libesedb-devel-20240420-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libesedb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libesedb-devel}"
SRC_URI[x86_64_v2_libesedb-devel.sha256sum] = "cd01ecbe711df4fb9b37aaf3c9f43da1b80a947a66e705a2dda841b2cebaaa53"

URI_x86_64_v2_python3-pyesedb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyesedb-20240420-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyesedb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyesedb}"
SRC_URI[x86_64_v2_python3-pyesedb.sha256sum] = "6aa98cbd8ca6690635e54e1e99565bf251fe60cc1b3c62a6a1854025d0feadfa"

URI_aarch64_libesedb = "${EPEL_MIRROR}/aarch64/Packages/l/libesedb-20240420-3.el10_0.aarch64.rpm;name=aarch64_libesedb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libesedb}"
SRC_URI[aarch64_libesedb.sha256sum] = "afe2a070c22721aa298d7fd7acfa1a8cb0062c27e390c3ac148c543be432c41f"

URI_aarch64_libesedb-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libesedb-devel-20240420-3.el10_0.aarch64.rpm;name=aarch64_libesedb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libesedb-devel}"
SRC_URI[aarch64_libesedb-devel.sha256sum] = "4a073d4973fdbd903741dd33de0349e10dc19506436147710cf84a6de18c4bf4"

URI_aarch64_python3-pyesedb = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyesedb-20240420-3.el10_0.aarch64.rpm;name=aarch64_python3-pyesedb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyesedb}"
SRC_URI[aarch64_python3-pyesedb.sha256sum] = "2d56e6f88ef2f5ce9fa843010288deb1f8ede4edbc9b18f64014754209e1859b"

RDEPENDS:libesedb = " \
 glibc \
 "
RDEPENDS:libesedb-devel = " \
 libesedb \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-pyesedb = " \
 glibc \
 libesedb \
 python3 \
 "
