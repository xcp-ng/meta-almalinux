# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Cairo"
PV = "1.109"
PR = "20.el10_2"
PACKAGES = " \
 perl-Cairo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Cairo-1.109-20.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d28125a0489091bbcfc49eca05094077a453102e455f2bc3c2d69df9864e04e"

URI_x86_64_v2_perl-Cairo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cairo-1.109-20.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Cairo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cairo}"
SRC_URI[x86_64_v2_perl-Cairo.sha256sum] = "96536190d87a25da258cd5195497058b0422e3142b088b38b98dfde56fe71884"

URI_aarch64_perl-Cairo = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cairo-1.109-20.el10_2.aarch64.rpm;name=aarch64_perl-Cairo;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cairo}"
SRC_URI[aarch64_perl-Cairo.sha256sum] = "9d5b872202889b0ed08d765c8a8b6b360b44452dfa4647f7c6c43b481f26b6b2"

RDEPENDS:perl-Cairo = " \
 cairo \
 glibc \
 perl-DynaLoader \
 perl-libs \
 "
