# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "emacs-auctex"
PV = "13.3"
PR = "5.el10"
PACKAGES = " \
 emacs-auctex \
 tex-preview \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/emacs-auctex-13.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c823e3da07bee594a1c8d278fbe4a574886026cee7465bff4e1b6e1ef7805711"

URI_x86_64_v2_emacs-auctex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/emacs-auctex-13.3-5.el10.noarch.rpm;name=x86_64_v2_emacs-auctex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_emacs-auctex}"
SRC_URI[x86_64_v2_emacs-auctex.sha256sum] = "90bf98e1edda6961ee7d2a0bb4923a1f0e5a9a350bf66b9d53e6bcb115ec9ec7"

URI_x86_64_v2_tex-preview = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tex-preview-13.3-5.el10.noarch.rpm;name=x86_64_v2_tex-preview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tex-preview}"
SRC_URI[x86_64_v2_tex-preview.sha256sum] = "15081a6ea3f78aa532220806d4d3e27550d99d74f76284340fa26dac0385e672"

URI_aarch64_emacs-auctex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/emacs-auctex-13.3-5.el10.noarch.rpm;name=aarch64_emacs-auctex;unpack=0"
SRC_URI:append = " ${URI_aarch64_emacs-auctex}"
SRC_URI[aarch64_emacs-auctex.sha256sum] = "90bf98e1edda6961ee7d2a0bb4923a1f0e5a9a350bf66b9d53e6bcb115ec9ec7"

URI_aarch64_tex-preview = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tex-preview-13.3-5.el10.noarch.rpm;name=aarch64_tex-preview;unpack=0"
SRC_URI:append = " ${URI_aarch64_tex-preview}"
SRC_URI[aarch64_tex-preview.sha256sum] = "15081a6ea3f78aa532220806d4d3e27550d99d74f76284340fa26dac0385e672"

RDEPENDS:emacs-auctex = " \
 ghostscript \
 tex-preview \
 texlive-collection-latexrecommended \
 texlive-dvipng \
 texlive-dvips \
 virtual/emacs_bin__ge_29.4 \
 "
RDEPENDS:tex-preview = " \
 texlive-collection-latexrecommended \
 "
