# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "givaro"
PV = "4.2.2"
PR = "1.el10_3"
PACKAGES = " \
 givaro \
 givaro-devel \
 givaro-static \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/givaro-4.2.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dc38d308ea40e036167cb78cc4ff1bba43e07545b87091ea0f4c3954d35aeb02"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/givaro-4.2.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_givaro;unpack=0"
SRC_URI[x86_64_v2_givaro.sha256sum] = "ddf397c36a24610ad9bf5748bd7e98e68610a5996ce8f5246aa76c4239d2b6af"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/givaro-devel-4.2.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_givaro-devel;unpack=0"
SRC_URI[x86_64_v2_givaro-devel.sha256sum] = "ca879b657f33b3b0780b64ada9a879fd3e796f0c3d05aa6bb57c3d8c5989ec9d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/givaro-static-4.2.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_givaro-static;unpack=0"
SRC_URI[x86_64_v2_givaro-static.sha256sum] = "7b51c3325ae7fa919c9772bd449e65ab44c4f509949a97b12d025eedf7112ec0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/givaro-4.2.2-1.el10_3.aarch64.rpm;name=aarch64_givaro;unpack=0"
SRC_URI[aarch64_givaro.sha256sum] = "a774bea73c9715fdb668793ace5aaf46a2e572c69cab37d9dd54a97be05b524e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/givaro-devel-4.2.2-1.el10_3.aarch64.rpm;name=aarch64_givaro-devel;unpack=0"
SRC_URI[aarch64_givaro-devel.sha256sum] = "89acbe46205815f30235a489bed8348ad8e55e7a262f8565f8e787a10b7b56d6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/givaro-static-4.2.2-1.el10_3.aarch64.rpm;name=aarch64_givaro-static;unpack=0"
SRC_URI[aarch64_givaro-static.sha256sum] = "b7ef995d5ff0403e69023324048e16a33dcc87f31e2c1d5c045f8c7e960f5770"

RDEPENDS:givaro = " \
 glibc \
 gmp \
 gmp-c++ \
 libgcc \
 libstdc++ \
 "
RDEPENDS:givaro-devel = " \
 bash \
 givaro \
 pkgconf-pkg-config \
 "
RDEPENDS:givaro-static = " \
 givaro-devel \
 "
