# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-podman"
PV = "129"
PR = "1.el10"
PACKAGES = " \
 cockpit-podman \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-podman-129-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c239a85e6f53fcc0d45782d62542cc990fc0a07298b875bf433616e5654a90a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-podman-129-1.el10.noarch.rpm;name=x86_64_v2_cockpit-podman;unpack=0"
SRC_URI[x86_64_v2_cockpit-podman.sha256sum] = "3bc09c7b48117950225abb47251d0e5a6e11f44264296e5e685a386a16186543"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-podman-129-1.el10.noarch.rpm;name=aarch64_cockpit-podman;unpack=0"
SRC_URI[aarch64_cockpit-podman.sha256sum] = "3bc09c7b48117950225abb47251d0e5a6e11f44264296e5e685a386a16186543"

RDEPENDS:cockpit-podman = " \
 cockpit-bridge \
 podman \
 "
