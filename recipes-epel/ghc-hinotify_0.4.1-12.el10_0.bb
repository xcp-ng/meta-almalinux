# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-hinotify"
PV = "0.4.1"
PR = "12.el10_0"
PACKAGES = " \
 ghc-hinotify \
 ghc-hinotify-devel \
 ghc-hinotify-doc \
 ghc-hinotify-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-hinotify-0.4.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8c649f75e415db235336c041b8cba25a2bac86d468d8435f2b709d4a8b9ce52"

URI_x86_64_v2_ghc-hinotify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hinotify-0.4.1-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hinotify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hinotify}"
SRC_URI[x86_64_v2_ghc-hinotify.sha256sum] = "3b5ea7bdea8b2f947572d792ac468c6badae6f81f834eb06a91c22628d5415f9"

URI_x86_64_v2_ghc-hinotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hinotify-devel-0.4.1-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hinotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hinotify-devel}"
SRC_URI[x86_64_v2_ghc-hinotify-devel.sha256sum] = "2d3bd557b8fb846921ba34c5e7eb56091962485aa4bdc03ea25f7a3c4c1d2eba"

URI_x86_64_v2_ghc-hinotify-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hinotify-doc-0.4.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hinotify-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hinotify-doc}"
SRC_URI[x86_64_v2_ghc-hinotify-doc.sha256sum] = "ef2302cfe35c277e4a0146a470e823f32984a87ed5cc23e4a636475bf1625471"

URI_x86_64_v2_ghc-hinotify-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hinotify-prof-0.4.1-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hinotify-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hinotify-prof}"
SRC_URI[x86_64_v2_ghc-hinotify-prof.sha256sum] = "ea59e9cb412c0363d0721a857be5394fa22022ffe0676794351c8d58f578101d"

URI_aarch64_ghc-hinotify = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hinotify-0.4.1-12.el10_0.aarch64.rpm;name=aarch64_ghc-hinotify;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hinotify}"
SRC_URI[aarch64_ghc-hinotify.sha256sum] = "52e72160023c2e9a6877276aebff67014fbeaca234319a975e0ecbb08e332d22"

URI_aarch64_ghc-hinotify-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hinotify-devel-0.4.1-12.el10_0.aarch64.rpm;name=aarch64_ghc-hinotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hinotify-devel}"
SRC_URI[aarch64_ghc-hinotify-devel.sha256sum] = "51685785e6ad359d2951f3574f5bc377c59254278f7cdf5cbf39e0d9962c308f"

URI_aarch64_ghc-hinotify-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hinotify-doc-0.4.1-12.el10_0.noarch.rpm;name=aarch64_ghc-hinotify-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hinotify-doc}"
SRC_URI[aarch64_ghc-hinotify-doc.sha256sum] = "7197215188ce0248972ced0cfee6823142a5b3b54afdbbcd5da181ee0c54559c"

URI_aarch64_ghc-hinotify-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hinotify-prof-0.4.1-12.el10_0.aarch64.rpm;name=aarch64_ghc-hinotify-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hinotify-prof}"
SRC_URI[aarch64_ghc-hinotify-prof.sha256sum] = "79b89942d4241097125060ce09ddd1486903c83a609cfdec714eb4695a822d59"

RDEPENDS:ghc-hinotify = " \
 ghc-array \
 ghc-async \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hinotify-devel = " \
 ghc-async-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-hinotify \
 ghc-unix-devel \
 "
RDEPENDS:ghc-hinotify-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hinotify-prof = " \
 ghc-async-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-hinotify-devel \
 ghc-unix-prof \
 "
