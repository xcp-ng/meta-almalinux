# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clustershell"
PV = "1.10.1"
PR = "1.el10_3"
PACKAGES = " \
 clustershell \
 python3-clustershell \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clustershell-1.10.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acee0c5d7e91c88eb4f7a7db8718363ae0a635f773cf76d08d152277547e8114"

URI_x86_64_v2_clustershell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clustershell-1.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_clustershell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clustershell}"
SRC_URI[x86_64_v2_clustershell.sha256sum] = "53cc6d5d6c48684d24d300f7cba4e2a1511d2a6ab82ddae706825736b375da06"

URI_x86_64_v2_python3-clustershell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-clustershell-1.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-clustershell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-clustershell}"
SRC_URI[x86_64_v2_python3-clustershell.sha256sum] = "246b9a8888aabec8d5290a54b11a4fc5ae41fb6e72ff08ca702ed0785b78ef08"

URI_aarch64_clustershell = "${EPEL_MIRROR}/aarch64/Packages/c/clustershell-1.10.1-1.el10_3.noarch.rpm;name=aarch64_clustershell;unpack=0"
SRC_URI:append = " ${URI_aarch64_clustershell}"
SRC_URI[aarch64_clustershell.sha256sum] = "998c508ebb69aff3c242d9f516fa1e2d512d37d6e49b30e23c6b294324bf2630"

URI_aarch64_python3-clustershell = "${EPEL_MIRROR}/aarch64/Packages/p/python3-clustershell-1.10.1-1.el10_3.noarch.rpm;name=aarch64_python3-clustershell;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-clustershell}"
SRC_URI[aarch64_python3-clustershell.sha256sum] = "8e80313a236e3518e8034474b336e63e645c18c387c70962a266c1a38657f7ec"

RDEPENDS:clustershell = " \
 python3-clustershell \
 vim-filesystem \
 "
RDEPENDS:python3-clustershell = " \
 python3 \
 python3-pyyaml \
 python3-setuptools \
 "
