# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kimageformats"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kimageformats \
 kf6-kimageformats-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kimageformats-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "06df2bb73e85efcbf1239747327505d7410f9c83cfafaaa9abf99ce345fdd9d3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kimageformats-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kimageformats;unpack=0"
SRC_URI[x86_64_v2_kf6-kimageformats.sha256sum] = "774ca01bd30c96fe637cf623c6f1a35be810cd8eb1b93fedd69ddeeb664daad7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kimageformats-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kimageformats-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kimageformats-devel.sha256sum] = "1b2c435b5415d34c71da83ba9a6d39a7acc951e5d70aa89ced41d26e8b782572"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kimageformats-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kimageformats;unpack=0"
SRC_URI[aarch64_kf6-kimageformats.sha256sum] = "91dccdf174cf8f2b288fe283ab78d55eb12b10b8782422b3d6038e4bbd56c374"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kimageformats-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kimageformats-devel;unpack=0"
SRC_URI[aarch64_kf6-kimageformats-devel.sha256sum] = "65b0e6a5abad49626c120929dda29318fd188d5c7f527b4f9d1e7ae0aefa7094"

RDEPENDS:kf6-kimageformats = " \
 LibRaw \
 glibc \
 imath \
 kf6-filesystem \
 kf6-karchive \
 libavif \
 libgcc \
 libheif \
 libjxl \
 libstdc++ \
 openexr-libs \
 openjpeg2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kimageformats-devel = " \
 cmake-filesystem \
 kf6-kimageformats \
 "
