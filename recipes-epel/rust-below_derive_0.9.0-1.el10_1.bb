# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below_derive"
PV = "0.9.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-below_derive+default-devel \
 rust-below_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below_derive-0.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2fdfd8a1f36fd4a4771a22c2868072f1791543de3894512a910854ad699b825"

URI_x86_64_v2_rust-below_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below_derive+default-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below_derive+default-devel}"
SRC_URI[x86_64_v2_rust-below_derive+default-devel.sha256sum] = "03421e8795b1d2650e99f6ae0fd0f78e8dd536bf720ac5a56d9570c072a4e8b0"

URI_x86_64_v2_rust-below_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below_derive-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below_derive-devel}"
SRC_URI[x86_64_v2_rust-below_derive-devel.sha256sum] = "40c2e04ae7c8ef84b9734bc4243fc0ee8c3124312bdf4fb4082e4c25c3d96f79"

URI_aarch64_rust-below_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below_derive+default-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below_derive+default-devel}"
SRC_URI[aarch64_rust-below_derive+default-devel.sha256sum] = "bc782a8c0b82affc810b284347a836eb1d2babed97dcd78463e97e8fc29a6c33"

URI_aarch64_rust-below_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below_derive-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below_derive-devel}"
SRC_URI[aarch64_rust-below_derive-devel.sha256sum] = "ac929838c7a81f75e1703452f9423d3789a0942b58e4a688997188491f5b426b"

RDEPENDS:rust-below_derive+default-devel = " \
 cargo \
 rust-below_derive-devel \
 "
RDEPENDS:rust-below_derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-proc-macro2+span-locations-devel \
 rust-quote+default-devel \
 rust-syn1+default-devel \
 rust-syn1+extra-traits-devel \
 rust-syn1+fold-devel \
 rust-syn1+full-devel \
 rust-syn1+visit-devel \
 rust-syn1+visit-mut-devel \
 "
