# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keychain"
PV = "3.0.4"
PR = "3.el10_3"
PACKAGES = " \
 keychain \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/keychain-3.0.4-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "06b1800022640508588106d37e1ae2e4eaea273326f2e5ddf78a548f40ceaef4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keychain-3.0.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_keychain;unpack=0"
SRC_URI[x86_64_v2_keychain.sha256sum] = "a3ac67cad69bf2532ce510d96120d4e8fa74a4a7494ad6901b46fd82eff8631a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/keychain-3.0.4-3.el10_3.noarch.rpm;name=aarch64_keychain;unpack=0"
SRC_URI[aarch64_keychain.sha256sum] = "2da8fbff4d0b33cbf5869f41fe062e51a7cf0835dda70a1d88cc1429440a58c8"

RDEPENDS:keychain = " \
 python3 \
 "
