# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-sl"
PV = "0.20070127"
PR = "36.el10"
PACKAGES = " \
 hunspell-sl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-sl-0.20070127-36.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47c82c9eab8acd8e9fbd59675b7eedecb50cfa2fb866b3e15b8b2992cede0ed3"

URI_x86_64_v2_hunspell-sl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-sl-0.20070127-36.el10.noarch.rpm;name=x86_64_v2_hunspell-sl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-sl}"
SRC_URI[x86_64_v2_hunspell-sl.sha256sum] = "eb934f12b5a4ca624be6b79c2822cf8d86fbd54101b6618683dd9fa627313f00"

URI_aarch64_hunspell-sl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-sl-0.20070127-36.el10.noarch.rpm;name=aarch64_hunspell-sl;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-sl}"
SRC_URI[aarch64_hunspell-sl.sha256sum] = "eb934f12b5a4ca624be6b79c2822cf8d86fbd54101b6618683dd9fa627313f00"

RDEPENDS:hunspell-sl = " \
 hunspell \
 "
