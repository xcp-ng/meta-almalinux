# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtmultimedia"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtmultimedia \
 qt5-qtmultimedia-devel \
 qt5-qtmultimedia-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtmultimedia-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2370574bfbea7e91fdee0889b863d04c20f3e615f583cf153f7e25dc9cf09545"

URI_x86_64_v2_qt5-qtmultimedia = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtmultimedia-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtmultimedia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtmultimedia}"
SRC_URI[x86_64_v2_qt5-qtmultimedia.sha256sum] = "41a03d012f4fa68bd53503b7505171b0d27027dc67b87d3b66c41525412d6ce1"

URI_x86_64_v2_qt5-qtmultimedia-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtmultimedia-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtmultimedia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtmultimedia-devel}"
SRC_URI[x86_64_v2_qt5-qtmultimedia-devel.sha256sum] = "cfcd0ce4887f862797a0c6e34f2880a0d9d705acdd255cf4bdb026b146a5f125"

URI_x86_64_v2_qt5-qtmultimedia-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtmultimedia-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtmultimedia-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtmultimedia-examples}"
SRC_URI[x86_64_v2_qt5-qtmultimedia-examples.sha256sum] = "d118324904ed7c360288caa9738fc756d2543bd0374885ef8efc8f0108b550c7"

URI_aarch64_qt5-qtmultimedia = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtmultimedia-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtmultimedia;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtmultimedia}"
SRC_URI[aarch64_qt5-qtmultimedia.sha256sum] = "3be20705e0a382beaeb377c559f3ac2329c727cda5a5fa0e3acfc0c18b488f62"

URI_aarch64_qt5-qtmultimedia-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtmultimedia-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtmultimedia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtmultimedia-devel}"
SRC_URI[aarch64_qt5-qtmultimedia-devel.sha256sum] = "ad914733c777a4148c2f912fe8d8a6b1e87312ee880884d593d866276ee72f46"

URI_aarch64_qt5-qtmultimedia-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtmultimedia-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtmultimedia-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtmultimedia-examples}"
SRC_URI[aarch64_qt5-qtmultimedia-examples.sha256sum] = "11c1f696cd6d7a2985f63a50908645ac75d9bcc7a03b0957155bf9302f3cbccc"

RDEPENDS:qt5-qtmultimedia = " \
 alsa-lib \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 libglvnd-glx \
 libstdc++ \
 openal-soft \
 pulseaudio-libs \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtmultimedia-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 pulseaudio-libs-devel \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtmultimedia \
 qt5-qtmultimedia-devel \
 "
RDEPENDS:qt5-qtmultimedia-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtmultimedia \
 "
