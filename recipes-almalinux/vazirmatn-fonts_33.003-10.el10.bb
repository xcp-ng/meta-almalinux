# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vazirmatn-fonts"
PV = "33.003"
PR = "10.el10"
PACKAGES = " \
 vazirmatn-vf-fonts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vazirmatn-fonts-33.003-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d590a64e07ede8db3e7d50aca14c28aeee1107abfaa6d448612a945c39982e70"

URI_x86_64_v2_vazirmatn-vf-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vazirmatn-vf-fonts-33.003-10.el10.noarch.rpm;name=x86_64_v2_vazirmatn-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vazirmatn-vf-fonts}"
SRC_URI[x86_64_v2_vazirmatn-vf-fonts.sha256sum] = "18a7d504917056f506f7d8d70710c9989c53d72bcc638e029d722da522460021"

URI_aarch64_vazirmatn-vf-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vazirmatn-vf-fonts-33.003-10.el10.noarch.rpm;name=aarch64_vazirmatn-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_vazirmatn-vf-fonts}"
SRC_URI[aarch64_vazirmatn-vf-fonts.sha256sum] = "18a7d504917056f506f7d8d70710c9989c53d72bcc638e029d722da522460021"

RDEPENDS:vazirmatn-vf-fonts = " \
 fonts-filesystem \
 "
