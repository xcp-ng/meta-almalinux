# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-coreos-installer"
PV = "0.26.0"
PR = "1.el10_2"
PACKAGES = " \
 coreos-installer \
 coreos-installer-bootinfra \
 coreos-installer-dracut \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-coreos-installer-0.26.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47713e78d40e602aecb781b190dda96ddea33ccd3085edd74632060adc530c62"

URI_x86_64_v2_coreos-installer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/coreos-installer-0.26.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_coreos-installer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coreos-installer}"
SRC_URI[x86_64_v2_coreos-installer.sha256sum] = "596ed324d48c0714d1fc7f8dd668b00fe452431d7a75fa8a0aea0d151bbfbede"

URI_x86_64_v2_coreos-installer-bootinfra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/coreos-installer-bootinfra-0.26.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_coreos-installer-bootinfra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coreos-installer-bootinfra}"
SRC_URI[x86_64_v2_coreos-installer-bootinfra.sha256sum] = "d067bf89c2622aaff494655336cffd5a0fdf23501aecc986c09d9c9ff3eec5a3"

URI_x86_64_v2_coreos-installer-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/coreos-installer-dracut-0.26.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_coreos-installer-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coreos-installer-dracut}"
SRC_URI[x86_64_v2_coreos-installer-dracut.sha256sum] = "aa4be1e57dc8df623a5c9c178c0d5fc86028c36b8bb7a4d776ded2153ab4fd99"

URI_aarch64_coreos-installer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/coreos-installer-0.26.0-1.el10_2.aarch64.rpm;name=aarch64_coreos-installer;unpack=0"
SRC_URI:append = " ${URI_aarch64_coreos-installer}"
SRC_URI[aarch64_coreos-installer.sha256sum] = "60dc331468da1d772fcbaa03b49257282584353f15ca7caa781384c47a8d89a0"

URI_aarch64_coreos-installer-bootinfra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/coreos-installer-bootinfra-0.26.0-1.el10_2.aarch64.rpm;name=aarch64_coreos-installer-bootinfra;unpack=0"
SRC_URI:append = " ${URI_aarch64_coreos-installer-bootinfra}"
SRC_URI[aarch64_coreos-installer-bootinfra.sha256sum] = "d11e2bde1e94719da3d293325b6aa8454e56dbce9eaef3ce72fb27ea5ad9d4e9"

URI_aarch64_coreos-installer-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/coreos-installer-dracut-0.26.0-1.el10_2.aarch64.rpm;name=aarch64_coreos-installer-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_coreos-installer-dracut}"
SRC_URI[aarch64_coreos-installer-dracut.sha256sum] = "8207aad8b42e2cd3300bd1b57a25182fc76fac99b3a66a2e43a23862d0a910e7"

RDEPENDS:coreos-installer = " \
 glibc \
 gnupg2 \
 kpartx \
 libgcc \
 libzstd \
 openssl-libs \
 systemd-udev \
 util-linux \
 xz-libs \
 "
RDEPENDS:coreos-installer-bootinfra = " \
 bash \
 coreos-installer \
 glibc \
 libgcc \
 libzstd \
 openssl-libs \
 xz-libs \
 "
RDEPENDS:coreos-installer-dracut = " \
 bash \
 coreos-installer \
 "
