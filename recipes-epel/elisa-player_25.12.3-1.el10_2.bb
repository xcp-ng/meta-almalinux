# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "elisa-player"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 elisa-player \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/elisa-player-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d749c04b0b8470cecb35478a010daf7dcb809e09831caccf3089d72379f00a0"

URI_x86_64_v2_elisa-player = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/elisa-player-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_elisa-player;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elisa-player}"
SRC_URI[x86_64_v2_elisa-player.sha256sum] = "4d438b35fdeac77f1f686628f7056ed11fb0ce5065d7cfc01917c61827df3f11"

URI_aarch64_elisa-player = "${EPEL_MIRROR}/aarch64/Packages/e/elisa-player-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_elisa-player;unpack=0"
SRC_URI:append = " ${URI_aarch64_elisa-player}"
SRC_URI[aarch64_elisa-player.sha256sum] = "dbcbe44ecb05e241675167a1eaa561c7f9880253c87c2bdf6fb56ec4c4254fa0"

RDEPENDS:elisa-player = " \
 dbus-common \
 glibc \
 hicolor-icon-theme \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemviews \
 kf6-kxmlgui \
 kf6-qqc2-desktop-style \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
