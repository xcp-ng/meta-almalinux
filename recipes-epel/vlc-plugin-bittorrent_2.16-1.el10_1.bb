# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vlc-plugin-bittorrent"
PV = "2.16"
PR = "1.el10_1"
PACKAGES = " \
 vlc-plugin-bittorrent \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vlc-plugin-bittorrent-2.16-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5492f19772b57018af2f084471682ec34430f36ac0824a5aada67552be3119fb"

URI_x86_64_v2_vlc-plugin-bittorrent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-bittorrent-2.16-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-bittorrent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-bittorrent}"
SRC_URI[x86_64_v2_vlc-plugin-bittorrent.sha256sum] = "6c8959cb7139a9ff93b71c184ae59974dc99cab4593af03899fcfd64f0316ba8"

URI_aarch64_vlc-plugin-bittorrent = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-bittorrent-2.16-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-bittorrent;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-bittorrent}"
SRC_URI[aarch64_vlc-plugin-bittorrent.sha256sum] = "a89cd14eab401bea74ea70e82b496bf6c6cc1fbe9554593151dc5e926f3627ba"

RDEPENDS:vlc-plugin-bittorrent = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 rb_libtorrent \
 vlc-libs \
 vlc-plugins-base \
 "
