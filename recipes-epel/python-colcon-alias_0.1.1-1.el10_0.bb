# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-alias"
PV = "0.1.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-alias \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-alias-0.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9548114c08b5f5286f46a1f8e7327c5f6218f64e3f09bfe4be8fd557c7feedc3"

URI_x86_64_v2_python3-colcon-alias = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-alias-0.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-alias;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-alias}"
SRC_URI[x86_64_v2_python3-colcon-alias.sha256sum] = "37e456b11c425e7312ab82b39b63f729ed944fb51b7068f3dfc87c4a5f115f65"

URI_aarch64_python3-colcon-alias = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-alias-0.1.1-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-alias;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-alias}"
SRC_URI[aarch64_python3-colcon-alias.sha256sum] = "e6adca66a7fbdeed6db1ac0dc5705cdc34aeec8cdd025e2e351f865d6556ba2f"

RDEPENDS:python3-colcon-alias = " \
 python3 \
 python3-colcon-core \
 python3-filelock \
 python3-pyyaml \
 "
