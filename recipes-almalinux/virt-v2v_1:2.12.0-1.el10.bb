# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virt-v2v"
PE = "1"
PV = "2.12.0"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 virt-v2v \
 virt-v2v-bash-completion \
 virt-v2v-man-pages-ja \
 virt-v2v-man-pages-uk \
"
PACKAGES:aarch64 = " \
 virt-v2v-bash-completion \
 virt-v2v-man-pages-ja \
 virt-v2v-man-pages-uk \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/virt-v2v-2.12.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b064fba6d5f4da38d16b2edf5778ffe3bdfb2ed7e3fdf5b50a9261d0111c335"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - virt-v2v-bash-completion: virt-v2v = 1:2.12.0-1.el10
# - virt-v2v-man-pages-ja: virt-v2v = 1:2.12.0-1.el10
# - virt-v2v-man-pages-uk: virt-v2v = 1:2.12.0-1.el10

URI_x86_64_v2_virt-v2v = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-v2v-2.12.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_virt-v2v;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-v2v}"
SRC_URI[x86_64_v2_virt-v2v.sha256sum] = "f7efd05f670d55ea2af85cbdfd4548256d4c54e28f0bdeb79756b365cbdf7380"

URI_x86_64_v2_virt-v2v-bash-completion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-v2v-bash-completion-2.12.0-1.el10.noarch.rpm;name=x86_64_v2_virt-v2v-bash-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-v2v-bash-completion}"
SRC_URI[x86_64_v2_virt-v2v-bash-completion.sha256sum] = "92c86e2fd49f9205afe04a413cd8dbdac6eec423c76e7a2c774d087ed9e2814c"

URI_x86_64_v2_virt-v2v-man-pages-ja = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/virt-v2v-man-pages-ja-2.12.0-1.el10.noarch.rpm;name=x86_64_v2_virt-v2v-man-pages-ja;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-v2v-man-pages-ja}"
SRC_URI[x86_64_v2_virt-v2v-man-pages-ja.sha256sum] = "d367068b5e1050fe749d968189aeeb34d4f5457fe68ea85bece5d7a40ea8a0c0"

URI_x86_64_v2_virt-v2v-man-pages-uk = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/virt-v2v-man-pages-uk-2.12.0-1.el10.noarch.rpm;name=x86_64_v2_virt-v2v-man-pages-uk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-v2v-man-pages-uk}"
SRC_URI[x86_64_v2_virt-v2v-man-pages-uk.sha256sum] = "9fb3315d3f01e8f6621db32c7e47e132f0aebc1156b77d42d869173495626c2e"

URI_aarch64_virt-v2v-bash-completion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-v2v-bash-completion-2.12.0-1.el10.noarch.rpm;name=aarch64_virt-v2v-bash-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-v2v-bash-completion}"
SRC_URI[aarch64_virt-v2v-bash-completion.sha256sum] = "92c86e2fd49f9205afe04a413cd8dbdac6eec423c76e7a2c774d087ed9e2814c"

URI_aarch64_virt-v2v-man-pages-ja = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/virt-v2v-man-pages-ja-2.12.0-1.el10.noarch.rpm;name=aarch64_virt-v2v-man-pages-ja;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-v2v-man-pages-ja}"
SRC_URI[aarch64_virt-v2v-man-pages-ja.sha256sum] = "d367068b5e1050fe749d968189aeeb34d4f5457fe68ea85bece5d7a40ea8a0c0"

URI_aarch64_virt-v2v-man-pages-uk = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/virt-v2v-man-pages-uk-2.12.0-1.el10.noarch.rpm;name=aarch64_virt-v2v-man-pages-uk;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-v2v-man-pages-uk}"
SRC_URI[aarch64_virt-v2v-man-pages-uk.sha256sum] = "9fb3315d3f01e8f6621db32c7e47e132f0aebc1156b77d42d869173495626c2e"

RDEPENDS:virt-v2v = " \
 curl \
 edk2-ovmf \
 gawk \
 glib2 \
 glibc \
 guestfs-tools \
 gzip \
 json-c \
 libgcc \
 libguestfs \
 libguestfs-winsupport \
 libguestfs-xfs \
 libnbd \
 libosinfo \
 libvirt-client \
 libvirt-libs \
 libxcrypt \
 libxml2 \
 mingw-srvany-redistributable \
 nbdkit-basic-filters \
 nbdkit-basic-plugins \
 nbdkit-curl-plugin \
 nbdkit-nbd-plugin \
 nbdkit-python-plugin \
 nbdkit-server \
 nbdkit-ssh-plugin \
 nbdkit-vddk-plugin \
 openssh-clients \
 openssl \
 pcre2 \
 python3 \
 qemu-img \
 unzip \
 "
RDEPENDS:virt-v2v-bash-completion:x86_64_v2 = " \
 bash-completion \
 virt-v2v \
"
RDEPENDS:virt-v2v-bash-completion:aarch64 = " \
 bash-completion \
"
RDEPENDS:virt-v2v-man-pages-ja:x86_64_v2 = " \
 virt-v2v \
"
RDEPENDS:virt-v2v-man-pages-ja:aarch64 = " \
  \
"
RDEPENDS:virt-v2v-man-pages-uk:x86_64_v2 = " \
 virt-v2v \
"
RDEPENDS:virt-v2v-man-pages-uk:aarch64 = " \
  \
"
