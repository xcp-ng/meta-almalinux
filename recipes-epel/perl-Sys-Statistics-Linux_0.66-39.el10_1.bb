# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sys-Statistics-Linux"
PV = "0.66"
PR = "39.el10_1"
PACKAGES = " \
 perl-Sys-Statistics-Linux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sys-Statistics-Linux-0.66-39.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "183c5df102177d5a424c464bb5d0e55ec92df39814ed06d375f2cc7e87c7abed"

URI_x86_64_v2_perl-Sys-Statistics-Linux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-Statistics-Linux-0.66-39.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sys-Statistics-Linux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-Statistics-Linux}"
SRC_URI[x86_64_v2_perl-Sys-Statistics-Linux.sha256sum] = "f553429f5e198be8bd05cf33ccf752b1155ad9b181eeb89282bd6791c8cabd51"

URI_aarch64_perl-Sys-Statistics-Linux = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-Statistics-Linux-0.66-39.el10_1.noarch.rpm;name=aarch64_perl-Sys-Statistics-Linux;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-Statistics-Linux}"
SRC_URI[aarch64_perl-Sys-Statistics-Linux.sha256sum] = "0c075bc323f1ca693aee71f6d1231fdb463237988fd077f387acb7c585f7e13c"

RDEPENDS:perl-Sys-Statistics-Linux = " \
 perl-Carp \
 perl-POSIX \
 perl-Sys-Statistics-Linux \
 perl-Time-HiRes \
 perl-constant \
 perl-libs \
 "
