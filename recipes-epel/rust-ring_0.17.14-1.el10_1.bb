# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ring"
PV = "0.17.14"
PR = "1.el10_1"
PACKAGES = " \
 rust-ring+alloc-devel \
 rust-ring+default-devel \
 rust-ring+dev_urandom_fallback-devel \
 rust-ring+less-safe-getrandom-custom-or-rdrand-devel \
 rust-ring+less-safe-getrandom-espidf-devel \
 rust-ring+slow_tests-devel \
 rust-ring+std-devel \
 rust-ring+test_logging-devel \
 rust-ring-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ring-0.17.14-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf4e82ce1965ae455f1994a1611862aabbf1c5085a8bd84bc520cc9fc1ff1971"

URI_x86_64_v2_rust-ring+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+alloc-devel-0.17.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+alloc-devel}"
SRC_URI[x86_64_v2_rust-ring+alloc-devel.sha256sum] = "1083741ecafbdfb95373901cb2eefa0a0b7531e60bb72bde6dd291fb037abec4"

URI_x86_64_v2_rust-ring+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+default-devel-0.17.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+default-devel}"
SRC_URI[x86_64_v2_rust-ring+default-devel.sha256sum] = "615246cc7fc101314194f5c244daa224d3fd3c3854d4323d78f7cf03c4948cb6"

URI_x86_64_v2_rust-ring+dev_urandom_fallback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+dev_urandom_fallback-devel-0.17.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+dev_urandom_fallback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+dev_urandom_fallback-devel}"
SRC_URI[x86_64_v2_rust-ring+dev_urandom_fallback-devel.sha256sum] = "88c223f03f8dc714773e65a37777f1ac7407e11a5960622fc24a7e6f2d73308a"

URI_x86_64_v2_rust-ring+less-safe-getrandom-custom-or-rdrand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+less-safe-getrandom-custom-or-rdrand-devel-0.17.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+less-safe-getrandom-custom-or-rdrand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+less-safe-getrandom-custom-or-rdrand-devel}"
SRC_URI[x86_64_v2_rust-ring+less-safe-getrandom-custom-or-rdrand-devel.sha256sum] = "306d5772ac2354447c06ad67a16997c22b59649665fce8d01cd8d0d1ddd5e6a2"

URI_x86_64_v2_rust-ring+less-safe-getrandom-espidf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+less-safe-getrandom-espidf-devel-0.17.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+less-safe-getrandom-espidf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+less-safe-getrandom-espidf-devel}"
SRC_URI[x86_64_v2_rust-ring+less-safe-getrandom-espidf-devel.sha256sum] = "cd6667d25d5309c2bbb675c38cebdecd92b08ffec4c916b169c3050e9fef59b3"

URI_x86_64_v2_rust-ring+slow_tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+slow_tests-devel-0.17.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+slow_tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+slow_tests-devel}"
SRC_URI[x86_64_v2_rust-ring+slow_tests-devel.sha256sum] = "9b318537a5d93144ddef416cff9e94b86b78a232a2ee611c0463ae77a2cabb43"

URI_x86_64_v2_rust-ring+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+std-devel-0.17.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+std-devel}"
SRC_URI[x86_64_v2_rust-ring+std-devel.sha256sum] = "1a094f6d6c921711d80fdda5020f5db39814a87930a21426bc64e386081a740f"

URI_x86_64_v2_rust-ring+test_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring+test_logging-devel-0.17.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring+test_logging-devel}"
SRC_URI[x86_64_v2_rust-ring+test_logging-devel.sha256sum] = "f09047a0bc5f4b57c97c603aae6adbbb903556007b9d2ac32337c0c0f3c90207"

URI_x86_64_v2_rust-ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ring-devel-0.17.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ring-devel}"
SRC_URI[x86_64_v2_rust-ring-devel.sha256sum] = "f0c9de1bf689fe4b58f5f19676a3f1b8b68d379f08e45174c9ef0079ae13068d"

URI_aarch64_rust-ring+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+alloc-devel-0.17.14-1.el10_1.noarch.rpm;name=aarch64_rust-ring+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+alloc-devel}"
SRC_URI[aarch64_rust-ring+alloc-devel.sha256sum] = "d54154077d8fead3d44af0827ed806ee5fee4f8b31d4fb3193c902b7f3a05176"

URI_aarch64_rust-ring+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+default-devel-0.17.14-1.el10_1.noarch.rpm;name=aarch64_rust-ring+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+default-devel}"
SRC_URI[aarch64_rust-ring+default-devel.sha256sum] = "79a94233abe129a5ea8a3c8beb8c4cd001cc055359137d5c98caa9714bdae93f"

URI_aarch64_rust-ring+dev_urandom_fallback-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+dev_urandom_fallback-devel-0.17.14-1.el10_1.noarch.rpm;name=aarch64_rust-ring+dev_urandom_fallback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+dev_urandom_fallback-devel}"
SRC_URI[aarch64_rust-ring+dev_urandom_fallback-devel.sha256sum] = "63a3f4bb71f129c3ce54dbfa6624bcae6d3b8fac9e01b9ddfdd32eac0b7b7ab1"

URI_aarch64_rust-ring+less-safe-getrandom-custom-or-rdrand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+less-safe-getrandom-custom-or-rdrand-devel-0.17.14-1.el10_1.noarch.rpm;name=aarch64_rust-ring+less-safe-getrandom-custom-or-rdrand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+less-safe-getrandom-custom-or-rdrand-devel}"
SRC_URI[aarch64_rust-ring+less-safe-getrandom-custom-or-rdrand-devel.sha256sum] = "c5b53ccba593dc361f5f879d7bcad2845a2825cabf856f1280d208897172a27c"

URI_aarch64_rust-ring+less-safe-getrandom-espidf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+less-safe-getrandom-espidf-devel-0.17.14-1.el10_1.noarch.rpm;name=aarch64_rust-ring+less-safe-getrandom-espidf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+less-safe-getrandom-espidf-devel}"
SRC_URI[aarch64_rust-ring+less-safe-getrandom-espidf-devel.sha256sum] = "bbad79ca4808b211eedf2101fe27cc928f80e2c71f67d75fda65963cb77f90dd"

URI_aarch64_rust-ring+slow_tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+slow_tests-devel-0.17.14-1.el10_1.noarch.rpm;name=aarch64_rust-ring+slow_tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+slow_tests-devel}"
SRC_URI[aarch64_rust-ring+slow_tests-devel.sha256sum] = "aafeab1da58cd8e9f3bfa7837b2e196fbccc68b8b1a3727dddbd6313cb14e3e1"

URI_aarch64_rust-ring+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+std-devel-0.17.14-1.el10_1.noarch.rpm;name=aarch64_rust-ring+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+std-devel}"
SRC_URI[aarch64_rust-ring+std-devel.sha256sum] = "9a9170f4122fd775b53829b9a78838eaef3ad94a725fad4e1690a073b67e05e4"

URI_aarch64_rust-ring+test_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring+test_logging-devel-0.17.14-1.el10_1.noarch.rpm;name=aarch64_rust-ring+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring+test_logging-devel}"
SRC_URI[aarch64_rust-ring+test_logging-devel.sha256sum] = "85597adc70cfdf093127d8cbb5e9ef9d3ac34f85065d21a4450646934792c3d6"

URI_aarch64_rust-ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ring-devel-0.17.14-1.el10_1.noarch.rpm;name=aarch64_rust-ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ring-devel}"
SRC_URI[aarch64_rust-ring-devel.sha256sum] = "21ed7fcf4f32a73c947b6118010094a3e0d589e9a00ecc5c931b05dd2bf651b1"

RDEPENDS:rust-ring+alloc-devel = " \
 cargo \
 rust-ring-devel \
 "
RDEPENDS:rust-ring+default-devel = " \
 cargo \
 rust-ring+alloc-devel \
 rust-ring+dev_urandom_fallback-devel \
 rust-ring-devel \
 "
RDEPENDS:rust-ring+dev_urandom_fallback-devel = " \
 cargo \
 rust-ring-devel \
 "
RDEPENDS:rust-ring+less-safe-getrandom-custom-or-rdrand-devel = " \
 cargo \
 rust-ring-devel \
 "
RDEPENDS:rust-ring+less-safe-getrandom-espidf-devel = " \
 cargo \
 rust-ring-devel \
 "
RDEPENDS:rust-ring+slow_tests-devel = " \
 cargo \
 rust-ring-devel \
 "
RDEPENDS:rust-ring+std-devel = " \
 cargo \
 rust-ring+alloc-devel \
 rust-ring-devel \
 "
RDEPENDS:rust-ring+test_logging-devel = " \
 cargo \
 rust-ring-devel \
 "
RDEPENDS:rust-ring-devel = " \
 cargo \
 gcc \
 perl-interpreter \
 rust \
 rust-cc-devel \
 rust-cfg-if-devel \
 rust-getrandom0.2+default-devel \
 rust-libc-devel \
 rust-untrusted+default-devel \
 "
