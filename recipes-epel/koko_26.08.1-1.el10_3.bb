# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "koko"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 koko \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/koko-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "67e8ef87ae6559f5baf6153c038ce45e4f2c87476092fb8e895c6f31783f7c14"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koko-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_koko;unpack=0"
SRC_URI[x86_64_v2_koko.sha256sum] = "455477d8c36eec6c4046f28e1211a6dacbc4a1398008c87352403c5b0471dc4c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/koko-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_koko;unpack=0"
SRC_URI[aarch64_koko.sha256sum] = "0ad2e5a770b88a6549cf2213613f923cefc1c6c8eb49541312e6711b2e6f64b3"

RDEPENDS:koko = " \
 exiv2-libs \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kwindowsystem \
 kf6-purpose \
 kirigami-app-components \
 kquickimageeditor-qt6 \
 libgcc \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qt6-qtsvg \
 "
