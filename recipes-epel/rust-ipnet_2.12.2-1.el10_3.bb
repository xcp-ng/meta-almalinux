# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ipnet"
PV = "2.12.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-ipnet+default-devel \
 rust-ipnet+heapless-devel \
 rust-ipnet+schemars08-devel \
 rust-ipnet+schemars1-devel \
 rust-ipnet+ser_as_str-devel \
 rust-ipnet+serde-devel \
 rust-ipnet+std-devel \
 rust-ipnet-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-ipnet-2.12.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9d08ae6cf1d346dc89fa0eeba07a9bc2f1e3a1e231a25ee1da0f824e99c71057"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+default-devel-2.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet+default-devel.sha256sum] = "0e8f43e19ba0e7e75366c6ed70a5aa4eccb108386a14f1eeef4e5b3cc61f233c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+heapless-devel-2.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+heapless-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet+heapless-devel.sha256sum] = "9d4e9a117fa1d35c3f4104046e73bb8d938628eca660b78b9bf8edb94aa84ede"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+schemars08-devel-2.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+schemars08-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet+schemars08-devel.sha256sum] = "40e5392a4f4ce034b4a85db5ace5ab36afb9cb59fef2bb94b8044e9867026827"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+schemars1-devel-2.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+schemars1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet+schemars1-devel.sha256sum] = "190fc94b6fa8122c833f2636a20e85bf6fee1d3e03253ddc579e02b5670cf5ff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+ser_as_str-devel-2.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+ser_as_str-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet+ser_as_str-devel.sha256sum] = "c04fedc304373bc2593ec4dc89e29add33a8ba1223a4a4ca759c22a27e34890c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+serde-devel-2.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet+serde-devel.sha256sum] = "c7c004b25c059b38a5849e0ef3014d0fc4443e8ad1accdad50fc018396bd57d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+std-devel-2.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet+std-devel.sha256sum] = "04220773bd4489f17d8b56e664b3191988e75c7dcdf592568aeb0869144a071d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet-devel-2.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet-devel.sha256sum] = "c3b4013685529bc7255a8f996ebe2ffb7468cb1ac6bcace63874673f170bfc72"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+default-devel-2.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet+default-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet+default-devel.sha256sum] = "8924537210837a5d6fc78b7f2869246b4f52fc2e7c47c8210c3d124f60e7cd65"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+heapless-devel-2.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet+heapless-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet+heapless-devel.sha256sum] = "9c9c040439cc67a357e970a746bdf95e6db2541fa5ed34e09381eeef3ede62dd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+schemars08-devel-2.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet+schemars08-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet+schemars08-devel.sha256sum] = "c2db53b4c96c5cbdb472a8cfb4de5a59ad4feb601c12a5868bd8689b07bcb5ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+schemars1-devel-2.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet+schemars1-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet+schemars1-devel.sha256sum] = "c867e8c8591190ec0f34110df66843e6e8e4848a0d76835e27bf15e85ec065ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+ser_as_str-devel-2.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet+ser_as_str-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet+ser_as_str-devel.sha256sum] = "e6ca9a8322c5c17ca3b7f51d986f73257e5511db528bd76287eaf289a277ff0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+serde-devel-2.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet+serde-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet+serde-devel.sha256sum] = "b5213099133ee05125d2da1e483e01a2795184ec9504f70b05fc3d4bfefb9208"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+std-devel-2.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet+std-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet+std-devel.sha256sum] = "e74a209abb1d704964272a8e0ee94ae49cf02263fc6a73f7bf03c0c4d588a5bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet-devel-2.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet-devel.sha256sum] = "20c4c0b2df497bef4b8faf16f322f02d1f361be16f9c7ec5ad4ff6c42f50993e"

RDEPENDS:rust-ipnet+default-devel = " \
 cargo \
 rust-ipnet+std-devel \
 rust-ipnet-devel \
 "
RDEPENDS:rust-ipnet+heapless-devel = " \
 cargo \
 rust-ipnet+serde-devel \
 rust-ipnet-devel \
 virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~ \
 "
RDEPENDS:rust-ipnet+schemars08-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-ipnet+schemars1-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-ipnet+ser_as_str-devel = " \
 cargo \
 rust-ipnet-devel \
 virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~ \
 "
RDEPENDS:rust-ipnet+serde-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ipnet+std-devel = " \
 cargo \
 rust-ipnet-devel \
 "
RDEPENDS:rust-ipnet-devel = " \
 cargo \
 "
