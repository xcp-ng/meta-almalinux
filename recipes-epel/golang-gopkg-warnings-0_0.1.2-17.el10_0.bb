# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-warnings-0"
PV = "0.1.2"
PR = "17.el10_0"
PACKAGES = " \
 golang-gopkg-warnings-0-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-warnings-0-0.1.2-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15ac216ae3044160b2c79e8277520f5295d77568f292f1bb7a4d5dd8725d3cb0"

URI_x86_64_v2_golang-gopkg-warnings-0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gopkg-warnings-0-devel-0.1.2-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gopkg-warnings-0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gopkg-warnings-0-devel}"
SRC_URI[x86_64_v2_golang-gopkg-warnings-0-devel.sha256sum] = "e20df7adc86ffe5d8daf95e7f38b4806de7f99407df4f86341d9cd7e25d5e2ce"

URI_aarch64_golang-gopkg-warnings-0-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-warnings-0-devel-0.1.2-17.el10_0.noarch.rpm;name=aarch64_golang-gopkg-warnings-0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-warnings-0-devel}"
SRC_URI[aarch64_golang-gopkg-warnings-0-devel.sha256sum] = "71ffa100e2911827fbb74bce5d23f0c8e6c0667337178d3e65c0e17bfb099831"

RDEPENDS:golang-gopkg-warnings-0-devel = " \
 go-filesystem \
 "
