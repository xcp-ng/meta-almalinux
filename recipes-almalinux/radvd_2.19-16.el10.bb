# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radvd"
PV = "2.19"
PR = "16.el10"
PACKAGES = " \
 radvd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/radvd-2.19-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9fc0dd7600587d861966d689fb54c39d349e9536d49eae8d996a095eff00c16"

URI_x86_64_v2_radvd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/radvd-2.19-16.el10.x86_64_v2.rpm;name=x86_64_v2_radvd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radvd}"
SRC_URI[x86_64_v2_radvd.sha256sum] = "7d43671eba0fd9e181ba291c9dfec7722cc024c64b86253fd7fc0104bc886cd0"

URI_aarch64_radvd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/radvd-2.19-16.el10.aarch64.rpm;name=aarch64_radvd;unpack=0"
SRC_URI:append = " ${URI_aarch64_radvd}"
SRC_URI[aarch64_radvd.sha256sum] = "5b790ab0ffb852afa74d04ec5fab9aadfcf1e277b3a89bd8286d0a619db4a586"

RDEPENDS:radvd = " \
 bash \
 glibc \
 shadow-utils \
 systemd \
 "
