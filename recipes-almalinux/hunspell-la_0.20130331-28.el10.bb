# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-la"
PV = "0.20130331"
PR = "28.el10"
PACKAGES = " \
 hunspell-la \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-la-0.20130331-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a983cb077b3113cb67730d536103d664c7430de6a097983ff5da0ac4fecd5929"

URI_x86_64_v2_hunspell-la = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-la-0.20130331-28.el10.noarch.rpm;name=x86_64_v2_hunspell-la;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-la}"
SRC_URI[x86_64_v2_hunspell-la.sha256sum] = "bbc694f2ea4fa6e1ef7453add4fe7e9c0deb0b6942943b568cdf0463969e81bb"

URI_aarch64_hunspell-la = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-la-0.20130331-28.el10.noarch.rpm;name=aarch64_hunspell-la;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-la}"
SRC_URI[aarch64_hunspell-la.sha256sum] = "bbc694f2ea4fa6e1ef7453add4fe7e9c0deb0b6942943b568cdf0463969e81bb"

RDEPENDS:hunspell-la = " \
 hunspell-filesystem \
 "
