# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-screen-autorotate"
PV = "27"
PR = "1.el10_2"
PACKAGES = " \
 gnome-shell-extension-screen-autorotate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnome-shell-extension-screen-autorotate-27-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef24934e80a31c21d6996bbf420d3a22ef83e46dcfdefb507b9958290718031f"

URI_x86_64_v2_gnome-shell-extension-screen-autorotate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-shell-extension-screen-autorotate-27-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-shell-extension-screen-autorotate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-screen-autorotate}"
SRC_URI[x86_64_v2_gnome-shell-extension-screen-autorotate.sha256sum] = "2243338ed2e149513e67f74cf6f339b9b9f61876c545cfccc0fb9e7d4b67b2a0"

URI_aarch64_gnome-shell-extension-screen-autorotate = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-shell-extension-screen-autorotate-27-1.el10_2.noarch.rpm;name=aarch64_gnome-shell-extension-screen-autorotate;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-screen-autorotate}"
SRC_URI[aarch64_gnome-shell-extension-screen-autorotate.sha256sum] = "21aa6cba3fd2abc0bdf01aae1c2fea347784a080a0b6d5dbf2e4e4294f4a5718"

RDEPENDS:gnome-shell-extension-screen-autorotate = " \
 gnome-shell \
 iio-sensor-proxy \
 "
