# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jaraco-envs"
PV = "2.6.0"
PR = "6.el10_0"
PACKAGES = " \
 python3-jaraco-envs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jaraco-envs-2.6.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e313aa42b4b2407ad13e28bd22f75d88dbff2ccffaeafe3c427d77299a8ebb8"

URI_x86_64_v2_python3-jaraco-envs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jaraco-envs-2.6.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jaraco-envs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jaraco-envs}"
SRC_URI[x86_64_v2_python3-jaraco-envs.sha256sum] = "33c033a1557d56286101bf78fbf7fba2ad36177134029287d276966d700eec41"

URI_aarch64_python3-jaraco-envs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jaraco-envs-2.6.0-6.el10_0.noarch.rpm;name=aarch64_python3-jaraco-envs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jaraco-envs}"
SRC_URI[aarch64_python3-jaraco-envs.sha256sum] = "866c144f5ed843e214c93cfac776a6cf89cbc283490fe360acdd3b223f9f8e5e"

RDEPENDS:python3-jaraco-envs = " \
 python3 \
 python3-path \
 python3-virtualenv \
 tox \
 "
