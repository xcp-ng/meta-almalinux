# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-test"
PV = "0.3.33"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-test+default-devel \
 rust-futures-test+std-devel \
 rust-futures-test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-test-0.3.33-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cdc9d9a635f49a33f9be4371d40c1095156ace8458e6ee578575cd695a92d3d"

URI_x86_64_v2_rust-futures-test+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-test+default-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-test+default-devel}"
SRC_URI[x86_64_v2_rust-futures-test+default-devel.sha256sum] = "2feaad4cb1b6a0d1df945afa16d2e03334c18840642fcf0a16362d3e634687c2"

URI_x86_64_v2_rust-futures-test+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-test+std-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-test+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-test+std-devel}"
SRC_URI[x86_64_v2_rust-futures-test+std-devel.sha256sum] = "f264688a3ee987fbcaf44b983e11a305604cec08b5ea494021b3622e4461993b"

URI_x86_64_v2_rust-futures-test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-test-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-test-devel}"
SRC_URI[x86_64_v2_rust-futures-test-devel.sha256sum] = "628bee08eb9655f99b35e989f4a3129eb4e4d35d06d749abf72acf4055101036"

URI_aarch64_rust-futures-test+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-test+default-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-test+default-devel}"
SRC_URI[aarch64_rust-futures-test+default-devel.sha256sum] = "31dc72f3ed69dd7a6175090374ffc5bd3df15197fcbfe3a17837a27ce8386e19"

URI_aarch64_rust-futures-test+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-test+std-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-test+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-test+std-devel}"
SRC_URI[aarch64_rust-futures-test+std-devel.sha256sum] = "993be418e2299d4f8950aebebdb3cc072f60e4657d2345b9c901c757e113615b"

URI_aarch64_rust-futures-test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-test-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-test-devel}"
SRC_URI[aarch64_rust-futures-test-devel.sha256sum] = "ba6a9d0e6bbdcadb6156e01f261cad55f48be02905d30e8b2ec3e0db706fdf1f"

RDEPENDS:rust-futures-test+default-devel = " \
 cargo \
 rust-futures-test+std-devel \
 rust-futures-test-devel \
 "
RDEPENDS:rust-futures-test+std-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-executor+std-devel \
 rust-futures-io+std-devel \
 rust-futures-task+std-devel \
 rust-futures-test-devel \
 rust-futures-util+io-devel \
 rust-futures-util+std-devel \
 "
RDEPENDS:rust-futures-test-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-futures-executor-devel \
 rust-futures-io-devel \
 rust-futures-macro-devel \
 rust-futures-sink-devel \
 rust-futures-task-devel \
 rust-futures-util-devel \
 rust-pin-project+default-devel \
 "
