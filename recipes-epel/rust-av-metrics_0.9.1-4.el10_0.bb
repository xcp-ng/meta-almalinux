# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-av-metrics"
PV = "0.9.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-av-metrics+default-devel \
 rust-av-metrics+serde-devel \
 rust-av-metrics-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-av-metrics-0.9.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14b6764bb5f1e760ff14653f40f6a71d33c8bf4e12f7674b727a99be0ea5e588"

URI_x86_64_v2_rust-av-metrics+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-metrics+default-devel-0.9.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-metrics+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-metrics+default-devel}"
SRC_URI[x86_64_v2_rust-av-metrics+default-devel.sha256sum] = "54e7ab8189eae425676071c40e7b94f1db30766810340f32396d7ecf22ff94a8"

URI_x86_64_v2_rust-av-metrics+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-metrics+serde-devel-0.9.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-metrics+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-metrics+serde-devel}"
SRC_URI[x86_64_v2_rust-av-metrics+serde-devel.sha256sum] = "fa11d0f5d400d40936e641004109c9d9e82992c068d8c30203fdf3a481a4338c"

URI_x86_64_v2_rust-av-metrics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-metrics-devel-0.9.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-metrics-devel}"
SRC_URI[x86_64_v2_rust-av-metrics-devel.sha256sum] = "78c4bf54f427df6fb1d76a33eec2275eaac7bf3a10976f4ee47c4be02a5cf3cb"

URI_aarch64_rust-av-metrics+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-metrics+default-devel-0.9.1-4.el10_0.noarch.rpm;name=aarch64_rust-av-metrics+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-metrics+default-devel}"
SRC_URI[aarch64_rust-av-metrics+default-devel.sha256sum] = "bbdb86e1b36b749a34c038d8dba79a689c5ab5015df0a9fa017efac4ebf9241d"

URI_aarch64_rust-av-metrics+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-metrics+serde-devel-0.9.1-4.el10_0.noarch.rpm;name=aarch64_rust-av-metrics+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-metrics+serde-devel}"
SRC_URI[aarch64_rust-av-metrics+serde-devel.sha256sum] = "0d75dfdfb61b1ce459aa1b7b3ffcdedba81da83dc143407edbff1c8658d3fc0f"

URI_aarch64_rust-av-metrics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-metrics-devel-0.9.1-4.el10_0.noarch.rpm;name=aarch64_rust-av-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-metrics-devel}"
SRC_URI[aarch64_rust-av-metrics-devel.sha256sum] = "94c2f6d5b49dbe993b8cced3979fce91c136ed6bcc029ef677855e9e807caf45"

RDEPENDS:rust-av-metrics+default-devel = " \
 cargo \
 rust-av-metrics-devel \
 "
RDEPENDS:rust-av-metrics+serde-devel = " \
 cargo \
 rust-av-metrics-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-av-metrics-devel = " \
 cargo \
 rust-crossbeam+default-devel \
 rust-itertools0.10+default-devel \
 rust-lab+default-devel \
 rust-num-traits+default-devel \
 rust-rayon+default-devel \
 rust-thiserror1+default-devel \
 rust-v_frame+default-devel \
 "
