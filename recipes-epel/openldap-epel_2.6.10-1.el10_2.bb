# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openldap-epel"
PV = "2.6.10"
PR = "1.el10_2"
PACKAGES = " \
 openldap-servers \
 openldap-slapi \
 openldap-slapi-compat \
 openldap-slapi-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/openldap-epel-2.6.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "31e89587821ef2d17a698340fffcc9a9d7b21f525b92a0cc136b49369eccd4be"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-servers-2.6.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-servers;unpack=0"
SRC_URI[x86_64_v2_openldap-servers.sha256sum] = "72223a5840fb5141eda3b37d8d2750156f4e38f0fae23ab29b5b7bb7908ee9aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-slapi-2.6.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-slapi;unpack=0"
SRC_URI[x86_64_v2_openldap-slapi.sha256sum] = "0cce51079b971d4615a86cbcebb1953ec135b3fa68e59581e1c087787d4d6d99"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-slapi-compat-2.6.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-slapi-compat;unpack=0"
SRC_URI[x86_64_v2_openldap-slapi-compat.sha256sum] = "3b77a91bfe0049a8d56bdcb687a28c66779ac297f37963fd04e17cc1131a1917"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-slapi-devel-2.6.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-slapi-devel;unpack=0"
SRC_URI[x86_64_v2_openldap-slapi-devel.sha256sum] = "efed61daabcb33b5522a1b039fcbae46305e6aae410d75d119b8337d8a2cf331"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openldap-servers-2.6.10-1.el10_2.aarch64.rpm;name=aarch64_openldap-servers;unpack=0"
SRC_URI[aarch64_openldap-servers.sha256sum] = "4206b7d13e0cde5b0760cde96030aca83c0d4d51ce17e81d5b2ed2a778ddadd9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openldap-slapi-2.6.10-1.el10_2.aarch64.rpm;name=aarch64_openldap-slapi;unpack=0"
SRC_URI[aarch64_openldap-slapi.sha256sum] = "3234e4ff6176cdd17e38238df7baeb2dfdf2befaa28233fff2beb70ec9329e8e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openldap-slapi-compat-2.6.10-1.el10_2.aarch64.rpm;name=aarch64_openldap-slapi-compat;unpack=0"
SRC_URI[aarch64_openldap-slapi-compat.sha256sum] = "10f5035cda37333fbbeb71f76e4a4c96c2fb052251a389489b2e9df62a5bf729"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openldap-slapi-devel-2.6.10-1.el10_2.aarch64.rpm;name=aarch64_openldap-slapi-devel;unpack=0"
SRC_URI[aarch64_openldap-slapi-devel.sha256sum] = "21ec0cf031ae8d6599cd1410914931bc8ca29bd10b0d83f32f55bfaba6b505e5"

RDEPENDS:openldap-servers = " \
 bash \
 cracklib \
 cyrus-sasl-lib \
 glibc \
 libevent \
 libgcc \
 libtool-ltdl \
 libxcrypt \
 openldap \
 openldap-slapi \
 openssl-libs \
 perl-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:openldap-slapi = " \
 glibc \
 libtool-ltdl \
 "
RDEPENDS:openldap-slapi-compat = " \
 glibc \
 openldap-slapi \
 "
RDEPENDS:openldap-slapi-devel = " \
 openldap-devel \
 openldap-slapi \
 "
