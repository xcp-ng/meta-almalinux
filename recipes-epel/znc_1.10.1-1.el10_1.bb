# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "znc"
PV = "1.10.1"
PR = "1.el10_1"
PACKAGES = " \
 znc \
 znc-devel \
 znc-modperl \
 znc-modpython \
 znc-modtcl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/znc-1.10.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8163821ea1346788a820414bbf35a8291af856070ffde8b9267c3a7a60ec6561"

URI_x86_64_v2_znc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/znc-1.10.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_znc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_znc}"
SRC_URI[x86_64_v2_znc.sha256sum] = "b914bf9d11e5279da9ba3b9a4c19b56c4a979cf6c9b5e1b1c26b7bc4fbf60f24"

URI_x86_64_v2_znc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/znc-devel-1.10.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_znc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_znc-devel}"
SRC_URI[x86_64_v2_znc-devel.sha256sum] = "1c61597ab780ea4aa89da24502ab96a83acb9e1f1255d6d9a9842838c4b8cd8d"

URI_x86_64_v2_znc-modperl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/znc-modperl-1.10.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_znc-modperl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_znc-modperl}"
SRC_URI[x86_64_v2_znc-modperl.sha256sum] = "f01a842b6cf82c70c69f01a312c0c8aac40c223c0735ace5ba21dbad87ce6646"

URI_x86_64_v2_znc-modpython = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/znc-modpython-1.10.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_znc-modpython;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_znc-modpython}"
SRC_URI[x86_64_v2_znc-modpython.sha256sum] = "e76b814c8a1aa16b0649c1a20a541ed99fcd366134a58ffdaff6fe231192da71"

URI_x86_64_v2_znc-modtcl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/znc-modtcl-1.10.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_znc-modtcl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_znc-modtcl}"
SRC_URI[x86_64_v2_znc-modtcl.sha256sum] = "3eb14a2ffe95132fca201253d386434cda3e7821bf492b818957e77077aaaa56"

URI_aarch64_znc = "${EPEL_MIRROR}/aarch64/Packages/z/znc-1.10.1-1.el10_1.aarch64.rpm;name=aarch64_znc;unpack=0"
SRC_URI:append = " ${URI_aarch64_znc}"
SRC_URI[aarch64_znc.sha256sum] = "73327a70a78f8b1b2644d4d555a9b2c27d9f5f460bba454f4a7f24ccf9c33bce"

URI_aarch64_znc-devel = "${EPEL_MIRROR}/aarch64/Packages/z/znc-devel-1.10.1-1.el10_1.aarch64.rpm;name=aarch64_znc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_znc-devel}"
SRC_URI[aarch64_znc-devel.sha256sum] = "b2d6d3ed7e888e74ea1ba7931b6d9cbba4ab9b074634c3ce4b2da3ed483721c6"

URI_aarch64_znc-modperl = "${EPEL_MIRROR}/aarch64/Packages/z/znc-modperl-1.10.1-1.el10_1.aarch64.rpm;name=aarch64_znc-modperl;unpack=0"
SRC_URI:append = " ${URI_aarch64_znc-modperl}"
SRC_URI[aarch64_znc-modperl.sha256sum] = "708f51f630bb0ad7d4945a60012d2abf875ce75930ee17f8124dc578ad4bab2b"

URI_aarch64_znc-modpython = "${EPEL_MIRROR}/aarch64/Packages/z/znc-modpython-1.10.1-1.el10_1.aarch64.rpm;name=aarch64_znc-modpython;unpack=0"
SRC_URI:append = " ${URI_aarch64_znc-modpython}"
SRC_URI[aarch64_znc-modpython.sha256sum] = "f84c9a760fb7845a3737c7690fabcb963907e3e9523a66a635bfa3765cf32f94"

URI_aarch64_znc-modtcl = "${EPEL_MIRROR}/aarch64/Packages/z/znc-modtcl-1.10.1-1.el10_1.aarch64.rpm;name=aarch64_znc-modtcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_znc-modtcl}"
SRC_URI[aarch64_znc-modtcl.sha256sum] = "cf46309dbdbf0f4d6fadc1354ab00f3806079845e595aced6bdfa8d5ef8ccfdc"

RDEPENDS:znc = " \
 bash \
 cyrus-sasl-lib \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 systemd \
 zlib-ng-compat \
 "
RDEPENDS:znc-devel = " \
 bash \
 c-ares-devel \
 gcc-c++ \
 glibc-devel \
 libicu-devel \
 openssl-devel \
 pkgconf-pkg-config \
 redhat-rpm-config \
 znc \
 "
RDEPENDS:znc-modperl = " \
 glibc \
 libgcc \
 libstdc++ \
 perl-DynaLoader \
 perl-Exporter \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-vars \
 znc \
 znc-modperl \
 "
RDEPENDS:znc-modpython = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 znc \
 "
RDEPENDS:znc-modtcl = " \
 glibc \
 libgcc \
 libstdc++ \
 tcl \
 znc \
 "
