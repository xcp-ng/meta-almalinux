# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-deprecated"
PV = "1.2.15"
PR = "1.el10_0"
PACKAGES = " \
 python3-deprecated \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-deprecated-1.2.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d4010aa0fc6b7f6f3804c5393d6dbe14ac1043ae26664eeb0df58cd07707ab6"

URI_x86_64_v2_python3-deprecated = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-deprecated-1.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-deprecated;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-deprecated}"
SRC_URI[x86_64_v2_python3-deprecated.sha256sum] = "d00a70f9840605587b64993b8fb300f49777660e8419c87d3ff525cfc024be88"

URI_aarch64_python3-deprecated = "${EPEL_MIRROR}/aarch64/Packages/p/python3-deprecated-1.2.15-1.el10_0.noarch.rpm;name=aarch64_python3-deprecated;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-deprecated}"
SRC_URI[aarch64_python3-deprecated.sha256sum] = "41a9382b517255a10eb9edc5bf09a8c1d0e3ee5411726b698e2610787ecee80c"

RDEPENDS:python3-deprecated = " \
 python3 \
 python3-wrapt \
 "
