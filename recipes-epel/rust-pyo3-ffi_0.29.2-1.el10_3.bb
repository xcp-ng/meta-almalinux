# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-ffi"
PV = "0.29.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-pyo3-ffi+abi3-devel \
 rust-pyo3-ffi+abi3-py310-devel \
 rust-pyo3-ffi+abi3-py311-devel \
 rust-pyo3-ffi+abi3-py312-devel \
 rust-pyo3-ffi+abi3-py313-devel \
 rust-pyo3-ffi+abi3-py314-devel \
 rust-pyo3-ffi+abi3-py315-devel \
 rust-pyo3-ffi+abi3-py38-devel \
 rust-pyo3-ffi+abi3-py39-devel \
 rust-pyo3-ffi+abi3t-devel \
 rust-pyo3-ffi+abi3t-py315-devel \
 rust-pyo3-ffi+default-devel \
 rust-pyo3-ffi+extension-module-devel \
 rust-pyo3-ffi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-ffi-0.29.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69279dccf193f581f6aebf41c8abadb1d2fdf568cdef045d0363a6a869b37993"

URI_x86_64_v2_rust-pyo3-ffi+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-devel.sha256sum] = "644aaeeaed7a37f11d54db0a44fef726766c04c07dc7d277c0e21a7ec7cdac46"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py310-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py310-devel.sha256sum] = "487679a2a0d0282f1e16b5ca3f2a88e2b5bbf0f731cca8e421d5497d17fed6c2"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py311-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py311-devel.sha256sum] = "b6c3012494b3f2a38930430176a37199a18a37ccc696ad3d30124fab8b938617"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py312-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py312-devel.sha256sum] = "6279802c9a434adb5f565c598d92fe2a1e26769ed5ee766454d60435898370cc"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py313-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py313-devel.sha256sum] = "9437a3ec34effdc9412fe54287d064df29bda41d4e50505c0718dfd3a19225d4"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py314-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py314-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py314-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py314-devel.sha256sum] = "ba306e9ffff20d5bf5d6076dd082a74aca4e12de8056abb6dd94a8428c04af41"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py315-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py315-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py315-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py315-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py315-devel.sha256sum] = "1c409492d2ed33d07985b7210d05bf302b9f426c43f4aab0421e24733fee57fe"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py38-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py38-devel.sha256sum] = "c76f1296e2fb89f090a81b1999d7885800b86253d3293054bfcd13f0b746d5ad"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py39-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py39-devel.sha256sum] = "c34d084df8b8126517c211c6b42a0ad99796dc23725d10d7eda0f74489c4e2e7"

URI_x86_64_v2_rust-pyo3-ffi+abi3t-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3t-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3t-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3t-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3t-devel.sha256sum] = "2f884f98fd8c666996cdf5d43554c10267b4eefc4c7365fe170d1dbc4bdd7add"

URI_x86_64_v2_rust-pyo3-ffi+abi3t-py315-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3t-py315-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3t-py315-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3t-py315-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3t-py315-devel.sha256sum] = "35d14bfcb263ff46b9e0c6bc491df1e57cb92f9ce63c01285b3e4d4e3b6819e5"

URI_x86_64_v2_rust-pyo3-ffi+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+default-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+default-devel.sha256sum] = "336c3f2198bf5ee29a568ad3a91788877e2d2eb39e591555e8dca8cbd07bbd8a"

URI_x86_64_v2_rust-pyo3-ffi+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+extension-module-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+extension-module-devel.sha256sum] = "68f7234b855ec590e696aa70fd2d9dffe652be6ae69998ba718700ed61f0d5f1"

URI_x86_64_v2_rust-pyo3-ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi-devel.sha256sum] = "76be9abbd7fed078e341e29e524bc0ab8e66e88ff5878d63e5e9456639dfae8c"

URI_aarch64_rust-pyo3-ffi+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-devel.sha256sum] = "784bea46dbfaffa574b52047cfb0ffb092e64a78132686775b6a78701ddccdb1"

URI_aarch64_rust-pyo3-ffi+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py310-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py310-devel.sha256sum] = "ffca8dff9a781140a3e1ee4e88edcadfae105355b03b88e6d05b4dd637be6651"

URI_aarch64_rust-pyo3-ffi+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py311-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py311-devel.sha256sum] = "f79e755858cbf3bb135a9b4fe43a1139ab0a7b160b35f39578e422ab26765f8b"

URI_aarch64_rust-pyo3-ffi+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py312-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py312-devel.sha256sum] = "d4fd4e6f0bab8b93190b9480772e0a07db6a08236e676b9b394b761c77c11aa9"

URI_aarch64_rust-pyo3-ffi+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py313-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py313-devel.sha256sum] = "c4d62bdfd0e7edf814880e2924e4bc74408de0de1e4681a3682319ff5a88604c"

URI_aarch64_rust-pyo3-ffi+abi3-py314-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py314-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py314-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py314-devel.sha256sum] = "be94168d217eefb53e82de970c1fa3a4981691f7314f79a691413dbc623bf6cd"

URI_aarch64_rust-pyo3-ffi+abi3-py315-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py315-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py315-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py315-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py315-devel.sha256sum] = "498944a22a3b1f74b5b4ec0daaa7001bef6b84b080cf24af4d83863a6238ac62"

URI_aarch64_rust-pyo3-ffi+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py38-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py38-devel.sha256sum] = "a1893458c050a4b6d7ad7c0f9c2b8e04df3a272fcb59f9873e985d5c932c3e50"

URI_aarch64_rust-pyo3-ffi+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py39-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py39-devel.sha256sum] = "3225e9617c9c4573f344c0a73671060d713a2012aaa1c7a4fad211202292d460"

URI_aarch64_rust-pyo3-ffi+abi3t-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3t-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3t-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3t-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3t-devel.sha256sum] = "c27d9d29336ee48d097d2563cacfe715a00a1d66e427cb0cba9ba6b183a7f8ee"

URI_aarch64_rust-pyo3-ffi+abi3t-py315-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3t-py315-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3t-py315-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3t-py315-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3t-py315-devel.sha256sum] = "d95f0644f03949c3ad19d5b0826244a2c167bd6c62d244014d4f350c9c8f083d"

URI_aarch64_rust-pyo3-ffi+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+default-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+default-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+default-devel.sha256sum] = "da27e1838a754fd0b9a81a95feff95f330e38fe3da076101be8ff46b5854273f"

URI_aarch64_rust-pyo3-ffi+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+extension-module-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+extension-module-devel.sha256sum] = "06e65c6119c5470cf04715d60353607763ceea2956988e9a58f82eff7e1fea1c"

URI_aarch64_rust-pyo3-ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi-devel}"
SRC_URI[aarch64_rust-pyo3-ffi-devel.sha256sum] = "5931d248b5ae5a5c6d9c154e516cd572f2c69c7b85a212083f96b49e673904dc"

RDEPENDS:rust-pyo3-ffi+abi3-devel = " \
 cargo \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py311-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py312-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py313-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py313-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py314-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py314-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py315-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py315-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py39-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py310-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3t-devel = " \
 cargo \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3t-py315-devel = " \
 cargo \
 rust-pyo3-ffi+abi3t-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+default-devel = " \
 cargo \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi-devel = " \
 cargo \
 python3-devel \
 rust \
 rust-libc+default-devel \
 rust-pyo3-build-config+default-devel \
 "
