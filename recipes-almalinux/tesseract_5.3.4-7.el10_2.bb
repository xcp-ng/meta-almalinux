# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tesseract"
PV = "5.3.4"
PR = "7.el10_2"
PACKAGES = " \
 tesseract \
 tesseract-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tesseract-5.3.4-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5196c3d13fa04a64be848a27e3a4d46999005d2a694df323b1f77ee319245c53"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-5.3.4-7.el10_2.x86_64_v2.rpm;name=x86_64_v2_tesseract;unpack=0"
SRC_URI[x86_64_v2_tesseract.sha256sum] = "c2bc980a3dde5f300753f4298bf6cc7acc33c8f8145961a949c1d858dce05817"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/tesseract-devel-5.3.4-7.el10_2.x86_64_v2.rpm;name=x86_64_v2_tesseract-devel;unpack=0"
SRC_URI[x86_64_v2_tesseract-devel.sha256sum] = "da10ee95971b415f0993680b7d5d0f20041125db0f5c6eae7caa698ec815a304"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-5.3.4-7.el10_2.aarch64.rpm;name=aarch64_tesseract;unpack=0"
SRC_URI[aarch64_tesseract.sha256sum] = "91d9a49b0d9e030c1b469c7a94bff4115f72e05f421264fb3b2cb21fa2acc1e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/tesseract-devel-5.3.4-7.el10_2.aarch64.rpm;name=aarch64_tesseract-devel;unpack=0"
SRC_URI[aarch64_tesseract-devel.sha256sum] = "8ab9feccdfb94540ee6fe427a3e9ef92b1311fcca5250240114435d9fdb0320f"

RDEPENDS:tesseract = " \
 glibc \
 leptonica \
 libgcc \
 libstdc++ \
 tesseract-langpack-eng \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:tesseract-devel = " \
 cmake-filesystem \
 leptonica-devel \
 pkgconf-pkg-config \
 tesseract \
 "
