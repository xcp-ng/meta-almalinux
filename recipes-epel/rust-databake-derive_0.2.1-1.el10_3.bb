# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-databake-derive"
PV = "0.2.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-databake-derive+default-devel \
 rust-databake-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-databake-derive-0.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01e1d0434df7ca11bedd454cee0958c048faa0ea672a20dc0b6bcf73a46aecd9"

URI_x86_64_v2_rust-databake-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake-derive+default-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake-derive+default-devel}"
SRC_URI[x86_64_v2_rust-databake-derive+default-devel.sha256sum] = "c2d293d28509d9267800465d6dd11059d22ab62545b65de359c4de04f90444b4"

URI_x86_64_v2_rust-databake-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake-derive-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake-derive-devel}"
SRC_URI[x86_64_v2_rust-databake-derive-devel.sha256sum] = "7d9d203c40c818e7f2819f35f6863be701251fb21a8a599ad2d17bce72ab5ff6"

URI_aarch64_rust-databake-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake-derive+default-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-databake-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake-derive+default-devel}"
SRC_URI[aarch64_rust-databake-derive+default-devel.sha256sum] = "ebfa38b6dd068a115e2affed3727930161fe6e582a3edb3d224f6955965d0415"

URI_aarch64_rust-databake-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake-derive-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-databake-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake-derive-devel}"
SRC_URI[aarch64_rust-databake-derive-devel.sha256sum] = "752a417fe88348815c4d7455dfc6d8b7b32e5ebed76fde99669ed0c7bbd6d2ed"

RDEPENDS:rust-databake-derive+default-devel = " \
 cargo \
 rust-databake-derive-devel \
 "
RDEPENDS:rust-databake-derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-synstructure+default-devel \
 "
