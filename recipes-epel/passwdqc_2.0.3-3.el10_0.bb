# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "passwdqc"
PV = "2.0.3"
PR = "3.el10_0"
PACKAGES = " \
 libpasswdqc \
 libpasswdqc-devel \
 pam_passwdqc \
 passwdqc \
 passwdqc-utils \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/passwdqc-2.0.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "86abc560e43444dfbb30f53021e20d4eddb19f43c54941041163b020db080081"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpasswdqc-2.0.3-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpasswdqc;unpack=0"
SRC_URI[x86_64_v2_libpasswdqc.sha256sum] = "74f8ca931ae6fc992d70f0893871fae1d51859c32ac7f070b2ab992f28fc49c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpasswdqc-devel-2.0.3-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpasswdqc-devel;unpack=0"
SRC_URI[x86_64_v2_libpasswdqc-devel.sha256sum] = "da3eea0b995478abc5ceb59c0d39209b838c6a4f92dbd607c2135ee2609f5694"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_passwdqc-2.0.3-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_passwdqc;unpack=0"
SRC_URI[x86_64_v2_pam_passwdqc.sha256sum] = "28c614f300241ff144dbdd430f8f3bc85a514fd4daee4415912675a9735e3369"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/passwdqc-2.0.3-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_passwdqc;unpack=0"
SRC_URI[x86_64_v2_passwdqc.sha256sum] = "b0f86e43d5d5f6cd910a25d5b2561abe2286c7ca4590476bb82ab406946bfd55"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/passwdqc-utils-2.0.3-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_passwdqc-utils;unpack=0"
SRC_URI[x86_64_v2_passwdqc-utils.sha256sum] = "24f4bfa6ad20d35c381fcca4e46dc3d87528c3d6fdeac12b1a6936097abc0e4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libpasswdqc-2.0.3-3.el10_0.aarch64.rpm;name=aarch64_libpasswdqc;unpack=0"
SRC_URI[aarch64_libpasswdqc.sha256sum] = "014c9fdcc524061a064aaa95fcaaaa4d63994697a826544e85e0acc420db6de3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libpasswdqc-devel-2.0.3-3.el10_0.aarch64.rpm;name=aarch64_libpasswdqc-devel;unpack=0"
SRC_URI[aarch64_libpasswdqc-devel.sha256sum] = "45af39c8ca221d93e059f20de6071e39e3b0ad9e53ac277d79ce15c877b666e7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pam_passwdqc-2.0.3-3.el10_0.aarch64.rpm;name=aarch64_pam_passwdqc;unpack=0"
SRC_URI[aarch64_pam_passwdqc.sha256sum] = "3bc734a38465130073eb7cdb54d8cf52891cfbac1cbad5d2ef47679e2cff81b2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/passwdqc-2.0.3-3.el10_0.aarch64.rpm;name=aarch64_passwdqc;unpack=0"
SRC_URI[aarch64_passwdqc.sha256sum] = "33b0dae4e332a7ffbd3324712353b94010d883fc0aa7dd6bc812ea931cc6a3aa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/passwdqc-utils-2.0.3-3.el10_0.aarch64.rpm;name=aarch64_passwdqc-utils;unpack=0"
SRC_URI[aarch64_passwdqc-utils.sha256sum] = "39a0d4897697046ad4a896a08181e7b85dd476c38691f3e46362ffbf3de8f09f"

RDEPENDS:libpasswdqc = " \
 glibc \
 "
RDEPENDS:libpasswdqc-devel = " \
 libpasswdqc \
 pkgconf-pkg-config \
 "
RDEPENDS:pam_passwdqc = " \
 glibc \
 libpasswdqc \
 libxcrypt \
 pam-libs \
 "
RDEPENDS:passwdqc = " \
 pam_passwdqc \
 passwdqc-utils \
 "
RDEPENDS:passwdqc-utils = " \
 glibc \
 libpasswdqc \
 "
