# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-Find-Object"
PV = "0.3.8"
PR = "1.el10_0"
PACKAGES = " \
 perl-File-Find-Object \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-Find-Object-0.3.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "378260c39b10dc2a9b07eea39e243abb9839dfaecb2f0342b0dc270159ec2aa1"

URI_x86_64_v2_perl-File-Find-Object = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Find-Object-0.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Find-Object;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Find-Object}"
SRC_URI[x86_64_v2_perl-File-Find-Object.sha256sum] = "44c453c7932a4fa48a85f72486e79e2ff0139ee0381981aa5e4b07c0c266d67b"

URI_aarch64_perl-File-Find-Object = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Find-Object-0.3.8-1.el10_0.noarch.rpm;name=aarch64_perl-File-Find-Object;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Find-Object}"
SRC_URI[aarch64_perl-File-Find-Object.sha256sum] = "57c18e1e6807071b5afe76f89880909d57ce570be7f83d19036c0872ed29edce"

RDEPENDS:perl-File-Find-Object = " \
 perl-Carp \
 perl-Class-XSAccessor \
 perl-Fcntl \
 perl-File-Find-Object \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-parent \
 "
