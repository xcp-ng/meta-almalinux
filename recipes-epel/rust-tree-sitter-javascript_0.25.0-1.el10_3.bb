# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-javascript"
PV = "0.25.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-javascript+default-devel \
 rust-tree-sitter-javascript-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-javascript-0.25.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58a57032da1e893f99965f45de2533abe4e6bd7b638db54aba7cc18708370277"

URI_x86_64_v2_rust-tree-sitter-javascript+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-javascript+default-devel-0.25.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-javascript+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-javascript+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-javascript+default-devel.sha256sum] = "450c65b6d1e3802e1fbe6316876ccd22d9cb41124e8dcc500209d6a96c466d06"

URI_x86_64_v2_rust-tree-sitter-javascript-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-javascript-devel-0.25.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-javascript-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-javascript-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-javascript-devel.sha256sum] = "ab759d4b395f0ce15a0948ef0e97d6bc568ce9cf008c705d7630693d2b4235de"

URI_aarch64_rust-tree-sitter-javascript+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-javascript+default-devel-0.25.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-javascript+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-javascript+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-javascript+default-devel.sha256sum] = "bff178e689bed63cfb82697af87d7ca1b8f692f17b2eaa6341f263b4afa89b00"

URI_aarch64_rust-tree-sitter-javascript-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-javascript-devel-0.25.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-javascript-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-javascript-devel}"
SRC_URI[aarch64_rust-tree-sitter-javascript-devel.sha256sum] = "77681dcf975e81c0c5196e2aeb5f03743985ebb348fcdd8b88a84368d8a59373"

RDEPENDS:rust-tree-sitter-javascript+default-devel = " \
 cargo \
 rust-tree-sitter-javascript-devel \
 "
RDEPENDS:rust-tree-sitter-javascript-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
