# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-utf8-width"
PV = "0.1.9"
PR = "1.el10_3"
PACKAGES = " \
 rust-utf8-width+default-devel \
 rust-utf8-width-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-utf8-width-0.1.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ba2cdc6c9f67daea5e6cc041ad921e31cd1de5f88f55d931a02586a531a7a84"

URI_x86_64_v2_rust-utf8-width+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf8-width+default-devel-0.1.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf8-width+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf8-width+default-devel}"
SRC_URI[x86_64_v2_rust-utf8-width+default-devel.sha256sum] = "b9b3198f51e4143900ddb1d0f0c1dd2665d85ec0f1e62345997f01df3bc3ae30"

URI_x86_64_v2_rust-utf8-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf8-width-devel-0.1.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf8-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf8-width-devel}"
SRC_URI[x86_64_v2_rust-utf8-width-devel.sha256sum] = "ba36095be909abde2a3c6fe2b70cc39f3506419f28a7f0e552dca259616f5dde"

URI_aarch64_rust-utf8-width+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf8-width+default-devel-0.1.9-1.el10_3.noarch.rpm;name=aarch64_rust-utf8-width+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf8-width+default-devel}"
SRC_URI[aarch64_rust-utf8-width+default-devel.sha256sum] = "d976123217eccaedb118bbd1b4807674fe69736e005c2b071262e9d5e601aca5"

URI_aarch64_rust-utf8-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf8-width-devel-0.1.9-1.el10_3.noarch.rpm;name=aarch64_rust-utf8-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf8-width-devel}"
SRC_URI[aarch64_rust-utf8-width-devel.sha256sum] = "45b6859eee6d1a7c6df2500f6e519d20d5a3fe62e6fabc8e5956ac30726247f6"

RDEPENDS:rust-utf8-width+default-devel = " \
 cargo \
 rust-utf8-width-devel \
 "
RDEPENDS:rust-utf8-width-devel = " \
 cargo \
 rust \
 "
