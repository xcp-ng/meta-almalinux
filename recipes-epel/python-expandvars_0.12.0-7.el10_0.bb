# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-expandvars"
PV = "0.12.0"
PR = "7.el10_0"
PACKAGES = " \
 python3-expandvars \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-expandvars-0.12.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "871c5af4b9440ef4d8fb25d7d814db1855b4762a2b8739a1b8b98b3e34a18d8e"

URI_x86_64_v2_python3-expandvars = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-expandvars-0.12.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-expandvars;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-expandvars}"
SRC_URI[x86_64_v2_python3-expandvars.sha256sum] = "ba34553b9a27af2463f9661d676dcdf0533b253d65c96f116d1c0a70e7610bc0"

URI_aarch64_python3-expandvars = "${EPEL_MIRROR}/aarch64/Packages/p/python3-expandvars-0.12.0-7.el10_0.noarch.rpm;name=aarch64_python3-expandvars;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-expandvars}"
SRC_URI[aarch64_python3-expandvars.sha256sum] = "7305e74590c443ea002d4e8d4e8c832d020e724f2f2c14c8a5452936476a70ed"

RDEPENDS:python3-expandvars = " \
 python3 \
 "
