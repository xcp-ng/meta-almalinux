# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Carp-Always"
PV = "0.16"
PR = "21.el10_0"
PACKAGES = " \
 perl-Carp-Always \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Carp-Always-0.16-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "396359df4a396ae54b3d93848429b9ef821a8b9b556023a0ec338bc5bf8752fd"

URI_x86_64_v2_perl-Carp-Always = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Carp-Always-0.16-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Carp-Always;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Carp-Always}"
SRC_URI[x86_64_v2_perl-Carp-Always.sha256sum] = "780b38db84012826e1c45056be3663c784363c589d44d3fa3910d3398c433d21"

URI_aarch64_perl-Carp-Always = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Carp-Always-0.16-21.el10_0.noarch.rpm;name=aarch64_perl-Carp-Always;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Carp-Always}"
SRC_URI[aarch64_perl-Carp-Always.sha256sum] = "4f86b4d8c19a55ada32d0e0a4c1e4793ee797a52305786146da9180738a7b3e4"

RDEPENDS:perl-Carp-Always = " \
 perl-Carp \
 perl-constant \
 perl-if \
 perl-libs \
 "
