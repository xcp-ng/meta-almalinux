# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "weechat"
PV = "4.10.0"
PR = "1.el10_2"
PACKAGES = " \
 weechat \
 weechat-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/weechat-4.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f07d8db3e79bdb55d7448a9b958e2b1539fa3cfcd3c7694ad003203606a8c2af"

URI_x86_64_v2_weechat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weechat-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weechat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_weechat}"
SRC_URI[x86_64_v2_weechat.sha256sum] = "0ac43b594adc06e0d114c070966aad73df646ffa608f9cbf2b0cea943be4db0d"

URI_x86_64_v2_weechat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weechat-devel-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weechat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_weechat-devel}"
SRC_URI[x86_64_v2_weechat-devel.sha256sum] = "b173471752a80188a07635f378f4e38f559d57554b93ef3b4e4d7d38772c7ed9"

URI_aarch64_weechat = "${EPEL_MIRROR}/aarch64/Packages/w/weechat-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_weechat;unpack=0"
SRC_URI:append = " ${URI_aarch64_weechat}"
SRC_URI[aarch64_weechat.sha256sum] = "47f54ac2f4ed33d5f19db3ee49f11c82e6573448a14fd375e5c8996e8b046a01"

URI_aarch64_weechat-devel = "${EPEL_MIRROR}/aarch64/Packages/w/weechat-devel-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_weechat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_weechat-devel}"
SRC_URI[aarch64_weechat-devel.sha256sum] = "cfd76857238f0b297e000d768c8b6ad13eb043d3afc4c7dbd51ec1f4d16aba0d"

RDEPENDS:weechat = " \
 cjson \
 enchant2 \
 glibc \
 gnutls \
 guile30 \
 hicolor-icon-theme \
 libgcc \
 libgcrypt \
 libzstd \
 lua-libs \
 ncurses-libs \
 perl-libs \
 python3-libs \
 ruby-libs \
 tcl \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:weechat-devel = " \
 pkgconf-pkg-config \
 weechat \
 "
