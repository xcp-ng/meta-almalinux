# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-packaging"
PV = "1"
PR = "16.1.el10_0"
PACKAGES = " \
 ansible-packaging \
 ansible-srpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-packaging-1-16.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e890994aaef0ea2c79247533b64e62afe2faa5a87d80a833696d779b46c3ec2c"

URI_x86_64_v2_ansible-packaging = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-packaging-1-16.1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-packaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-packaging}"
SRC_URI[x86_64_v2_ansible-packaging.sha256sum] = "cb9eab7da11ec8e6c5ee046c2d068f4025f82084ae54be319f5434fa2503bdbe"

URI_x86_64_v2_ansible-srpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-srpm-macros-1-16.1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-srpm-macros}"
SRC_URI[x86_64_v2_ansible-srpm-macros.sha256sum] = "671fddd8f2f918ba1d1c52306d73be14b5bde3a0d2ce93de0072f00baf46551d"

URI_aarch64_ansible-packaging = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-packaging-1-16.1.el10_0.noarch.rpm;name=aarch64_ansible-packaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-packaging}"
SRC_URI[aarch64_ansible-packaging.sha256sum] = "a04be7e2f7d46c81638ea72df456a3650a11b70450db8f5b24751f01e801fdd9"

URI_aarch64_ansible-srpm-macros = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-srpm-macros-1-16.1.el10_0.noarch.rpm;name=aarch64_ansible-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-srpm-macros}"
SRC_URI[aarch64_ansible-srpm-macros.sha256sum] = "11c8cdf730ae0a38b440863be5cecaee12329f120ac1f5807f10144c2d8fda75"

RDEPENDS:ansible-packaging = " \
 ansible-core \
 ansible-srpm-macros \
 python3 \
 python3-pyyaml \
 "
RDEPENDS:ansible-srpm-macros = " \
 "
