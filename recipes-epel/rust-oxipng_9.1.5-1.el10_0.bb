# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-oxipng"
PV = "9.1.5"
PR = "1.el10_0"
PACKAGES = " \
 oxipng \
 rust-oxipng+binary-devel \
 rust-oxipng+default-devel \
 rust-oxipng+filetime-devel \
 rust-oxipng+freestanding-devel \
 rust-oxipng+parallel-devel \
 rust-oxipng+sanity-checks-devel \
 rust-oxipng+system-libdeflate-devel \
 rust-oxipng+zopfli-devel \
 rust-oxipng-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-oxipng-9.1.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6be86a0eff2d7ace8d432e3ace862b5bc65f8c5d19e8b8cc3344accb4245a449"

URI_x86_64_v2_oxipng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxipng-9.1.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oxipng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oxipng}"
SRC_URI[x86_64_v2_oxipng.sha256sum] = "ed53a50be19c298c3542990a6a63cc905d2a7ea3b03bbedddd7053757d8cf9c7"

URI_x86_64_v2_rust-oxipng+binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+binary-devel-9.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+binary-devel}"
SRC_URI[x86_64_v2_rust-oxipng+binary-devel.sha256sum] = "189ef25e187af9ae010e503b2936790edfab097f8d6f6a11d3eacc7b1ca0e048"

URI_x86_64_v2_rust-oxipng+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+default-devel-9.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+default-devel}"
SRC_URI[x86_64_v2_rust-oxipng+default-devel.sha256sum] = "82dbbb0a111c87231c851a698f201714360f8d8ca14271a708aca8b75e861658"

URI_x86_64_v2_rust-oxipng+filetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+filetime-devel-9.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+filetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+filetime-devel}"
SRC_URI[x86_64_v2_rust-oxipng+filetime-devel.sha256sum] = "d1bb0f238d9f64fefa76b5b3364bc3720f385829c633ccf4e17c1d76ee6f3b9f"

URI_x86_64_v2_rust-oxipng+freestanding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+freestanding-devel-9.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+freestanding-devel}"
SRC_URI[x86_64_v2_rust-oxipng+freestanding-devel.sha256sum] = "b35fe00171db76eace4503cbec3554acae767b0daf1222b4638c572e1b937443"

URI_x86_64_v2_rust-oxipng+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+parallel-devel-9.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+parallel-devel}"
SRC_URI[x86_64_v2_rust-oxipng+parallel-devel.sha256sum] = "fc6e8ee81dc7973c87e72477edca331ee62595392aae005dcc539ccb923af8de"

URI_x86_64_v2_rust-oxipng+sanity-checks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+sanity-checks-devel-9.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+sanity-checks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+sanity-checks-devel}"
SRC_URI[x86_64_v2_rust-oxipng+sanity-checks-devel.sha256sum] = "b8f02dbc819453cb0bab3f148752d991985abc26b6c1acb4c8a378cdb8456a58"

URI_x86_64_v2_rust-oxipng+system-libdeflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+system-libdeflate-devel-9.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+system-libdeflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+system-libdeflate-devel}"
SRC_URI[x86_64_v2_rust-oxipng+system-libdeflate-devel.sha256sum] = "f3adcf09392297f9b9ae46f439697cef40a5f1e88e1c47b293f34baf3191437e"

URI_x86_64_v2_rust-oxipng+zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+zopfli-devel-9.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+zopfli-devel}"
SRC_URI[x86_64_v2_rust-oxipng+zopfli-devel.sha256sum] = "01f89bf805238ef7f04706ade7d9ecb94db79b4766b75343dbcbbd27eadb6c40"

URI_x86_64_v2_rust-oxipng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng-devel-9.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng-devel}"
SRC_URI[x86_64_v2_rust-oxipng-devel.sha256sum] = "deca6a0d678ed3e60a72e64dbee2a954cef2a120326a6b2d2c4aaf92665104a0"

URI_aarch64_oxipng = "${EPEL_MIRROR}/aarch64/Packages/o/oxipng-9.1.5-1.el10_0.aarch64.rpm;name=aarch64_oxipng;unpack=0"
SRC_URI:append = " ${URI_aarch64_oxipng}"
SRC_URI[aarch64_oxipng.sha256sum] = "ff6a82b1fb7fe639b16dcc9184bfa62e7b1b48df1b4fd9216943ab09c9418d2e"

URI_aarch64_rust-oxipng+binary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+binary-devel-9.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-oxipng+binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+binary-devel}"
SRC_URI[aarch64_rust-oxipng+binary-devel.sha256sum] = "b9113a275ee70d8db50d94fdd629077c8fc2fb35494690410bcc328f1692a3a0"

URI_aarch64_rust-oxipng+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+default-devel-9.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-oxipng+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+default-devel}"
SRC_URI[aarch64_rust-oxipng+default-devel.sha256sum] = "a63ce0f0cbc5adbe334aa84804476f45c3b53c3e476fee0ba38dea81c6293f40"

URI_aarch64_rust-oxipng+filetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+filetime-devel-9.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-oxipng+filetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+filetime-devel}"
SRC_URI[aarch64_rust-oxipng+filetime-devel.sha256sum] = "52e8a310779f5f3d97c1a758103f8f72d0a3e279410e02bd0612800d7a30f3d4"

URI_aarch64_rust-oxipng+freestanding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+freestanding-devel-9.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-oxipng+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+freestanding-devel}"
SRC_URI[aarch64_rust-oxipng+freestanding-devel.sha256sum] = "f176dee344e3eb7a107c2a79fd8cc5eb2c1c2e38ec414e5255c4f26041649a78"

URI_aarch64_rust-oxipng+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+parallel-devel-9.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-oxipng+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+parallel-devel}"
SRC_URI[aarch64_rust-oxipng+parallel-devel.sha256sum] = "afdddc1c78ab48623714a7accd0196cb2880b3e709f4b7759588f4f1efb227e2"

URI_aarch64_rust-oxipng+sanity-checks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+sanity-checks-devel-9.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-oxipng+sanity-checks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+sanity-checks-devel}"
SRC_URI[aarch64_rust-oxipng+sanity-checks-devel.sha256sum] = "8dd7bc6241549c57103435618f0794ad73c2093c3af2e8098a5fdfa4cf2d5662"

URI_aarch64_rust-oxipng+system-libdeflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+system-libdeflate-devel-9.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-oxipng+system-libdeflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+system-libdeflate-devel}"
SRC_URI[aarch64_rust-oxipng+system-libdeflate-devel.sha256sum] = "667e1d3d4b4708ae786899d6b00c8360f6338c2a3a9164b210b900bb56675716"

URI_aarch64_rust-oxipng+zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+zopfli-devel-9.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-oxipng+zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+zopfli-devel}"
SRC_URI[aarch64_rust-oxipng+zopfli-devel.sha256sum] = "1b1ba40742f129c0aad98c45557b8d2ccab6de8b8954742ee89f1c01e3b855ee"

URI_aarch64_rust-oxipng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng-devel-9.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-oxipng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng-devel}"
SRC_URI[aarch64_rust-oxipng-devel.sha256sum] = "f8ed9517cb8e3e10e307ed6cbb2e99fa7e00cc269e01101976b0a9775ec6c04b"

RDEPENDS:oxipng = " \
 glibc \
 libdeflate \
 libgcc \
 "
RDEPENDS:rust-oxipng+binary-devel = " \
 cargo \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-env_logger+auto-color-devel \
 rust-env_logger-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+default-devel = " \
 cargo \
 rust-oxipng+binary-devel \
 rust-oxipng+filetime-devel \
 rust-oxipng+parallel-devel \
 rust-oxipng+zopfli-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+filetime-devel = " \
 cargo \
 rust-filetime+default-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+freestanding-devel = " \
 cargo \
 rust-libdeflater+freestanding-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+parallel-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-indexmap+rayon-devel \
 rust-oxipng-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-oxipng+sanity-checks-devel = " \
 cargo \
 rust-image+png-devel \
 rust-image-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+system-libdeflate-devel = " \
 cargo \
 rust-libdeflater+dynamic-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+zopfli-devel = " \
 cargo \
 rust-oxipng-devel \
 rust-zopfli+std-devel \
 rust-zopfli+zlib-devel \
 rust-zopfli-devel \
 "
RDEPENDS:rust-oxipng-devel = " \
 cargo \
 rust \
 rust-bitvec+default-devel \
 rust-indexmap+default-devel \
 rust-libdeflater+default-devel \
 rust-log+default-devel \
 rust-rgb+default-devel \
 rust-rustc-hash+default-devel \
 "
