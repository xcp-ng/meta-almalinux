# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-integer"
PV = "0.1.47"
PR = "1.el10_3"
PACKAGES = " \
 rust-num-integer+default-devel \
 rust-num-integer+i128-devel \
 rust-num-integer+std-devel \
 rust-num-integer-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-num-integer-0.1.47-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2f525a570892f355e51695087342028d417731ef2cef1661ba13ce78f919bb44"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer+default-devel-0.1.47-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-num-integer+default-devel.sha256sum] = "f4b7dce953a7b83e4d02c33a06082f430f312221667bb18e3728b859ec5bfd51"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer+i128-devel-0.1.47-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer+i128-devel;unpack=0"
SRC_URI[x86_64_v2_rust-num-integer+i128-devel.sha256sum] = "9d9bdc80b875a425bc6e679a5a76202ec580a7cf611dbf37c51971545dee37e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer+std-devel-0.1.47-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-num-integer+std-devel.sha256sum] = "561cdadd79d7888360cd847ecfe57e5dcd71bedfae8960d92fdc58b95a6805c5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer-devel-0.1.47-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer-devel;unpack=0"
SRC_URI[x86_64_v2_rust-num-integer-devel.sha256sum] = "d95ed8d76e564e0da7608c1987dcfc7452e203384ed312a8479dbbe4e7d0d096"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer+default-devel-0.1.47-1.el10_3.noarch.rpm;name=aarch64_rust-num-integer+default-devel;unpack=0"
SRC_URI[aarch64_rust-num-integer+default-devel.sha256sum] = "75df6ffaf67ae021dd18cd7d3fe572f7fd2e624ff4171803a60a89c46d1ddebf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer+i128-devel-0.1.47-1.el10_3.noarch.rpm;name=aarch64_rust-num-integer+i128-devel;unpack=0"
SRC_URI[aarch64_rust-num-integer+i128-devel.sha256sum] = "15dd4144dbc8923ccbe4d46f7196ba850e6b09ca542e3a42d4ab9b2d89858ef8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer+std-devel-0.1.47-1.el10_3.noarch.rpm;name=aarch64_rust-num-integer+std-devel;unpack=0"
SRC_URI[aarch64_rust-num-integer+std-devel.sha256sum] = "3213fa49c357fa5fec0ef9c285ee8984721f6cedb92e463073418847c723ce7a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer-devel-0.1.47-1.el10_3.noarch.rpm;name=aarch64_rust-num-integer-devel;unpack=0"
SRC_URI[aarch64_rust-num-integer-devel.sha256sum] = "9df0626ce9baf152a331191bf7df402c3d3a49d6f976eaf1f4db50c1e92e0056"

RDEPENDS:rust-num-integer+default-devel = " \
 cargo \
 rust-num-integer+std-devel \
 rust-num-integer-devel \
 "
RDEPENDS:rust-num-integer+i128-devel = " \
 cargo \
 rust-num-integer-devel \
 "
RDEPENDS:rust-num-integer+std-devel = " \
 cargo \
 rust-num-integer-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-num-integer-devel = " \
 cargo \
 rust \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
