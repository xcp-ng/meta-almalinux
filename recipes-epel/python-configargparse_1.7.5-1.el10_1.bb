# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-configargparse"
PV = "1.7.5"
PR = "1.el10_1"
PACKAGES = " \
 python3-configargparse \
 python3-configargparse+yaml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-configargparse-1.7.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea603cd72f3a250d78ff8000a1f3dd41ff0f912bf86f61b7950f5c9b6cb72522"

URI_x86_64_v2_python3-configargparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-configargparse-1.7.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-configargparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-configargparse}"
SRC_URI[x86_64_v2_python3-configargparse.sha256sum] = "6b506c7a81eb4d1c53956175f15abffd87dde50054352aa7ecc1b01bb45018e3"

URI_x86_64_v2_python3-configargparse+yaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-configargparse+yaml-1.7.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-configargparse+yaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-configargparse+yaml}"
SRC_URI[x86_64_v2_python3-configargparse+yaml.sha256sum] = "8097e7324f7675cf3cb674c62f20b83870c32772805484f9e68f0ee6534588d8"

URI_aarch64_python3-configargparse = "${EPEL_MIRROR}/aarch64/Packages/p/python3-configargparse-1.7.5-1.el10_1.noarch.rpm;name=aarch64_python3-configargparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-configargparse}"
SRC_URI[aarch64_python3-configargparse.sha256sum] = "a8b64b4b68ec82de716b8c9956430ed1a48508a2487fb22c8d08e95b8b74ab66"

URI_aarch64_python3-configargparse+yaml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-configargparse+yaml-1.7.5-1.el10_1.noarch.rpm;name=aarch64_python3-configargparse+yaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-configargparse+yaml}"
SRC_URI[aarch64_python3-configargparse+yaml.sha256sum] = "4ceb9f9ff50619985e4b3858e9b277e14be9e517efbfec2e495a85c9e87f1dce"

RDEPENDS:python3-configargparse = " \
 python3 \
 "
RDEPENDS:python3-configargparse+yaml = " \
 python3 \
 python3-configargparse \
 python3-pyyaml \
 "
