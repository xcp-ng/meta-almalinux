# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uresourced"
PV = "0.5.4"
PR = "4.el10"
PACKAGES = " \
 uresourced \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/uresourced-0.5.4-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69774869713bd2560620dc7f9c1f7a9df771b1878c09210ea6c2fb8ef365a47b"

URI_x86_64_v2_uresourced = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/uresourced-0.5.4-4.el10.x86_64_v2.rpm;name=x86_64_v2_uresourced;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uresourced}"
SRC_URI[x86_64_v2_uresourced.sha256sum] = "d194ecc505405145b836bf560532e5718721b859053cd97917b726498692f1b9"

URI_aarch64_uresourced = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/uresourced-0.5.4-4.el10.aarch64.rpm;name=aarch64_uresourced;unpack=0"
SRC_URI:append = " ${URI_aarch64_uresourced}"
SRC_URI[aarch64_uresourced.sha256sum] = "cf21a34515953d732833f27b43eb36bba88f8fb081fc72163ed855f59d4d0e69"

RDEPENDS:uresourced = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 pipewire-libs \
 systemd-libs \
 "
