# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "license-validate"
PV = "25"
PR = "2.el10_0"
PACKAGES = " \
 license-validate \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/license-validate-25-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3e223deea183daa72460de96346f918f75ffc3b626d03df73eedcb30e9182186"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/license-validate-25-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_license-validate;unpack=0"
SRC_URI[x86_64_v2_license-validate.sha256sum] = "0c1b03574392a13d649d07a72e3d9da42635ad33f98984acd148bf523696fa9c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/license-validate-25-2.el10_0.noarch.rpm;name=aarch64_license-validate;unpack=0"
SRC_URI[aarch64_license-validate.sha256sum] = "193c361bede37febc961ed1e383f39b52b80edc8a16eafcaf56b16f887431400"

RDEPENDS:license-validate = " \
 fedora-license-data \
 python3 \
 python3-lark \
 "
