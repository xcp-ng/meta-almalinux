# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lshw"
PV = "B.02.20"
PR = "6.el10"
PACKAGES = " \
 lshw \
 lshw-gui \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lshw-B.02.20-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fda489245b65782927ec2bdef32f166e54a12d0bc689f9e371835fb2b82ec207"

URI_x86_64_v2_lshw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lshw-B.02.20-6.el10.x86_64_v2.rpm;name=x86_64_v2_lshw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lshw}"
SRC_URI[x86_64_v2_lshw.sha256sum] = "220ebe05c3b3e4a33247ee3f8f745df1e04ad8bc02d088ceaf25a48297cf2afb"

URI_x86_64_v2_lshw-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lshw-gui-B.02.20-6.el10.x86_64_v2.rpm;name=x86_64_v2_lshw-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lshw-gui}"
SRC_URI[x86_64_v2_lshw-gui.sha256sum] = "5db019bd8ed72003086d1340bead980e27631bde5013b5a35ac8f0d8e11a7ea8"

URI_aarch64_lshw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lshw-B.02.20-6.el10.aarch64.rpm;name=aarch64_lshw;unpack=0"
SRC_URI:append = " ${URI_aarch64_lshw}"
SRC_URI[aarch64_lshw.sha256sum] = "d318820ae221df66ebb0af1f657af92cdc9868f2474e89ed8ef5e0b889bacfde"

URI_aarch64_lshw-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lshw-gui-B.02.20-6.el10.aarch64.rpm;name=aarch64_lshw-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_lshw-gui}"
SRC_URI[aarch64_lshw-gui.sha256sum] = "83effce3d0c3f02830bd816d0dc3106a70d86e753e2327829656a1037f140227"

RDEPENDS:lshw = " \
 glibc \
 hwdata \
 libgcc \
 libstdc++ \
 sqlite-libs \
 "
RDEPENDS:lshw-gui = " \
 bash \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libgcc \
 libstdc++ \
 lshw \
 polkit \
 sqlite-libs \
 "
