# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openssh"
PV = "9.9p1"
PR = "28.el10_2.alma.1"
PACKAGES = " \
 openssh \
 openssh-askpass \
 openssh-clients \
 openssh-keycat \
 openssh-keysign \
 openssh-server \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openssh-9.9p1-28.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5e5da85452c0b60090007372b5a2f898dc91f30401921aa2a26b03a1980c020a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-9.9p1-28.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh;unpack=0"
SRC_URI[x86_64_v2_openssh.sha256sum] = "bae956cd98b399616e94d0dfff2417d67c65545d570ed92e8f70f0d125b03628"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssh-askpass-9.9p1-28.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-askpass;unpack=0"
SRC_URI[x86_64_v2_openssh-askpass.sha256sum] = "c8ad2c6ee067358bcdc396fd65d702e96b57c12130354888ec823019343bcdae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-clients-9.9p1-28.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-clients;unpack=0"
SRC_URI[x86_64_v2_openssh-clients.sha256sum] = "6125657c973cd3931f8b0b71f854f70234a645dfee31006008ada1e3e96dbb68"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-keycat-9.9p1-28.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-keycat;unpack=0"
SRC_URI[x86_64_v2_openssh-keycat.sha256sum] = "35c0cdfd234796a39be78ea5b01eb969462947b7e25249c74cf9e67a129e5f03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssh-keysign-9.9p1-28.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-keysign;unpack=0"
SRC_URI[x86_64_v2_openssh-keysign.sha256sum] = "3097ebb4ac28d09ca50cc03c2773ba80f0ba7810c777edfb4bf7115305360216"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-server-9.9p1-28.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-server;unpack=0"
SRC_URI[x86_64_v2_openssh-server.sha256sum] = "978c70f3b12a7de0258605c9ad765097096b3574f5200fcfb6b08c39aa1c7d91"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-9.9p1-28.el10_2.alma.1.aarch64.rpm;name=aarch64_openssh;unpack=0"
SRC_URI[aarch64_openssh.sha256sum] = "ad8294f3aef5cf176714c76f93d1a2f4acf1d4fe983198957996e1a843015e4e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssh-askpass-9.9p1-28.el10_2.alma.1.aarch64.rpm;name=aarch64_openssh-askpass;unpack=0"
SRC_URI[aarch64_openssh-askpass.sha256sum] = "97686d76136b9ec90fa056a969307a864637c0c09c094dd56ca7b17fe91c0824"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-clients-9.9p1-28.el10_2.alma.1.aarch64.rpm;name=aarch64_openssh-clients;unpack=0"
SRC_URI[aarch64_openssh-clients.sha256sum] = "3ef1eaca68db9d9364e9761692a7bcf3f9f9dde597167c629932385b06d3dfc5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-keycat-9.9p1-28.el10_2.alma.1.aarch64.rpm;name=aarch64_openssh-keycat;unpack=0"
SRC_URI[aarch64_openssh-keycat.sha256sum] = "0dc6d8b9d88cb2d69078b45b148e61a27cce68c43a5ab95c6b2846665150dcaa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssh-keysign-9.9p1-28.el10_2.alma.1.aarch64.rpm;name=aarch64_openssh-keysign;unpack=0"
SRC_URI[aarch64_openssh-keysign.sha256sum] = "ef366fdbf894c71976aab84f5b96f441aa2d9d0da5991325eebeba36a8696d75"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-server-9.9p1-28.el10_2.alma.1.aarch64.rpm;name=aarch64_openssh-server;unpack=0"
SRC_URI[aarch64_openssh-server.sha256sum] = "f3d0ecdf47d2f21a04a7eccb6245446ea4f3a76428a4915a048684290ec42fe5"

RDEPENDS:openssh = " \
 audit-libs \
 glibc \
 libselinux \
 openssl-libs \
 util-linux \
 "
RDEPENDS:openssh-askpass = " \
 glib2 \
 glibc \
 gtk3 \
 openssh \
 "
RDEPENDS:openssh-clients = " \
 bash \
 crypto-policies \
 glibc \
 krb5-libs \
 libedit \
 libfido2 \
 libselinux \
 openssh \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:openssh-keycat = " \
 glibc \
 openssh \
 pam-libs \
 "
RDEPENDS:openssh-keysign = " \
 glibc \
 openssh \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:openssh-server = " \
 audit-libs \
 bash \
 crypto-policies \
 glibc \
 krb5-libs \
 libcom_err \
 libselinux \
 libxcrypt \
 openssh \
 openssl-libs \
 pam \
 pam-libs \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
