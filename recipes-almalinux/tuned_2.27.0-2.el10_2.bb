# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tuned"
PV = "2.27.0"
PR = "2.el10_2"
PACKAGES = " \
 tuned \
 tuned-gtk \
 tuned-ppd \
 tuned-profiles-atomic \
 tuned-profiles-cpu-partitioning \
 tuned-profiles-mssql \
 tuned-profiles-oracle \
 tuned-profiles-postgresql \
 tuned-profiles-spectrumscale \
 tuned-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tuned-2.27.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f05c545e446a600678ede1df63c59bfb7058ab2a8309ce038f8b2dde6c6e944"

URI_x86_64_v2_tuned = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tuned-2.27.0-2.el10_2.noarch.rpm;name=x86_64_v2_tuned;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned}"
SRC_URI[x86_64_v2_tuned.sha256sum] = "91790676b140d318e470e8312ae64f4896306ec8a349ade1ef5b696ae7ebed6b"

URI_x86_64_v2_tuned-gtk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-gtk-2.27.0-2.el10_2.noarch.rpm;name=x86_64_v2_tuned-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-gtk}"
SRC_URI[x86_64_v2_tuned-gtk.sha256sum] = "8375a1e3999853ecb12fa17a791e1224babfe70589c5572b6e227c65b9f75fff"

URI_x86_64_v2_tuned-ppd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-ppd-2.27.0-2.el10_2.noarch.rpm;name=x86_64_v2_tuned-ppd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-ppd}"
SRC_URI[x86_64_v2_tuned-ppd.sha256sum] = "6956324054a9f81f12c501e392ccbbf6821d16b76bd2662c88f55dec73956dd7"

URI_x86_64_v2_tuned-profiles-atomic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-atomic-2.27.0-2.el10_2.noarch.rpm;name=x86_64_v2_tuned-profiles-atomic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-atomic}"
SRC_URI[x86_64_v2_tuned-profiles-atomic.sha256sum] = "413556d5be868815577994a19487a3612dc39b1a4ad3dac116668ab50a2177de"

URI_x86_64_v2_tuned-profiles-cpu-partitioning = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tuned-profiles-cpu-partitioning-2.27.0-2.el10_2.noarch.rpm;name=x86_64_v2_tuned-profiles-cpu-partitioning;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-cpu-partitioning}"
SRC_URI[x86_64_v2_tuned-profiles-cpu-partitioning.sha256sum] = "33ea81c70fe42a6b76f1405def3ab1f3d60b583e9edac9491b3d71b803fe10c1"

URI_x86_64_v2_tuned-profiles-mssql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-mssql-2.27.0-2.el10_2.noarch.rpm;name=x86_64_v2_tuned-profiles-mssql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-mssql}"
SRC_URI[x86_64_v2_tuned-profiles-mssql.sha256sum] = "8e9b21558aa6d2f29466827898f21f2913c2d5c2fa47099802a8e8a0b4983d41"

URI_x86_64_v2_tuned-profiles-oracle = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-oracle-2.27.0-2.el10_2.noarch.rpm;name=x86_64_v2_tuned-profiles-oracle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-oracle}"
SRC_URI[x86_64_v2_tuned-profiles-oracle.sha256sum] = "a982296984e19f388c6b6410b7750d03a5c2508cc626810f2600c3b6a598310a"

URI_x86_64_v2_tuned-profiles-postgresql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-postgresql-2.27.0-2.el10_2.noarch.rpm;name=x86_64_v2_tuned-profiles-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-postgresql}"
SRC_URI[x86_64_v2_tuned-profiles-postgresql.sha256sum] = "3d9db9152a5ce6cc6884f137c314567dd227d8af86c958a488072590fa31f2db"

URI_x86_64_v2_tuned-profiles-spectrumscale = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-spectrumscale-2.27.0-2.el10_2.noarch.rpm;name=x86_64_v2_tuned-profiles-spectrumscale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-spectrumscale}"
SRC_URI[x86_64_v2_tuned-profiles-spectrumscale.sha256sum] = "4f906ec4e8be9c99e154f4725cdc7174b3a246113951dd13482a59e760a9e7ef"

URI_x86_64_v2_tuned-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-utils-2.27.0-2.el10_2.noarch.rpm;name=x86_64_v2_tuned-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-utils}"
SRC_URI[x86_64_v2_tuned-utils.sha256sum] = "59595223bfa8c1b0b4238afebb434d2b833bc85f36980da31f33f8eadf4743e5"

URI_aarch64_tuned = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tuned-2.27.0-2.el10_2.noarch.rpm;name=aarch64_tuned;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned}"
SRC_URI[aarch64_tuned.sha256sum] = "91790676b140d318e470e8312ae64f4896306ec8a349ade1ef5b696ae7ebed6b"

URI_aarch64_tuned-gtk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-gtk-2.27.0-2.el10_2.noarch.rpm;name=aarch64_tuned-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-gtk}"
SRC_URI[aarch64_tuned-gtk.sha256sum] = "8375a1e3999853ecb12fa17a791e1224babfe70589c5572b6e227c65b9f75fff"

URI_aarch64_tuned-ppd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-ppd-2.27.0-2.el10_2.noarch.rpm;name=aarch64_tuned-ppd;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-ppd}"
SRC_URI[aarch64_tuned-ppd.sha256sum] = "6956324054a9f81f12c501e392ccbbf6821d16b76bd2662c88f55dec73956dd7"

URI_aarch64_tuned-profiles-atomic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-atomic-2.27.0-2.el10_2.noarch.rpm;name=aarch64_tuned-profiles-atomic;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-atomic}"
SRC_URI[aarch64_tuned-profiles-atomic.sha256sum] = "413556d5be868815577994a19487a3612dc39b1a4ad3dac116668ab50a2177de"

URI_aarch64_tuned-profiles-cpu-partitioning = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tuned-profiles-cpu-partitioning-2.27.0-2.el10_2.noarch.rpm;name=aarch64_tuned-profiles-cpu-partitioning;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-cpu-partitioning}"
SRC_URI[aarch64_tuned-profiles-cpu-partitioning.sha256sum] = "33ea81c70fe42a6b76f1405def3ab1f3d60b583e9edac9491b3d71b803fe10c1"

URI_aarch64_tuned-profiles-mssql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-mssql-2.27.0-2.el10_2.noarch.rpm;name=aarch64_tuned-profiles-mssql;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-mssql}"
SRC_URI[aarch64_tuned-profiles-mssql.sha256sum] = "8e9b21558aa6d2f29466827898f21f2913c2d5c2fa47099802a8e8a0b4983d41"

URI_aarch64_tuned-profiles-oracle = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-oracle-2.27.0-2.el10_2.noarch.rpm;name=aarch64_tuned-profiles-oracle;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-oracle}"
SRC_URI[aarch64_tuned-profiles-oracle.sha256sum] = "a982296984e19f388c6b6410b7750d03a5c2508cc626810f2600c3b6a598310a"

URI_aarch64_tuned-profiles-postgresql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-postgresql-2.27.0-2.el10_2.noarch.rpm;name=aarch64_tuned-profiles-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-postgresql}"
SRC_URI[aarch64_tuned-profiles-postgresql.sha256sum] = "3d9db9152a5ce6cc6884f137c314567dd227d8af86c958a488072590fa31f2db"

URI_aarch64_tuned-profiles-spectrumscale = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-spectrumscale-2.27.0-2.el10_2.noarch.rpm;name=aarch64_tuned-profiles-spectrumscale;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-spectrumscale}"
SRC_URI[aarch64_tuned-profiles-spectrumscale.sha256sum] = "4f906ec4e8be9c99e154f4725cdc7174b3a246113951dd13482a59e760a9e7ef"

URI_aarch64_tuned-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-utils-2.27.0-2.el10_2.noarch.rpm;name=aarch64_tuned-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-utils}"
SRC_URI[aarch64_tuned-utils.sha256sum] = "59595223bfa8c1b0b4238afebb434d2b833bc85f36980da31f33f8eadf4743e5"

RDEPENDS:tuned = " \
 bash \
 dbus \
 ethtool \
 gawk \
 hdparm \
 iproute \
 kmod \
 polkit \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-inotify \
 python3-linux-procfs \
 python3-pyudev \
 systemd \
 util-linux \
 virt-what \
 "
RDEPENDS:tuned-gtk = " \
 polkit \
 powertop \
 python3 \
 python3-gobject-base \
 tuned \
 "
RDEPENDS:tuned-ppd = " \
 bash \
 python3 \
 tuned \
 "
RDEPENDS:tuned-profiles-atomic = " \
 tuned \
 "
RDEPENDS:tuned-profiles-cpu-partitioning = " \
 bash \
 tuned \
 "
RDEPENDS:tuned-profiles-mssql = " \
 tuned \
 "
RDEPENDS:tuned-profiles-oracle = " \
 tuned \
 "
RDEPENDS:tuned-profiles-postgresql = " \
 tuned \
 "
RDEPENDS:tuned-profiles-spectrumscale = " \
 tuned \
 "
RDEPENDS:tuned-utils = " \
 powertop \
 python3 \
 tuned \
 "
