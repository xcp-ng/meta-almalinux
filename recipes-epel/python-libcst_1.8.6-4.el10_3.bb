# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-libcst"
PV = "1.8.6"
PR = "4.el10_3"
PACKAGES = " \
 python3-libcst \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-libcst-1.8.6-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59ecef29252cd16c9a6ec38bceeee2a6c8dda50c84efbe81e2275622b80abcd2"

URI_x86_64_v2_python3-libcst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libcst-1.8.6-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-libcst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libcst}"
SRC_URI[x86_64_v2_python3-libcst.sha256sum] = "d87593549c6cb0d461bb794758e007dcc3bcb7d3c2a7217b360ec8724d54285f"

URI_aarch64_python3-libcst = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libcst-1.8.6-4.el10_3.aarch64.rpm;name=aarch64_python3-libcst;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libcst}"
SRC_URI[aarch64_python3-libcst.sha256sum] = "065af946b4b882b2eaa17bfef83b737b049d9127a4e8f97e385600bac9ceb268"

RDEPENDS:python3-libcst = " \
 glibc \
 libgcc \
 python3 \
 python3-pyyaml \
 "
