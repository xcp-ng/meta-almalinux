# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ajsonrpc"
PV = "1.2.0"
PR = "12.el10_1"
PACKAGES = " \
 python3-ajsonrpc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ajsonrpc-1.2.0-12.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81c4c151b9e456f323559000b77c259c20bf34fea10f39be2bee734d60a5c80e"

URI_x86_64_v2_python3-ajsonrpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ajsonrpc-1.2.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ajsonrpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ajsonrpc}"
SRC_URI[x86_64_v2_python3-ajsonrpc.sha256sum] = "a299eae14861e61b58d1bcede856d0436ec8dde81fceee15efa03a8bfb7b7b9c"

URI_aarch64_python3-ajsonrpc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ajsonrpc-1.2.0-12.el10_1.noarch.rpm;name=aarch64_python3-ajsonrpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ajsonrpc}"
SRC_URI[aarch64_python3-ajsonrpc.sha256sum] = "22a669663e79e2b77188bcbdece6952ce7d2f3ab23920dec65f84da9fb184019"

RDEPENDS:python3-ajsonrpc = " \
 python3 \
 "
