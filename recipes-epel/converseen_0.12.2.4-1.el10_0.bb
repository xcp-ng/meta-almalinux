# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "converseen"
PV = "0.12.2.4"
PR = "1.el10_0"
PACKAGES = " \
 converseen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/converseen-0.12.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2d7af2ea4565e91f7969ee184c75530f0985f86e3f980e9b0537090d7b0ab88"

URI_x86_64_v2_converseen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/converseen-0.12.2.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_converseen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_converseen}"
SRC_URI[x86_64_v2_converseen.sha256sum] = "4a18c9a700836787f3cadc0e521d70809e7367f70528a8b72f595fa540a755b8"

URI_aarch64_converseen = "${EPEL_MIRROR}/aarch64/Packages/c/converseen-0.12.2.4-1.el10_0.aarch64.rpm;name=aarch64_converseen;unpack=0"
SRC_URI:append = " ${URI_aarch64_converseen}"
SRC_URI[aarch64_converseen.sha256sum] = "08d82e64ae97393b30325f5fa1888e06539eeb583d93c44dc0cf8100e9ff6d57"

RDEPENDS:converseen = " \
 ImageMagick-c++ \
 ImageMagick-libs \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
