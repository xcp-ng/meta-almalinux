# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "procmail"
PV = "3.24"
PR = "8.el10"
PACKAGES = " \
 procmail \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/procmail-3.24-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7538c3dbddfa938eb5eb031edd023a14eb6e0fcd07849e11e4665e0b8b581fd"

URI_x86_64_v2_procmail = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/procmail-3.24-8.el10.x86_64_v2.rpm;name=x86_64_v2_procmail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_procmail}"
SRC_URI[x86_64_v2_procmail.sha256sum] = "d77eb28eea74da38e6ff51f0bc3704075124528b43082c2cbd13481c70237690"

URI_aarch64_procmail = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/procmail-3.24-8.el10.aarch64.rpm;name=aarch64_procmail;unpack=0"
SRC_URI:append = " ${URI_aarch64_procmail}"
SRC_URI[aarch64_procmail.sha256sum] = "8839fed0fa1226055bf396543578fc934fb4920c40c685946a99fb5083c8dbe2"

RDEPENDS:procmail = " \
 bash \
 glibc \
 "
