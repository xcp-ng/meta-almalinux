# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_date"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_date+default-devel \
 rust-uu_date+i18n-datetime-devel \
 rust-uu_date-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_date-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "975f64eb8d368bf34c922d244078fbf070596b79aeb05f1f15d68818ba3f0c51"

URI_x86_64_v2_rust-uu_date+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_date+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_date+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_date+default-devel}"
SRC_URI[x86_64_v2_rust-uu_date+default-devel.sha256sum] = "87f66541b8d0176a1ec5b70841bbe00ec8aab187e13bbea8f51cb2155c46fbf9"

URI_x86_64_v2_rust-uu_date+i18n-datetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_date+i18n-datetime-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_date+i18n-datetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_date+i18n-datetime-devel}"
SRC_URI[x86_64_v2_rust-uu_date+i18n-datetime-devel.sha256sum] = "1613db07286fd354021cef2f68fcc5e1bcf2c23399a878d8cb6f6177d9a6b830"

URI_x86_64_v2_rust-uu_date-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_date-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_date-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_date-devel}"
SRC_URI[x86_64_v2_rust-uu_date-devel.sha256sum] = "e64b5c7936a7820c7713a4acd62ed5ee651d8f913d9da3f2e0d3fe5a0db9e553"

URI_aarch64_rust-uu_date+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_date+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_date+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_date+default-devel}"
SRC_URI[aarch64_rust-uu_date+default-devel.sha256sum] = "32b545b756535d6fb0c67a429cbc9ce242cd0d3154d98498f0264c66274db7a4"

URI_aarch64_rust-uu_date+i18n-datetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_date+i18n-datetime-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_date+i18n-datetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_date+i18n-datetime-devel}"
SRC_URI[aarch64_rust-uu_date+i18n-datetime-devel.sha256sum] = "1c5b86936090b91e8b2cee1765b216854e4b1b82b74005f0283b1b077fcf2299"

URI_aarch64_rust-uu_date-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_date-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_date-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_date-devel}"
SRC_URI[aarch64_rust-uu_date-devel.sha256sum] = "5cabf16551f08a7c094e107aa9c6ab86fde5f51122b2bb224c3b7900c046e0cf"

RDEPENDS:rust-uu_date+default-devel = " \
 cargo \
 rust-uu_date+i18n-datetime-devel \
 rust-uu_date-devel \
 "
RDEPENDS:rust-uu_date+i18n-datetime-devel = " \
 cargo \
 rust-icu_calendar+default-devel \
 rust-icu_locale+default-devel \
 rust-jiff-icu+default-devel \
 rust-uu_date-devel \
 rust-uucore+i18n-datetime-devel \
 "
RDEPENDS:rust-uu_date-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-jiff+default-devel \
 rust-jiff+tzdb-bundle-platform-devel \
 rust-jiff+tzdb-concatenated-devel \
 rust-jiff+tzdb-zoneinfo-devel \
 rust-nix0.30+time-devel \
 rust-nix0.30-devel \
 rust-parse_datetime+default-devel \
 rust-regex+default-devel \
 rust-uucore+default-devel \
 rust-uucore+i18n-datetime-devel \
 rust-uucore+parser-devel \
 "
