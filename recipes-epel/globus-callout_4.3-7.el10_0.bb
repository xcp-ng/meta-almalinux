# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-callout"
PV = "4.3"
PR = "7.el10_0"
PACKAGES = " \
 globus-callout \
 globus-callout-devel \
 globus-callout-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-callout-4.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "596008cf749bd0994b030809ee59976984411b6bb40cc594f867bae7de09beda"

URI_x86_64_v2_globus-callout = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-callout-4.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-callout;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-callout}"
SRC_URI[x86_64_v2_globus-callout.sha256sum] = "61eff83491cdd3d7a6eb6d1c354e93a5891cd839e61fae63364e90b2746db38a"

URI_x86_64_v2_globus-callout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-callout-devel-4.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-callout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-callout-devel}"
SRC_URI[x86_64_v2_globus-callout-devel.sha256sum] = "60fa850057f5180755a5791cbe7b454ab9cdd02b2800c01f9b64bc577ecbf8f9"

URI_x86_64_v2_globus-callout-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-callout-doc-4.3-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-callout-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-callout-doc}"
SRC_URI[x86_64_v2_globus-callout-doc.sha256sum] = "69d9de7c36a4b28ac8ef3230495dd37edecd4812fc640eec2c9495e0a7b2bc2b"

URI_aarch64_globus-callout = "${EPEL_MIRROR}/aarch64/Packages/g/globus-callout-4.3-7.el10_0.aarch64.rpm;name=aarch64_globus-callout;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-callout}"
SRC_URI[aarch64_globus-callout.sha256sum] = "ce64311b3c9e8946187216e67bb200a483ca0022bf092729ea9c9312317ba656"

URI_aarch64_globus-callout-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-callout-devel-4.3-7.el10_0.aarch64.rpm;name=aarch64_globus-callout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-callout-devel}"
SRC_URI[aarch64_globus-callout-devel.sha256sum] = "89b0412bd8c58b16b90c00843fcefe9b704143ef1feaefd7a53c73497f2f6d18"

URI_aarch64_globus-callout-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-callout-doc-4.3-7.el10_0.noarch.rpm;name=aarch64_globus-callout-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-callout-doc}"
SRC_URI[aarch64_globus-callout-doc.sha256sum] = "9ac8b75546260abded61c5fe339f882a1607a182c08a712b3333866e059ab9d1"

RDEPENDS:globus-callout = " \
 glibc \
 globus-common \
 libtool-ltdl \
 "
RDEPENDS:globus-callout-devel = " \
 globus-callout \
 globus-common-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-callout-doc = " \
 "
