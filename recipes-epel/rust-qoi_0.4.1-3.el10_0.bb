# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-qoi"
PV = "0.4.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-qoi+alloc-devel \
 rust-qoi+default-devel \
 rust-qoi+reference-devel \
 rust-qoi+std-devel \
 rust-qoi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-qoi-0.4.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "febe6177972d52cac4915ef570375cf4665c755fe798e0fcd65352d29b93e0b6"

URI_x86_64_v2_rust-qoi+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-qoi+alloc-devel-0.4.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-qoi+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-qoi+alloc-devel}"
SRC_URI[x86_64_v2_rust-qoi+alloc-devel.sha256sum] = "41fdcbf3ff21b75b2c9b19baf6be2fdd67f85dea079b82244898b15ca17154c9"

URI_x86_64_v2_rust-qoi+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-qoi+default-devel-0.4.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-qoi+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-qoi+default-devel}"
SRC_URI[x86_64_v2_rust-qoi+default-devel.sha256sum] = "ef8f090751d5848cbabaf8cd3792e63bd40a10f188e7a31ea988996489d740e9"

URI_x86_64_v2_rust-qoi+reference-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-qoi+reference-devel-0.4.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-qoi+reference-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-qoi+reference-devel}"
SRC_URI[x86_64_v2_rust-qoi+reference-devel.sha256sum] = "3c44cec00af77edd780a61788b39d21d50fe20377d31b9f7b4d2f1a0ea2fd81a"

URI_x86_64_v2_rust-qoi+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-qoi+std-devel-0.4.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-qoi+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-qoi+std-devel}"
SRC_URI[x86_64_v2_rust-qoi+std-devel.sha256sum] = "950e7ee10fd4c3014003d25a60a1b4d44c8dca967e75e4cd58e4aca643ed10bc"

URI_x86_64_v2_rust-qoi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-qoi-devel-0.4.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-qoi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-qoi-devel}"
SRC_URI[x86_64_v2_rust-qoi-devel.sha256sum] = "fe85dc8baefd6b0d02e209bd8b2a8b9535e9f4e850220d3803f85900f5406879"

URI_aarch64_rust-qoi+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-qoi+alloc-devel-0.4.1-3.el10_0.noarch.rpm;name=aarch64_rust-qoi+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-qoi+alloc-devel}"
SRC_URI[aarch64_rust-qoi+alloc-devel.sha256sum] = "39b1e291dbb825749386df99659d9976cbe3e082790319a7534943c7ea4a4c58"

URI_aarch64_rust-qoi+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-qoi+default-devel-0.4.1-3.el10_0.noarch.rpm;name=aarch64_rust-qoi+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-qoi+default-devel}"
SRC_URI[aarch64_rust-qoi+default-devel.sha256sum] = "77bab9309af5fc0ead6006261b802fd4b258bbd289eaf4d343f1a1a98c1374f2"

URI_aarch64_rust-qoi+reference-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-qoi+reference-devel-0.4.1-3.el10_0.noarch.rpm;name=aarch64_rust-qoi+reference-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-qoi+reference-devel}"
SRC_URI[aarch64_rust-qoi+reference-devel.sha256sum] = "78cb23e75270bf392119be484031cb3152e14a598a6df6aaffb2dcdd8babe043"

URI_aarch64_rust-qoi+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-qoi+std-devel-0.4.1-3.el10_0.noarch.rpm;name=aarch64_rust-qoi+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-qoi+std-devel}"
SRC_URI[aarch64_rust-qoi+std-devel.sha256sum] = "2a19222ecfa0736f9794b57ddff0ccff5be2f8d3566ff0b4df3c0be2034e1aa4"

URI_aarch64_rust-qoi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-qoi-devel-0.4.1-3.el10_0.noarch.rpm;name=aarch64_rust-qoi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-qoi-devel}"
SRC_URI[aarch64_rust-qoi-devel.sha256sum] = "d648338435a834d77cec43c01678b19859bd6862c7eb05e4ee64e6cfeac99ccf"

RDEPENDS:rust-qoi+alloc-devel = " \
 cargo \
 rust-qoi-devel \
 "
RDEPENDS:rust-qoi+default-devel = " \
 cargo \
 rust-qoi+std-devel \
 rust-qoi-devel \
 "
RDEPENDS:rust-qoi+reference-devel = " \
 cargo \
 rust-qoi-devel \
 "
RDEPENDS:rust-qoi+std-devel = " \
 cargo \
 rust-qoi-devel \
 "
RDEPENDS:rust-qoi-devel = " \
 cargo \
 rust \
 rust-bytemuck+default-devel \
 "
