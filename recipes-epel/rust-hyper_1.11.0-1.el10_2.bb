# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hyper"
PV = "1.11.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-hyper+capi-devel \
 rust-hyper+client-devel \
 rust-hyper+default-devel \
 rust-hyper+ffi-devel \
 rust-hyper+full-devel \
 rust-hyper+http1-devel \
 rust-hyper+http2-devel \
 rust-hyper+server-devel \
 rust-hyper+tracing-devel \
 rust-hyper-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hyper-1.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7424ee15a24a4d3bf07c5dcd31f99d20f1aed478af3f215a988b818f29a93748"

URI_x86_64_v2_rust-hyper+capi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+capi-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+capi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+capi-devel}"
SRC_URI[x86_64_v2_rust-hyper+capi-devel.sha256sum] = "ce92442e20058287fdbb6b451265b77b3724e777155d44e1f5a0156618c7084f"

URI_x86_64_v2_rust-hyper+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+client-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+client-devel}"
SRC_URI[x86_64_v2_rust-hyper+client-devel.sha256sum] = "3e627cf66136ddf0045c98f10585f3348fb85283607b4c6c07a7632b783f6ffe"

URI_x86_64_v2_rust-hyper+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+default-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+default-devel}"
SRC_URI[x86_64_v2_rust-hyper+default-devel.sha256sum] = "49511e8d3528c7950cb02f28f288759a2d845fff29ac177adc993ff561332cd1"

URI_x86_64_v2_rust-hyper+ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+ffi-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+ffi-devel}"
SRC_URI[x86_64_v2_rust-hyper+ffi-devel.sha256sum] = "2ee3b8bed955e1a530af01062dc9e8df721c81d5ca5c3e1807ef88c429485c5c"

URI_x86_64_v2_rust-hyper+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+full-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+full-devel}"
SRC_URI[x86_64_v2_rust-hyper+full-devel.sha256sum] = "65ade2b2cf5ac4ff3ce0c0f73a63ea9814f14df3bcabd2b7bb85dc69e4b1daf4"

URI_x86_64_v2_rust-hyper+http1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+http1-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+http1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+http1-devel}"
SRC_URI[x86_64_v2_rust-hyper+http1-devel.sha256sum] = "9b47ffb7b87a0d210a4631dd13f8d2bbbf6ff6f2b22b308970adaa922628e6e6"

URI_x86_64_v2_rust-hyper+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+http2-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+http2-devel}"
SRC_URI[x86_64_v2_rust-hyper+http2-devel.sha256sum] = "9ad8275dd8869f257e0d6111e334f7ae14633e7943f874740321ad77aeb5f179"

URI_x86_64_v2_rust-hyper+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+server-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+server-devel}"
SRC_URI[x86_64_v2_rust-hyper+server-devel.sha256sum] = "3ba4440f7bc984bd23b7e5fc3f755237616a0d88feb8fb57ad6b3486bdea30a2"

URI_x86_64_v2_rust-hyper+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+tracing-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+tracing-devel}"
SRC_URI[x86_64_v2_rust-hyper+tracing-devel.sha256sum] = "be8eab66ec1cb89c9550b5537e6ca378feec8b64977440dbbfbb04f0ae7adf19"

URI_x86_64_v2_rust-hyper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-devel}"
SRC_URI[x86_64_v2_rust-hyper-devel.sha256sum] = "9519ec0cd1dbdb4e525fc248c183b3722d02fac271053386eac8f657ed93c387"

URI_aarch64_rust-hyper+capi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+capi-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+capi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+capi-devel}"
SRC_URI[aarch64_rust-hyper+capi-devel.sha256sum] = "7ffc4e229bb4465dbecb3e4bc523ceb026d5e2244b7964998c6a4cd07345fc13"

URI_aarch64_rust-hyper+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+client-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+client-devel}"
SRC_URI[aarch64_rust-hyper+client-devel.sha256sum] = "4de5766de12a26e1648087d18e3bf280547a78d88481ad6885ac6c2e885a060b"

URI_aarch64_rust-hyper+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+default-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+default-devel}"
SRC_URI[aarch64_rust-hyper+default-devel.sha256sum] = "eab825c1e5f0ff4d8484683f6f128df2057e089fc80add2d4ae1f6ab0252f9db"

URI_aarch64_rust-hyper+ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+ffi-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+ffi-devel}"
SRC_URI[aarch64_rust-hyper+ffi-devel.sha256sum] = "6e0ed6b23b70612ee44032bdb6af643fa7577b31eb8f4e62032c2246606ffd4f"

URI_aarch64_rust-hyper+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+full-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+full-devel}"
SRC_URI[aarch64_rust-hyper+full-devel.sha256sum] = "a505d652af6ccd3936a507a6607138b040e42816e9d77805272a17e43e67fc9c"

URI_aarch64_rust-hyper+http1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+http1-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+http1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+http1-devel}"
SRC_URI[aarch64_rust-hyper+http1-devel.sha256sum] = "eca6795e6c22bbfd428d0b4345902b87180cfa3171b975e302190947656118aa"

URI_aarch64_rust-hyper+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+http2-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+http2-devel}"
SRC_URI[aarch64_rust-hyper+http2-devel.sha256sum] = "69932cbf38d850c2165a1a8346b4d585edc160bc2bb76b294c3ae3b6d5dd288c"

URI_aarch64_rust-hyper+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+server-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+server-devel}"
SRC_URI[aarch64_rust-hyper+server-devel.sha256sum] = "5932cbaafd4a7bc361e9f1a140110589c9893bf9ad0886e2138c2116f8802c36"

URI_aarch64_rust-hyper+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+tracing-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+tracing-devel}"
SRC_URI[aarch64_rust-hyper+tracing-devel.sha256sum] = "d78b6ddffef1507c1dfe23384b837db50b7affdf87226e27b00b65ae95ab65b3"

URI_aarch64_rust-hyper-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-devel}"
SRC_URI[aarch64_rust-hyper-devel.sha256sum] = "fb8baf26203d11002a9f05fc4fdd81d4ff7a0d7e88a750bd4450f6630124bd25"

RDEPENDS:rust-hyper+capi-devel = " \
 cargo \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+client-devel = " \
 cargo \
 rust-hyper-devel \
 rust-pin-project-lite+default-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 rust-want+default-devel \
 "
RDEPENDS:rust-hyper+default-devel = " \
 cargo \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+ffi-devel = " \
 cargo \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http-body-util+default-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+full-devel = " \
 cargo \
 rust-hyper+client-devel \
 rust-hyper+http1-devel \
 rust-hyper+http2-devel \
 rust-hyper+server-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+http1-devel = " \
 cargo \
 rust-atomic-waker+default-devel \
 rust-futures-channel+default-devel \
 rust-futures-core+default-devel \
 rust-httparse+default-devel \
 rust-hyper-devel \
 rust-itoa+default-devel \
 "
RDEPENDS:rust-hyper+http2-devel = " \
 cargo \
 rust-atomic-waker+default-devel \
 rust-futures-channel+default-devel \
 rust-futures-core+default-devel \
 rust-h2+default-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+server-devel = " \
 cargo \
 rust-httpdate+default-devel \
 rust-hyper-devel \
 rust-pin-project-lite+default-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-hyper+tracing-devel = " \
 cargo \
 rust-hyper-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-hyper-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
