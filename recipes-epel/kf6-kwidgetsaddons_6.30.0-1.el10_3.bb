# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kwidgetsaddons"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kwidgetsaddons \
 kf6-kwidgetsaddons-devel \
 kf6-kwidgetsaddons-doc \
 kf6-kwidgetsaddons-html \
 python3-kf6-kwidgetsaddons \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kwidgetsaddons-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1d59b184055d3f1068d4694a29564776774e087d0c7baaf9c9adefde93a443b1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwidgetsaddons;unpack=0"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons.sha256sum] = "6462742171d337d8f18ca5aeb6fb2cbdf72e487641a38608cfb72b487612a41d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwidgetsaddons-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons-devel.sha256sum] = "0ac2ee1b7b3cc1e39ff8944a364c96746212370c464f06d33aa8f7ae7095d4be"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwidgetsaddons-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons-doc.sha256sum] = "844686b322b8a4ee48c6a6ecbf28713368ef72b33e6142af938b87553a6177da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwidgetsaddons-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons-html.sha256sum] = "8faec9e14e4970ab6ca0b69b50023b29bdaa1662a4966adb3fd3fef9bc45283d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kwidgetsaddons-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kwidgetsaddons;unpack=0"
SRC_URI[x86_64_v2_python3-kf6-kwidgetsaddons.sha256sum] = "c141df0ac65e887c23e3422c7d721abef976ef37535ebec173f453611c11f3fe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kwidgetsaddons;unpack=0"
SRC_URI[aarch64_kf6-kwidgetsaddons.sha256sum] = "c3947b6b5c196fce186e8089b20c2e123f41af85f27919e56197403a630fa001"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kwidgetsaddons-devel;unpack=0"
SRC_URI[aarch64_kf6-kwidgetsaddons-devel.sha256sum] = "119d682010fd34cf8c85f8719d30eb994d802c5a972d9299cb9e2dbf4c9c2d37"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kwidgetsaddons-doc;unpack=0"
SRC_URI[aarch64_kf6-kwidgetsaddons-doc.sha256sum] = "47ec61f55c8232a4a18487ccdb404aa65343aae9464fa0f29f8dd01fbe050297"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kwidgetsaddons-html;unpack=0"
SRC_URI[aarch64_kf6-kwidgetsaddons-html.sha256sum] = "ca9f50ca21dc32b1c2b86392c526bd5a7ddaa4c106cbbf280e8edf005d481566"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kwidgetsaddons-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kwidgetsaddons;unpack=0"
SRC_URI[aarch64_python3-kf6-kwidgetsaddons.sha256sum] = "f3b4729e8280ed6e7518c96b6fab63c3f169ae655d93aaa960e7c9843a536240"

RDEPENDS:kf6-kwidgetsaddons = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kwidgetsaddons-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kwidgetsaddons-doc = " \
 "
RDEPENDS:kf6-kwidgetsaddons-html = " \
 "
RDEPENDS:python3-kf6-kwidgetsaddons = " \
 glibc \
 kf6-kwidgetsaddons \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
