# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "katarakt"
PV = "0.3"
PR = "1.el10_2"
PACKAGES = " \
 katarakt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/katarakt-0.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1a1b7f01b9ef9b2a687b7bb41b2272fc907e4669c0ca4f83cadc04e56a58e89"

URI_x86_64_v2_katarakt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/katarakt-0.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_katarakt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_katarakt}"
SRC_URI[x86_64_v2_katarakt.sha256sum] = "4def5a42f33f9fd93ec91e011e0f27bb3802eeaddfde12e32f83b22e0cdbf059"

URI_aarch64_katarakt = "${EPEL_MIRROR}/aarch64/Packages/k/katarakt-0.3-1.el10_2.aarch64.rpm;name=aarch64_katarakt;unpack=0"
SRC_URI:append = " ${URI_aarch64_katarakt}"
SRC_URI[aarch64_katarakt.sha256sum] = "36ab69003c8dac244b41fd67fc1d6458fd4cbc7ce95335667eae95c43b95e9aa"

RDEPENDS:katarakt = " \
 glibc \
 libgcc \
 libstdc++ \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
