# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "testssl"
PV = "3.2.3"
PR = "1.el10_2"
PACKAGES = " \
 testssl \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/testssl-3.2.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "59895504469ddb83cd959eedb286497a5ade5f842feb9008081412ea0c51c954"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/testssl-3.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_testssl;unpack=0"
SRC_URI[x86_64_v2_testssl.sha256sum] = "6cccfd8cdd2104ea03f3c7aed83bdbfe8e2521403984ec08bb8dc761952d1d13"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/testssl-3.2.3-1.el10_2.noarch.rpm;name=aarch64_testssl;unpack=0"
SRC_URI[aarch64_testssl.sha256sum] = "ff30cc53939612ac7df918f9d3af22ea037a3ad07958b7f7b39b6bd7f8f5c741"

RDEPENDS:testssl = " \
 bash \
 bind-utils \
 ca-certificates \
 gawk \
 glibc-common \
 grep \
 hostname \
 ncurses \
 openssl \
 procps-ng \
 sed \
 util-linux \
 virtual/coreutils \
 "
