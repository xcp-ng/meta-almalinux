# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "compsize"
PV = "1.5^git20250123.d79eacf"
PR = "12.el10"
PACKAGES = " \
 compsize \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/compsize-1.5^git20250123.d79eacf-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc36b9f964c117cff54e22341a8bd6bd8a33d7bbdeba8c9eac06db11951b2c90"

URI_x86_64_v2_compsize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/compsize-1.5^git20250123.d79eacf-12.el10.x86_64_v2.rpm;name=x86_64_v2_compsize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compsize}"
SRC_URI[x86_64_v2_compsize.sha256sum] = "537e062557809ab5afb20f7d882cdeacb3f1337c527d606eaff51a1858a12e30"

URI_aarch64_compsize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/compsize-1.5^git20250123.d79eacf-12.el10.aarch64.rpm;name=aarch64_compsize;unpack=0"
SRC_URI:append = " ${URI_aarch64_compsize}"
SRC_URI[aarch64_compsize.sha256sum] = "436f19d9f4deef6cf126c8e2c85e45329783b2f646ead9d3168ddaa76579c3b0"

RDEPENDS:compsize = " \
 glibc \
 "
