# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-fingertree"
PV = "0.1.5.0"
PR = "9.el10_0"
PACKAGES = " \
 ghc-fingertree \
 ghc-fingertree-devel \
 ghc-fingertree-doc \
 ghc-fingertree-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-fingertree-0.1.5.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7eb81edf96ce2279aff17cc4b5efe4be2908dee285b1932e6d52eeb83f90be8b"

URI_x86_64_v2_ghc-fingertree = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fingertree-0.1.5.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fingertree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fingertree}"
SRC_URI[x86_64_v2_ghc-fingertree.sha256sum] = "92f1d95be025778b5d7a8e38d1d74a9d5ff9b7072ba014386d7b3e36d4f53332"

URI_x86_64_v2_ghc-fingertree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fingertree-devel-0.1.5.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fingertree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fingertree-devel}"
SRC_URI[x86_64_v2_ghc-fingertree-devel.sha256sum] = "a7b63c56671fdcd54e41a375aa726b5be88e808ef7b523f0c7c6f62337cc710a"

URI_x86_64_v2_ghc-fingertree-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fingertree-doc-0.1.5.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-fingertree-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fingertree-doc}"
SRC_URI[x86_64_v2_ghc-fingertree-doc.sha256sum] = "3a704568d20e83fec2f1c1445eb2e951554b3451951f701768dbcdd3bee8a0d4"

URI_x86_64_v2_ghc-fingertree-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fingertree-prof-0.1.5.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fingertree-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fingertree-prof}"
SRC_URI[x86_64_v2_ghc-fingertree-prof.sha256sum] = "b4913ef331690cec2dde0465591625d61a3fe5c2c0402246e2587f877bd6934f"

URI_aarch64_ghc-fingertree = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fingertree-0.1.5.0-9.el10_0.aarch64.rpm;name=aarch64_ghc-fingertree;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fingertree}"
SRC_URI[aarch64_ghc-fingertree.sha256sum] = "2d318b9219ca4c5ed2143a00b3af8050a7b43d4f7ef9146b5958ff389c642f00"

URI_aarch64_ghc-fingertree-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fingertree-devel-0.1.5.0-9.el10_0.aarch64.rpm;name=aarch64_ghc-fingertree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fingertree-devel}"
SRC_URI[aarch64_ghc-fingertree-devel.sha256sum] = "40ba8a8d95a52ce5a2ab0c67a227ad6a153db9b533edb892a0c425522c2ead5f"

URI_aarch64_ghc-fingertree-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fingertree-doc-0.1.5.0-9.el10_0.noarch.rpm;name=aarch64_ghc-fingertree-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fingertree-doc}"
SRC_URI[aarch64_ghc-fingertree-doc.sha256sum] = "39f3c27ccbd16ba01b29a369e2981236537aaa29fa8e39b8b1c1dd89f5dc04a8"

URI_aarch64_ghc-fingertree-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fingertree-prof-0.1.5.0-9.el10_0.aarch64.rpm;name=aarch64_ghc-fingertree-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fingertree-prof}"
SRC_URI[aarch64_ghc-fingertree-prof.sha256sum] = "d2b01847d2d465fb435165189b12423441f06bf38c4f64ec782d3c7e1731a085"

RDEPENDS:ghc-fingertree = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-fingertree-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-fingertree \
 "
RDEPENDS:ghc-fingertree-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-fingertree-prof = " \
 ghc-base-prof \
 ghc-fingertree-devel \
 "
