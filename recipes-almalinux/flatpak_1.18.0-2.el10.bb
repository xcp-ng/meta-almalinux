# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatpak"
PV = "1.18.0"
PR = "2.el10"
PACKAGES = " \
 flatpak \
 flatpak-devel \
 flatpak-libs \
 flatpak-selinux \
 flatpak-session-helper \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/flatpak-1.18.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "adfb8d44e2d42558234bf6edf4559022ffdf02195f1193b36215019bf958303f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-1.18.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak;unpack=0"
SRC_URI[x86_64_v2_flatpak.sha256sum] = "1ec91246e5e7a417cb16e5a77b05910eb36817cc30e3eb87ee82285ba64a4205"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/flatpak-devel-1.18.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak-devel;unpack=0"
SRC_URI[x86_64_v2_flatpak-devel.sha256sum] = "41ef22a1685fc29b3360b8438f37364d8e01d39067cc55d6348865450201919f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-libs-1.18.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak-libs;unpack=0"
SRC_URI[x86_64_v2_flatpak-libs.sha256sum] = "9957ddcfda42495a52df1491d766b422ed746a34b944d5f13a482a38f60bbac8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-selinux-1.18.0-2.el10.noarch.rpm;name=x86_64_v2_flatpak-selinux;unpack=0"
SRC_URI[x86_64_v2_flatpak-selinux.sha256sum] = "83cb85c5bb79107b27b9532ebc8b7df25af616a237f20b0339fb2832a630d0b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-session-helper-1.18.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak-session-helper;unpack=0"
SRC_URI[x86_64_v2_flatpak-session-helper.sha256sum] = "d4e6031a8b6aa2da5d73472f54f5017acdcd3dd5100b10b7ffb5c6613079f2c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-1.18.0-2.el10.aarch64.rpm;name=aarch64_flatpak;unpack=0"
SRC_URI[aarch64_flatpak.sha256sum] = "a0ea69ed65f5cfbe2f202e6402f22a92446f7183384bc702a63420ca2549dfd5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/flatpak-devel-1.18.0-2.el10.aarch64.rpm;name=aarch64_flatpak-devel;unpack=0"
SRC_URI[aarch64_flatpak-devel.sha256sum] = "0f83477fef0212f7db2deef1cf7f284424d759821ae0929e3284762b5ff2311c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-libs-1.18.0-2.el10.aarch64.rpm;name=aarch64_flatpak-libs;unpack=0"
SRC_URI[aarch64_flatpak-libs.sha256sum] = "1587cabae7fd3639e03f16b704311c4e5d49dca647c34648c3ba534d078d0d35"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-selinux-1.18.0-2.el10.noarch.rpm;name=aarch64_flatpak-selinux;unpack=0"
SRC_URI[aarch64_flatpak-selinux.sha256sum] = "83cb85c5bb79107b27b9532ebc8b7df25af616a237f20b0339fb2832a630d0b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-session-helper-1.18.0-2.el10.aarch64.rpm;name=aarch64_flatpak-session-helper;unpack=0"
SRC_URI[aarch64_flatpak-session-helper.sha256sum] = "7cd865f9ffafcee0e5471fe3ac36bd05fa93438ff00aa5ea860a10e08820e5e5"

RDEPENDS:flatpak:x86_64_v2 = " \
 appstream \
 bash \
 bubblewrap \
 dconf \
 flatpak-selinux \
 flatpak-session-helper \
 fuse3 \
 fuse3-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gpgme \
 json-glib \
 libXau \
 libarchive \
 libgcc \
 librsvg2 \
 libseccomp \
 libwayland-client \
 libxml2 \
 libzstd \
 ostree-libs \
 polkit-libs \
 python3 \
 shadow-utils \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__ge_7.29.0 \
 xdg-dbus-proxy \
"
RDEPENDS:flatpak:aarch64 = " \
 appstream \
 bash \
 bubblewrap \
 dconf \
 flatpak-selinux \
 flatpak-session-helper \
 fuse3 \
 fuse3-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gpgme \
 json-glib \
 libXau \
 libarchive \
 libgcc \
 librsvg2 \
 libseccomp \
 libwayland-client \
 libxml2 \
 libzstd \
 ostree-libs \
 polkit-libs \
 python3 \
 shadow-utils \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__ge_7.29.0 \
 xdg-dbus-proxy \
"
RDEPENDS:flatpak-devel = " \
 dconf-devel \
 flatpak \
 flatpak-libs \
 glib2-devel \
 json-glib-devel \
 libXau-devel \
 libarchive-devel \
 libcurl-devel \
 libseccomp-devel \
 libxml2-devel \
 libzstd-devel \
 ostree-devel \
 pkgconf-pkg-config \
 polkit-devel \
 systemd-devel \
 virtual/pkgconfig_gpgme__ge_1.8.0 \
 wayland-devel \
 "
RDEPENDS:flatpak-libs = " \
 bubblewrap \
 dconf \
 glib2 \
 glibc \
 gpgme \
 json-glib \
 libXau \
 libarchive \
 libgcc \
 libseccomp \
 libwayland-client \
 libxml2 \
 libzstd \
 ostree-libs \
 polkit-libs \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:flatpak-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
RDEPENDS:flatpak-session-helper = " \
 glib2 \
 glibc \
 libgcc \
 systemd \
 "
