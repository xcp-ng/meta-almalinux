# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "acpid"
PV = "2.0.34"
PR = "10.el10"
PACKAGES = " \
 acpid \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/acpid-2.0.34-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac8068b1ffab453e588a260434a52fa2b50dd629d6de502e57ee7fef984bdee1"

URI_x86_64_v2_acpid = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/acpid-2.0.34-10.el10.x86_64_v2.rpm;name=x86_64_v2_acpid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_acpid}"
SRC_URI[x86_64_v2_acpid.sha256sum] = "400c5578111dda61e88af2b114968b02f674a9d0e654caed0741700f0bbdc261"

URI_aarch64_acpid = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/acpid-2.0.34-10.el10.aarch64.rpm;name=aarch64_acpid;unpack=0"
SRC_URI:append = " ${URI_aarch64_acpid}"
SRC_URI[aarch64_acpid.sha256sum] = "2eb29ee45855bce333cf9a81c4ab8b931895876d0982f08ac0b03855838df024"

RDEPENDS:acpid = " \
 bash \
 glibc \
 systemd \
 "
