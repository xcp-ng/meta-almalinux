# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libicns"
PV = "0.8.1"
PR = "32.el10_0"
PACKAGES = " \
 libicns \
 libicns-devel \
 libicns-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libicns-0.8.1-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0d8ec5e60b482ca6b0986f0483b3ef4912142f78e5c0096b1994ab09f6d45f7"

URI_x86_64_v2_libicns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libicns-0.8.1-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libicns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libicns}"
SRC_URI[x86_64_v2_libicns.sha256sum] = "5e8d9048e2970eaa6a5792a4807ca3dc5a913ccafc5c16d643a7b88b3810e6df"

URI_x86_64_v2_libicns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libicns-devel-0.8.1-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libicns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libicns-devel}"
SRC_URI[x86_64_v2_libicns-devel.sha256sum] = "922e9ef1db878e0b6911c2fbc8a63c0076aa155bf79711aa6424984941e0305a"

URI_x86_64_v2_libicns-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libicns-utils-0.8.1-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libicns-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libicns-utils}"
SRC_URI[x86_64_v2_libicns-utils.sha256sum] = "2c85bb6e5ff7362b21355dbf0a06d9497478d8915f57e96748d156ddbfd1ab2f"

URI_aarch64_libicns = "${EPEL_MIRROR}/aarch64/Packages/l/libicns-0.8.1-32.el10_0.aarch64.rpm;name=aarch64_libicns;unpack=0"
SRC_URI:append = " ${URI_aarch64_libicns}"
SRC_URI[aarch64_libicns.sha256sum] = "621024faf306bc3dbf4b9f3b3a8cc5e61033d66d4535f36c67cd1c6ad65f7f1b"

URI_aarch64_libicns-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libicns-devel-0.8.1-32.el10_0.aarch64.rpm;name=aarch64_libicns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libicns-devel}"
SRC_URI[aarch64_libicns-devel.sha256sum] = "936a1d804302f2cb697283b4ab9efac8c35438318935c44dfafd1ccbe0b7d9ee"

URI_aarch64_libicns-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libicns-utils-0.8.1-32.el10_0.aarch64.rpm;name=aarch64_libicns-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libicns-utils}"
SRC_URI[aarch64_libicns-utils.sha256sum] = "4fd17fc9ce2af5642450058f84835560210171e689c4206415845ea427dbb429"

RDEPENDS:libicns = " \
 glibc \
 jasper-libs \
 libpng \
 "
RDEPENDS:libicns-devel = " \
 libicns \
 pkgconf-pkg-config \
 "
RDEPENDS:libicns-utils = " \
 glibc \
 libicns \
 libpng \
 "
