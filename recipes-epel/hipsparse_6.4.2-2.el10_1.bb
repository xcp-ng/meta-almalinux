# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipsparse"
PV = "6.4.2"
PR = "2.el10_1"
PACKAGES:x86_64_v2 = " \
 hipsparse \
 hipsparse-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipsparse-6.4.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb736407ce01aae1f8b8539d2f75bf3bc3b1317b65f71c0eb8711e1c914731b9"

URI_x86_64_v2_hipsparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsparse-6.4.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsparse}"
SRC_URI[x86_64_v2_hipsparse.sha256sum] = "859972e61f0b46bd3d6803ea832d30c249b12103bdf748d67917821a035a69ab"

URI_x86_64_v2_hipsparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsparse-devel-6.4.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsparse-devel}"
SRC_URI[x86_64_v2_hipsparse-devel.sha256sum] = "0a9b93788673b236b6f7748b6dedad65c6510d83fb5685263f9897bdbdbffd24"

RDEPENDS:hipsparse = " \
 glibc \
 libstdc++ \
 rocm-hip \
 rocsparse \
 "
RDEPENDS:hipsparse-devel = " \
 cmake-filesystem \
 hipsparse \
 "
