# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsoup3"
PV = "3.6.5"
PR = "3.el10_0.9"
PACKAGES = " \
 libsoup3 \
 libsoup3-devel \
 libsoup3-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libsoup3-3.6.5-3.el10_0.9.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "453d666add1121ca4a6581aab2c2b385061954b031bb7d657b54d0e735cf6458"

URI_x86_64_v2_libsoup3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsoup3-3.6.5-3.el10_0.9.x86_64_v2.rpm;name=x86_64_v2_libsoup3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsoup3}"
SRC_URI[x86_64_v2_libsoup3.sha256sum] = "346e9f1709892c4f189709f9cff662d3bb03415340efdd6993c94abbfac8692d"

URI_x86_64_v2_libsoup3-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsoup3-devel-3.6.5-3.el10_0.9.x86_64_v2.rpm;name=x86_64_v2_libsoup3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsoup3-devel}"
SRC_URI[x86_64_v2_libsoup3-devel.sha256sum] = "27fb92d56ba060e8877d5c6900f076e798d5d15b4bdbd21f77a01091cdd3b81c"

URI_x86_64_v2_libsoup3-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsoup3-doc-3.6.5-3.el10_0.9.noarch.rpm;name=x86_64_v2_libsoup3-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsoup3-doc}"
SRC_URI[x86_64_v2_libsoup3-doc.sha256sum] = "063378dbed913a29843308d35a16af1f76f0a6b1d3d42d1fd66f01017d35ac0d"

URI_aarch64_libsoup3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsoup3-3.6.5-3.el10_0.9.aarch64.rpm;name=aarch64_libsoup3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsoup3}"
SRC_URI[aarch64_libsoup3.sha256sum] = "72cad6001a69a2928c95f1bdd11e80b91c0719d6e728a163cd8fdda556b831e7"

URI_aarch64_libsoup3-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsoup3-devel-3.6.5-3.el10_0.9.aarch64.rpm;name=aarch64_libsoup3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsoup3-devel}"
SRC_URI[aarch64_libsoup3-devel.sha256sum] = "3ea32e471b9d994057ccf3f5a64db15b878abb9241e9c7fdedbcd5add6efb2a9"

URI_aarch64_libsoup3-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsoup3-doc-3.6.5-3.el10_0.9.noarch.rpm;name=aarch64_libsoup3-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsoup3-doc}"
SRC_URI[aarch64_libsoup3-doc.sha256sum] = "063378dbed913a29843308d35a16af1f76f0a6b1d3d42d1fd66f01017d35ac0d"

RDEPENDS:libsoup3 = " \
 glib2 \
 glibc \
 krb5-libs \
 libbrotli \
 libnghttp2 \
 libpsl \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:libsoup3-devel = " \
 brotli-devel \
 glib2-devel \
 krb5-devel \
 libnghttp2-devel \
 libpsl-devel \
 libsoup3 \
 pkgconf-pkg-config \
 sqlite-devel \
 sysprof-capture-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:libsoup3-doc = " \
 "
