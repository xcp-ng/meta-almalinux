# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fpc"
PV = "3.2.2"
PR = "20.el10_1"
PACKAGES:x86_64_v2 = " \
 fpc \
 fpc-doc \
 fpc-ide \
 fpc-src \
 fpc-units-x86_64-linux \
"
PACKAGES:aarch64 = " \
 fpc \
 fpc-doc \
 fpc-ide \
 fpc-src \
 fpc-units-aarch64-linux \
"

URI_src = "${EPELSRC_MIRROR}/Packages/f/fpc-3.2.2-20.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3173b72b3f05e282af4968555fbb7640d54203955fead8d7660a28b3cc1ca17"

URI_x86_64_v2_fpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fpc-3.2.2-20.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fpc}"
SRC_URI[x86_64_v2_fpc.sha256sum] = "d693908e4d20811a32abf05a9123b15faafe14fcf5a1c1701c1ba8cdd7b21af4"

URI_x86_64_v2_fpc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fpc-doc-3.2.2-20.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fpc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fpc-doc}"
SRC_URI[x86_64_v2_fpc-doc.sha256sum] = "3ac63b0444a2692dcccc5aa649f7c030d0062cfe88cf61827dda3f9d57a7c229"

URI_x86_64_v2_fpc-ide = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fpc-ide-3.2.2-20.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fpc-ide;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fpc-ide}"
SRC_URI[x86_64_v2_fpc-ide.sha256sum] = "f5d6698bc48249c6ae0e0e6d4daa720c18b195177d9e31bba856c80a8f5dcb63"

URI_x86_64_v2_fpc-src = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fpc-src-3.2.2-20.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fpc-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fpc-src}"
SRC_URI[x86_64_v2_fpc-src.sha256sum] = "b1f51bba9d5361bcb3c4719a85336e8b8ab3b45ee050acb5b3e541710b452582"

URI_x86_64_v2_fpc-units-x86_64-linux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fpc-units-x86_64-linux-3.2.2-20.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fpc-units-x86_64-linux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fpc-units-x86_64-linux}"
SRC_URI[x86_64_v2_fpc-units-x86_64-linux.sha256sum] = "d7e265cf6beef87bb565f334c69da63ed2b201aeaff085a5bbbf06311eaa92e7"

URI_aarch64_fpc = "${EPEL_MIRROR}/aarch64/Packages/f/fpc-3.2.2-20.el10_1.aarch64.rpm;name=aarch64_fpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fpc}"
SRC_URI[aarch64_fpc.sha256sum] = "623e16dcd644d5038af65f092d12fc17838eb8a34e355375a079e2036f6ecb61"

URI_aarch64_fpc-doc = "${EPEL_MIRROR}/aarch64/Packages/f/fpc-doc-3.2.2-20.el10_1.aarch64.rpm;name=aarch64_fpc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fpc-doc}"
SRC_URI[aarch64_fpc-doc.sha256sum] = "a691996ea59c01790f239e3784748a61e41d8116fee63df44e60dc8199919d87"

URI_aarch64_fpc-ide = "${EPEL_MIRROR}/aarch64/Packages/f/fpc-ide-3.2.2-20.el10_1.aarch64.rpm;name=aarch64_fpc-ide;unpack=0"
SRC_URI:append = " ${URI_aarch64_fpc-ide}"
SRC_URI[aarch64_fpc-ide.sha256sum] = "a596e134a2c5b6ab9323ed816576bf19d70723aa9864122e3a3c92036b1d7ac5"

URI_aarch64_fpc-src = "${EPEL_MIRROR}/aarch64/Packages/f/fpc-src-3.2.2-20.el10_1.noarch.rpm;name=aarch64_fpc-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_fpc-src}"
SRC_URI[aarch64_fpc-src.sha256sum] = "c2aed07b93b1e2578d9372d083b95fd5284fad5bf5534e0c5bd28ee0dcf3220b"

URI_aarch64_fpc-units-aarch64-linux = "${EPEL_MIRROR}/aarch64/Packages/f/fpc-units-aarch64-linux-3.2.2-20.el10_1.aarch64.rpm;name=aarch64_fpc-units-aarch64-linux;unpack=0"
SRC_URI:append = " ${URI_aarch64_fpc-units-aarch64-linux}"
SRC_URI[aarch64_fpc-units-aarch64-linux.sha256sum] = "d86e10b0595fcedfbeb6bfb35ee71c23c241c2f500b8773bbe90d4185f43b33f"

RDEPENDS:fpc:x86_64_v2 = " \
 bash \
 binutils \
 fpc-units-x86_64-linux \
 glibc \
"
RDEPENDS:fpc:aarch64 = " \
 bash \
 binutils \
 fpc-units-aarch64-linux \
 glibc \
"
RDEPENDS:fpc-doc = " \
 "
RDEPENDS:fpc-ide:x86_64_v2 = " \
 fpc-units-x86_64-linux \
 gpm \
 ncurses \
"
RDEPENDS:fpc-ide:aarch64 = " \
 fpc-units-aarch64-linux \
 gpm \
 ncurses \
"
RDEPENDS:fpc-src = " \
 bash \
 "
RDEPENDS:fpc-units-x86_64-linux = " \
 "
RDEPENDS:fpc-units-aarch64-linux = " \
 "
