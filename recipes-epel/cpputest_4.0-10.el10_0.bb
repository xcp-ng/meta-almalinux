# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cpputest"
PV = "4.0"
PR = "10.el10_0"
PACKAGES = " \
 cpputest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cpputest-4.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21da2f814a78f98d488140fe826762660fad5970975326bc20371aa02909425d"

URI_x86_64_v2_cpputest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cpputest-devel-4.0-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cpputest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cpputest-devel}"
SRC_URI[x86_64_v2_cpputest-devel.sha256sum] = "61c27e20516876b1e245fc583af49a825cf3e7210e5e3bafe8302dcf64fbbc65"

URI_aarch64_cpputest-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cpputest-devel-4.0-10.el10_0.aarch64.rpm;name=aarch64_cpputest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cpputest-devel}"
SRC_URI[aarch64_cpputest-devel.sha256sum] = "60237908dc83c2edd874540aaff5a6c26c413c4cb1c943b3edc94d205d8bab09"

RDEPENDS:cpputest-devel = " \
 cmake-filesystem \
 gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 pkgconf-pkg-config \
 "
