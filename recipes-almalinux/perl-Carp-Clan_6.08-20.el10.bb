# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Carp-Clan"
PV = "6.08"
PR = "20.el10"
PACKAGES = " \
 perl-Carp-Clan \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Carp-Clan-6.08-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de1bf74815bbb4bd6090f4158a54b06d2d03047afbc2909dd45f4356d545e2c2"

URI_x86_64_v2_perl-Carp-Clan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Carp-Clan-6.08-20.el10.noarch.rpm;name=x86_64_v2_perl-Carp-Clan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Carp-Clan}"
SRC_URI[x86_64_v2_perl-Carp-Clan.sha256sum] = "116bc6e3e7ac11d5df7110ae7f66a67a2c43dd1cb0b94344e6d7882f8d79b48b"

URI_aarch64_perl-Carp-Clan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Carp-Clan-6.08-20.el10.noarch.rpm;name=aarch64_perl-Carp-Clan;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Carp-Clan}"
SRC_URI[aarch64_perl-Carp-Clan.sha256sum] = "116bc6e3e7ac11d5df7110ae7f66a67a2c43dd1cb0b94344e6d7882f8d79b48b"

RDEPENDS:perl-Carp-Clan = " \
 perl-libs \
 perl-overload \
 "
