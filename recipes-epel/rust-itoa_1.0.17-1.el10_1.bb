# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-itoa"
PV = "1.0.17"
PR = "1.el10_1"
PACKAGES = " \
 rust-itoa+default-devel \
 rust-itoa+no-panic-devel \
 rust-itoa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-itoa-1.0.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "134ccfe92e0b04734fd6c482876d18f25f5476aa6415392d3b4514293b660f31"

URI_x86_64_v2_rust-itoa+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoa+default-devel-1.0.17-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoa+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoa+default-devel}"
SRC_URI[x86_64_v2_rust-itoa+default-devel.sha256sum] = "488b4a41aa92358be9e6dd7b777236efc2c69cd83741d0161d892e1a18a627e2"

URI_x86_64_v2_rust-itoa+no-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoa+no-panic-devel-1.0.17-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoa+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoa+no-panic-devel}"
SRC_URI[x86_64_v2_rust-itoa+no-panic-devel.sha256sum] = "9c5ef8092743ebe395da80eb6466d483017e4039f4c0a94cf07436557ca1f181"

URI_x86_64_v2_rust-itoa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoa-devel-1.0.17-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoa-devel}"
SRC_URI[x86_64_v2_rust-itoa-devel.sha256sum] = "b1b7bc802df6c036be5c502128a3bf94a93324f20e854429db9a807c72f2aed4"

URI_aarch64_rust-itoa+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoa+default-devel-1.0.17-1.el10_1.noarch.rpm;name=aarch64_rust-itoa+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoa+default-devel}"
SRC_URI[aarch64_rust-itoa+default-devel.sha256sum] = "930aaf905ee6bfe3ab896e7cc24918a5cb78c6101be750f021468e1d882bf7e6"

URI_aarch64_rust-itoa+no-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoa+no-panic-devel-1.0.17-1.el10_1.noarch.rpm;name=aarch64_rust-itoa+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoa+no-panic-devel}"
SRC_URI[aarch64_rust-itoa+no-panic-devel.sha256sum] = "b960cb805e65844056e84d894938dde594c44fefb956061e20b8d4ba480f7edd"

URI_aarch64_rust-itoa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoa-devel-1.0.17-1.el10_1.noarch.rpm;name=aarch64_rust-itoa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoa-devel}"
SRC_URI[aarch64_rust-itoa-devel.sha256sum] = "38c8b04ed17e888b4e8995e73b95ef462e102fd863c03d0a623198df6ddecc9d"

RDEPENDS:rust-itoa+default-devel = " \
 cargo \
 rust-itoa-devel \
 "
RDEPENDS:rust-itoa+no-panic-devel = " \
 cargo \
 rust-itoa-devel \
 rust-no-panic+default-devel \
 "
RDEPENDS:rust-itoa-devel = " \
 cargo \
 rust \
 "
