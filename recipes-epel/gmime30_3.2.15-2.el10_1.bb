# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gmime30"
PV = "3.2.15"
PR = "2.el10_1"
PACKAGES = " \
 gmime30 \
 gmime30-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gmime30-3.2.15-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5365e67e8d9c4e43f46ce3d723fbe33c00a9be4f86a8d6246e8c53b991e90781"

URI_x86_64_v2_gmime30 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gmime30-3.2.15-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gmime30;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gmime30}"
SRC_URI[x86_64_v2_gmime30.sha256sum] = "7d412d733087b1cafa9d7e28d131e16205db72b8182e40c3f76a49315cb144f8"

URI_x86_64_v2_gmime30-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gmime30-devel-3.2.15-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gmime30-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gmime30-devel}"
SRC_URI[x86_64_v2_gmime30-devel.sha256sum] = "e872034088e93ec1982199098faa8790c04540391f11d500abd02289624a7cd0"

URI_aarch64_gmime30 = "${EPEL_MIRROR}/aarch64/Packages/g/gmime30-3.2.15-2.el10_1.aarch64.rpm;name=aarch64_gmime30;unpack=0"
SRC_URI:append = " ${URI_aarch64_gmime30}"
SRC_URI[aarch64_gmime30.sha256sum] = "c64173f57b70874c041073363d108f103afbd146a67f2ca29e73569964b836b0"

URI_aarch64_gmime30-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gmime30-devel-3.2.15-2.el10_1.aarch64.rpm;name=aarch64_gmime30-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gmime30-devel}"
SRC_URI[aarch64_gmime30-devel.sha256sum] = "d5a73cc3bdb335079df88025e01c28bdc7394d174d2c20a9baff94951e8f9678"

RDEPENDS:gmime30 = " \
 glib2 \
 glibc \
 gpgme \
 libgpg-error \
 zlib-ng-compat \
 "
RDEPENDS:gmime30-devel = " \
 glib2-devel \
 gmime30 \
 pkgconf-pkg-config \
 "
