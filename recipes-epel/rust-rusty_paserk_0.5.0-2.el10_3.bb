# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rusty_paserk"
PV = "0.5.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-rusty_paserk+arbitrary-devel \
 rust-rusty_paserk+default-devel \
 rust-rusty_paserk+serde-devel \
 rust-rusty_paserk+v3-devel \
 rust-rusty_paserk+v4-devel \
 rust-rusty_paserk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rusty_paserk-0.5.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e23e4a84c5c881756cc7ab2f43b7bf5cd6b5563afcefc33d17397e1000678e2a"

URI_x86_64_v2_rust-rusty_paserk+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paserk+arbitrary-devel-0.5.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paserk+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paserk+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-rusty_paserk+arbitrary-devel.sha256sum] = "408d8fa2eacf7744ad64fc5da03910a901c84179bbfcd6dc10d06e75c56ed0dd"

URI_x86_64_v2_rust-rusty_paserk+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paserk+default-devel-0.5.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paserk+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paserk+default-devel}"
SRC_URI[x86_64_v2_rust-rusty_paserk+default-devel.sha256sum] = "fa1b0c92eec3bbecd82f1ca8eb767a55ac94b4ceab4ba7f4b20c29373452dcea"

URI_x86_64_v2_rust-rusty_paserk+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paserk+serde-devel-0.5.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paserk+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paserk+serde-devel}"
SRC_URI[x86_64_v2_rust-rusty_paserk+serde-devel.sha256sum] = "c402b090072e022cf811aa368ea44591b39b230c790ad39b5d57be0c4c664bde"

URI_x86_64_v2_rust-rusty_paserk+v3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paserk+v3-devel-0.5.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paserk+v3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paserk+v3-devel}"
SRC_URI[x86_64_v2_rust-rusty_paserk+v3-devel.sha256sum] = "d1954f77125dff754a32ab64c473ce9d1a095ee8826cd1e4d1a0c2ed2c10c995"

URI_x86_64_v2_rust-rusty_paserk+v4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paserk+v4-devel-0.5.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paserk+v4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paserk+v4-devel}"
SRC_URI[x86_64_v2_rust-rusty_paserk+v4-devel.sha256sum] = "0b5a2a095fa3b439335e83ae054ce05599ca98f03044fa2fcfda319fb6b1286c"

URI_x86_64_v2_rust-rusty_paserk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paserk-devel-0.5.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paserk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paserk-devel}"
SRC_URI[x86_64_v2_rust-rusty_paserk-devel.sha256sum] = "db5b9efc2f27f190addbb4cdb5cc27410179e9eee3379aa2003edcdb87dc54a6"

URI_aarch64_rust-rusty_paserk+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paserk+arbitrary-devel-0.5.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paserk+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paserk+arbitrary-devel}"
SRC_URI[aarch64_rust-rusty_paserk+arbitrary-devel.sha256sum] = "5cf0e2cb543c31a29ea9cc0f63c38bdba238081653352d174f7053e01609bc46"

URI_aarch64_rust-rusty_paserk+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paserk+default-devel-0.5.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paserk+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paserk+default-devel}"
SRC_URI[aarch64_rust-rusty_paserk+default-devel.sha256sum] = "9d8c6abb5b62e9e94ed815a6bcb94c9a598e40e6b697f5767d6fa9551d5aaea5"

URI_aarch64_rust-rusty_paserk+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paserk+serde-devel-0.5.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paserk+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paserk+serde-devel}"
SRC_URI[aarch64_rust-rusty_paserk+serde-devel.sha256sum] = "5ff5727fa916cfe96f78038b393366bbfde026f8bb2ae7dbfcfc8b36d892e352"

URI_aarch64_rust-rusty_paserk+v3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paserk+v3-devel-0.5.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paserk+v3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paserk+v3-devel}"
SRC_URI[aarch64_rust-rusty_paserk+v3-devel.sha256sum] = "5248046666077546324f6847988dd32855492897f467461600c291a5c7ca76c1"

URI_aarch64_rust-rusty_paserk+v4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paserk+v4-devel-0.5.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paserk+v4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paserk+v4-devel}"
SRC_URI[aarch64_rust-rusty_paserk+v4-devel.sha256sum] = "fed48ec99e9eabfbfd418923cc6e6b4f73267cd9144046cc9553ed205fa1bc03"

URI_aarch64_rust-rusty_paserk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paserk-devel-0.5.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paserk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paserk-devel}"
SRC_URI[aarch64_rust-rusty_paserk-devel.sha256sum] = "75d312c9582fa662fb9c4af643933921ef5e342df5613ebf6887259fc99f2c29"

RDEPENDS:rust-rusty_paserk+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-rusty_paserk-devel \
 "
RDEPENDS:rust-rusty_paserk+default-devel = " \
 cargo \
 rust-rusty_paserk+v4-devel \
 rust-rusty_paserk-devel \
 "
RDEPENDS:rust-rusty_paserk+serde-devel = " \
 cargo \
 rust-rusty_paserk-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-rusty_paserk+v3-devel = " \
 cargo \
 rust-aes0.8+default-devel \
 rust-ctr+default-devel \
 rust-hmac0.12+default-devel \
 rust-p384+default-devel \
 rust-p384+ecdh-devel \
 rust-p384+pkcs8-devel \
 rust-pbkdf2_0.12+default-devel \
 rust-rusty_paserk-devel \
 rust-rusty_paseto+v3_local-devel \
 rust-rusty_paseto+v3_public-devel \
 rust-sha2_0.10+default-devel \
 "
RDEPENDS:rust-rusty_paserk+v4-devel = " \
 cargo \
 rust-argon2+default-devel \
 rust-blake2+default-devel \
 rust-chacha20_0.9+default-devel \
 rust-curve25519-dalek+default-devel \
 rust-ed25519-dalek+default-devel \
 rust-ed25519-dalek+hazmat-devel \
 rust-rusty_paserk-devel \
 rust-rusty_paseto+v4_local-devel \
 rust-rusty_paseto+v4_public-devel \
 rust-sha2_0.10+default-devel \
 "
RDEPENDS:rust-rusty_paserk-devel = " \
 cargo \
 rust-base64_0.22+default-devel \
 rust-base64ct+default-devel \
 rust-cipher0.4+default-devel \
 rust-digest0.10+default-devel \
 rust-digest0.10+mac-devel \
 rust-generic-array+default-devel \
 rust-rand0.8+default-devel \
 rust-rusty_paseto+core-devel \
 rust-rusty_paseto-devel \
 rust-subtle+default-devel \
 "
