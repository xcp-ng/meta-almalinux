# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-doc"
PV = "6.9.1"
PR = "3.el10_2"
PACKAGES = " \
 qt6-doc \
 qt6-doc-devel \
 qt6-doc-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-doc-6.9.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43837f0aa7da916b5b4159ea665ad3c6be2e48a0be09f5336815086ba8e65811"

URI_x86_64_v2_qt6-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-doc-6.9.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qt6-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-doc}"
SRC_URI[x86_64_v2_qt6-doc.sha256sum] = "a92270f0ec15aa470f48d1e7d3ca997f00ec203457cb567cfa11016a6fc900af"

URI_x86_64_v2_qt6-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-doc-devel-6.9.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qt6-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-doc-devel}"
SRC_URI[x86_64_v2_qt6-doc-devel.sha256sum] = "70b091da3e6a62b4a7c36c6865b4b747801f9678183f2020478d574ffd37f660"

URI_x86_64_v2_qt6-doc-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-doc-html-6.9.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qt6-doc-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-doc-html}"
SRC_URI[x86_64_v2_qt6-doc-html.sha256sum] = "f98e467a6cd7b806640d2e9d5893fa026594c9c25ab01a852e68d2d6ba2858c3"

URI_aarch64_qt6-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-doc-6.9.1-3.el10_2.noarch.rpm;name=aarch64_qt6-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-doc}"
SRC_URI[aarch64_qt6-doc.sha256sum] = "3bed82fe39fbb947646b98b4e98d6ed70b25fc1df5d09e1e10379d5e8e1250b6"

URI_aarch64_qt6-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-doc-devel-6.9.1-3.el10_2.noarch.rpm;name=aarch64_qt6-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-doc-devel}"
SRC_URI[aarch64_qt6-doc-devel.sha256sum] = "78cb8468ea0df0962419bc2a884672f83777f24719366668b0d259488518d1be"

URI_aarch64_qt6-doc-html = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-doc-html-6.9.1-3.el10_2.noarch.rpm;name=aarch64_qt6-doc-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-doc-html}"
SRC_URI[aarch64_qt6-doc-html.sha256sum] = "c2e23589ed66a2ee93997741bd0efebcd5d8b109f72eab3220447f2c631523e3"

RDEPENDS:qt6-doc = " \
 "
RDEPENDS:qt6-doc-devel = " \
 "
RDEPENDS:qt6-doc-html = " \
 "
