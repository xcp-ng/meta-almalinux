# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_distr"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_distr+alloc-devel \
 rust-rand_distr+default-devel \
 rust-rand_distr+serde-devel \
 rust-rand_distr+std-devel \
 rust-rand_distr+std_math-devel \
 rust-rand_distr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_distr-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcacbce5d03520fbf9deef182e42dbe6209cde483d2a3f9cff11479686bf8211"

URI_x86_64_v2_rust-rand_distr+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr+alloc-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand_distr+alloc-devel.sha256sum] = "50752cfb40917725c87edb8d64f8a26ecd5941ac3110c3f93ebeeb5573081977"

URI_x86_64_v2_rust-rand_distr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr+default-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr+default-devel}"
SRC_URI[x86_64_v2_rust-rand_distr+default-devel.sha256sum] = "24ad42019c1c679a61d5adbdac1e929dbb586b1b7f02fd807395eb5b4aaf3b8f"

URI_x86_64_v2_rust-rand_distr+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr+serde-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_distr+serde-devel.sha256sum] = "5c2fa28d5e0238f8884903a5f85881871137035675eb03f7f29e7b720db80414"

URI_x86_64_v2_rust-rand_distr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr+std-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr+std-devel}"
SRC_URI[x86_64_v2_rust-rand_distr+std-devel.sha256sum] = "114722eebf993a4a449b68494ac8c58ce6a028e3ce24cde78176d022a3b9e850"

URI_x86_64_v2_rust-rand_distr+std_math-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr+std_math-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr+std_math-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr+std_math-devel}"
SRC_URI[x86_64_v2_rust-rand_distr+std_math-devel.sha256sum] = "cab532cdc8467bc0f57cf7ed1e8df61a54bbe771998a292098af3870ec16b9bf"

URI_x86_64_v2_rust-rand_distr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr-devel}"
SRC_URI[x86_64_v2_rust-rand_distr-devel.sha256sum] = "4a1a789c53bfea4a6b3ba88046408d75f98b078622124f2d2bbd6f2cb23ae36b"

URI_aarch64_rust-rand_distr+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr+alloc-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_distr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr+alloc-devel}"
SRC_URI[aarch64_rust-rand_distr+alloc-devel.sha256sum] = "c940407c0b773b09aca5cc24bce02ccfc359bf65156ec6e459c774595c58d2de"

URI_aarch64_rust-rand_distr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr+default-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_distr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr+default-devel}"
SRC_URI[aarch64_rust-rand_distr+default-devel.sha256sum] = "8b7370432d42301b6da12a4d61e7140bcaafc4566a3cfc0ba0062d42678e16bd"

URI_aarch64_rust-rand_distr+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr+serde-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_distr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr+serde-devel}"
SRC_URI[aarch64_rust-rand_distr+serde-devel.sha256sum] = "bea3343bb4eb05dd15def4e8805175f01a2fee9f0e23b452fdc16a2d11030cea"

URI_aarch64_rust-rand_distr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr+std-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_distr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr+std-devel}"
SRC_URI[aarch64_rust-rand_distr+std-devel.sha256sum] = "8beba1ca6714a520810492998a5328f9cf21e1af5d8501d3f04c641b51ccfb75"

URI_aarch64_rust-rand_distr+std_math-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr+std_math-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_distr+std_math-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr+std_math-devel}"
SRC_URI[aarch64_rust-rand_distr+std_math-devel.sha256sum] = "f0149176e0af2845b1bc4ca366188e7ca2c3257d39f2fc728c55957b96217a17"

URI_aarch64_rust-rand_distr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr-devel}"
SRC_URI[aarch64_rust-rand_distr-devel.sha256sum] = "f7a8eb251df09b3dda0967f23179dc2729427fe34e0d806ae938a817827712b6"

RDEPENDS:rust-rand_distr+alloc-devel = " \
 cargo \
 rust-rand+alloc-devel \
 rust-rand_distr-devel \
 "
RDEPENDS:rust-rand_distr+default-devel = " \
 cargo \
 rust-rand_distr+std-devel \
 rust-rand_distr-devel \
 "
RDEPENDS:rust-rand_distr+serde-devel = " \
 cargo \
 rust-rand+serde-devel \
 rust-rand_distr-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_with+default-devel \
 "
RDEPENDS:rust-rand_distr+std-devel = " \
 cargo \
 rust-rand+std-devel \
 rust-rand_distr+alloc-devel \
 rust-rand_distr-devel \
 "
RDEPENDS:rust-rand_distr+std_math-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-rand_distr-devel \
 "
RDEPENDS:rust-rand_distr-devel = " \
 cargo \
 rust \
 rust-num-traits+libm-devel \
 rust-num-traits-devel \
 rust-rand-devel \
 "
