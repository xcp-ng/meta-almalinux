# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libjcat"
PV = "0.2.2"
PR = "2.el10"
PACKAGES = " \
 libjcat \
 libjcat-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libjcat-0.2.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61fb0341029dc360cf24652469e94e5bb38e551e90ed1724d4192242be35e50b"

URI_x86_64_v2_libjcat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libjcat-0.2.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_libjcat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjcat}"
SRC_URI[x86_64_v2_libjcat.sha256sum] = "6b28ba258945a0642551e8833ecab94ff988958a0cc629e707e5beb2a480b32a"

URI_x86_64_v2_libjcat-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libjcat-devel-0.2.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_libjcat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjcat-devel}"
SRC_URI[x86_64_v2_libjcat-devel.sha256sum] = "7a6c81e6ded7b507af0cf0c70fb93a0b3bfbb06eeaeea55374dbd36a55ed9bde"

URI_aarch64_libjcat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libjcat-0.2.2-2.el10.aarch64.rpm;name=aarch64_libjcat;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjcat}"
SRC_URI[aarch64_libjcat.sha256sum] = "a31d98916a128b54dfcd9413cab6c2762d1e4df4b3b805d65213d4cb3fadcf7f"

URI_aarch64_libjcat-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libjcat-devel-0.2.2-2.el10.aarch64.rpm;name=aarch64_libjcat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjcat-devel}"
SRC_URI[aarch64_libjcat-devel.sha256sum] = "f70aba1fc0876908e34d8ab08409bd990efa26cdddbed808d127b6538783a9de"

RDEPENDS:libjcat = " \
 glib2 \
 glibc \
 gnutls \
 gpgme \
 json-glib \
 libgcc \
 libgpg-error \
 "
RDEPENDS:libjcat-devel = " \
 glib2-devel \
 gnutls-devel \
 json-glib-devel \
 libjcat \
 pkgconf-pkg-config \
 "
