# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Compress-Raw-Zlib"
PV = "2.212"
PR = "512.el10"
PACKAGES = " \
 perl-Compress-Raw-Zlib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Compress-Raw-Zlib-2.212-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e74f24e78d10083390c92f8caed400f35b69fd897e68e3121a456f0d130a6dd0"

URI_x86_64_v2_perl-Compress-Raw-Zlib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Compress-Raw-Zlib-2.212-512.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Compress-Raw-Zlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Compress-Raw-Zlib}"
SRC_URI[x86_64_v2_perl-Compress-Raw-Zlib.sha256sum] = "e33f80f8d317f75c5c825cbecbf276f27ff56b3567ee42bf20a08d8ca92c0533"

URI_aarch64_perl-Compress-Raw-Zlib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Compress-Raw-Zlib-2.212-512.el10.aarch64.rpm;name=aarch64_perl-Compress-Raw-Zlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Compress-Raw-Zlib}"
SRC_URI[aarch64_perl-Compress-Raw-Zlib.sha256sum] = "97dc32697b13cca3b1809b7bd406fc42fdc57f5f4973c05881482b6418c36a08"

RDEPENDS:perl-Compress-Raw-Zlib = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-constant \
 perl-libs \
 zlib-ng-compat \
 "
