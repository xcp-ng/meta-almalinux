# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mytop"
PV = "1.7"
PR = "24.b737f60.el10_0"
PACKAGES = " \
 mytop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mytop-1.7-24.b737f60.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f549e2ffa911fb4be80342fe5c65b5f43158d3c49c3ab6ee510b817acf4f288"

URI_x86_64_v2_mytop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mytop-1.7-24.b737f60.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mytop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mytop}"
SRC_URI[x86_64_v2_mytop.sha256sum] = "935fe656044799f482b1959a3378d3ba326bb0a6809d6039993e1599528bc9fb"

URI_aarch64_mytop = "${EPEL_MIRROR}/aarch64/Packages/m/mytop-1.7-24.b737f60.el10_0.noarch.rpm;name=aarch64_mytop;unpack=0"
SRC_URI:append = " ${URI_aarch64_mytop}"
SRC_URI[aarch64_mytop.sha256sum] = "13ddafcf8fe40de7b677f5c712720b19e0641ec9159b9ec6fa39d32bb8f19965"

RDEPENDS:mytop = " \
 perl-DBD-MySQL \
 perl-DBI \
 perl-Getopt-Long \
 perl-Socket \
 perl-Term-ANSIColor \
 perl-TermReadKey \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
