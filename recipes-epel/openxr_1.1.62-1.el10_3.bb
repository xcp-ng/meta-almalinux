# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openxr"
PV = "1.1.62"
PR = "1.el10_3"
PACKAGES = " \
 openxr \
 openxr-devel \
 openxr-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/openxr-1.1.62-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ea364aa77d2fd89620f218f1578907516550035d56443151c8d97d517fcafc5a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openxr-1.1.62-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openxr;unpack=0"
SRC_URI[x86_64_v2_openxr.sha256sum] = "f8c84d12da576ec089600276b3e8fb86788613ca9406925505ee712c05cbecc2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openxr-devel-1.1.62-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openxr-devel;unpack=0"
SRC_URI[x86_64_v2_openxr-devel.sha256sum] = "c1b95fdc499a40290be4d3a90f2267c1e0a30c4f0479fd48c8e73faff496662c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openxr-libs-1.1.62-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openxr-libs;unpack=0"
SRC_URI[x86_64_v2_openxr-libs.sha256sum] = "04a0819c0745c2f5b3a6d13fa8fcb6c453f18f4680090dc76f2317fffc73772f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openxr-1.1.62-1.el10_3.aarch64.rpm;name=aarch64_openxr;unpack=0"
SRC_URI[aarch64_openxr.sha256sum] = "dec6a816c06b2564de234b7b9903584a37d8859137493f91342d4979c9116811"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openxr-devel-1.1.62-1.el10_3.aarch64.rpm;name=aarch64_openxr-devel;unpack=0"
SRC_URI[aarch64_openxr-devel.sha256sum] = "fac7b325da32d198e6411744af192e532555501b1b94943a6c5c0bdd8bca2032"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openxr-libs-1.1.62-1.el10_3.aarch64.rpm;name=aarch64_openxr-libs;unpack=0"
SRC_URI[aarch64_openxr-libs.sha256sum] = "9c44de91edf3ec5afb52b1ed63bcaf7fc3d3c07d146fd7905d39cabb6fa28fab"

RDEPENDS:openxr = " \
 glibc \
 libX11 \
 libXxf86vm \
 libgcc \
 libstdc++ \
 openxr-libs \
 vulkan-loader \
 "
RDEPENDS:openxr-devel = " \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 openxr-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openxr-libs = " \
 glibc \
 jsoncpp \
 libgcc \
 libstdc++ \
 "
