# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-associative-cache"
PV = "2.0.0"
PR = "4.el10_1"
PACKAGES = " \
 rust-associative-cache+default-devel \
 rust-associative-cache+rand-devel \
 rust-associative-cache-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-associative-cache-2.0.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6cb25fd61ba71714c021d56627a2028a56dc3f988b52d107167b533ad9f30d1"

URI_x86_64_v2_rust-associative-cache+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-associative-cache+default-devel-2.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-associative-cache+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-associative-cache+default-devel}"
SRC_URI[x86_64_v2_rust-associative-cache+default-devel.sha256sum] = "d698c4c497d8e022c3f37d353151de6ceb89bbee691561b3576f9cd92aaed029"

URI_x86_64_v2_rust-associative-cache+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-associative-cache+rand-devel-2.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-associative-cache+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-associative-cache+rand-devel}"
SRC_URI[x86_64_v2_rust-associative-cache+rand-devel.sha256sum] = "55282be0176747865d5431ac34b32286dcc14f6aab6e9b19aae8a0fda34263a4"

URI_x86_64_v2_rust-associative-cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-associative-cache-devel-2.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-associative-cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-associative-cache-devel}"
SRC_URI[x86_64_v2_rust-associative-cache-devel.sha256sum] = "5986e28541b1e8365503c45b77fbb5f4ccb90f63b341143f94bafbbd647c791c"

URI_aarch64_rust-associative-cache+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-associative-cache+default-devel-2.0.0-4.el10_1.noarch.rpm;name=aarch64_rust-associative-cache+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-associative-cache+default-devel}"
SRC_URI[aarch64_rust-associative-cache+default-devel.sha256sum] = "5b1991ac7820cfb30e0da76824a8a9a7f75ef0ccd45bc24338611acdfa79381e"

URI_aarch64_rust-associative-cache+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-associative-cache+rand-devel-2.0.0-4.el10_1.noarch.rpm;name=aarch64_rust-associative-cache+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-associative-cache+rand-devel}"
SRC_URI[aarch64_rust-associative-cache+rand-devel.sha256sum] = "a92c687b89f2876c44067cf59f43cfc73f45663aa157a09c27a584893e884694"

URI_aarch64_rust-associative-cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-associative-cache-devel-2.0.0-4.el10_1.noarch.rpm;name=aarch64_rust-associative-cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-associative-cache-devel}"
SRC_URI[aarch64_rust-associative-cache-devel.sha256sum] = "0de40faf61eb63f3a1308b0387aa8d4df32d7529281806b7a46714f8f20081c8"

RDEPENDS:rust-associative-cache+default-devel = " \
 cargo \
 rust-associative-cache-devel \
 "
RDEPENDS:rust-associative-cache+rand-devel = " \
 cargo \
 rust-associative-cache-devel \
 rust-rand0.8+default-devel \
 "
RDEPENDS:rust-associative-cache-devel = " \
 cargo \
 rust \
 "
