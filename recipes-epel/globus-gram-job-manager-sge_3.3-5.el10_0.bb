# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager-sge"
PV = "3.3"
PR = "5.el10_0"
PACKAGES = " \
 globus-gram-job-manager-sge \
 globus-gram-job-manager-sge-setup-poll \
 globus-gram-job-manager-sge-setup-seg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-sge-3.3-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f6cc5f28b93728a83d6ab44dfe7b4300de911e85f4c44d40322a953812a375b"

URI_x86_64_v2_globus-gram-job-manager-sge = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-sge-3.3-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-sge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-sge}"
SRC_URI[x86_64_v2_globus-gram-job-manager-sge.sha256sum] = "a71ecf9229bdb228428d4b7afdba806dcb688acc7b9e4b9ad48e335939591235"

URI_x86_64_v2_globus-gram-job-manager-sge-setup-poll = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-sge-setup-poll-3.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-job-manager-sge-setup-poll;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-sge-setup-poll}"
SRC_URI[x86_64_v2_globus-gram-job-manager-sge-setup-poll.sha256sum] = "3b2d9c2ab78d0f654eef0c28638ff905709bafe8d7a58b67178f1fc8f147716a"
RPROVIDES:globus-gram-job-manager-sge-setup-poll:x86_64_v2 = "virtual/globus-gram-job-manager-sge-setup_eq_3.3-5.el10_0.alma_altarch"

URI_x86_64_v2_globus-gram-job-manager-sge-setup-seg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-sge-setup-seg-3.3-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-sge-setup-seg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-sge-setup-seg}"
SRC_URI[x86_64_v2_globus-gram-job-manager-sge-setup-seg.sha256sum] = "194a9800e54e4ed48a51cbd126d7f1e71975d0022fb91010721fa2331c7a5df6"
RPROVIDES:globus-gram-job-manager-sge-setup-seg:x86_64_v2 = "virtual/globus-gram-job-manager-sge-setup_eq_3.3-5.el10_0.alma_altarch"

URI_aarch64_globus-gram-job-manager-sge = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-sge-3.3-5.el10_0.aarch64.rpm;name=aarch64_globus-gram-job-manager-sge;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-sge}"
SRC_URI[aarch64_globus-gram-job-manager-sge.sha256sum] = "2b5b93c12fe5065403c506145efb4acba9af671aea089c35edbfc1c8353ac1d5"

URI_aarch64_globus-gram-job-manager-sge-setup-poll = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-sge-setup-poll-3.3-5.el10_0.noarch.rpm;name=aarch64_globus-gram-job-manager-sge-setup-poll;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-sge-setup-poll}"
SRC_URI[aarch64_globus-gram-job-manager-sge-setup-poll.sha256sum] = "d78208e7c3239c8d7d4bc6cbfc8fc9e0f7638339fecdc41b0388f0b7b90758e4"
RPROVIDES:globus-gram-job-manager-sge-setup-poll:aarch64 = "virtual/globus-gram-job-manager-sge-setup_eq_3.3-5.el10_0"

URI_aarch64_globus-gram-job-manager-sge-setup-seg = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-sge-setup-seg-3.3-5.el10_0.aarch64.rpm;name=aarch64_globus-gram-job-manager-sge-setup-seg;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-sge-setup-seg}"
SRC_URI[aarch64_globus-gram-job-manager-sge-setup-seg.sha256sum] = "29c7bf8668d3ae208bd2db9780d70d2c38f9fa309ec181a4373f01a8bd4ab16c"
RPROVIDES:globus-gram-job-manager-sge-setup-seg:aarch64 = "virtual/globus-gram-job-manager-sge-setup_eq_3.3-5.el10_0"

RDEPENDS:globus-gram-job-manager-sge:x86_64_v2 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IO \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-sge-setup_eq_3.3-5.el10_0.alma_altarch \
"
RDEPENDS:globus-gram-job-manager-sge:aarch64 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IO \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-sge-setup_eq_3.3-5.el10_0 \
"
RDEPENDS:globus-gram-job-manager-sge-setup-poll = " \
 bash \
 globus-gram-job-manager-scripts \
 globus-gram-job-manager-sge \
 "
RDEPENDS:globus-gram-job-manager-sge-setup-seg = " \
 bash \
 glibc \
 globus-common \
 globus-gram-job-manager-scripts \
 globus-gram-job-manager-sge \
 globus-scheduler-event-generator \
 globus-scheduler-event-generator-progs \
 systemd \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/globus-gram-job-manager-sge-setup_eq_3.3-5.el10_0.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/globus-gram-job-manager-sge-setup_eq_3.3-5.el10_0"
