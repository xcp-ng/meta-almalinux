# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "f40-backgrounds"
PV = "40.2.0"
PR = "3.el10_0"
PACKAGES = " \
 f40-backgrounds \
 f40-backgrounds-base \
 f40-backgrounds-budgie \
 f40-backgrounds-extras-base \
 f40-backgrounds-extras-gnome \
 f40-backgrounds-extras-kde \
 f40-backgrounds-extras-mate \
 f40-backgrounds-extras-xfce \
 f40-backgrounds-gnome \
 f40-backgrounds-kde \
 f40-backgrounds-mate \
 f40-backgrounds-xfce \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/f40-backgrounds-40.2.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f15ea27ba6c0e347ccd1491a5d049a5a159d67a3926b990a1e8ae7d483c6bf9b"

URI_x86_64_v2_f40-backgrounds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f40-backgrounds-40.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f40-backgrounds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f40-backgrounds}"
SRC_URI[x86_64_v2_f40-backgrounds.sha256sum] = "0097f454c477b4b1e6ee945aaa52de347d73eeb39b1e76d6c08dacb40c6173da"

URI_x86_64_v2_f40-backgrounds-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f40-backgrounds-base-40.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f40-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f40-backgrounds-base}"
SRC_URI[x86_64_v2_f40-backgrounds-base.sha256sum] = "9016aebe812c3c55312f7d5e56fc1d75a2363e705e0a31b639cb8772105a6645"

URI_x86_64_v2_f40-backgrounds-budgie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f40-backgrounds-budgie-40.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f40-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f40-backgrounds-budgie}"
SRC_URI[x86_64_v2_f40-backgrounds-budgie.sha256sum] = "bdb27bebe8349a90b73ed2a4c5a62991d2a813cf5f805b44d3b63308896107ab"

URI_x86_64_v2_f40-backgrounds-extras-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f40-backgrounds-extras-base-40.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f40-backgrounds-extras-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f40-backgrounds-extras-base}"
SRC_URI[x86_64_v2_f40-backgrounds-extras-base.sha256sum] = "84e86e0d219d701460437885bb89b72f59f8744b6b1a07230ef75a34f3d740b2"

URI_x86_64_v2_f40-backgrounds-extras-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f40-backgrounds-extras-gnome-40.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f40-backgrounds-extras-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f40-backgrounds-extras-gnome}"
SRC_URI[x86_64_v2_f40-backgrounds-extras-gnome.sha256sum] = "f176f4521a0dc9ab4830739cb77c4e266589a54368f012d638979eac467b975c"

URI_x86_64_v2_f40-backgrounds-extras-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f40-backgrounds-extras-kde-40.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f40-backgrounds-extras-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f40-backgrounds-extras-kde}"
SRC_URI[x86_64_v2_f40-backgrounds-extras-kde.sha256sum] = "85bf01b194c57ed34b26e4f6aaf224a5b175dde3c555904818ad5c9fcbe2a47f"

URI_x86_64_v2_f40-backgrounds-extras-mate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f40-backgrounds-extras-mate-40.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f40-backgrounds-extras-mate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f40-backgrounds-extras-mate}"
SRC_URI[x86_64_v2_f40-backgrounds-extras-mate.sha256sum] = "5cf1b848437779e1163695ef6af156fee5e552996785316ced92c6c9648eddd7"

URI_x86_64_v2_f40-backgrounds-extras-xfce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f40-backgrounds-extras-xfce-40.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f40-backgrounds-extras-xfce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f40-backgrounds-extras-xfce}"
SRC_URI[x86_64_v2_f40-backgrounds-extras-xfce.sha256sum] = "032562da8c9fb341a9482afd4dc32dd7db39382de9744f8a625577f1ce7ec7a2"

URI_x86_64_v2_f40-backgrounds-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f40-backgrounds-gnome-40.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f40-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f40-backgrounds-gnome}"
SRC_URI[x86_64_v2_f40-backgrounds-gnome.sha256sum] = "170e6e0049929087a089460441db461932396a237f14b40b9711e56ad99dd763"

URI_x86_64_v2_f40-backgrounds-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f40-backgrounds-kde-40.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f40-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f40-backgrounds-kde}"
SRC_URI[x86_64_v2_f40-backgrounds-kde.sha256sum] = "4b47bc1ac585b244e14153c90f2431140fe99cfb67f9ebdc0fb45c2ee645857b"

URI_x86_64_v2_f40-backgrounds-mate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f40-backgrounds-mate-40.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f40-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f40-backgrounds-mate}"
SRC_URI[x86_64_v2_f40-backgrounds-mate.sha256sum] = "805280550b63a0ebdb8915561587faec8406f563fdef10925c8e5c807026fbd0"

URI_x86_64_v2_f40-backgrounds-xfce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f40-backgrounds-xfce-40.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f40-backgrounds-xfce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f40-backgrounds-xfce}"
SRC_URI[x86_64_v2_f40-backgrounds-xfce.sha256sum] = "db8f151b482f55f5380f69f04bfff5006ab52e027705e047cd89f65dcc5e79f2"

URI_aarch64_f40-backgrounds = "${EPEL_MIRROR}/aarch64/Packages/f/f40-backgrounds-40.2.0-3.el10_0.noarch.rpm;name=aarch64_f40-backgrounds;unpack=0"
SRC_URI:append = " ${URI_aarch64_f40-backgrounds}"
SRC_URI[aarch64_f40-backgrounds.sha256sum] = "d4c911d4fd118a2e617c26bfb57f5a5ae21b4644a8f210c24a3c188d56dc81e3"

URI_aarch64_f40-backgrounds-base = "${EPEL_MIRROR}/aarch64/Packages/f/f40-backgrounds-base-40.2.0-3.el10_0.noarch.rpm;name=aarch64_f40-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_f40-backgrounds-base}"
SRC_URI[aarch64_f40-backgrounds-base.sha256sum] = "05506927b6877fdde8d46aeab5cb494b00c022fc9cffd9ec8643ff56b7ff4403"

URI_aarch64_f40-backgrounds-budgie = "${EPEL_MIRROR}/aarch64/Packages/f/f40-backgrounds-budgie-40.2.0-3.el10_0.noarch.rpm;name=aarch64_f40-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_aarch64_f40-backgrounds-budgie}"
SRC_URI[aarch64_f40-backgrounds-budgie.sha256sum] = "4fa301f1e5300c851f046d154a83e16570800f5b5dc278a8554a88154e351aa0"

URI_aarch64_f40-backgrounds-extras-base = "${EPEL_MIRROR}/aarch64/Packages/f/f40-backgrounds-extras-base-40.2.0-3.el10_0.noarch.rpm;name=aarch64_f40-backgrounds-extras-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_f40-backgrounds-extras-base}"
SRC_URI[aarch64_f40-backgrounds-extras-base.sha256sum] = "430056a57010af13353d0637c0a72a75771487d312b188063ac64536b082d84c"

URI_aarch64_f40-backgrounds-extras-gnome = "${EPEL_MIRROR}/aarch64/Packages/f/f40-backgrounds-extras-gnome-40.2.0-3.el10_0.noarch.rpm;name=aarch64_f40-backgrounds-extras-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_f40-backgrounds-extras-gnome}"
SRC_URI[aarch64_f40-backgrounds-extras-gnome.sha256sum] = "54861d4faa1bd84a3a5ecadbb0250f36c4f02aeaf68fd530d2797f30a4d6ba68"

URI_aarch64_f40-backgrounds-extras-kde = "${EPEL_MIRROR}/aarch64/Packages/f/f40-backgrounds-extras-kde-40.2.0-3.el10_0.noarch.rpm;name=aarch64_f40-backgrounds-extras-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_f40-backgrounds-extras-kde}"
SRC_URI[aarch64_f40-backgrounds-extras-kde.sha256sum] = "91ff9767ffbd644c988c9eb87faa88be670f1e703736e7e1f0d58d88f98c0c86"

URI_aarch64_f40-backgrounds-extras-mate = "${EPEL_MIRROR}/aarch64/Packages/f/f40-backgrounds-extras-mate-40.2.0-3.el10_0.noarch.rpm;name=aarch64_f40-backgrounds-extras-mate;unpack=0"
SRC_URI:append = " ${URI_aarch64_f40-backgrounds-extras-mate}"
SRC_URI[aarch64_f40-backgrounds-extras-mate.sha256sum] = "2924d6a5b848e7cbbb82699113df66e689aa6ae1279e84c59918ca8e988e93dd"

URI_aarch64_f40-backgrounds-extras-xfce = "${EPEL_MIRROR}/aarch64/Packages/f/f40-backgrounds-extras-xfce-40.2.0-3.el10_0.noarch.rpm;name=aarch64_f40-backgrounds-extras-xfce;unpack=0"
SRC_URI:append = " ${URI_aarch64_f40-backgrounds-extras-xfce}"
SRC_URI[aarch64_f40-backgrounds-extras-xfce.sha256sum] = "634a333bd25f8a4a05e424959591b2064c0061b584ed57602d9a626f3b79d685"

URI_aarch64_f40-backgrounds-gnome = "${EPEL_MIRROR}/aarch64/Packages/f/f40-backgrounds-gnome-40.2.0-3.el10_0.noarch.rpm;name=aarch64_f40-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_f40-backgrounds-gnome}"
SRC_URI[aarch64_f40-backgrounds-gnome.sha256sum] = "513e02156436e6932a6e8ef3729c65e9ca47153467b6083c13147ebe8ff8c228"

URI_aarch64_f40-backgrounds-kde = "${EPEL_MIRROR}/aarch64/Packages/f/f40-backgrounds-kde-40.2.0-3.el10_0.noarch.rpm;name=aarch64_f40-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_f40-backgrounds-kde}"
SRC_URI[aarch64_f40-backgrounds-kde.sha256sum] = "408653bdc81102a8d4c1d8cd92fd5d532f8b8b888c1bf1033b95caab9735e53c"

URI_aarch64_f40-backgrounds-mate = "${EPEL_MIRROR}/aarch64/Packages/f/f40-backgrounds-mate-40.2.0-3.el10_0.noarch.rpm;name=aarch64_f40-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_aarch64_f40-backgrounds-mate}"
SRC_URI[aarch64_f40-backgrounds-mate.sha256sum] = "e6e9ccfc83a2af05daa86cfbff40a66f8fbb4a83afbcac9a2807f3431602abd5"

URI_aarch64_f40-backgrounds-xfce = "${EPEL_MIRROR}/aarch64/Packages/f/f40-backgrounds-xfce-40.2.0-3.el10_0.noarch.rpm;name=aarch64_f40-backgrounds-xfce;unpack=0"
SRC_URI:append = " ${URI_aarch64_f40-backgrounds-xfce}"
SRC_URI[aarch64_f40-backgrounds-xfce.sha256sum] = "70cecb94af5355a5e31a1de8a3183330e366aa9b213b88915849a9881537330f"

RDEPENDS:f40-backgrounds = " \
 f40-backgrounds-budgie \
 f40-backgrounds-gnome \
 f40-backgrounds-kde \
 f40-backgrounds-mate \
 f40-backgrounds-xfce \
 "
RDEPENDS:f40-backgrounds-base = " \
 "
RDEPENDS:f40-backgrounds-budgie = " \
 f40-backgrounds-base \
 "
RDEPENDS:f40-backgrounds-extras-base = " \
 "
RDEPENDS:f40-backgrounds-extras-gnome = " \
 f40-backgrounds-extras-base \
 "
RDEPENDS:f40-backgrounds-extras-kde = " \
 f40-backgrounds-extras-base \
 "
RDEPENDS:f40-backgrounds-extras-mate = " \
 f40-backgrounds-extras-base \
 "
RDEPENDS:f40-backgrounds-extras-xfce = " \
 f40-backgrounds-extras-base \
 "
RDEPENDS:f40-backgrounds-gnome = " \
 f40-backgrounds-base \
 "
RDEPENDS:f40-backgrounds-kde = " \
 f40-backgrounds-base \
 kde-filesystem \
 "
RDEPENDS:f40-backgrounds-mate = " \
 f40-backgrounds-base \
 "
RDEPENDS:f40-backgrounds-xfce = " \
 f40-backgrounds-base \
 "
