# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-milou"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-milou \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-milou-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b548c8f6e703c23c80ea9f000cdbd6bbe9c2e399112be8a0d17ebe0154835d2b"

URI_x86_64_v2_plasma-milou = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-milou-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-milou;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-milou}"
SRC_URI[x86_64_v2_plasma-milou.sha256sum] = "1acfadc17fcd7c70d5545b2c0f6357447dc28c9d981896b5fe5d72a6ce857bed"

URI_aarch64_plasma-milou = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-milou-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-milou;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-milou}"
SRC_URI[aarch64_plasma-milou.sha256sum] = "3a51f29b029f30d7d878efedd3d8512677cf831b9e2c74d14412fb24f551086f"

RDEPENDS:plasma-milou = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-krunner \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
