# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cramjam"
PV = "2.10.0"
PR = "3.el10_0"
PACKAGES = " \
 python3-cramjam \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cramjam-2.10.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7dbf0538745d81fc936581bab10d1c1a3af3fe609ca31bb35c9b94e269c1812"

URI_x86_64_v2_python3-cramjam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cramjam-2.10.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-cramjam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cramjam}"
SRC_URI[x86_64_v2_python3-cramjam.sha256sum] = "6056860c46be998965cd54e6c9e6414fe25776e21929ceeab9f3f12f96345ac0"

URI_aarch64_python3-cramjam = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cramjam-2.10.0-3.el10_0.aarch64.rpm;name=aarch64_python3-cramjam;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cramjam}"
SRC_URI[aarch64_python3-cramjam.sha256sum] = "12f2c4a519be10547ff4988f1c11270ba7444bc34ccf2488ac0fd16458b8120f"

RDEPENDS:python3-cramjam = " \
 bzip2-libs \
 glibc \
 libgcc \
 libzstd \
 lz4-libs \
 python3 \
 xz-libs \
 "
