# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-carlito-fonts"
PV = "1.103"
PR = "0.26.20130920.el10"
PACKAGES = " \
 google-carlito-fonts \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/google-carlito-fonts-1.103-0.26.20130920.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e02e705dbd352a9a5ead5f2e156fcd6d81ebc48885b899a50b467724da81e89a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/google-carlito-fonts-1.103-0.26.20130920.el10.noarch.rpm;name=x86_64_v2_google-carlito-fonts;unpack=0"
SRC_URI[x86_64_v2_google-carlito-fonts.sha256sum] = "fa7e375471bbca0ab93b0a10ad0aa8ffc679085e12ba524256fc9adfd9430cd6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/google-carlito-fonts-1.103-0.26.20130920.el10.noarch.rpm;name=aarch64_google-carlito-fonts;unpack=0"
SRC_URI[aarch64_google-carlito-fonts.sha256sum] = "fa7e375471bbca0ab93b0a10ad0aa8ffc679085e12ba524256fc9adfd9430cd6"

RDEPENDS:google-carlito-fonts = " \
 fonts-filesystem \
 "
