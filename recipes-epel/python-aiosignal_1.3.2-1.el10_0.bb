# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aiosignal"
PV = "1.3.2"
PR = "1.el10_0"
PACKAGES = " \
 python3-aiosignal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aiosignal-1.3.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e26e05cae89f739f9146185844802d1d5123a923b94f51c49792061d28b46488"

URI_x86_64_v2_python3-aiosignal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiosignal-1.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aiosignal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiosignal}"
SRC_URI[x86_64_v2_python3-aiosignal.sha256sum] = "069150a88bcbabcb443a9bc9e0339380b9407518d998d33a4128f0bbeb151c55"

URI_aarch64_python3-aiosignal = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiosignal-1.3.2-1.el10_0.noarch.rpm;name=aarch64_python3-aiosignal;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiosignal}"
SRC_URI[aarch64_python3-aiosignal.sha256sum] = "a19837a6f7af4827ccbda6b4b502177beaf01e1d3c30a8823e5e5a8c690c0d4d"

RDEPENDS:python3-aiosignal = " \
 python3 \
 python3-frozenlist \
 "
