# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwin"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 kwin \
 kwin-common \
 kwin-devel \
 kwin-doc \
 kwin-libs \
 kwin-wayland \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwin-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80a33dea7ed792a1a2b18eaa317a2e5f2db347d854b6e6fbda2d6451cbd82eaa"

URI_x86_64_v2_kwin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin}"
SRC_URI[x86_64_v2_kwin.sha256sum] = "6f068a0323d69c156a9cfe3696686018160dee1fb1d9a18a8ffeabd15766d513"

URI_x86_64_v2_kwin-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-common-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin-common}"
SRC_URI[x86_64_v2_kwin-common.sha256sum] = "f90e65e8ca63010d8db204852f4f68262c7a990a50fac3e2ef0a05466002f1df"

URI_x86_64_v2_kwin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin-devel}"
SRC_URI[x86_64_v2_kwin-devel.sha256sum] = "46da66e0d5fb6270cb622e08a6d584ec773015863de19477e4521bcbaba90e43"

URI_x86_64_v2_kwin-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-doc-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kwin-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin-doc}"
SRC_URI[x86_64_v2_kwin-doc.sha256sum] = "e2561d36eab6c46a8a675f5f498de73e22afae15ad7f1fded03fb08ce2d3f0f2"

URI_x86_64_v2_kwin-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-libs-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin-libs}"
SRC_URI[x86_64_v2_kwin-libs.sha256sum] = "624624fab8257f766bdba945d5f5165b2dc1d492e447b1e148fb1cdc241727ee"

URI_x86_64_v2_kwin-wayland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwin-wayland-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwin-wayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwin-wayland}"
SRC_URI[x86_64_v2_kwin-wayland.sha256sum] = "a9f9c35c9b16b55e486eab18447eae152267eebead74ffce09e496cc6cdc474e"
RPROVIDES:kwin-wayland:x86_64_v2 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_aarch64_kwin = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kwin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin}"
SRC_URI[aarch64_kwin.sha256sum] = "5eaf4da0831ad2a9a0806007377f1b84e255337d505ddb1e5827bafa4bfba5d6"

URI_aarch64_kwin-common = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-common-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kwin-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin-common}"
SRC_URI[aarch64_kwin-common.sha256sum] = "2e233f6bd8fa2c6b62c8d2e82c7cf2e50d55c41a50dd7f19a387abaaaf73bcf1"

URI_aarch64_kwin-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kwin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin-devel}"
SRC_URI[aarch64_kwin-devel.sha256sum] = "e620c115047b5f6cb1695255137141e7d7b34f0a9c348dcc51044ad4689d2952"

URI_aarch64_kwin-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-doc-6.3.6-1.el10_0.noarch.rpm;name=aarch64_kwin-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin-doc}"
SRC_URI[aarch64_kwin-doc.sha256sum] = "198b81c66a0b74c42c8322a422fa5c458b21e4e9eee473c57d7d56180bfc8a22"

URI_aarch64_kwin-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-libs-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kwin-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin-libs}"
SRC_URI[aarch64_kwin-libs.sha256sum] = "8d2df20c361d48ab58426fa10fd8960a2efb8b81f949b83d3a5268dcfa337c6a"

URI_aarch64_kwin-wayland = "${EPEL_MIRROR}/aarch64/Packages/k/kwin-wayland-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kwin-wayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwin-wayland}"
SRC_URI[aarch64_kwin-wayland.sha256sum] = "39cf1e81d4088c81968cdb8781428e9d960080a251f00aa72d31b4390fb422c4"
RPROVIDES:kwin-wayland:aarch64 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

RDEPENDS:kwin = " \
 kf6-kdeclarative \
 kf6-kirigami \
 kscreenlocker \
 kwin-common \
 kwin-libs \
 kwin-wayland \
 libplasma \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
RDEPENDS:kwin-common = " \
 glibc \
 kdecoration \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kf6-ksvg \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kwayland \
 kwin-libs \
 libeis \
 libepoxy \
 libstdc++ \
 libwayland-client \
 pipewire-libs \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools \
 qt6-qtwayland \
 "
RDEPENDS:kwin-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kservice-devel \
 kf6-kwindowsystem-devel \
 kwin-common \
 kwin-libs \
 "
RDEPENDS:kwin-doc = " \
 kwin \
 "
RDEPENDS:kwin-libs = " \
 glibc \
 kdecoration \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kglobalacceld \
 kscreenlocker \
 kwayland \
 lcms2 \
 libdisplay-info \
 libdrm \
 libepoxy \
 libinput \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 libxcb \
 libxcvt \
 libxkbcommon \
 mesa-libgbm \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsensors \
 qt6-qtsvg \
 systemd-libs \
 xcb-util-cursor \
 xcb-util-keysyms \
 xcb-util-wm \
 "
RDEPENDS:kwin-wayland = " \
 glibc \
 kdecoration \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-knotifications \
 kf6-kservice \
 kf6-ksvg \
 kf6-kwindowsystem \
 kglobalacceld \
 kwin-common \
 kwin-libs \
 libcanberra \
 libepoxy \
 libstdc++ \
 libxcb \
 qaccessibilityclient-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 systemd-libs \
 xorg-x11-server-Xwayland \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

PROVIDES:append:aarch64 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"
