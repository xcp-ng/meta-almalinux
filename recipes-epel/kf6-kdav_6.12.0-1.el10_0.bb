# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdav"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kdav \
 kf6-kdav-devel \
 kf6-kdav-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdav-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "078cac6e378193bf87edc4db057f8eebd0e0096cfc95242ad90c274b683d0f48"

URI_x86_64_v2_kf6-kdav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdav}"
SRC_URI[x86_64_v2_kf6-kdav.sha256sum] = "885f749b476674927232b114e5f1e437189691e114fedd82aa13e096c2eb551f"

URI_x86_64_v2_kf6-kdav-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdav-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdav-devel}"
SRC_URI[x86_64_v2_kf6-kdav-devel.sha256sum] = "adcc2bd0722fd875ddbeb92a36901414f0d7240364e3b7a9131233dc102863f7"

URI_x86_64_v2_kf6-kdav-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdav-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdav-doc}"
SRC_URI[x86_64_v2_kf6-kdav-doc.sha256sum] = "4cc98913775bb71c83dddb9cddc5ed0f2ef22ca0fa258db88016e1df1473c5c5"

URI_aarch64_kf6-kdav = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kdav;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdav}"
SRC_URI[aarch64_kf6-kdav.sha256sum] = "36c29d77f6d816966f500dee0434df9ad5fbf00208ff212d381bf69ca059bca9"

URI_aarch64_kf6-kdav-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kdav-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdav-devel}"
SRC_URI[aarch64_kf6-kdav-devel.sha256sum] = "af4b37207bb5b7fb546596408fa163819cfa28c58e2d86a60248652cbb76d222"

URI_aarch64_kf6-kdav-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kdav-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdav-doc}"
SRC_URI[aarch64_kf6-kdav-doc.sha256sum] = "937eb6826dd406f4290aa7b086db86e30b887f85b6a4a9c253f0960ec17d7acb"

RDEPENDS:kf6-kdav = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kdav-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kdav \
 "
RDEPENDS:kf6-kdav-doc = " \
 "
