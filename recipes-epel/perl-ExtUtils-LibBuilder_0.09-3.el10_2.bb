# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-LibBuilder"
PV = "0.09"
PR = "3.el10_2"
PACKAGES = " \
 perl-ExtUtils-LibBuilder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-ExtUtils-LibBuilder-0.09-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ebd20e466a31ac350f852b08c7fd132467b6f1e8033d8de4396f1058e1cad8e"

URI_x86_64_v2_perl-ExtUtils-LibBuilder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-LibBuilder-0.09-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-LibBuilder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-ExtUtils-LibBuilder}"
SRC_URI[x86_64_v2_perl-ExtUtils-LibBuilder.sha256sum] = "82e6be6ede62ff1df801c730e4ee22ed2eb53effb1b96768bb94227d0cc491f7"

URI_aarch64_perl-ExtUtils-LibBuilder = "${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-LibBuilder-0.09-3.el10_2.noarch.rpm;name=aarch64_perl-ExtUtils-LibBuilder;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-ExtUtils-LibBuilder}"
SRC_URI[aarch64_perl-ExtUtils-LibBuilder.sha256sum] = "7ed00711b6d2d8d806a507c028a359ad72c744a26beb56f82089a2830cbf8d02"

RDEPENDS:perl-ExtUtils-LibBuilder = " \
 perl-ExtUtils-CBuilder \
 perl-File-Temp \
 perl-PathTools \
 perl-base \
 perl-libs \
 "
