# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocprim"
PV = "7.2.0"
PR = "5.el10_3"
PACKAGES:x86_64_v2 = " \
 rocprim-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocprim-7.2.0-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a09714c33dae25cfe634e52ddb7cfedbf62077f9324c5f6a5102a7f2f839879d"

URI_x86_64_v2_rocprim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocprim-devel-7.2.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rocprim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocprim-devel}"
SRC_URI[x86_64_v2_rocprim-devel.sha256sum] = "ff03050ce63d172827f3ddcf430f1426af4e7a281e64a4c4a3f88209de70b1fa"

RDEPENDS:rocprim-devel = " \
 cmake-filesystem \
 rocm-filesystem \
 "
