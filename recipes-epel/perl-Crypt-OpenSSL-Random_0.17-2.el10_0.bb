# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-OpenSSL-Random"
PV = "0.17"
PR = "2.el10_0"
PACKAGES = " \
 perl-Crypt-OpenSSL-Random \
 perl-Crypt-OpenSSL-Random-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-OpenSSL-Random-0.17-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86d0beab863ee5b300340fb8ba6889d3bff245fe842ec786a0afab3e61283b71"

URI_x86_64_v2_perl-Crypt-OpenSSL-Random = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-Random-0.17-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-Random;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-Random}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-Random.sha256sum] = "f4c80b018d73ba399244039472a2ea3902855e499b7bfa2d179710ab7c45b64f"

URI_x86_64_v2_perl-Crypt-OpenSSL-Random-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-Random-tests-0.17-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-Random-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-Random-tests}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-Random-tests.sha256sum] = "b661b7b2e606a00661deded7609c0a77b4582779adc1277466854a4618b182ea"

URI_aarch64_perl-Crypt-OpenSSL-Random = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-Random-0.17-2.el10_0.aarch64.rpm;name=aarch64_perl-Crypt-OpenSSL-Random;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-Random}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-Random.sha256sum] = "5172ce2197e12b2edcf74f378a339f91936ac9fcdfa10a3b33f49e859ee42328"

URI_aarch64_perl-Crypt-OpenSSL-Random-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-Random-tests-0.17-2.el10_0.noarch.rpm;name=aarch64_perl-Crypt-OpenSSL-Random-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-Random-tests}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-Random-tests.sha256sum] = "c8e6c513c9fe42423fbca7caf85434f7165c49267562a9501dbdf5170de45ece"

RDEPENDS:perl-Crypt-OpenSSL-Random = " \
 glibc \
 openssl-libs \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Crypt-OpenSSL-Random-tests = " \
 bash \
 perl-Crypt-OpenSSL-Random \
 perl-Test-Harness \
 "
