# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hplip"
PV = "3.23.12"
PR = "10.el10_2.5"
PACKAGES = " \
 hplip \
 hplip-common \
 hplip-libs \
 libsane-hpaio \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hplip-3.23.12-10.el10_2.5.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "218b7a25b0b747e2d3e7b26b44cf9bdffa36b48f4fedad721cf93f6ceb010db1"

URI_x86_64_v2_hplip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hplip-3.23.12-10.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_hplip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hplip}"
SRC_URI[x86_64_v2_hplip.sha256sum] = "0b8511bdcf0f3a91c0e27a6b281da84aa8a1236e4fcb4fe02f7b5c37406ee88c"

URI_x86_64_v2_hplip-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hplip-common-3.23.12-10.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_hplip-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hplip-common}"
SRC_URI[x86_64_v2_hplip-common.sha256sum] = "4c4ee80ec33b594b411b120da96d1d455252d6071e959c868a49320f1d9841dc"

URI_x86_64_v2_hplip-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hplip-libs-3.23.12-10.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_hplip-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hplip-libs}"
SRC_URI[x86_64_v2_hplip-libs.sha256sum] = "f9fc2df65613ff1b8c3e8a68c91d42f0c05c1cc74a7a8e92e83716a1cf5441df"

URI_x86_64_v2_libsane-hpaio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsane-hpaio-3.23.12-10.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_libsane-hpaio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsane-hpaio}"
SRC_URI[x86_64_v2_libsane-hpaio.sha256sum] = "fe4d025c6f7d0238232c83d904c614a4901fa65fe8c336f08c62065dc494bb16"

URI_aarch64_hplip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hplip-3.23.12-10.el10_2.5.aarch64.rpm;name=aarch64_hplip;unpack=0"
SRC_URI:append = " ${URI_aarch64_hplip}"
SRC_URI[aarch64_hplip.sha256sum] = "deaaed487f166e9102285107a9da30a2d3e671e98e6c71da602099ac6387084d"

URI_aarch64_hplip-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hplip-common-3.23.12-10.el10_2.5.aarch64.rpm;name=aarch64_hplip-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_hplip-common}"
SRC_URI[aarch64_hplip-common.sha256sum] = "c2f916d38398772097e79d9b66fff8f70b3676133d5e9c68645a06cd073e8892"

URI_aarch64_hplip-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hplip-libs-3.23.12-10.el10_2.5.aarch64.rpm;name=aarch64_hplip-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_hplip-libs}"
SRC_URI[aarch64_hplip-libs.sha256sum] = "1bba0587a96917bdf5a14576215f3772a28c0d5c627a246c0428e192ec11e011"

URI_aarch64_libsane-hpaio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsane-hpaio-3.23.12-10.el10_2.5.aarch64.rpm;name=aarch64_libsane-hpaio;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsane-hpaio}"
SRC_URI[aarch64_libsane-hpaio.sha256sum] = "4b9f201c3c97fcf4cedc8f3d05c4382a0330d9247c2255a81debff024fa97009"

RDEPENDS:hplip = " \
 bash \
 cups \
 cups-libs \
 curl \
 dbus-libs \
 gawk \
 glibc \
 gnupg2 \
 hplip-libs \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 python3 \
 python3-dbus \
 systemd \
 tar \
 usbutils \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:hplip-common = " \
 "
RDEPENDS:hplip-libs = " \
 avahi \
 avahi-libs \
 cups-libs \
 dbus-libs \
 glibc \
 hplip-common \
 libusb1 \
 net-snmp-libs \
 openssl-libs \
 python3 \
 sane-backends-libs \
 "
RDEPENDS:libsane-hpaio = " \
 avahi \
 avahi-libs \
 cups-libs \
 dbus-libs \
 glibc \
 hplip-libs \
 libusb1 \
 net-snmp-libs \
 openssl-libs \
 sane-backends \
 "
