# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mrcfile"
PV = "1.5.4"
PR = "1.el10_0"
PACKAGES = " \
 python3-mrcfile \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-mrcfile-1.5.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ee4996d41852d6011c320ec606a89206e45e944c5d61cb33dc6dd27082692c06"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrcfile-1.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrcfile;unpack=0"
SRC_URI[x86_64_v2_python3-mrcfile.sha256sum] = "935be034defe36bae0e1b4fef3b57495ad851f0d2a7db6cc12b765ca42234476"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-mrcfile-1.5.4-1.el10_0.noarch.rpm;name=aarch64_python3-mrcfile;unpack=0"
SRC_URI[aarch64_python3-mrcfile.sha256sum] = "e638a80d81fb872161e3d038575b4218bf3947f2f7d1dffa00018c0cd66bceef"

RDEPENDS:python3-mrcfile = " \
 python3 \
 python3-numpy \
 "
