# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fapolicyd"
PV = "2.0.1"
PR = "1.el10"
PACKAGES = " \
 fapolicyd \
 fapolicyd-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fapolicyd-2.0.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3c9903ab9d7b726bb98ceac153e255831345666f4c51dcbd0cc02b094bbdd8f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fapolicyd-2.0.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_fapolicyd;unpack=0"
SRC_URI[x86_64_v2_fapolicyd.sha256sum] = "1c529a4a69da8b79a2acf42316e4c67a79bcf33a67560b22031f84450ca016ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fapolicyd-selinux-2.0.1-1.el10.noarch.rpm;name=x86_64_v2_fapolicyd-selinux;unpack=0"
SRC_URI[x86_64_v2_fapolicyd-selinux.sha256sum] = "6855cca3e241491adb1fa9f4929d79ebdc2fcd2457ce775e958bf399ceb7e2e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fapolicyd-2.0.1-1.el10.aarch64.rpm;name=aarch64_fapolicyd;unpack=0"
SRC_URI[aarch64_fapolicyd.sha256sum] = "a9c858dc01dcf783af4f656d924d3f21dc04beae5d9048e79baae805d28bee79"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fapolicyd-selinux-2.0.1-1.el10.noarch.rpm;name=aarch64_fapolicyd-selinux;unpack=0"
SRC_URI[aarch64_fapolicyd-selinux.sha256sum] = "6855cca3e241491adb1fa9f4929d79ebdc2fcd2457ce775e958bf399ceb7e2e6"

RDEPENDS:fapolicyd = " \
 bash \
 file-libs \
 glibc \
 libcap-ng \
 libseccomp \
 lmdb-libs \
 openssl-libs \
 rpm-libs \
 rpm-plugin-fapolicyd \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:fapolicyd-selinux = " \
 bash \
 fapolicyd \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
