# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-winnow"
PV = "1.0.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-winnow+alloc-devel \
 rust-winnow+ascii-devel \
 rust-winnow+binary-devel \
 rust-winnow+debug-devel \
 rust-winnow+default-devel \
 rust-winnow+parser-devel \
 rust-winnow+simd-devel \
 rust-winnow+std-devel \
 rust-winnow+unstable-doc-devel \
 rust-winnow+unstable-recover-devel \
 rust-winnow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-winnow-1.0.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "848d7299821d1b01258f48c7033915dc129c9782fbca9cdca91c027980c1afcd"

URI_x86_64_v2_rust-winnow+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+alloc-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+alloc-devel}"
SRC_URI[x86_64_v2_rust-winnow+alloc-devel.sha256sum] = "450032f2887f572f9f85817253baac85bb35a8f97f96f890102842a4fe99092c"

URI_x86_64_v2_rust-winnow+ascii-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+ascii-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+ascii-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+ascii-devel}"
SRC_URI[x86_64_v2_rust-winnow+ascii-devel.sha256sum] = "68e9dd0522bc00dbab8bfce93561510a7f955b46684ff1894e394c3ab7db02bf"

URI_x86_64_v2_rust-winnow+binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+binary-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+binary-devel}"
SRC_URI[x86_64_v2_rust-winnow+binary-devel.sha256sum] = "a96a410f6ddf25568720de5ac27139bf198f653509491f2089407d24230b37c4"

URI_x86_64_v2_rust-winnow+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+debug-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+debug-devel}"
SRC_URI[x86_64_v2_rust-winnow+debug-devel.sha256sum] = "a559dbe61d217b91dad56449b71d82ba53bc011b92bc78a6d665e112a14bdd42"

URI_x86_64_v2_rust-winnow+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+default-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+default-devel}"
SRC_URI[x86_64_v2_rust-winnow+default-devel.sha256sum] = "8fb72aac90225acead8d401b1d8ad82b3e35b7c3eb563de5d9c2fb9418d839b1"

URI_x86_64_v2_rust-winnow+parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+parser-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+parser-devel}"
SRC_URI[x86_64_v2_rust-winnow+parser-devel.sha256sum] = "39b3309790de5707b1e4581ddf9e8c7e38609f1b0618c166ccd53d1b8a7bad6d"

URI_x86_64_v2_rust-winnow+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+simd-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+simd-devel}"
SRC_URI[x86_64_v2_rust-winnow+simd-devel.sha256sum] = "564ca01fb64711509f09455894a25404e58560f9a2ac310899fdc28e166ad7c8"

URI_x86_64_v2_rust-winnow+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+std-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+std-devel}"
SRC_URI[x86_64_v2_rust-winnow+std-devel.sha256sum] = "3ee8fe4c742216f54626c3fcb9499351eedb7c382d2061bfaf829d17edd0ff9b"

URI_x86_64_v2_rust-winnow+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+unstable-doc-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-winnow+unstable-doc-devel.sha256sum] = "38c50c6bac0ceb38171318b3cee9ffc962038fba1361ad7245b9a05a3a811c7b"

URI_x86_64_v2_rust-winnow+unstable-recover-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+unstable-recover-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+unstable-recover-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+unstable-recover-devel}"
SRC_URI[x86_64_v2_rust-winnow+unstable-recover-devel.sha256sum] = "e3774c2bfb93a6c715db10944da483c6eff6e75b2e97454f8e6aece193b734e9"

URI_x86_64_v2_rust-winnow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow-devel}"
SRC_URI[x86_64_v2_rust-winnow-devel.sha256sum] = "5491fc1ad986d039229574cb543427ff97f043f01eab707ff9a51a7d50de560e"

URI_aarch64_rust-winnow+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+alloc-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-winnow+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+alloc-devel}"
SRC_URI[aarch64_rust-winnow+alloc-devel.sha256sum] = "0b3d4dbdab4e7517cba57e0a9a2f2d4c547f5009ab2aa20e0987e5f5cf176a9c"

URI_aarch64_rust-winnow+ascii-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+ascii-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-winnow+ascii-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+ascii-devel}"
SRC_URI[aarch64_rust-winnow+ascii-devel.sha256sum] = "c88d3d1f1928704ad8a5ac60bcefb24c7c285c539b1d2ed16a14e4dfec803d9a"

URI_aarch64_rust-winnow+binary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+binary-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-winnow+binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+binary-devel}"
SRC_URI[aarch64_rust-winnow+binary-devel.sha256sum] = "d4fb4fae0b580e328abc43c4cec5237eb8a8d622dcfab9c2dd10b430794b77f6"

URI_aarch64_rust-winnow+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+debug-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-winnow+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+debug-devel}"
SRC_URI[aarch64_rust-winnow+debug-devel.sha256sum] = "311514d71ea82e4992be8621b5bb17fff5af1e005449217d7cdf212d3df3322f"

URI_aarch64_rust-winnow+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+default-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-winnow+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+default-devel}"
SRC_URI[aarch64_rust-winnow+default-devel.sha256sum] = "2b6f0afb2679692fae60753c142299e90ab278648da726c11ac63ed271f8e467"

URI_aarch64_rust-winnow+parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+parser-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-winnow+parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+parser-devel}"
SRC_URI[aarch64_rust-winnow+parser-devel.sha256sum] = "6688bc294100df058ce939b8430001ef9afc8f3bac7dd590c66353dca2a26590"

URI_aarch64_rust-winnow+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+simd-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-winnow+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+simd-devel}"
SRC_URI[aarch64_rust-winnow+simd-devel.sha256sum] = "5b9aed2edeb0d45fbd46125d9736f2acd45f57c7440b57bb7f2fbff710bd6564"

URI_aarch64_rust-winnow+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+std-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-winnow+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+std-devel}"
SRC_URI[aarch64_rust-winnow+std-devel.sha256sum] = "ed3a6d85eb6e96ae2470994dc01a42685286c9dc1388ca85ef2b4c2a08b193ec"

URI_aarch64_rust-winnow+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+unstable-doc-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-winnow+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+unstable-doc-devel}"
SRC_URI[aarch64_rust-winnow+unstable-doc-devel.sha256sum] = "e0b1186d65b38a96c821598ca489a928e8164b4b9f78845aaeb0b977e151f3d1"

URI_aarch64_rust-winnow+unstable-recover-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+unstable-recover-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-winnow+unstable-recover-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+unstable-recover-devel}"
SRC_URI[aarch64_rust-winnow+unstable-recover-devel.sha256sum] = "e7d0f678b94f1f6137d0173911e4d7831118c4d4e061f2744867709c4b247a00"

URI_aarch64_rust-winnow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-winnow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow-devel}"
SRC_URI[aarch64_rust-winnow-devel.sha256sum] = "116e6da8bade93f351338497a438a1102319a27f132eedf37b6132077c89c966"

RDEPENDS:rust-winnow+alloc-devel = " \
 cargo \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+ascii-devel = " \
 cargo \
 rust-winnow+parser-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+binary-devel = " \
 cargo \
 rust-winnow+parser-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+debug-devel = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-anstyle+default-devel \
 rust-terminal_size+default-devel \
 rust-winnow+std-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+default-devel = " \
 cargo \
 rust-winnow+ascii-devel \
 rust-winnow+binary-devel \
 rust-winnow+std-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+parser-devel = " \
 cargo \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+simd-devel = " \
 cargo \
 rust-memchr-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-winnow+alloc-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+unstable-doc-devel = " \
 cargo \
 rust-winnow+alloc-devel \
 rust-winnow+ascii-devel \
 rust-winnow+binary-devel \
 rust-winnow+simd-devel \
 rust-winnow+std-devel \
 rust-winnow+unstable-recover-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+unstable-recover-devel = " \
 cargo \
 rust-winnow+parser-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow-devel = " \
 cargo \
 rust \
 "
