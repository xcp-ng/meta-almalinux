# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wpa_supplicant"
PE = "1"
PV = "2.11"
PR = "4.el10"
PACKAGES = " \
 wpa_supplicant \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/wpa_supplicant-2.11-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56449c0fe2eb1197cd673e7da6823536c0dbc8583b6acf895a93d7cd238446af"

URI_x86_64_v2_wpa_supplicant = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/wpa_supplicant-2.11-4.el10.x86_64_v2.rpm;name=x86_64_v2_wpa_supplicant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wpa_supplicant}"
SRC_URI[x86_64_v2_wpa_supplicant.sha256sum] = "868948e45eb8501dc564a5e7c85c46a5e202110894bea2bda0ac73a107a69ab9"

URI_aarch64_wpa_supplicant = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/wpa_supplicant-2.11-4.el10.aarch64.rpm;name=aarch64_wpa_supplicant;unpack=0"
SRC_URI:append = " ${URI_aarch64_wpa_supplicant}"
SRC_URI[aarch64_wpa_supplicant.sha256sum] = "ec39f5ae9ed4b75baeedfd800a83eba8020ea9e187ef5ed02f3f08c5b69b8055"

RDEPENDS:wpa_supplicant = " \
 bash \
 dbus-libs \
 glibc \
 libnl3 \
 openssl-libs \
 pkcs11-provider \
 systemd \
 "
