# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-good"
PV = "1.26.7"
PR = "2.el10_2.8"
PACKAGES = " \
 gstreamer1-plugins-good \
 gstreamer1-plugins-good-gtk \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-good-1.26.7-2.el10_2.8.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1d9203b5c7ff3c986bb4ec1b34679cb9de3f3fb8e72622380ff85bed408a7be7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-good-1.26.7-2.el10_2.8.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-good;unpack=0"
SRC_URI[x86_64_v2_gstreamer1-plugins-good.sha256sum] = "f8def2d456b9152de50359f536d5b771d2e33077fcee89037c600a1b0c9514c3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-good-gtk-1.26.7-2.el10_2.8.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-good-gtk;unpack=0"
SRC_URI[x86_64_v2_gstreamer1-plugins-good-gtk.sha256sum] = "c9902bafc2742ad68689ca646e625212f728018d5d73f43fb4595507995c7b20"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-good-1.26.7-2.el10_2.8.aarch64.rpm;name=aarch64_gstreamer1-plugins-good;unpack=0"
SRC_URI[aarch64_gstreamer1-plugins-good.sha256sum] = "c0935a5b6e436480ddf8f70e3f09e327bb26c257ae79f5501b4d66f9341bed74"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-good-gtk-1.26.7-2.el10_2.8.aarch64.rpm;name=aarch64_gstreamer1-plugins-good-gtk;unpack=0"
SRC_URI[aarch64_gstreamer1-plugins-good-gtk.sha256sum] = "5a6d4f0c9e63beee6cf7c611303f8b7e37d63f68c0a8720adfc0ca7ebaf31ca7"

RDEPENDS:gstreamer1-plugins-good = " \
 bzip2-libs \
 cairo \
 cairo-gobject \
 flac-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 lame-libs \
 libX11 \
 libXdamage \
 libXext \
 libXfixes \
 libXtst \
 libgcc \
 libgudev \
 libjpeg-turbo \
 libpng \
 libshout \
 libstdc++ \
 libv4l \
 libvpx \
 libxml2 \
 mpg123-libs \
 openssl-libs \
 orc \
 pulseaudio-libs \
 speex \
 taglib \
 twolame-libs \
 wavpack \
 zlib-ng-compat \
 "
RDEPENDS:gstreamer1-plugins-good-gtk = " \
 cairo \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gstreamer1-plugins-good \
 gtk3 \
 "
