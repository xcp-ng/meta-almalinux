# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cswrap"
PV = "2.2.4"
PR = "2.el10_0"
PACKAGES = " \
 csexec \
 cswrap \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cswrap-2.2.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cc2ba9fde5e9851b2deec5ff8cddcd9a0a4dd43286bb377714712a2d4e691fd5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csexec-2.2.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csexec;unpack=0"
SRC_URI[x86_64_v2_csexec.sha256sum] = "fcbefcd7809701044bb994121f315be36dd49d7471dd1bb3901e59786fa6c226"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cswrap-2.2.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cswrap;unpack=0"
SRC_URI[x86_64_v2_cswrap.sha256sum] = "9f0c1401f5e82e46b5e9cc08e370474ed914971010aa49b4d8ff3ede5b584127"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/csexec-2.2.4-2.el10_0.aarch64.rpm;name=aarch64_csexec;unpack=0"
SRC_URI[aarch64_csexec.sha256sum] = "94e1da1bbe7c15cf9fb562428b0af30a4f0205fc61a8905ba5a24b80f9828b05"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cswrap-2.2.4-2.el10_0.aarch64.rpm;name=aarch64_cswrap;unpack=0"
SRC_URI[aarch64_cswrap.sha256sum] = "8286653419abdbcbabd5654f548f9eb70d49e57759824070566a01087b4cd087"

RDEPENDS:csexec = " \
 glibc \
 "
RDEPENDS:cswrap = " \
 glibc \
 "
