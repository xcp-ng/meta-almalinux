# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crun"
PV = "1.23.1"
PR = "1.el10_0"
PACKAGES = " \
 crun \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/crun-1.23.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb432199dd59f97cb8ed2932428684a3ce1f923c34133b99b8f0d6e06136dec4"

URI_x86_64_v2_crun = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crun-1.23.1-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_crun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crun}"
SRC_URI[x86_64_v2_crun.sha256sum] = "2554e60c65feaaf94282b4eee86ddedb8a3ddbee0ab676dc84974798fe583da3"

URI_aarch64_crun = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crun-1.23.1-1.el10_0.aarch64.rpm;name=aarch64_crun;unpack=0"
SRC_URI:append = " ${URI_aarch64_crun}"
SRC_URI[aarch64_crun.sha256sum] = "21d918072d95f55ccbdd033010737e3b64a6c77bc5dc53e682f1270eba0ef567"

RDEPENDS:crun = " \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 systemd-libs \
 "
