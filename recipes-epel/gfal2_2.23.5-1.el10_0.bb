# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gfal2"
PV = "2.23.5"
PR = "1.el10_0"
PACKAGES = " \
 gfal2 \
 gfal2-all \
 gfal2-devel \
 gfal2-doc \
 gfal2-plugin-file \
 gfal2-plugin-http \
 gfal2-plugin-mock \
 gfal2-plugin-srm \
 gfal2-plugin-xrootd \
 gfal2-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gfal2-2.23.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6d69852fe061322faa30ae33bc72adf9cb106eac598a17feee613aabe2cafd9"

URI_x86_64_v2_gfal2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-2.23.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2}"
SRC_URI[x86_64_v2_gfal2.sha256sum] = "68112585fbc9e9e466a13a8b9ee27d178e8171c62fd376468700b1567bb54006"

URI_x86_64_v2_gfal2-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-all-2.23.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-all}"
SRC_URI[x86_64_v2_gfal2-all.sha256sum] = "4078eda76f415d6233eb6bce5259d113e17ba466ebb5814f414919cad30fbf93"

URI_x86_64_v2_gfal2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-devel-2.23.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-devel}"
SRC_URI[x86_64_v2_gfal2-devel.sha256sum] = "895f049abe08241c6341d4efce0c6dc3f22fdd4600c56306538c5278b8b198e2"

URI_x86_64_v2_gfal2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-doc-2.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gfal2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-doc}"
SRC_URI[x86_64_v2_gfal2-doc.sha256sum] = "b8a97ebf7105e8d5539136402f409da5e872d9ad547e109b208945cfd96321b4"

URI_x86_64_v2_gfal2-plugin-file = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-file-2.23.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-file}"
SRC_URI[x86_64_v2_gfal2-plugin-file.sha256sum] = "bad0269d0464e249e6160ec23ac73fdc0f411ab07a44cc49976d6b1f92fcc180"

URI_x86_64_v2_gfal2-plugin-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-http-2.23.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-http}"
SRC_URI[x86_64_v2_gfal2-plugin-http.sha256sum] = "09ce10b25909ae2e192200d30cc06fcb886c7473875a86236ad7f9f9df51fc09"

URI_x86_64_v2_gfal2-plugin-mock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-mock-2.23.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-mock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-mock}"
SRC_URI[x86_64_v2_gfal2-plugin-mock.sha256sum] = "398d408c79cea5d37da8eaad46522a8948f3c32c5c6fba6bc79e248e7e014b9b"

URI_x86_64_v2_gfal2-plugin-srm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-srm-2.23.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-srm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-srm}"
SRC_URI[x86_64_v2_gfal2-plugin-srm.sha256sum] = "daa7e3ad4ea4e83036b7ac33b7e95de4cec81cd30150f3db5b531df6697ccbbe"

URI_x86_64_v2_gfal2-plugin-xrootd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-xrootd-2.23.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-xrootd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-xrootd}"
SRC_URI[x86_64_v2_gfal2-plugin-xrootd.sha256sum] = "528ea16b960eea31e60db51fb54406cc1256b63a1e2b2b3ad598f36590ca213f"

URI_x86_64_v2_gfal2-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-tests-2.23.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-tests}"
SRC_URI[x86_64_v2_gfal2-tests.sha256sum] = "604994db5b7a68c5c1398903f2fb0e46fb1bcc5f58fa2c6449a4cdc81819dbbf"

URI_aarch64_gfal2 = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-2.23.5-1.el10_0.aarch64.rpm;name=aarch64_gfal2;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2}"
SRC_URI[aarch64_gfal2.sha256sum] = "2031628215b4ccf37e2f15d809ec4f8186130421457444d687bd7176b5e3f740"

URI_aarch64_gfal2-all = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-all-2.23.5-1.el10_0.aarch64.rpm;name=aarch64_gfal2-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-all}"
SRC_URI[aarch64_gfal2-all.sha256sum] = "c67296e1ed34b43f4d0a9449df34360bddbbfdc94c397fe172279834b23d2e58"

URI_aarch64_gfal2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-devel-2.23.5-1.el10_0.aarch64.rpm;name=aarch64_gfal2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-devel}"
SRC_URI[aarch64_gfal2-devel.sha256sum] = "2ebcc548f863ada4ad7290e40155e17133b2ade882c0a2f5a46fa527b85d5d27"

URI_aarch64_gfal2-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-doc-2.23.5-1.el10_0.noarch.rpm;name=aarch64_gfal2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-doc}"
SRC_URI[aarch64_gfal2-doc.sha256sum] = "3c2aceeac2c9c21f026f03fab666e110881489ce1870df9551b37ba4272786c8"

URI_aarch64_gfal2-plugin-file = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-file-2.23.5-1.el10_0.aarch64.rpm;name=aarch64_gfal2-plugin-file;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-file}"
SRC_URI[aarch64_gfal2-plugin-file.sha256sum] = "5ed0ff6d9cf0983c22152878aec9a9ea947769eda496062ae5dc4d621a02add7"

URI_aarch64_gfal2-plugin-http = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-http-2.23.5-1.el10_0.aarch64.rpm;name=aarch64_gfal2-plugin-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-http}"
SRC_URI[aarch64_gfal2-plugin-http.sha256sum] = "6c49fe289b1b67d1eed16cbd3af75d8d1399d6a12c1766ffe616427f51eeb7af"

URI_aarch64_gfal2-plugin-mock = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-mock-2.23.5-1.el10_0.aarch64.rpm;name=aarch64_gfal2-plugin-mock;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-mock}"
SRC_URI[aarch64_gfal2-plugin-mock.sha256sum] = "52272e85bb11d1bdaa572c3b925aae64f345cd416302d194ce9e47bbdec7cff6"

URI_aarch64_gfal2-plugin-srm = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-srm-2.23.5-1.el10_0.aarch64.rpm;name=aarch64_gfal2-plugin-srm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-srm}"
SRC_URI[aarch64_gfal2-plugin-srm.sha256sum] = "6b20bf80095d807aff731f42a187dfbf791e5bf30463d34d2d7b778b1fe3efd5"

URI_aarch64_gfal2-plugin-xrootd = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-xrootd-2.23.5-1.el10_0.aarch64.rpm;name=aarch64_gfal2-plugin-xrootd;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-xrootd}"
SRC_URI[aarch64_gfal2-plugin-xrootd.sha256sum] = "7e685904012ab6637d326d91d4ebcc88318c17b58a7c600e4f88a5e8996edfa9"

URI_aarch64_gfal2-tests = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-tests-2.23.5-1.el10_0.aarch64.rpm;name=aarch64_gfal2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-tests}"
SRC_URI[aarch64_gfal2-tests.sha256sum] = "d3e51467580a6a91029629f344521acd1bbbe5ff177ca44ddc8115892977fbf0"

RDEPENDS:gfal2 = " \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 openldap \
 pugixml \
 "
RDEPENDS:gfal2-all = " \
 gfal2 \
 gfal2-plugin-file \
 gfal2-plugin-http \
 gfal2-plugin-srm \
 gfal2-plugin-xrootd \
 "
RDEPENDS:gfal2-devel = " \
 gfal2 \
 gfal2-devel \
 glib2-devel \
 libattr-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gfal2-doc = " \
 "
RDEPENDS:gfal2-plugin-file = " \
 gfal2 \
 glib2 \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:gfal2-plugin-http = " \
 cryptopp \
 davix-libs \
 gfal2 \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gfal2-plugin-mock = " \
 gfal2 \
 glib2 \
 glibc \
 libuuid \
 "
RDEPENDS:gfal2-plugin-srm = " \
 gfal2 \
 glib2 \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 srm-ifce \
 "
RDEPENDS:gfal2-plugin-xrootd = " \
 gfal2 \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 xrootd-client-libs \
 "
RDEPENDS:gfal2-tests = " \
 cryptopp \
 davix-libs \
 gfal2 \
 gfal2-all \
 gfal2-plugin-mock \
 glib2 \
 glibc \
 gtest \
 json-c \
 libgcc \
 libstdc++ \
 "
