# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virtme-ng"
PV = "1.41"
PR = "2.el10_3"
PACKAGES = " \
 virtme-ng \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/virtme-ng-1.41-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55426aa3e679a63f94a725439137d35fac642362914b42ee5291a4fe0f105b84"

URI_x86_64_v2_virtme-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/virtme-ng-1.41-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_virtme-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virtme-ng}"
SRC_URI[x86_64_v2_virtme-ng.sha256sum] = "f5101f7bd802d2c7b65d7533f88f9e02004df6b48b05ccbb1eb14f4b135affed"

URI_aarch64_virtme-ng = "${EPEL_MIRROR}/aarch64/Packages/v/virtme-ng-1.41-2.el10_3.aarch64.rpm;name=aarch64_virtme-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_virtme-ng}"
SRC_URI[aarch64_virtme-ng.sha256sum] = "1de737d5cdeff7ea07d05d5858ca8231572326619698960ac36acf688a0e07f3"

RDEPENDS:virtme-ng:x86_64_v2 = " \
 bash \
 glibc \
 python3 \
 python3-argcomplete \
 python3-requests \
"
RDEPENDS:virtme-ng:aarch64 = " \
 bash \
 python3 \
 python3-argcomplete \
 python3-requests \
"
