# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-File"
PV = "1.99.3"
PR = "4.el10_0"
PACKAGES = " \
 perl-Test-File \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-File-1.99.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a018496338ce0d3cc701fbab61b2001ee5e60629643291ee9080f6b7f25b8c9"

URI_x86_64_v2_perl-Test-File = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-File-1.99.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-File;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-File}"
SRC_URI[x86_64_v2_perl-Test-File.sha256sum] = "d1d62ad86e5d94e54136211d595422d142241c18fb055e0df23e92899ee061b0"

URI_aarch64_perl-Test-File = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-File-1.99.3-4.el10_0.noarch.rpm;name=aarch64_perl-Test-File;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-File}"
SRC_URI[aarch64_perl-Test-File.sha256sum] = "da94e43930e033a8d9b0bbbe5829a2c1160408960c0d4a108e2e39f90ecc2860"

RDEPENDS:perl-Test-File = " \
 perl-Carp \
 perl-Exporter \
 perl-PathTools \
 perl-Test-Simple \
 perl-libs \
 perl-vars \
 "
