# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytecheck_derive"
PV = "0.8.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-bytecheck_derive+default-devel \
 rust-bytecheck_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytecheck_derive-0.8.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aeedcd15c6cdeb66cd2b79717d9306944814abc7a9bf6bc2737494cfe99da5e2"

URI_x86_64_v2_rust-bytecheck_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck_derive+default-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck_derive+default-devel}"
SRC_URI[x86_64_v2_rust-bytecheck_derive+default-devel.sha256sum] = "6f5ac487841c856261c0ff0e7ddb538d08d05317e52ef8615dd9aba0686aec60"

URI_x86_64_v2_rust-bytecheck_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck_derive-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck_derive-devel}"
SRC_URI[x86_64_v2_rust-bytecheck_derive-devel.sha256sum] = "815867b5a97615e7d33adfaf6e31ce063c5b7bb9a73b7df63c646d69386c72a5"

URI_aarch64_rust-bytecheck_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck_derive+default-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytecheck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck_derive+default-devel}"
SRC_URI[aarch64_rust-bytecheck_derive+default-devel.sha256sum] = "f586d44cf2efd814ccfb3248fa7618c9fd1c0095f3031ef9cbc29593a6b56d0b"

URI_aarch64_rust-bytecheck_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck_derive-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytecheck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck_derive-devel}"
SRC_URI[aarch64_rust-bytecheck_derive-devel.sha256sum] = "c224b883f94fabd65c077edf0d261f93bbd06c381f8f1cdeaa01a04097ec4d13"

RDEPENDS:rust-bytecheck_derive+default-devel = " \
 cargo \
 rust-bytecheck_derive-devel \
 "
RDEPENDS:rust-bytecheck_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
