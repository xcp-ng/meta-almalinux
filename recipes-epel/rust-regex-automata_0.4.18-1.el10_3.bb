# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex-automata"
PV = "0.4.18"
PR = "1.el10_3"
PACKAGES = " \
 rust-regex-automata+alloc-devel \
 rust-regex-automata+default-devel \
 rust-regex-automata+dfa-build-devel \
 rust-regex-automata+dfa-devel \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+internal-instrument-devel \
 rust-regex-automata+internal-instrument-pikevm-devel \
 rust-regex-automata+logging-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-backtrack-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+perf-inline-devel \
 rust-regex-automata+perf-literal-devel \
 rust-regex-automata+perf-literal-multisubstring-devel \
 rust-regex-automata+perf-literal-substring-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata+unicode-age-devel \
 rust-regex-automata+unicode-bool-devel \
 rust-regex-automata+unicode-case-devel \
 rust-regex-automata+unicode-devel \
 rust-regex-automata+unicode-gencat-devel \
 rust-regex-automata+unicode-perl-devel \
 rust-regex-automata+unicode-script-devel \
 rust-regex-automata+unicode-segment-devel \
 rust-regex-automata+unicode-word-boundary-devel \
 rust-regex-automata-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-automata-0.4.18-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a83b46b71a682c85214f32e0a5306f77426a918c19d2034c7fa017e29f0287d9"

URI_x86_64_v2_rust-regex-automata+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+alloc-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+alloc-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+alloc-devel.sha256sum] = "a111e9435f725eb09aeb53f58f442f713f45e2fa111e61fd4cffb79e42b4b073"

URI_x86_64_v2_rust-regex-automata+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+default-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+default-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+default-devel.sha256sum] = "3242feb8007651edcff2d7201cb887e3e4a6db2b15554ff7b3a1b2b1d03570a4"

URI_x86_64_v2_rust-regex-automata+dfa-build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-build-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-build-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-build-devel.sha256sum] = "2806945fb6b7abea6c952c18eb232c5754c0621e7454d985456d016983885bc5"

URI_x86_64_v2_rust-regex-automata+dfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-devel.sha256sum] = "add92eed3efc9ba1b698c45d8a5a6f39bf6db2f3d19766d3cced79c94870ccb3"

URI_x86_64_v2_rust-regex-automata+dfa-onepass-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-onepass-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-onepass-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-onepass-devel.sha256sum] = "e6f6202b43dd4b91c61ef5a66bdba6384c29188c01d14e17d153f197c95efb49"

URI_x86_64_v2_rust-regex-automata+dfa-search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-search-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-search-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-search-devel.sha256sum] = "e99e4a4398c0ae178465b6957bb529ed12aa0a1d967bc04e29b239e7716d9499"

URI_x86_64_v2_rust-regex-automata+hybrid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+hybrid-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+hybrid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+hybrid-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+hybrid-devel.sha256sum] = "ad8968ef4a32a25a3574640dd3a9f5f1f99afb89e954cf2d407f3145e1c4c82b"

URI_x86_64_v2_rust-regex-automata+internal-instrument-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+internal-instrument-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+internal-instrument-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+internal-instrument-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+internal-instrument-devel.sha256sum] = "58fa45271a3394a90705fb173cc5b243650e336e8903e8f5b5d9429cf79718ea"

URI_x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+internal-instrument-pikevm-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel.sha256sum] = "12823b186b139af8db496be8de70980c9ee310618b9c390b834f53bfa3c2ad23"

URI_x86_64_v2_rust-regex-automata+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+logging-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+logging-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+logging-devel.sha256sum] = "fef5ad7c3460971d6c4bc6e4ba5c0025dcc95246fcece50f0683ab0dc9f5932d"

URI_x86_64_v2_rust-regex-automata+meta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+meta-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+meta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+meta-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+meta-devel.sha256sum] = "48f113bebb85d43fc48f092a4f45dc04e0b6800e9bbd0a19faa7a86f2c377f1e"

URI_x86_64_v2_rust-regex-automata+nfa-backtrack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-backtrack-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-backtrack-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-backtrack-devel.sha256sum] = "5cc85cab2e2464407396db744e017762343e7581605e93f3da5a58a7ced6d9ea"

URI_x86_64_v2_rust-regex-automata+nfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-devel.sha256sum] = "171abc1f6ff2a229e55172c1617f89cea80dc6da8f14033b7f8b5599f2eb6390"

URI_x86_64_v2_rust-regex-automata+nfa-pikevm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-pikevm-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-pikevm-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-pikevm-devel.sha256sum] = "9b861b9238ffabe25bad77f4b8efddae74eba25830842ad9a3121b8259e117eb"

URI_x86_64_v2_rust-regex-automata+nfa-thompson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-thompson-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-thompson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-thompson-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-thompson-devel.sha256sum] = "c299d0fc89159edb3f3fb4ea2be2638174080e53cde5118240675e7153f055ae"

URI_x86_64_v2_rust-regex-automata+perf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-devel.sha256sum] = "e2526d89eae507e13be6934d90b618ae826421abc36426d8d84bde5ae3f312f9"

URI_x86_64_v2_rust-regex-automata+perf-inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-inline-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-inline-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-inline-devel.sha256sum] = "4172e013ef02075aa785b8cbb5fc1416d65f8b9f5c0c69c75948724eba748f97"

URI_x86_64_v2_rust-regex-automata+perf-literal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-literal-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-literal-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-literal-devel.sha256sum] = "48f2cc329086a595b436f2abaab6d019d70de0f0ffd3cb3466b11437c23aa10b"

URI_x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-literal-multisubstring-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel.sha256sum] = "23a8b6de1b33b19d209f2910ea449ada1a70955b60d1b2fb66c8503b7bd201bf"

URI_x86_64_v2_rust-regex-automata+perf-literal-substring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-literal-substring-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-literal-substring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-literal-substring-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-literal-substring-devel.sha256sum] = "08460d39980d160540fd12f99c73b8a479025a9ded60e9710d49c06ee4e9a80a"

URI_x86_64_v2_rust-regex-automata+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+std-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+std-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+std-devel.sha256sum] = "9352adb067783f2e5f263afaedd224588087e017bd19e170cf090f37473bc0f8"

URI_x86_64_v2_rust-regex-automata+syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+syntax-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+syntax-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+syntax-devel.sha256sum] = "23124502c8c1826c59cd06e7f5500619e4db195de83217064392d2eaba44506f"

URI_x86_64_v2_rust-regex-automata+unicode-age-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-age-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-age-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-age-devel.sha256sum] = "0c12186421337532d07a5c8e7d018281168ad58ec24f3fcda2af51c0f27c8c82"

URI_x86_64_v2_rust-regex-automata+unicode-bool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-bool-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-bool-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-bool-devel.sha256sum] = "ce7086a52b2420048fef6f68a13014c65913c55a9135f0f41540f41b513d5fed"

URI_x86_64_v2_rust-regex-automata+unicode-case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-case-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-case-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-case-devel.sha256sum] = "6fc6398ad22ebecadc617f8ceb5a5fd8ef7de2881176811e26235fdda7e5e892"

URI_x86_64_v2_rust-regex-automata+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-devel.sha256sum] = "c2768c2f045abd8397e7fcdcadb7c9db56e4f361d69a6265c03729b77bc24f2a"

URI_x86_64_v2_rust-regex-automata+unicode-gencat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-gencat-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-gencat-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-gencat-devel.sha256sum] = "1627d2938f169d7515ee2e47958a7e2a02fd63849cd40989e2471ef7f4804549"

URI_x86_64_v2_rust-regex-automata+unicode-perl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-perl-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-perl-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-perl-devel.sha256sum] = "e94bc8bef7d654b2402240851a15a65798000a69845ab958ee9e6de42c0fe32f"

URI_x86_64_v2_rust-regex-automata+unicode-script-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-script-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-script-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-script-devel.sha256sum] = "2351472707ee0c74d15cb5fef08406865f9a0c560d7ecd891ffbb73847c53733"

URI_x86_64_v2_rust-regex-automata+unicode-segment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-segment-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-segment-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-segment-devel.sha256sum] = "baba6bc7d547f9938e09a4647368bda6c7112e09c9cf6341811968aa70b1bc0d"

URI_x86_64_v2_rust-regex-automata+unicode-word-boundary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-word-boundary-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-word-boundary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-word-boundary-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-word-boundary-devel.sha256sum] = "9ce183499835bc72dc7f60fad2de9f093c3f202bf6519e757c152dba9b51bfeb"

URI_x86_64_v2_rust-regex-automata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata-devel-0.4.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata-devel}"
SRC_URI[x86_64_v2_rust-regex-automata-devel.sha256sum] = "c2a404e9f118adfdf33a9fea52e6dc5d9dd8ae72178e878ade995e75c1fd7370"

URI_aarch64_rust-regex-automata+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+alloc-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+alloc-devel}"
SRC_URI[aarch64_rust-regex-automata+alloc-devel.sha256sum] = "bb1a8220cf6770955c61957f496e85c20d51e470f62d3fec41f5a15b5ceaa828"

URI_aarch64_rust-regex-automata+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+default-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+default-devel}"
SRC_URI[aarch64_rust-regex-automata+default-devel.sha256sum] = "2a8fdf0be6c8b051eb0a3b125b9d42c2f00dd3985bfa4748d260782259dc29d1"

URI_aarch64_rust-regex-automata+dfa-build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-build-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+dfa-build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-build-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-build-devel.sha256sum] = "8fa123f8a8693788437605c2443681c99aaca30dabf743256765b21be490f018"

URI_aarch64_rust-regex-automata+dfa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+dfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-devel.sha256sum] = "452d9d618324ad4cb0226d0463dd00b22e5b2f15e3367d3bd4bc52ed26ec710a"

URI_aarch64_rust-regex-automata+dfa-onepass-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-onepass-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+dfa-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-onepass-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-onepass-devel.sha256sum] = "2adf9d34dcda3414de4a7a0158cab33ddf441575cfd0333c2d3dbdaa08b901b3"

URI_aarch64_rust-regex-automata+dfa-search-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-search-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+dfa-search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-search-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-search-devel.sha256sum] = "78cd909bf9bea6d43f595a264420b4c1aaa8c3074b72502a7eed0d2e6190fb54"

URI_aarch64_rust-regex-automata+hybrid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+hybrid-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+hybrid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+hybrid-devel}"
SRC_URI[aarch64_rust-regex-automata+hybrid-devel.sha256sum] = "d029f80990ebe67205828ee4ecfb76add0b361cb532b7b066704e6eb7e32f17f"

URI_aarch64_rust-regex-automata+internal-instrument-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+internal-instrument-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+internal-instrument-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+internal-instrument-devel}"
SRC_URI[aarch64_rust-regex-automata+internal-instrument-devel.sha256sum] = "1b3a057d9476bf8b0b4a293bdcec4d21d0a67dea6b025ec015e138ed456ab7cb"

URI_aarch64_rust-regex-automata+internal-instrument-pikevm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+internal-instrument-pikevm-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+internal-instrument-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+internal-instrument-pikevm-devel}"
SRC_URI[aarch64_rust-regex-automata+internal-instrument-pikevm-devel.sha256sum] = "a698c20cb9e1773e1c5407abc706e15e6683f70df6d8b6c72826274592a118e4"

URI_aarch64_rust-regex-automata+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+logging-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+logging-devel}"
SRC_URI[aarch64_rust-regex-automata+logging-devel.sha256sum] = "8f9e90384275eae8d4746f5f294cdc3886d7c2d9473daec308132b52a8e360ee"

URI_aarch64_rust-regex-automata+meta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+meta-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+meta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+meta-devel}"
SRC_URI[aarch64_rust-regex-automata+meta-devel.sha256sum] = "b049ca94988a095e0749e52349784afd7d9ad64d4f1d5fafb589cca91db7ef81"

URI_aarch64_rust-regex-automata+nfa-backtrack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-backtrack-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+nfa-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-backtrack-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-backtrack-devel.sha256sum] = "4ca81b392b014877b5ef7dcab8e713ab89b20c550302b897d24d1b65c809355c"

URI_aarch64_rust-regex-automata+nfa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+nfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-devel.sha256sum] = "add74948e994e548f19082bb324ccff40105ed98cd7426e7a418dd77f64deca4"

URI_aarch64_rust-regex-automata+nfa-pikevm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-pikevm-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+nfa-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-pikevm-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-pikevm-devel.sha256sum] = "b16003ed1d76cf5cdbe70c6d9c24312b2bad93ae3eab140983e90b5daf882ae3"

URI_aarch64_rust-regex-automata+nfa-thompson-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-thompson-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+nfa-thompson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-thompson-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-thompson-devel.sha256sum] = "f43c39a05f740c603c04af1c9ad7d779e15eb0ca9bc6065f661a83a7e5f6d2e8"

URI_aarch64_rust-regex-automata+perf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+perf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-devel.sha256sum] = "0c2fc96e22cc5f604881542ed4e0d118fd0315bc95d7cd6f48521b03c05fa5b2"

URI_aarch64_rust-regex-automata+perf-inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-inline-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-inline-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-inline-devel.sha256sum] = "ef14797c4f17728fd10218207e9c075156c6c0471cf5be818ce72c3b97a284e3"

URI_aarch64_rust-regex-automata+perf-literal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-literal-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-literal-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-literal-devel.sha256sum] = "b386d2d90a52ecf1af282d1229f3522e3f6920bed84d42aac32a49827f744c61"

URI_aarch64_rust-regex-automata+perf-literal-multisubstring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-literal-multisubstring-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+perf-literal-multisubstring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-literal-multisubstring-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-literal-multisubstring-devel.sha256sum] = "0a2a5629130e84f956016d3db5ebe07689b044c0e7ed1557fdb9fc12b4edff47"

URI_aarch64_rust-regex-automata+perf-literal-substring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-literal-substring-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+perf-literal-substring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-literal-substring-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-literal-substring-devel.sha256sum] = "2d8140b87874572f8deb0e19fa05e2e2d18c69b762e6f16d37cf60d6fe8eb780"

URI_aarch64_rust-regex-automata+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+std-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+std-devel}"
SRC_URI[aarch64_rust-regex-automata+std-devel.sha256sum] = "0e5ad898dfe78df7c6af466ddb669810d3cea06e7af79719e9425264c03018fd"

URI_aarch64_rust-regex-automata+syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+syntax-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+syntax-devel}"
SRC_URI[aarch64_rust-regex-automata+syntax-devel.sha256sum] = "89b434b40fd18e3ff8aa7c1bab60760948c0de88b31a25bc86aec2257175b472"

URI_aarch64_rust-regex-automata+unicode-age-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-age-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-age-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-age-devel.sha256sum] = "86dac1093d00287bf8b7bb7981128b3af799bd731f61ec78be727bd504eeb3b4"

URI_aarch64_rust-regex-automata+unicode-bool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-bool-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-bool-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-bool-devel.sha256sum] = "f90d06582b708b1490682d55c68f567d8389248067dcd5577d8c49f34a67e414"

URI_aarch64_rust-regex-automata+unicode-case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-case-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-case-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-case-devel.sha256sum] = "61c323e6d7b4a463168f5b4d970b82211404ebff38ed50da84b5e816c31ec2b7"

URI_aarch64_rust-regex-automata+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-devel.sha256sum] = "18fef84b5138017789262fcbebc07c333f6b5182ac8eec561bd77333db9818b4"

URI_aarch64_rust-regex-automata+unicode-gencat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-gencat-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-gencat-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-gencat-devel.sha256sum] = "7c7e940aa972d9ca65952e5fc1097d418340132578a837e40d66facf9ba99e9f"

URI_aarch64_rust-regex-automata+unicode-perl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-perl-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-perl-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-perl-devel.sha256sum] = "fe4ae8149551f83091044b936943324bcf1eadd2af4b8e8b8b2afbb00cfab2c9"

URI_aarch64_rust-regex-automata+unicode-script-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-script-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-script-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-script-devel.sha256sum] = "4d3cb4a66b19d62799ee22493184d856d0c7e7174a2d67cf92e67e04e675c94f"

URI_aarch64_rust-regex-automata+unicode-segment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-segment-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-segment-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-segment-devel.sha256sum] = "9ab63500446691c46a7e1f1b138aab8efe30df886f10c49fd56af7ea89b7bd1c"

URI_aarch64_rust-regex-automata+unicode-word-boundary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-word-boundary-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata+unicode-word-boundary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-word-boundary-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-word-boundary-devel.sha256sum] = "addd56383070d695e91072d77ce9e896d1d37e4c0be2ceaaf372c361439bf45a"

URI_aarch64_rust-regex-automata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata-devel-0.4.18-1.el10_3.noarch.rpm;name=aarch64_rust-regex-automata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata-devel}"
SRC_URI[aarch64_rust-regex-automata-devel.sha256sum] = "70f164504c537039b3a25a515661f4f4319eb1a12f6a72a296d561f718c577b3"

RDEPENDS:rust-regex-automata+alloc-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+default-devel = " \
 cargo \
 rust-regex-automata+dfa-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata+unicode-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-build-devel = " \
 cargo \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-devel = " \
 cargo \
 rust-regex-automata+dfa-build-devel \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-onepass-devel = " \
 cargo \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-search-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+hybrid-devel = " \
 cargo \
 rust-regex-automata+alloc-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+internal-instrument-devel = " \
 cargo \
 rust-regex-automata+internal-instrument-pikevm-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+internal-instrument-pikevm-devel = " \
 cargo \
 rust-regex-automata+logging-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+logging-devel = " \
 cargo \
 rust-aho-corasick+logging-devel \
 rust-aho-corasick-devel \
 rust-log+default-devel \
 rust-memchr+logging-devel \
 rust-memchr-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+meta-devel = " \
 cargo \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-backtrack-devel = " \
 cargo \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-devel = " \
 cargo \
 rust-regex-automata+nfa-backtrack-devel \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-pikevm-devel = " \
 cargo \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-thompson-devel = " \
 cargo \
 rust-regex-automata+alloc-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-devel = " \
 cargo \
 rust-regex-automata+perf-inline-devel \
 rust-regex-automata+perf-literal-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-inline-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-literal-devel = " \
 cargo \
 rust-regex-automata+perf-literal-multisubstring-devel \
 rust-regex-automata+perf-literal-substring-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-literal-multisubstring-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-literal-substring-devel = " \
 cargo \
 rust-aho-corasick+perf-literal-devel \
 rust-aho-corasick-devel \
 rust-memchr-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+std-devel = " \
 cargo \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-regex-automata+alloc-devel \
 rust-regex-automata-devel \
 rust-regex-syntax+std-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+syntax-devel = " \
 cargo \
 rust-regex-automata+alloc-devel \
 rust-regex-automata-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-age-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-age-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-bool-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-bool-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-case-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-case-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-devel = " \
 cargo \
 rust-regex-automata+unicode-age-devel \
 rust-regex-automata+unicode-bool-devel \
 rust-regex-automata+unicode-case-devel \
 rust-regex-automata+unicode-gencat-devel \
 rust-regex-automata+unicode-perl-devel \
 rust-regex-automata+unicode-script-devel \
 rust-regex-automata+unicode-segment-devel \
 rust-regex-automata+unicode-word-boundary-devel \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-gencat-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-gencat-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-perl-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-perl-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-script-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-script-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-segment-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-segment-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-word-boundary-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata-devel = " \
 cargo \
 rust \
 "
