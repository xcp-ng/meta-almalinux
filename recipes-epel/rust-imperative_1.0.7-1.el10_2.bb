# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-imperative"
PV = "1.0.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-imperative+default-devel \
 rust-imperative-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-imperative-1.0.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6cc9380fb5fb85fed01fc62f1cef3922a0c1d2057dcf3248951f81cb3a931e2b"

URI_x86_64_v2_rust-imperative+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imperative+default-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imperative+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imperative+default-devel}"
SRC_URI[x86_64_v2_rust-imperative+default-devel.sha256sum] = "19d53489a1bcc28ca6ed2fd71441309e189e6faf69713d17ab282abc60be2b55"

URI_x86_64_v2_rust-imperative-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imperative-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imperative-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imperative-devel}"
SRC_URI[x86_64_v2_rust-imperative-devel.sha256sum] = "31e56b3443f94ffb3f273854581b22d98fb1e3bd4a243cfa3d3d99279c72f885"

URI_aarch64_rust-imperative+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imperative+default-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-imperative+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imperative+default-devel}"
SRC_URI[aarch64_rust-imperative+default-devel.sha256sum] = "65cc250f8490531ad8d21c008c50f2a25188079c523a745cb8ed8f71b11c79cb"

URI_aarch64_rust-imperative-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imperative-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-imperative-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imperative-devel}"
SRC_URI[aarch64_rust-imperative-devel.sha256sum] = "cddf2e66a886f777b32f241a0052feee73716254ded094967404d3b88368f0e8"

RDEPENDS:rust-imperative+default-devel = " \
 cargo \
 rust-imperative-devel \
 "
RDEPENDS:rust-imperative-devel = " \
 cargo \
 rust \
 rust-phf+default-devel \
 rust-rust-stemmers+default-devel \
 "
