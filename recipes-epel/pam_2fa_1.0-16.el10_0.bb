# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam_2fa"
PV = "1.0"
PR = "16.el10_0"
PACKAGES = " \
 pam_2fa \
 pam_ssh_user_auth \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam_2fa-1.0-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abc089ac06cce8c7b865672aebc89194913944b09ccd1b20f76898a43635a4e5"

URI_x86_64_v2_pam_2fa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_2fa-1.0-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_2fa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_2fa}"
SRC_URI[x86_64_v2_pam_2fa.sha256sum] = "48205248cab3467b5ca32399022cf40b8f788b87fdb05cf82d04332530d4d3ac"

URI_x86_64_v2_pam_ssh_user_auth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_ssh_user_auth-1.0-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_ssh_user_auth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_ssh_user_auth}"
SRC_URI[x86_64_v2_pam_ssh_user_auth.sha256sum] = "1cb2034f382823b91b14f32971b2e673a63f4f29fa6a377d5cbbcc1f07b7d038"

URI_aarch64_pam_2fa = "${EPEL_MIRROR}/aarch64/Packages/p/pam_2fa-1.0-16.el10_0.aarch64.rpm;name=aarch64_pam_2fa;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_2fa}"
SRC_URI[aarch64_pam_2fa.sha256sum] = "7b7d63b362d36e93dd4c7aa1a7e0f24949f6e818f83025894137705ca324e5b1"

URI_aarch64_pam_ssh_user_auth = "${EPEL_MIRROR}/aarch64/Packages/p/pam_ssh_user_auth-1.0-16.el10_0.aarch64.rpm;name=aarch64_pam_ssh_user_auth;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_ssh_user_auth}"
SRC_URI[aarch64_pam_ssh_user_auth.sha256sum] = "093389e298878b02a1a7fff04cfd8b800e6a2ca5cfafa00f7479457cd7960aa1"

RDEPENDS:pam_2fa = " \
 glibc \
 openldap \
 pam \
 pam-libs \
 virtual/libcurl.so.4___64bit_ \
 ykclient \
 "
RDEPENDS:pam_ssh_user_auth = " \
 glibc \
 pam \
 pam-libs \
 "
