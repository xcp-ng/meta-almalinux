# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_json"
PV = "1.0.149"
PR = "1.el10_1"
PACKAGES = " \
 rust-serde_json+alloc-devel \
 rust-serde_json+arbitrary_precision-devel \
 rust-serde_json+default-devel \
 rust-serde_json+float_roundtrip-devel \
 rust-serde_json+indexmap-devel \
 rust-serde_json+preserve_order-devel \
 rust-serde_json+raw_value-devel \
 rust-serde_json+std-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-serde_json-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_json-1.0.149-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eee294c1f832471e0a07932d7df28b0233026f1f047186e6975fbbe0d67f5ae6"

URI_x86_64_v2_rust-serde_json+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+alloc-devel-1.0.149-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde_json+alloc-devel.sha256sum] = "aa50ba89d244e3daadca9466f53b8f57952859de0d9f54808a13346cc761047e"

URI_x86_64_v2_rust-serde_json+arbitrary_precision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+arbitrary_precision-devel-1.0.149-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+arbitrary_precision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+arbitrary_precision-devel}"
SRC_URI[x86_64_v2_rust-serde_json+arbitrary_precision-devel.sha256sum] = "80c4e41870089bb9d412facdbe88481abb46fd807994d449d197436f051ed216"

URI_x86_64_v2_rust-serde_json+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+default-devel-1.0.149-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+default-devel}"
SRC_URI[x86_64_v2_rust-serde_json+default-devel.sha256sum] = "bd5a967dffffe9ffba835c5ab5c4387be4c0cf915cd55239cbfbc4b66d0788a2"

URI_x86_64_v2_rust-serde_json+float_roundtrip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+float_roundtrip-devel-1.0.149-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+float_roundtrip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+float_roundtrip-devel}"
SRC_URI[x86_64_v2_rust-serde_json+float_roundtrip-devel.sha256sum] = "4bec9f3d77a9c25848257c0e234719dbb0ff4ad1a4ddbc4b679b32c3ec1234f7"

URI_x86_64_v2_rust-serde_json+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+indexmap-devel-1.0.149-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+indexmap-devel}"
SRC_URI[x86_64_v2_rust-serde_json+indexmap-devel.sha256sum] = "53f9f8083efb32c43a478704e7d6a3c2fca0a9b43195c3188e8ff5f3f9cf0676"

URI_x86_64_v2_rust-serde_json+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+preserve_order-devel-1.0.149-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-serde_json+preserve_order-devel.sha256sum] = "70c7644531fe491bcdbc5e08ff8d00829214c8e86c6ffb32a3d566822b835334"

URI_x86_64_v2_rust-serde_json+raw_value-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+raw_value-devel-1.0.149-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+raw_value-devel}"
SRC_URI[x86_64_v2_rust-serde_json+raw_value-devel.sha256sum] = "8078fc72195b15d02591cd0e10a04340e5ee284c6baf7d52f54fdeea9a1d0ed0"

URI_x86_64_v2_rust-serde_json+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+std-devel-1.0.149-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+std-devel}"
SRC_URI[x86_64_v2_rust-serde_json+std-devel.sha256sum] = "af6dfa916d04a786978f22bbb4f6bbcd87aebc07f3f88b45683ac1e55b6619c3"

URI_x86_64_v2_rust-serde_json+unbounded_depth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+unbounded_depth-devel-1.0.149-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+unbounded_depth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+unbounded_depth-devel}"
SRC_URI[x86_64_v2_rust-serde_json+unbounded_depth-devel.sha256sum] = "54dbdcde25c1f2299548cbade48570bbf6b7fb3377fb0167b59c3f1bcfbbb5b4"

URI_x86_64_v2_rust-serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json-devel-1.0.149-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json-devel}"
SRC_URI[x86_64_v2_rust-serde_json-devel.sha256sum] = "9fa205061076e255d3741a5a27508b83cb051750814ccada8968efd83063877d"

URI_aarch64_rust-serde_json+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+alloc-devel-1.0.149-1.el10_1.noarch.rpm;name=aarch64_rust-serde_json+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+alloc-devel}"
SRC_URI[aarch64_rust-serde_json+alloc-devel.sha256sum] = "4e1c13d6cbd4ac8cd3bdf598e80ed1154c0d777422dd0e1302680b04e80b4cd3"

URI_aarch64_rust-serde_json+arbitrary_precision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+arbitrary_precision-devel-1.0.149-1.el10_1.noarch.rpm;name=aarch64_rust-serde_json+arbitrary_precision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+arbitrary_precision-devel}"
SRC_URI[aarch64_rust-serde_json+arbitrary_precision-devel.sha256sum] = "07330e7ea12203c801cde3a31655583bbf87bd4b5a5ee69266f79ccc122a17b2"

URI_aarch64_rust-serde_json+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+default-devel-1.0.149-1.el10_1.noarch.rpm;name=aarch64_rust-serde_json+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+default-devel}"
SRC_URI[aarch64_rust-serde_json+default-devel.sha256sum] = "aab462a0205f1737ed004dc4296ebec026f19e1e01d57eb684c32f0b2600921e"

URI_aarch64_rust-serde_json+float_roundtrip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+float_roundtrip-devel-1.0.149-1.el10_1.noarch.rpm;name=aarch64_rust-serde_json+float_roundtrip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+float_roundtrip-devel}"
SRC_URI[aarch64_rust-serde_json+float_roundtrip-devel.sha256sum] = "1c8fcb28b494a7c938acca11f37c0ad71c2afb4318e7317e4f2cf084965f6304"

URI_aarch64_rust-serde_json+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+indexmap-devel-1.0.149-1.el10_1.noarch.rpm;name=aarch64_rust-serde_json+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+indexmap-devel}"
SRC_URI[aarch64_rust-serde_json+indexmap-devel.sha256sum] = "ba47acc587b29ab7bc83ffb24149fc3f913e673066378f806167ad88a577318d"

URI_aarch64_rust-serde_json+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+preserve_order-devel-1.0.149-1.el10_1.noarch.rpm;name=aarch64_rust-serde_json+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+preserve_order-devel}"
SRC_URI[aarch64_rust-serde_json+preserve_order-devel.sha256sum] = "f29735b1abad1edf4b5f864860b88922f45ca00f009d9bcdd135c49067a210ad"

URI_aarch64_rust-serde_json+raw_value-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+raw_value-devel-1.0.149-1.el10_1.noarch.rpm;name=aarch64_rust-serde_json+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+raw_value-devel}"
SRC_URI[aarch64_rust-serde_json+raw_value-devel.sha256sum] = "6eeef14cef3ab77fcd55e00e50ae53a1cd3ff9724cd739d1276dd72ed38d2239"

URI_aarch64_rust-serde_json+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+std-devel-1.0.149-1.el10_1.noarch.rpm;name=aarch64_rust-serde_json+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+std-devel}"
SRC_URI[aarch64_rust-serde_json+std-devel.sha256sum] = "7039750cc8224c46cc5df0c4c088bba731b963c56177487f750d428607d6e8a5"

URI_aarch64_rust-serde_json+unbounded_depth-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+unbounded_depth-devel-1.0.149-1.el10_1.noarch.rpm;name=aarch64_rust-serde_json+unbounded_depth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+unbounded_depth-devel}"
SRC_URI[aarch64_rust-serde_json+unbounded_depth-devel.sha256sum] = "71160ae22deb42b0b8cbdf6580e95273e9f8e3b87683e8b18058eb5cba2a7f41"

URI_aarch64_rust-serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json-devel-1.0.149-1.el10_1.noarch.rpm;name=aarch64_rust-serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json-devel}"
SRC_URI[aarch64_rust-serde_json-devel.sha256sum] = "e95781628c1cfea41ab7d7b73252b111ac8db50e429b36210d5640edbf3902d3"

RDEPENDS:rust-serde_json+alloc-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+arbitrary_precision-devel = " \
 cargo \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+default-devel = " \
 cargo \
 rust-serde_json+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+float_roundtrip-devel = " \
 cargo \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+preserve_order-devel = " \
 cargo \
 rust-serde_json+indexmap-devel \
 rust-serde_json+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+raw_value-devel = " \
 cargo \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-serde_core+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+unbounded_depth-devel = " \
 cargo \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json-devel = " \
 cargo \
 rust \
 rust-itoa+default-devel \
 rust-memchr-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 rust-zmij+default-devel \
 "
