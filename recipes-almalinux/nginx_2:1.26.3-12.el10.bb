# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx"
PE = "2"
PV = "1.26.3"
PR = "12.el10"
PACKAGES = " \
 nginx \
 nginx-all-modules \
 nginx-core \
 nginx-filesystem \
 nginx-mod-devel \
 nginx-mod-http-image-filter \
 nginx-mod-http-perl \
 nginx-mod-http-xslt-filter \
 nginx-mod-mail \
 nginx-mod-stream \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nginx-1.26.3-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "031741cf88ee8088dabde90216f0d155be7842ba774ce764712748dd9fdf1065"

URI_x86_64_v2_nginx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-1.26.3-12.el10.x86_64_v2.rpm;name=x86_64_v2_nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx}"
SRC_URI[x86_64_v2_nginx.sha256sum] = "7b7da4e4f1e91da7e741dc1662ae167b140f8e6f644c85b6943cafde08de95ec"
RPROVIDES:nginx:x86_64_v2 = "virtual/httpd_or_nginx virtual/webserver"

URI_x86_64_v2_nginx-all-modules = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-all-modules-1.26.3-12.el10.noarch.rpm;name=x86_64_v2_nginx-all-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-all-modules}"
SRC_URI[x86_64_v2_nginx-all-modules.sha256sum] = "78a24fdf092703862e90aa48bbeb083c22a55be85569ca5bcafb346c1a14b77f"

URI_x86_64_v2_nginx-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-core-1.26.3-12.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-core}"
SRC_URI[x86_64_v2_nginx-core.sha256sum] = "82c29b15eeefe032e9221abda5e8d7cd4e0e22f444cf8ca38024edb5455608fb"

URI_x86_64_v2_nginx-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-filesystem-1.26.3-12.el10.noarch.rpm;name=x86_64_v2_nginx-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-filesystem}"
SRC_URI[x86_64_v2_nginx-filesystem.sha256sum] = "1a217f67416c7ebff70d01e5b8881f1518142df35442a643101ffb3f73973b83"

URI_x86_64_v2_nginx-mod-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nginx-mod-devel-1.26.3-12.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-devel}"
SRC_URI[x86_64_v2_nginx-mod-devel.sha256sum] = "4223c0c11e1545a6cf353172d2a2618b14272cd2cdd58ad56fabbc6aad110364"

URI_x86_64_v2_nginx-mod-http-image-filter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-image-filter-1.26.3-12.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-image-filter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-http-image-filter}"
SRC_URI[x86_64_v2_nginx-mod-http-image-filter.sha256sum] = "117d6081dd501bc63160a87398287e31d1f0cf95f12afd3dc928cc9f89782314"

URI_x86_64_v2_nginx-mod-http-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-perl-1.26.3-12.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-http-perl}"
SRC_URI[x86_64_v2_nginx-mod-http-perl.sha256sum] = "6dad01365e8106471a1c05b3d4b58ec8891dde261f65c4e799981d2a09637cf2"

URI_x86_64_v2_nginx-mod-http-xslt-filter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-xslt-filter-1.26.3-12.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-xslt-filter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-http-xslt-filter}"
SRC_URI[x86_64_v2_nginx-mod-http-xslt-filter.sha256sum] = "e6cd805c3301b3bdeabcb98e68dcdb4cc61d043144467afa8800fdd6f6fa9f64"

URI_x86_64_v2_nginx-mod-mail = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-mail-1.26.3-12.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-mail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-mail}"
SRC_URI[x86_64_v2_nginx-mod-mail.sha256sum] = "8c5e1fa65aebe643e26563f46b9f7144212ae5d161aa7a0c4f9f08dea5ce9f1c"

URI_x86_64_v2_nginx-mod-stream = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-stream-1.26.3-12.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-stream;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-stream}"
SRC_URI[x86_64_v2_nginx-mod-stream.sha256sum] = "a9b64f5fe15d1997a241db1cf5c7b6d193d58799563c50195eda4827d365cb94"

URI_aarch64_nginx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-1.26.3-12.el10.aarch64.rpm;name=aarch64_nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx}"
SRC_URI[aarch64_nginx.sha256sum] = "7e6ddbc99f62beb8d6f1801dd92b0cf8a4df1ef51860c2178d0c9f262e837abf"
RPROVIDES:nginx:aarch64 = "virtual/httpd_or_nginx virtual/webserver"

URI_aarch64_nginx-all-modules = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-all-modules-1.26.3-12.el10.noarch.rpm;name=aarch64_nginx-all-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-all-modules}"
SRC_URI[aarch64_nginx-all-modules.sha256sum] = "78a24fdf092703862e90aa48bbeb083c22a55be85569ca5bcafb346c1a14b77f"

URI_aarch64_nginx-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-core-1.26.3-12.el10.aarch64.rpm;name=aarch64_nginx-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-core}"
SRC_URI[aarch64_nginx-core.sha256sum] = "28d2afad30f9b5bb4f1aa12c84190bcb68c481199ed7df2ab2ea8aef1e1f1a47"

URI_aarch64_nginx-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-filesystem-1.26.3-12.el10.noarch.rpm;name=aarch64_nginx-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-filesystem}"
SRC_URI[aarch64_nginx-filesystem.sha256sum] = "1a217f67416c7ebff70d01e5b8881f1518142df35442a643101ffb3f73973b83"

URI_aarch64_nginx-mod-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nginx-mod-devel-1.26.3-12.el10.aarch64.rpm;name=aarch64_nginx-mod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-devel}"
SRC_URI[aarch64_nginx-mod-devel.sha256sum] = "bf2892dce8fca2a13c00f542791aa7c74d15a50bf3beb026f5aa21e0825199ad"

URI_aarch64_nginx-mod-http-image-filter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-image-filter-1.26.3-12.el10.aarch64.rpm;name=aarch64_nginx-mod-http-image-filter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-http-image-filter}"
SRC_URI[aarch64_nginx-mod-http-image-filter.sha256sum] = "a3a354ce79f933a69c3f9a5e0380cfdbf25a27c122fca11ff69a9ecfb22f913b"

URI_aarch64_nginx-mod-http-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-perl-1.26.3-12.el10.aarch64.rpm;name=aarch64_nginx-mod-http-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-http-perl}"
SRC_URI[aarch64_nginx-mod-http-perl.sha256sum] = "9b69d62b3442104f37c092d32b4f387d123be52fce28a9e5f5cc5a0de158941f"

URI_aarch64_nginx-mod-http-xslt-filter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-xslt-filter-1.26.3-12.el10.aarch64.rpm;name=aarch64_nginx-mod-http-xslt-filter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-http-xslt-filter}"
SRC_URI[aarch64_nginx-mod-http-xslt-filter.sha256sum] = "d98062a1bd4360429d2d05890541bd0c36c1e41277e00e59286099017ad1f8b7"

URI_aarch64_nginx-mod-mail = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-mail-1.26.3-12.el10.aarch64.rpm;name=aarch64_nginx-mod-mail;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-mail}"
SRC_URI[aarch64_nginx-mod-mail.sha256sum] = "fc45764108182e0b1680545d4986aa1763e2808f205aa93bd4fc8cabe56a0917"

URI_aarch64_nginx-mod-stream = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-stream-1.26.3-12.el10.aarch64.rpm;name=aarch64_nginx-mod-stream;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-stream}"
SRC_URI[aarch64_nginx-mod-stream.sha256sum] = "f03e0c53c73ac3dda0b40b476355c61a9652d24ebfb7cedb8919fa08a25f346c"

RDEPENDS:nginx = " \
 almalinux-logos-httpd \
 bash \
 nginx-core \
 nginx-filesystem \
 systemd \
 "
RDEPENDS:nginx-all-modules = " \
 nginx-mod-http-image-filter \
 nginx-mod-http-perl \
 nginx-mod-http-xslt-filter \
 nginx-mod-mail \
 nginx-mod-stream \
 "
RDEPENDS:nginx-core = " \
 glibc \
 libxcrypt \
 nginx-filesystem \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:nginx-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:nginx-mod-devel = " \
 bash \
 gcc \
 gd-devel \
 libxslt-devel \
 make \
 nginx \
 openssl-devel \
 pcre2-devel \
 perl-Exporter \
 perl-ExtUtils-Embed \
 perl-constant \
 perl-devel \
 perl-interpreter \
 perl-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:nginx-mod-http-image-filter = " \
 bash \
 gd \
 glibc \
 nginx \
 "
RDEPENDS:nginx-mod-http-perl = " \
 bash \
 glibc \
 nginx \
 perl-Exporter \
 perl-constant \
 perl-libs \
 "
RDEPENDS:nginx-mod-http-xslt-filter = " \
 bash \
 glibc \
 libxml2 \
 libxslt \
 nginx \
 "
RDEPENDS:nginx-mod-mail = " \
 bash \
 glibc \
 nginx \
 "
RDEPENDS:nginx-mod-stream = " \
 bash \
 glibc \
 nginx \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/httpd_or_nginx rpm/virtual/webserver"

PROVIDES:append:aarch64 = " rpm/virtual/httpd_or_nginx rpm/virtual/webserver"
