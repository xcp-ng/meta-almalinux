# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pipewire"
PV = "1.4.11"
PR = "1.el10_2.1"
PACKAGES = " \
 pipewire \
 pipewire-alsa \
 pipewire-devel \
 pipewire-gstreamer \
 pipewire-jack-audio-connection-kit \
 pipewire-jack-audio-connection-kit-devel \
 pipewire-jack-audio-connection-kit-libs \
 pipewire-libs \
 pipewire-module-x11 \
 pipewire-plugin-libcamera \
 pipewire-pulseaudio \
 pipewire-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pipewire-1.4.11-1.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "14a3f570528844259dbcf840bdd81f31cc9deb9c2cbae7d00910f1dc4e8819e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-1.4.11-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pipewire;unpack=0"
SRC_URI[x86_64_v2_pipewire.sha256sum] = "a319adcadac952563501ac65085967157692905d4479cabc440a624e0527a46d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-alsa-1.4.11-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pipewire-alsa;unpack=0"
SRC_URI[x86_64_v2_pipewire-alsa.sha256sum] = "da0c2885e9f86431ef51dada5857d29703f131a641fa8609a92c58bf1dc8c3ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-devel-1.4.11-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pipewire-devel;unpack=0"
SRC_URI[x86_64_v2_pipewire-devel.sha256sum] = "c8e0e36373118906e56ce07f13ee548fc666e52c5343f931c32039042e3c20ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-gstreamer-1.4.11-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pipewire-gstreamer;unpack=0"
SRC_URI[x86_64_v2_pipewire-gstreamer.sha256sum] = "30082ae9f4636bc0371b107473e2fd8b684e2b45259c10858c0a830c9d46b034"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-1.4.11-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit;unpack=0"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit.sha256sum] = "cd5a49624459529e0b804d7d38f4433dae1945ac6de97be95caebd82ee3a4438"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-devel-1.4.11-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit-devel;unpack=0"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit-devel.sha256sum] = "e5cfbc8f470a70816a9f604d20c415531b37f61c53991ac89cb216246a55e98a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-libs-1.4.11-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit-libs;unpack=0"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit-libs.sha256sum] = "1078c3e3468f836a8117ad9439cb5fe7f24e33cdea4bfd2653479d78c7fb3adf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-libs-1.4.11-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pipewire-libs;unpack=0"
SRC_URI[x86_64_v2_pipewire-libs.sha256sum] = "17ddef1da155ead568c36145e1e737ca8d4d33391034d5bb05841a2016ca0f70"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-module-x11-1.4.11-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pipewire-module-x11;unpack=0"
SRC_URI[x86_64_v2_pipewire-module-x11.sha256sum] = "8ba9bf3f984f0a8d1483c036915149a76c49a3e9f929825d8346bf92446682f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-plugin-libcamera-1.4.11-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pipewire-plugin-libcamera;unpack=0"
SRC_URI[x86_64_v2_pipewire-plugin-libcamera.sha256sum] = "26705d4af2821a697855a482bb874758a626892270142dbd4122ff076db0fdbe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-pulseaudio-1.4.11-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pipewire-pulseaudio;unpack=0"
SRC_URI[x86_64_v2_pipewire-pulseaudio.sha256sum] = "18e2bd67724eb1dde547705de406e25ea5ff108bdc5344ed51fc30ccd5c5a5e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-utils-1.4.11-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pipewire-utils;unpack=0"
SRC_URI[x86_64_v2_pipewire-utils.sha256sum] = "2bb73e0cffaaf86b17919a5a5e3f7cddc681f8d3eaaec0316c2b19914c4a8d9f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-1.4.11-1.el10_2.1.aarch64.rpm;name=aarch64_pipewire;unpack=0"
SRC_URI[aarch64_pipewire.sha256sum] = "3db94a8329bb6be3ccc0b85215739d27b7ce6730976bfcb5f748a4925ea094a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-alsa-1.4.11-1.el10_2.1.aarch64.rpm;name=aarch64_pipewire-alsa;unpack=0"
SRC_URI[aarch64_pipewire-alsa.sha256sum] = "f3427dc227839d4bed8b97cca0a51519f6ffdedfc5fabfd505d6ef0f3a26930d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-devel-1.4.11-1.el10_2.1.aarch64.rpm;name=aarch64_pipewire-devel;unpack=0"
SRC_URI[aarch64_pipewire-devel.sha256sum] = "7b1bba02850f23e276540b55bcd289f2fccc655dfe307789904d3f21fa829493"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-gstreamer-1.4.11-1.el10_2.1.aarch64.rpm;name=aarch64_pipewire-gstreamer;unpack=0"
SRC_URI[aarch64_pipewire-gstreamer.sha256sum] = "c8611317482f4e8447b46228bae6521e28c01c5b1c76d86471371d246d2371ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-1.4.11-1.el10_2.1.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit;unpack=0"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit.sha256sum] = "985c30087fe7ecea67de571e3d6ecac4bf2c72501b538db64b01ecec8cd53b55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-devel-1.4.11-1.el10_2.1.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit-devel;unpack=0"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit-devel.sha256sum] = "549eb5ba6d7bd05c35f550048ec6fa0a2ae67906a5d3d37e11a4935032617a8d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-libs-1.4.11-1.el10_2.1.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit-libs;unpack=0"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit-libs.sha256sum] = "735a9881abf4632b94fac57b2be0fc327a6cf7732b2f8319ddb6c8a9a90a84c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-libs-1.4.11-1.el10_2.1.aarch64.rpm;name=aarch64_pipewire-libs;unpack=0"
SRC_URI[aarch64_pipewire-libs.sha256sum] = "efe81313c9ad9caeff3871c95481ec0df4fd4ea10ddcc090d0c9a4e4da87f267"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-module-x11-1.4.11-1.el10_2.1.aarch64.rpm;name=aarch64_pipewire-module-x11;unpack=0"
SRC_URI[aarch64_pipewire-module-x11.sha256sum] = "fb8ef4ff0f0047b6311b9b1b3894eb1d8df03337696a741d4b6478639e1984fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-plugin-libcamera-1.4.11-1.el10_2.1.aarch64.rpm;name=aarch64_pipewire-plugin-libcamera;unpack=0"
SRC_URI[aarch64_pipewire-plugin-libcamera.sha256sum] = "d0c27fe2e96fbddef544ffcab938672cae77e1a1a6eb3665e3eb6929d6ec5cfe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-pulseaudio-1.4.11-1.el10_2.1.aarch64.rpm;name=aarch64_pipewire-pulseaudio;unpack=0"
SRC_URI[aarch64_pipewire-pulseaudio.sha256sum] = "8dfdc648264c86dd8c5b2b9218f4c58271e5cf61155a86a66dd48d475566f534"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-utils-1.4.11-1.el10_2.1.aarch64.rpm;name=aarch64_pipewire-utils;unpack=0"
SRC_URI[aarch64_pipewire-utils.sha256sum] = "df7c10055d0573936bd94145c1edf0e28d443478ec36d4dc070a58a17bd9c51b"

RDEPENDS:pipewire = " \
 bash \
 glibc \
 pipewire-libs \
 rtkit \
 systemd \
 wireplumber \
 "
RDEPENDS:pipewire-alsa = " \
 alsa-lib \
 glibc \
 pipewire-libs \
 "
RDEPENDS:pipewire-devel = " \
 pipewire-devel \
 pipewire-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pipewire-gstreamer = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libgcc \
 pipewire-libs \
 "
RDEPENDS:pipewire-jack-audio-connection-kit = " \
 pipewire-jack-audio-connection-kit-libs \
 "
RDEPENDS:pipewire-jack-audio-connection-kit-devel = " \
 pipewire-jack-audio-connection-kit-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pipewire-jack-audio-connection-kit-libs = " \
 bash \
 glibc \
 pipewire-jack-audio-connection-kit \
 pipewire-libs \
 "
RDEPENDS:pipewire-libs = " \
 alsa-lib \
 avahi-libs \
 bluez-libs \
 dbus-libs \
 fdk-aac-free \
 fftw-libs-single \
 glib2 \
 glibc \
 libgcc \
 liblc3 \
 libldac \
 libsbc \
 libselinux \
 libsndfile \
 libstdc++ \
 libusb1 \
 openssl-libs \
 opus \
 pulseaudio-libs \
 systemd-libs \
 webrtc-audio-processing \
 "
RDEPENDS:pipewire-module-x11 = " \
 glibc \
 libX11 \
 libXfixes \
 libcanberra \
 pipewire-libs \
 "
RDEPENDS:pipewire-plugin-libcamera = " \
 glibc \
 libcamera \
 libdrm \
 libgcc \
 libstdc++ \
 pipewire-libs \
 "
RDEPENDS:pipewire-pulseaudio = " \
 avahi-libs \
 bash \
 dbus-libs \
 glib2 \
 glibc \
 libgcc \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:pipewire-utils = " \
 alsa-lib \
 dbus-libs \
 glibc \
 libgcc \
 libsndfile \
 ncurses-libs \
 pipewire \
 pipewire-libs \
 readline \
 "
