# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-axum-core"
PV = "0.5.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-axum-core+default-devel \
 rust-axum-core+tracing-devel \
 rust-axum-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-axum-core-0.5.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "211f83d0d979ff59120d8802b12c86c75a63e83ddd2292aab7c7d682987f0feb"

URI_x86_64_v2_rust-axum-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-core+default-devel-0.5.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-core+default-devel}"
SRC_URI[x86_64_v2_rust-axum-core+default-devel.sha256sum] = "ddab76c08105527ad2ab139600373bf2e5645ec1eacbb6699dd72c8abbde4484"

URI_x86_64_v2_rust-axum-core+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-core+tracing-devel-0.5.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-core+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-core+tracing-devel}"
SRC_URI[x86_64_v2_rust-axum-core+tracing-devel.sha256sum] = "574a0c4fed1a8426cd2d0916eb25332902590bf1a599e2f4d7383c8e7eaa21a1"

URI_x86_64_v2_rust-axum-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-core-devel-0.5.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-core-devel}"
SRC_URI[x86_64_v2_rust-axum-core-devel.sha256sum] = "1ee0896eeb87a4a58a7166f52a5607a61912b49803dd296f5a24e0757214b769"

URI_aarch64_rust-axum-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-core+default-devel-0.5.6-1.el10_2.noarch.rpm;name=aarch64_rust-axum-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-core+default-devel}"
SRC_URI[aarch64_rust-axum-core+default-devel.sha256sum] = "dd764e7aa48fda4fcc223ba06642b8f70235b6cac11a691fa977874b2df34e49"

URI_aarch64_rust-axum-core+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-core+tracing-devel-0.5.6-1.el10_2.noarch.rpm;name=aarch64_rust-axum-core+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-core+tracing-devel}"
SRC_URI[aarch64_rust-axum-core+tracing-devel.sha256sum] = "694a3c2bdb6e73ff01551626a319b79bd48362a630b81d720cf4be6fa83a1198"

URI_aarch64_rust-axum-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-core-devel-0.5.6-1.el10_2.noarch.rpm;name=aarch64_rust-axum-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-core-devel}"
SRC_URI[aarch64_rust-axum-core-devel.sha256sum] = "172b9da0d3e05017574634d96a3a84d03fd213e1d037863c9983126d39445afb"

RDEPENDS:rust-axum-core+default-devel = " \
 cargo \
 rust-axum-core-devel \
 "
RDEPENDS:rust-axum-core+tracing-devel = " \
 cargo \
 rust-axum-core-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-axum-core-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-futures-core+default-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-mime+default-devel \
 rust-pin-project-lite+default-devel \
 rust-sync_wrapper+default-devel \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
