# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ncclient"
PV = "0.6.19"
PR = "1.el10_1"
PACKAGES = " \
 python-ncclient-doc \
 python3-ncclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ncclient-0.6.19-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45cc7ffbc4671840e7ac643b8826b704757885692ff5c2f0a35b228063d1b477"

URI_x86_64_v2_python-ncclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-ncclient-doc-0.6.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-ncclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-ncclient-doc}"
SRC_URI[x86_64_v2_python-ncclient-doc.sha256sum] = "e82800500dc30693a417d9e7a320f290b62a9f83c1595f4077d4be6f4d179aa4"

URI_x86_64_v2_python3-ncclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ncclient-0.6.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ncclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ncclient}"
SRC_URI[x86_64_v2_python3-ncclient.sha256sum] = "1f5c512b8d95480ab995411d3db8251763ef3b5cffd0d25e8aee30cbe88a758b"

URI_aarch64_python-ncclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-ncclient-doc-0.6.19-1.el10_1.noarch.rpm;name=aarch64_python-ncclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-ncclient-doc}"
SRC_URI[aarch64_python-ncclient-doc.sha256sum] = "3b2096ba123d1f25770960cce4a98d941991cd2d3f9332b9ff3d44f52cd68749"

URI_aarch64_python3-ncclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ncclient-0.6.19-1.el10_1.noarch.rpm;name=aarch64_python3-ncclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ncclient}"
SRC_URI[aarch64_python3-ncclient.sha256sum] = "438e6e98d98624c235800151b747de66a30db8b7129a200c5dbf4aba8fe32685"

RDEPENDS:python-ncclient-doc = " \
 "
RDEPENDS:python3-ncclient = " \
 python3 \
 python3-lxml \
 python3-paramiko \
 "
