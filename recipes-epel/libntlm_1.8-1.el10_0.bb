# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libntlm"
PV = "1.8"
PR = "1.el10_0"
PACKAGES = " \
 libntlm \
 libntlm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libntlm-1.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67b7023bf4d06715b6d6ae454b3ba5131d7a012e8694600b61a6c287a0df8a80"

URI_x86_64_v2_libntlm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libntlm-1.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libntlm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libntlm}"
SRC_URI[x86_64_v2_libntlm.sha256sum] = "822e2ec96f61302a5671223dde3dd64da8a344cbf1aebabaad317d6d405ea61b"

URI_x86_64_v2_libntlm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libntlm-devel-1.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libntlm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libntlm-devel}"
SRC_URI[x86_64_v2_libntlm-devel.sha256sum] = "98e7ccda7444d2658e07039e359a7ff97ddab5ed89ee86a93fb1f61fe8045268"

URI_aarch64_libntlm = "${EPEL_MIRROR}/aarch64/Packages/l/libntlm-1.8-1.el10_0.aarch64.rpm;name=aarch64_libntlm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libntlm}"
SRC_URI[aarch64_libntlm.sha256sum] = "c9525c50591166a63fa28b42cec5615b160747722fa11e2a47a9de867bf3f7ec"

URI_aarch64_libntlm-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libntlm-devel-1.8-1.el10_0.aarch64.rpm;name=aarch64_libntlm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libntlm-devel}"
SRC_URI[aarch64_libntlm-devel.sha256sum] = "e8174c6f3ff78ba29c35e43ad93d6420d55cb4f92cfa054195f7b06ab57e16fe"

RDEPENDS:libntlm = " \
 glibc \
 "
RDEPENDS:libntlm-devel = " \
 libntlm \
 pkgconf-pkg-config \
 "
