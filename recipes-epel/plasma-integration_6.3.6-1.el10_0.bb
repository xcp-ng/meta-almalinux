# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-integration"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-integration \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-integration-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "788da310cd79db6f04dea3a6d1ec5d73c14d5de2d2b7f5a31dae6af2d8919bb9"

URI_x86_64_v2_plasma-integration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-integration-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-integration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-integration}"
SRC_URI[x86_64_v2_plasma-integration.sha256sum] = "2609d2f154721a96a3f011465fda8cf6e2dcc365a2eb7c88273b1d1703566628"

URI_aarch64_plasma-integration = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-integration-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-integration;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-integration}"
SRC_URI[aarch64_plasma-integration.sha256sum] = "62903fce55145251e4c5c897db1ad1c0f62a9e1bb5339ee7ea972595900539bf"

RDEPENDS:plasma-integration = " \
 breeze-cursor-theme \
 breeze-icon-theme \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-qqc2-desktop-style \
 libXcursor \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-breeze \
 qqc2-breeze-style \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 "
