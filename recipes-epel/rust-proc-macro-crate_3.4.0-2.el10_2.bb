# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro-crate"
PV = "3.4.0"
PR = "2.el10_2"
PACKAGES = " \
 rust-proc-macro-crate+default-devel \
 rust-proc-macro-crate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro-crate-3.4.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "752b80ef389840a777d729782de2ac8252386d0f7f8ac009aeede6831f1ad4e6"

URI_x86_64_v2_rust-proc-macro-crate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-crate+default-devel-3.4.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-crate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-crate+default-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-crate+default-devel.sha256sum] = "00ace45842ef508be55cd1cf13eee4f4b40a83e47c91cef277a7d3bf1e9e2c5c"

URI_x86_64_v2_rust-proc-macro-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-crate-devel-3.4.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-crate-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-crate-devel.sha256sum] = "e69b1e696c346738c6b6315a4315af2c8b2fa9b4ca460018953219707a51e0d7"

URI_aarch64_rust-proc-macro-crate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-crate+default-devel-3.4.0-2.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-crate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-crate+default-devel}"
SRC_URI[aarch64_rust-proc-macro-crate+default-devel.sha256sum] = "e733bae9d6a687ab52650f2637c75f7c86964f42003a94ada74a1c3f4cee9160"

URI_aarch64_rust-proc-macro-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-crate-devel-3.4.0-2.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-crate-devel}"
SRC_URI[aarch64_rust-proc-macro-crate-devel.sha256sum] = "1d0c1589586775f778a20bac9ee6c4bfec3477c4d49aa0a54db0f6f5ae903a13"

RDEPENDS:rust-proc-macro-crate+default-devel = " \
 cargo \
 rust-proc-macro-crate-devel \
 "
RDEPENDS:rust-proc-macro-crate-devel = " \
 cargo \
 rust \
 virtual/crate_toml_edit/parse__ge_0.23.2_with_crate_toml_edit/parse__lt_0.25.0~ \
 virtual/crate_toml_edit__ge_0.23.2_with_crate_toml_edit__lt_0.25.0~ \
 "
