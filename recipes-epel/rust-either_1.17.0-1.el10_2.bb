# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-either"
PV = "1.17.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-either+default-devel \
 rust-either+serde-devel \
 rust-either+std-devel \
 rust-either+use_std-devel \
 rust-either-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-either-1.17.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b829290e69ce424fa26f3e1c4fd557576d89b498e7ea55bf09d877ca5d3c7409"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+default-devel-1.17.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-either+default-devel.sha256sum] = "523f607bca1eeaa2f29b5237e013b29842b02e7fb99ab1f90f60d3a4d1756f12"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+serde-devel-1.17.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-either+serde-devel.sha256sum] = "1429f22895bfabb833548cd0fcd95d9594fe5ed33f5e2131ee01a77936f26e48"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+std-devel-1.17.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-either+std-devel.sha256sum] = "7966b32def254d23e07cf2fa5ff872306e3d14971f8b190ff31a7d3d08c12e94"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+use_std-devel-1.17.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+use_std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-either+use_std-devel.sha256sum] = "6e50ff65d0e727055442416c205a600bfde6c2525a2047f59b0d089cd6f5a50d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either-devel-1.17.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either-devel;unpack=0"
SRC_URI[x86_64_v2_rust-either-devel.sha256sum] = "d9a4fd4a6319e5eaedab96d3e6110bb35bf5cce0ba2e618e54803c3f397fab8f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-either+default-devel-1.17.0-1.el10_2.noarch.rpm;name=aarch64_rust-either+default-devel;unpack=0"
SRC_URI[aarch64_rust-either+default-devel.sha256sum] = "e4577906846464e74479b0fac00b3056b4f5aa462464dcbe256ceacdf72a7cc3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-either+serde-devel-1.17.0-1.el10_2.noarch.rpm;name=aarch64_rust-either+serde-devel;unpack=0"
SRC_URI[aarch64_rust-either+serde-devel.sha256sum] = "78a31d61c293378e0ba49b8379b751f7e46d10ea0f3829b0f7d3add3b4b82621"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-either+std-devel-1.17.0-1.el10_2.noarch.rpm;name=aarch64_rust-either+std-devel;unpack=0"
SRC_URI[aarch64_rust-either+std-devel.sha256sum] = "e27f4ac21e4ce3516de1ec139377a12ece16c6374daa7aeee17c6bb18123cf27"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-either+use_std-devel-1.17.0-1.el10_2.noarch.rpm;name=aarch64_rust-either+use_std-devel;unpack=0"
SRC_URI[aarch64_rust-either+use_std-devel.sha256sum] = "68d9f3e4454ef9330ed477db989756cddeab26576f52c87f81bf24e368f282f8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-either-devel-1.17.0-1.el10_2.noarch.rpm;name=aarch64_rust-either-devel;unpack=0"
SRC_URI[aarch64_rust-either-devel.sha256sum] = "a5853312bf2b41a62b64047e2c5cd01a93e5fecf425af81cf2a6a36e4b3e3987"

RDEPENDS:rust-either+default-devel = " \
 cargo \
 rust-either+std-devel \
 rust-either-devel \
 "
RDEPENDS:rust-either+serde-devel = " \
 cargo \
 rust-either-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-either+std-devel = " \
 cargo \
 rust-either-devel \
 "
RDEPENDS:rust-either+use_std-devel = " \
 cargo \
 rust-either+std-devel \
 rust-either-devel \
 "
RDEPENDS:rust-either-devel = " \
 cargo \
 rust \
 "
