# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ongres-stringprep"
PV = "1.1"
PR = "16.el10"
PACKAGES = " \
 ongres-stringprep \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ongres-stringprep-1.1-16.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "30d47c58db642ec12a36a060d85e0a648b4d8bdf80e29314e47ef71c37793c62"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ongres-stringprep-1.1-16.el10.noarch.rpm;name=x86_64_v2_ongres-stringprep;unpack=0"
SRC_URI[x86_64_v2_ongres-stringprep.sha256sum] = "bb67d2b90eb9d67cb1caa991d005d008fce84a144fbe421f3df870414986a8b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ongres-stringprep-1.1-16.el10.noarch.rpm;name=aarch64_ongres-stringprep;unpack=0"
SRC_URI[aarch64_ongres-stringprep.sha256sum] = "bb67d2b90eb9d67cb1caa991d005d008fce84a144fbe421f3df870414986a8b4"

RDEPENDS:ongres-stringprep = " \
 javapackages-filesystem \
 "
