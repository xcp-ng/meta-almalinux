# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-asgiref"
PV = "3.8.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-asgiref \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-asgiref-3.8.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "152fc7954a0768c682a6943dc35a57b2342e1027807ce0f85941dc403013e286"

URI_x86_64_v2_python3-asgiref = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-asgiref-3.8.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-asgiref;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-asgiref}"
SRC_URI[x86_64_v2_python3-asgiref.sha256sum] = "d92af58e8dd9ba5a0ca2ce0ca87f8ee62e52cbf580934d357a96a58120bd261d"

URI_aarch64_python3-asgiref = "${EPEL_MIRROR}/aarch64/Packages/p/python3-asgiref-3.8.1-1.el10_0.noarch.rpm;name=aarch64_python3-asgiref;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-asgiref}"
SRC_URI[aarch64_python3-asgiref.sha256sum] = "d4a5fe7c590d769bc7e6cb29262025484ab5594752f6eeea356ca8e0c2e4cea2"

RDEPENDS:python3-asgiref = " \
 python3 \
 "
