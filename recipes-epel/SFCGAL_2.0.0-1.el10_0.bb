# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "SFCGAL"
PV = "2.0.0"
PR = "1.el10_0"
PACKAGES = " \
 SFCGAL \
 SFCGAL-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/SFCGAL-2.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "719a5cd6c15bb74b72e7de088443e071681423734c1b66c55c9e01e32d09d6d7"

URI_x86_64_v2_SFCGAL = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SFCGAL-2.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SFCGAL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SFCGAL}"
SRC_URI[x86_64_v2_SFCGAL.sha256sum] = "e2516704f89d5c2b56e00c2287ee5da0d80b54fd3fdd4161817f671aeb81d120"

URI_x86_64_v2_SFCGAL-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SFCGAL-devel-2.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SFCGAL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SFCGAL-devel}"
SRC_URI[x86_64_v2_SFCGAL-devel.sha256sum] = "5c03486a3013c194bcd7321abf55d96faf16ae3a75d7040ab920e13eb00c2b2d"

URI_aarch64_SFCGAL = "${EPEL_MIRROR}/aarch64/Packages/s/SFCGAL-2.0.0-1.el10_0.aarch64.rpm;name=aarch64_SFCGAL;unpack=0"
SRC_URI:append = " ${URI_aarch64_SFCGAL}"
SRC_URI[aarch64_SFCGAL.sha256sum] = "f88c73ebd10d5420b333c95659a3ec56a1dbebe92a3024304d46bf03f8c4bbe5"

URI_aarch64_SFCGAL-devel = "${EPEL_MIRROR}/aarch64/Packages/s/SFCGAL-devel-2.0.0-1.el10_0.aarch64.rpm;name=aarch64_SFCGAL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_SFCGAL-devel}"
SRC_URI[aarch64_SFCGAL-devel.sha256sum] = "42ccfbe7e2dcf313cd3e77ffac0bbf22aa93133ac53974d5925ba420ae6cfe4e"

RDEPENDS:SFCGAL = " \
 boost-serialization \
 glibc \
 gmp \
 gmp-c++ \
 libgcc \
 libstdc++ \
 mpfr \
 "
RDEPENDS:SFCGAL-devel = " \
 SFCGAL \
 bash \
 pkgconf-pkg-config \
 "
