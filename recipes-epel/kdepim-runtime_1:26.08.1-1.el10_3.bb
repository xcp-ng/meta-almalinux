# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdepim-runtime"
PE = "1"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kdepim-runtime \
 kdepim-runtime-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdepim-runtime-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "95ba989610272d564d3447bf7aa91a2a4b989de568e68a564a6a0728c6f6c6b3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdepim-runtime-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdepim-runtime;unpack=0"
SRC_URI[x86_64_v2_kdepim-runtime.sha256sum] = "0d6ad582bbf75a75e0b06fe9e44cbfed012b39d32fd1f98e89dbe0e10346989f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdepim-runtime-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdepim-runtime-libs;unpack=0"
SRC_URI[x86_64_v2_kdepim-runtime-libs.sha256sum] = "8195d52a8ecc7825935b371b69d54539ecdc4903a0c3f15cced4c8dbdd5fe887"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdepim-runtime-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdepim-runtime;unpack=0"
SRC_URI[aarch64_kdepim-runtime.sha256sum] = "25f852ddb5846ed77461cc58f7cf418be43b9179ab2db6911ef22ef112d95ac2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdepim-runtime-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdepim-runtime-libs;unpack=0"
SRC_URI[aarch64_kdepim-runtime-libs.sha256sum] = "18be876119ed2a88a9efc2a346e1d0b898b080449a6d1c64e420b22f5c116769"

RDEPENDS:kdepim-runtime = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 cyrus-sasl-lib \
 glibc \
 kdepim-runtime-libs \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kdav \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kmime \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kidentitymanagement \
 kimap \
 kmailtransport \
 kmbox \
 ktextaddons-qt6 \
 libgcc \
 libkgapi \
 libstdc++ \
 pimcommon \
 qca-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtnetworkauth \
 qt6-qtspeech \
 qt6-qtwebengine \
 qtkeychain-qt6 \
 "
RDEPENDS:kdepim-runtime-libs = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kdav \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kmime \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 kimap \
 kldap \
 kmailtransport \
 kmbox \
 libgcc \
 libkgapi \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
