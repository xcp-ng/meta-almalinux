# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "v4l-utils"
PV = "1.26.1"
PR = "4.el10"
PACKAGES = " \
 libv4l \
 libv4l-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/v4l-utils-1.26.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc4d8fb9384e6a37203883743c8a56dd8404275cbc971987341ebe42ecee734f"

URI_x86_64_v2_libv4l = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libv4l-1.26.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_libv4l;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libv4l}"
SRC_URI[x86_64_v2_libv4l.sha256sum] = "e1b736f322e1ea5f917b0dbc21d7099e8dc11d75f5f5259584e9833538a13b60"

URI_x86_64_v2_libv4l-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libv4l-devel-1.26.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_libv4l-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libv4l-devel}"
SRC_URI[x86_64_v2_libv4l-devel.sha256sum] = "c33fde29ebcae6748a88ae8cf5677ccfb01a4daa1c13dc7aded6501b9f625787"

URI_aarch64_libv4l = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libv4l-1.26.1-4.el10.aarch64.rpm;name=aarch64_libv4l;unpack=0"
SRC_URI:append = " ${URI_aarch64_libv4l}"
SRC_URI[aarch64_libv4l.sha256sum] = "704b4bca5ef8b5e148a1e9fff2e62f1e7dca7a2ad1493adf782a18ca2ad497c4"

URI_aarch64_libv4l-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libv4l-devel-1.26.1-4.el10.aarch64.rpm;name=aarch64_libv4l-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libv4l-devel}"
SRC_URI[aarch64_libv4l-devel.sha256sum] = "aacb8069909da2c1ed4a60435fd66b17fab266967eee21816a040e4040c72b4c"

RDEPENDS:libv4l = " \
 glibc \
 libjpeg-turbo \
 "
RDEPENDS:libv4l-devel = " \
 libjpeg-turbo-devel \
 libv4l \
 libv4l-devel \
 pkgconf-pkg-config \
 "
