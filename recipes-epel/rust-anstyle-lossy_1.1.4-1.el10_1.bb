# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-lossy"
PV = "1.1.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-anstyle-lossy+default-devel \
 rust-anstyle-lossy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-lossy-1.1.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86e5bce4f09d607a4672e2ebdb2a50d1b9c229c0061fb172ece90d8b7532f833"

URI_x86_64_v2_rust-anstyle-lossy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-lossy+default-devel-1.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-lossy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-lossy+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle-lossy+default-devel.sha256sum] = "cefa31c7da37b6ff001e37a20c243490bd0eae4053e3eac5e02f8e578ef3ffa0"

URI_x86_64_v2_rust-anstyle-lossy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-lossy-devel-1.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-lossy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-lossy-devel}"
SRC_URI[x86_64_v2_rust-anstyle-lossy-devel.sha256sum] = "1c52fb4051ddbf99ef070dea1f8ff4d35d7152daef2b21b897fc6565a198d512"

URI_aarch64_rust-anstyle-lossy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-lossy+default-devel-1.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-anstyle-lossy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-lossy+default-devel}"
SRC_URI[aarch64_rust-anstyle-lossy+default-devel.sha256sum] = "941ae1aaa0c90d98aaac8bb7b62144cb3c5f90f5dbd364a2cf7c8b394b6adb14"

URI_aarch64_rust-anstyle-lossy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-lossy-devel-1.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-anstyle-lossy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-lossy-devel}"
SRC_URI[aarch64_rust-anstyle-lossy-devel.sha256sum] = "f1daac80d917b8925f44c97bdf3c80710cf28a28361f8f174b6140fbd83fdd42"

RDEPENDS:rust-anstyle-lossy+default-devel = " \
 cargo \
 rust-anstyle-lossy-devel \
 "
RDEPENDS:rust-anstyle-lossy-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 "
