# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mono"
PV = "6.14.1"
PR = "1.el10_2"
PACKAGES = " \
 ibm-data-db2 \
 mono-complete \
 mono-core \
 mono-data \
 mono-data-oracle \
 mono-data-sqlite \
 mono-devel \
 mono-extras \
 mono-locale-extras \
 mono-mvc \
 mono-mvc-devel \
 mono-reactive \
 mono-reactive-devel \
 mono-reactive-winforms \
 mono-wcf \
 mono-web \
 mono-web-devel \
 mono-winforms \
 mono-winfx \
 monodoc \
 monodoc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mono-6.14.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45ea43012d9e37014ab4c0c8294df522e970363b1988c9e12fe030d7614b7403"

URI_x86_64_v2_ibm-data-db2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ibm-data-db2-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ibm-data-db2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibm-data-db2}"
SRC_URI[x86_64_v2_ibm-data-db2.sha256sum] = "720f733966d5e852b6585f63a186f5ed8413fe8e9de4146cabac9325e75914a0"

URI_x86_64_v2_mono-complete = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-complete-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-complete;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-complete}"
SRC_URI[x86_64_v2_mono-complete.sha256sum] = "31af31eaf7383083a951984c42d07348e621c3b99e4a3d7a92a939c6524c681e"

URI_x86_64_v2_mono-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-core-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-core}"
SRC_URI[x86_64_v2_mono-core.sha256sum] = "46ab9bb036f921c5c0994c3c16613ae3bf9cc73fef3a1021913a3330e305d488"
RPROVIDES:mono-core:x86_64_v2 = "virtual/mono_System.Data__eq_4.0.0.0 virtual/mono_System.EnterpriseServices__eq_4.0.0.0 virtual/mono_System.Runtime.Caching__eq_4.0.0.0 virtual/mono_System.Transactions__eq_4.0.0.0 virtual/mono_System.Xaml__eq_4.0.0.0"

URI_x86_64_v2_mono-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-data-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-data}"
SRC_URI[x86_64_v2_mono-data.sha256sum] = "a662c74cc278084062eb8ac7e8c6c9fd2f6943b4c285160e89069c48b6cdd5d7"
RPROVIDES:mono-data:x86_64_v2 = "virtual/mono_System.Data.Services.Client__eq_4.0.0.0 virtual/mono_System.Data__eq_4.0.0.0 virtual/mono_System.EnterpriseServices__eq_4.0.0.0 virtual/mono_System.Transactions__eq_4.0.0.0"

URI_x86_64_v2_mono-data-oracle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-data-oracle-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-data-oracle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-data-oracle}"
SRC_URI[x86_64_v2_mono-data-oracle.sha256sum] = "0c35d83a1c73a2169e929ca78efa0e9000db91927e6eab115e7e5e28950a1bbe"

URI_x86_64_v2_mono-data-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-data-sqlite-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-data-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-data-sqlite}"
SRC_URI[x86_64_v2_mono-data-sqlite.sha256sum] = "e8c448fcdbb7453d74f5b7705724ee95a827158ade1eea08d19ae60c18dae746"

URI_x86_64_v2_mono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-devel-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-devel}"
SRC_URI[x86_64_v2_mono-devel.sha256sum] = "8fd18cb760cf0c4d607bdd92326ede9638dd1c59ba4a2eb7f88d34c3b0b1b697"

URI_x86_64_v2_mono-extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-extras-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-extras}"
SRC_URI[x86_64_v2_mono-extras.sha256sum] = "bae02cbda91a0a1350d31527d8254b7110e998e07ce311df15f003e96679f5ff"
RPROVIDES:mono-extras:x86_64_v2 = "virtual/mono_System.Runtime.Caching__eq_4.0.0.0 virtual/mono_System.Xaml__eq_4.0.0.0"

URI_x86_64_v2_mono-locale-extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-locale-extras-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-locale-extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-locale-extras}"
SRC_URI[x86_64_v2_mono-locale-extras.sha256sum] = "c3cb88775a3ccea9b12d48df3d0cf0ee2a7c8e2fd6e3f1608b22061f3b4fb439"

URI_x86_64_v2_mono-mvc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-mvc-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-mvc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-mvc}"
SRC_URI[x86_64_v2_mono-mvc.sha256sum] = "0ce94b78c01a139bf9cbab9e2e95631c5497d9c3dec41a78c049463ba39fe7de"

URI_x86_64_v2_mono-mvc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-mvc-devel-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-mvc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-mvc-devel}"
SRC_URI[x86_64_v2_mono-mvc-devel.sha256sum] = "5a65710d252ee967c76fdcae020bf7954a1e9079f57f7554e0a931ea1457af16"

URI_x86_64_v2_mono-reactive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-reactive-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-reactive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-reactive}"
SRC_URI[x86_64_v2_mono-reactive.sha256sum] = "9d1bdc5163ac7dad7b2f70084d970cebf52c110acbe03a893ec46124a108f114"

URI_x86_64_v2_mono-reactive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-reactive-devel-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-reactive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-reactive-devel}"
SRC_URI[x86_64_v2_mono-reactive-devel.sha256sum] = "f64df8f1c9101b6b50302ae5f148254f9b7b19f466bdefd4c7651ecc214b2c9c"

URI_x86_64_v2_mono-reactive-winforms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-reactive-winforms-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-reactive-winforms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-reactive-winforms}"
SRC_URI[x86_64_v2_mono-reactive-winforms.sha256sum] = "b13c8d024e5b087f65fc6261ca29e77ebb54a7101c898f5f5e7fda3b272c9ba1"

URI_x86_64_v2_mono-wcf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-wcf-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-wcf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-wcf}"
SRC_URI[x86_64_v2_mono-wcf.sha256sum] = "9eb7664ee28e2ac05f30a22ef0e7da22799f35a5155383e14d59c7d06473408c"

URI_x86_64_v2_mono-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-web-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-web}"
SRC_URI[x86_64_v2_mono-web.sha256sum] = "1ecb906bf4aef5d45ee7b1debca28c72f5d8bbce93d077245972b3ddd5f1fdb3"

URI_x86_64_v2_mono-web-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-web-devel-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-web-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-web-devel}"
SRC_URI[x86_64_v2_mono-web-devel.sha256sum] = "f5b30c87d2192cc0422f5964adfcda56e9c59707fe792661394446bedd082ab6"

URI_x86_64_v2_mono-winforms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-winforms-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-winforms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-winforms}"
SRC_URI[x86_64_v2_mono-winforms.sha256sum] = "4a54849788ad4fe4cdf22461c35bd293ee0169ab8111464919cea6e6079882f6"

URI_x86_64_v2_mono-winfx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mono-winfx-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mono-winfx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mono-winfx}"
SRC_URI[x86_64_v2_mono-winfx.sha256sum] = "43a8d3ac0459e9256841a893485ea66143be80ec552a50cefd2e276cf9dd7402"
RPROVIDES:mono-winfx:x86_64_v2 = "virtual/mono_System.Data.Services.Client__eq_4.0.0.0"

URI_x86_64_v2_monodoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/monodoc-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_monodoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_monodoc}"
SRC_URI[x86_64_v2_monodoc.sha256sum] = "f129ccea9707232da96d50adbd6c1fd8ab9f381df8bc6a64de9b85f3c11da36c"

URI_x86_64_v2_monodoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/monodoc-devel-6.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_monodoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_monodoc-devel}"
SRC_URI[x86_64_v2_monodoc-devel.sha256sum] = "d3976d45c90f795e8eaeaab6fe103757ba525b05788c859a50d1ce088bfdfb7d"

URI_aarch64_ibm-data-db2 = "${EPEL_MIRROR}/aarch64/Packages/i/ibm-data-db2-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_ibm-data-db2;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibm-data-db2}"
SRC_URI[aarch64_ibm-data-db2.sha256sum] = "1705ed63328fe532b19f0550cc21428f9f236c64c25be51de19a191983d48e58"

URI_aarch64_mono-complete = "${EPEL_MIRROR}/aarch64/Packages/m/mono-complete-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-complete;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-complete}"
SRC_URI[aarch64_mono-complete.sha256sum] = "4c705de4c41ad74007dae81b9224ebb8ce7a66068d0d8bf1e4d4c7c6b3f793f7"

URI_aarch64_mono-core = "${EPEL_MIRROR}/aarch64/Packages/m/mono-core-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-core}"
SRC_URI[aarch64_mono-core.sha256sum] = "a3d5697ffa93c94086c11bf643737df43dc4d1ccd7d3bdcccdd7d634fee00177"
RPROVIDES:mono-core:aarch64 = "virtual/mono_System.Data__eq_4.0.0.0 virtual/mono_System.EnterpriseServices__eq_4.0.0.0 virtual/mono_System.Runtime.Caching__eq_4.0.0.0 virtual/mono_System.Transactions__eq_4.0.0.0 virtual/mono_System.Xaml__eq_4.0.0.0"

URI_aarch64_mono-data = "${EPEL_MIRROR}/aarch64/Packages/m/mono-data-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-data}"
SRC_URI[aarch64_mono-data.sha256sum] = "6bff309849c1d2aafe7581691998b8ba0117c0947d7a4fb2102e374dae444449"
RPROVIDES:mono-data:aarch64 = "virtual/mono_System.Data.Services.Client__eq_4.0.0.0 virtual/mono_System.Data__eq_4.0.0.0 virtual/mono_System.EnterpriseServices__eq_4.0.0.0 virtual/mono_System.Transactions__eq_4.0.0.0"

URI_aarch64_mono-data-oracle = "${EPEL_MIRROR}/aarch64/Packages/m/mono-data-oracle-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-data-oracle;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-data-oracle}"
SRC_URI[aarch64_mono-data-oracle.sha256sum] = "8bb11b87aa0b4e34cd499bd0a5f587a00ac75676348e6341bf56f04daa6218a2"

URI_aarch64_mono-data-sqlite = "${EPEL_MIRROR}/aarch64/Packages/m/mono-data-sqlite-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-data-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-data-sqlite}"
SRC_URI[aarch64_mono-data-sqlite.sha256sum] = "9608cb88ecd189ed438059c14c020fbe7bcec168218864da6a87c66639d43ff9"

URI_aarch64_mono-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mono-devel-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-devel}"
SRC_URI[aarch64_mono-devel.sha256sum] = "f8d300f0952979f26de7cf31db60e8832cd367f2815f4e2aa561e9295e758dad"

URI_aarch64_mono-extras = "${EPEL_MIRROR}/aarch64/Packages/m/mono-extras-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-extras}"
SRC_URI[aarch64_mono-extras.sha256sum] = "4eaa94f2805c5c3d7e7b5724412127e009677273cd7739b50382ac8df7f9ef8f"
RPROVIDES:mono-extras:aarch64 = "virtual/mono_System.Runtime.Caching__eq_4.0.0.0 virtual/mono_System.Xaml__eq_4.0.0.0"

URI_aarch64_mono-locale-extras = "${EPEL_MIRROR}/aarch64/Packages/m/mono-locale-extras-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-locale-extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-locale-extras}"
SRC_URI[aarch64_mono-locale-extras.sha256sum] = "ad6ed53f383c3d8fc34436fe2390325e7ee5d846d0452c67ba03173dac8d3fdb"

URI_aarch64_mono-mvc = "${EPEL_MIRROR}/aarch64/Packages/m/mono-mvc-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-mvc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-mvc}"
SRC_URI[aarch64_mono-mvc.sha256sum] = "091db2da47a117a7bcde4b74c33377ccccdce68054a8f944a94ceb4d118dafa8"

URI_aarch64_mono-mvc-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mono-mvc-devel-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-mvc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-mvc-devel}"
SRC_URI[aarch64_mono-mvc-devel.sha256sum] = "b739b911542cd3e2926f3b60f85a6b5b45f75e1f88a78a94f42fe31ec2cd983f"

URI_aarch64_mono-reactive = "${EPEL_MIRROR}/aarch64/Packages/m/mono-reactive-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-reactive;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-reactive}"
SRC_URI[aarch64_mono-reactive.sha256sum] = "be4b0eb9ed6f7d9e538042a7d077f002efae8f177b33950eba5b802c8d5779cf"

URI_aarch64_mono-reactive-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mono-reactive-devel-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-reactive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-reactive-devel}"
SRC_URI[aarch64_mono-reactive-devel.sha256sum] = "42e7d42c0d27c5e6e90482a6d1571d383ce98cca196e2b9cbae74e85298cafc4"

URI_aarch64_mono-reactive-winforms = "${EPEL_MIRROR}/aarch64/Packages/m/mono-reactive-winforms-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-reactive-winforms;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-reactive-winforms}"
SRC_URI[aarch64_mono-reactive-winforms.sha256sum] = "a714cebb803e316da0384c86d6a88fe995c1631bb6286b4a238bd5fe19b6faaa"

URI_aarch64_mono-wcf = "${EPEL_MIRROR}/aarch64/Packages/m/mono-wcf-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-wcf;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-wcf}"
SRC_URI[aarch64_mono-wcf.sha256sum] = "90fb8015d94451a390b444070f8b44b9142600ffba41f38d6af9aadc6c11154c"

URI_aarch64_mono-web = "${EPEL_MIRROR}/aarch64/Packages/m/mono-web-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-web}"
SRC_URI[aarch64_mono-web.sha256sum] = "8e03aa83c36bc67e881619646c2f0ab7917d64868404c506f6e64d5aa97aa8c4"

URI_aarch64_mono-web-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mono-web-devel-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-web-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-web-devel}"
SRC_URI[aarch64_mono-web-devel.sha256sum] = "c2f6c214bf94c8eaac05a6c202034b21bc7d90f92e3bd1142378d1401e534f6f"

URI_aarch64_mono-winforms = "${EPEL_MIRROR}/aarch64/Packages/m/mono-winforms-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-winforms;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-winforms}"
SRC_URI[aarch64_mono-winforms.sha256sum] = "81025088ab720faaa8049139a1c4b3130dc814c45af7e9e156306705caf9188e"

URI_aarch64_mono-winfx = "${EPEL_MIRROR}/aarch64/Packages/m/mono-winfx-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_mono-winfx;unpack=0"
SRC_URI:append = " ${URI_aarch64_mono-winfx}"
SRC_URI[aarch64_mono-winfx.sha256sum] = "900101c7ad879c49ddd6e448b5e1941fa391493d46e2e22d70015a318b5e1299"
RPROVIDES:mono-winfx:aarch64 = "virtual/mono_System.Data.Services.Client__eq_4.0.0.0"

URI_aarch64_monodoc = "${EPEL_MIRROR}/aarch64/Packages/m/monodoc-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_monodoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_monodoc}"
SRC_URI[aarch64_monodoc.sha256sum] = "56402f30fd485c55240bf57d7dd4f38aaeeadfa3452d7306da5b05ff9eebf27e"

URI_aarch64_monodoc-devel = "${EPEL_MIRROR}/aarch64/Packages/m/monodoc-devel-6.14.1-1.el10_2.aarch64.rpm;name=aarch64_monodoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_monodoc-devel}"
SRC_URI[aarch64_monodoc-devel.sha256sum] = "b47f24e71785e207f642714241ea4672477f3d3f50e77a335a5a08f6fdd6831a"

RDEPENDS:ibm-data-db2 = " \
 mono-core \
 virtual/mono_System.Data__eq_4.0.0.0 \
 "
RDEPENDS:mono-complete = " \
 ibm-data-db2 \
 mono-core \
 mono-data \
 mono-data-oracle \
 mono-data-sqlite \
 mono-devel \
 mono-extras \
 mono-locale-extras \
 mono-mvc \
 mono-reactive \
 mono-wcf \
 mono-web \
 mono-winforms \
 mono-winfx \
 monodoc \
 "
RDEPENDS:mono-core = " \
 bash \
 glibc \
 libgcc \
 libgdiplus \
 mono-data \
 mono-extras \
 mono-wcf \
 mono-web \
 python3 \
 zlib-ng-compat \
 "
RDEPENDS:mono-data = " \
 bash \
 mono-core \
 mono-wcf \
 mono-web \
 "
RDEPENDS:mono-data-oracle = " \
 mono-core \
 virtual/mono_System.Data__eq_4.0.0.0 \
 virtual/mono_System.EnterpriseServices__eq_4.0.0.0 \
 "
RDEPENDS:mono-data-sqlite = " \
 mono-core \
 sqlite-libs \
 virtual/mono_System.Data__eq_4.0.0.0 \
 virtual/mono_System.Transactions__eq_4.0.0.0 \
 "
RDEPENDS:mono-devel = " \
 bash \
 glib2-devel \
 glibc \
 libgcc \
 mono-core \
 mono-data \
 mono-extras \
 mono-mvc \
 mono-wcf \
 mono-web \
 mono-winforms \
 monodoc \
 pkgconf-pkg-config \
 virtual/mono_System.Data.Services.Client__eq_4.0.0.0 \
 virtual/mono_System.Data__eq_4.0.0.0 \
 virtual/mono_System.EnterpriseServices__eq_4.0.0.0 \
 virtual/mono_System.Transactions__eq_4.0.0.0 \
 virtual/mono_System.Xaml__eq_4.0.0.0 \
 zlib-ng-compat \
 "
RDEPENDS:mono-extras = " \
 bash \
 mono-core \
 mono-winforms \
 virtual/mono_System.Data__eq_4.0.0.0 \
 "
RDEPENDS:mono-locale-extras = " \
 mono-core \
 "
RDEPENDS:mono-mvc = " \
 mono-core \
 mono-data \
 mono-wcf \
 mono-web \
 mono-winforms \
 virtual/mono_System.Runtime.Caching__eq_4.0.0.0 \
 "
RDEPENDS:mono-mvc-devel = " \
 mono-core \
 pkgconf-pkg-config \
 "
RDEPENDS:mono-reactive = " \
 mono-core \
 "
RDEPENDS:mono-reactive-devel = " \
 mono-core \
 mono-reactive \
 pkgconf-pkg-config \
 "
RDEPENDS:mono-reactive-winforms = " \
 mono-core \
 mono-reactive \
 mono-winforms \
 mono-winfx \
 "
RDEPENDS:mono-wcf = " \
 mono-core \
 mono-data \
 mono-extras \
 mono-mvc \
 mono-web \
 virtual/mono_System.Transactions__eq_4.0.0.0 \
 "
RDEPENDS:mono-web = " \
 bash \
 mono-core \
 mono-data \
 mono-data-sqlite \
 mono-mvc \
 mono-wcf \
 mono-winforms \
 virtual/mono_System.Data__eq_4.0.0.0 \
 virtual/mono_System.EnterpriseServices__eq_4.0.0.0 \
 "
RDEPENDS:mono-web-devel = " \
 mono-core \
 mono-web \
 pkgconf-pkg-config \
 "
RDEPENDS:mono-winforms = " \
 mono-core \
 mono-web \
 virtual/mono_System.Data__eq_4.0.0.0 \
 "
RDEPENDS:mono-winfx = " \
 mono-core \
 virtual/mono_System.Xaml__eq_4.0.0.0 \
 "
RDEPENDS:monodoc = " \
 bash \
 mono-core \
 "
RDEPENDS:monodoc-devel = " \
 mono-core \
 monodoc \
 pkgconf-pkg-config \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/mono_System.Data.Services.Client__eq_4.0.0.0 rpm/virtual/mono_System.Data__eq_4.0.0.0 rpm/virtual/mono_System.EnterpriseServices__eq_4.0.0.0 rpm/virtual/mono_System.Runtime.Caching__eq_4.0.0.0 rpm/virtual/mono_System.Transactions__eq_4.0.0.0 rpm/virtual/mono_System.Xaml__eq_4.0.0.0"

PROVIDES:append:aarch64 = " rpm/virtual/mono_System.Data.Services.Client__eq_4.0.0.0 rpm/virtual/mono_System.Data__eq_4.0.0.0 rpm/virtual/mono_System.EnterpriseServices__eq_4.0.0.0 rpm/virtual/mono_System.Runtime.Caching__eq_4.0.0.0 rpm/virtual/mono_System.Transactions__eq_4.0.0.0 rpm/virtual/mono_System.Xaml__eq_4.0.0.0"
