# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-qrcode"
PV = "7.4.2"
PR = "13.el10"
PACKAGES = " \
 python3-qrcode \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-qrcode-7.4.2-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2355bef6cee44f634adfb6b814aa7198e73d3b85abb276523ac3e13a2830d589"

URI_x86_64_v2_python3-qrcode = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-qrcode-7.4.2-13.el10.noarch.rpm;name=x86_64_v2_python3-qrcode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-qrcode}"
SRC_URI[x86_64_v2_python3-qrcode.sha256sum] = "c2bec6fd51d6d7b30e0c1cb76cf3ddedd4a75105cb434a7d75c96861af7dfadd"

URI_aarch64_python3-qrcode = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-qrcode-7.4.2-13.el10.noarch.rpm;name=aarch64_python3-qrcode;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-qrcode}"
SRC_URI[aarch64_python3-qrcode.sha256sum] = "c2bec6fd51d6d7b30e0c1cb76cf3ddedd4a75105cb434a7d75c96861af7dfadd"

RDEPENDS:python3-qrcode = " \
 python3 \
 python3-typing-extensions \
 "
