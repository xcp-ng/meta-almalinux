# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-msgpack"
PV = "1.1.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-msgpack \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-msgpack-1.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffca34cd0aa11ee7b4711fbf4ebd17d9c9604fc8b32fa67d8e2e5913f8c7cacc"

URI_x86_64_v2_python3-msgpack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-msgpack-1.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-msgpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-msgpack}"
SRC_URI[x86_64_v2_python3-msgpack.sha256sum] = "6e11542a0875404878b61668fb4d6818e2f178626841baab13f9030aa974cfc1"

URI_aarch64_python3-msgpack = "${EPEL_MIRROR}/aarch64/Packages/p/python3-msgpack-1.1.1-1.el10_2.aarch64.rpm;name=aarch64_python3-msgpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-msgpack}"
SRC_URI[aarch64_python3-msgpack.sha256sum] = "e1ce806d5f7cb359a8e88d634483402a9fc8a8ef972c825f761f3dab6e609aa3"

RDEPENDS:python3-msgpack = " \
 glibc \
 python3 \
 "
