# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clevis-pin-tpm2"
PV = "0.5.3"
PR = "8.el10"
PACKAGES = " \
 clevis-pin-tpm2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/clevis-pin-tpm2-0.5.3-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8c49854dff9599bd07a3b2d2b195cf430345aab3c2e07caa154c39f9858a748"

URI_x86_64_v2_clevis-pin-tpm2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-pin-tpm2-0.5.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_clevis-pin-tpm2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clevis-pin-tpm2}"
SRC_URI[x86_64_v2_clevis-pin-tpm2.sha256sum] = "3d2a1dd324d7ab07eebb63973d4a06508fb104c1b3531fbfcb9c2ae1a8cc6d7b"

URI_aarch64_clevis-pin-tpm2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-pin-tpm2-0.5.3-8.el10.aarch64.rpm;name=aarch64_clevis-pin-tpm2;unpack=0"
SRC_URI:append = " ${URI_aarch64_clevis-pin-tpm2}"
SRC_URI[aarch64_clevis-pin-tpm2.sha256sum] = "cab0b2da11ff020ba2e540b189926a19f22c00ba217dc6ada966a814bc6ac50d"

RDEPENDS:clevis-pin-tpm2 = " \
 clevis \
 glibc \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
