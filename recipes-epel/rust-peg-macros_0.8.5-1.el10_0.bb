# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-peg-macros"
PV = "0.8.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-peg-macros+default-devel \
 rust-peg-macros+trace-devel \
 rust-peg-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-peg-macros-0.8.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c26bfd50521dfac350a87f202e002e978a808704c114e962b73138d5e81f526c"

URI_x86_64_v2_rust-peg-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-macros+default-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-macros+default-devel}"
SRC_URI[x86_64_v2_rust-peg-macros+default-devel.sha256sum] = "fad21e257a8e3c5a4e411563f5933977a8ac7cc8c247b0c83b8fbd413f201a97"

URI_x86_64_v2_rust-peg-macros+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-macros+trace-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-macros+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-macros+trace-devel}"
SRC_URI[x86_64_v2_rust-peg-macros+trace-devel.sha256sum] = "b0ad69010bf7c6dd35caf3c2daf2555af9521511158b81bcbfdf2522ec450c7c"

URI_x86_64_v2_rust-peg-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-macros-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-macros-devel}"
SRC_URI[x86_64_v2_rust-peg-macros-devel.sha256sum] = "acf713891cdd372679c5b15101c6bdd87eba2a68d4a958253dd03b65ee5fdfc1"

URI_aarch64_rust-peg-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-macros+default-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-peg-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-macros+default-devel}"
SRC_URI[aarch64_rust-peg-macros+default-devel.sha256sum] = "1e1b57001e491a6b8f051ad140f03416f2da7cdb795811e0f4386bbc055e2ba6"

URI_aarch64_rust-peg-macros+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-macros+trace-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-peg-macros+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-macros+trace-devel}"
SRC_URI[aarch64_rust-peg-macros+trace-devel.sha256sum] = "03d0fe184d46b96812f01e4d9022eb2a65a8d316d84cac9a1dbd1dc7005ebab9"

URI_aarch64_rust-peg-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-macros-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-peg-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-macros-devel}"
SRC_URI[aarch64_rust-peg-macros-devel.sha256sum] = "006666eb09dd8d75b93da47cdaf37e8218b77850dc5c56d3967cea5165776428"

RDEPENDS:rust-peg-macros+default-devel = " \
 cargo \
 rust-peg-macros-devel \
 "
RDEPENDS:rust-peg-macros+trace-devel = " \
 cargo \
 rust-peg-macros-devel \
 "
RDEPENDS:rust-peg-macros-devel = " \
 cargo \
 rust-peg-runtime+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
