# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-v_frame"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-v_frame+default-devel \
 rust-v_frame+padding_api-devel \
 rust-v_frame-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-v_frame-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e9d5781b76361a7b0491567c9a9b28e5309bab6127527541c6b5be068ddda24"

URI_x86_64_v2_rust-v_frame+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame+default-devel}"
SRC_URI[x86_64_v2_rust-v_frame+default-devel.sha256sum] = "6a1edabcb810bd2e28d8d1fd7ff02464f36dd589bc9fd49ede12a997cc208f88"

URI_x86_64_v2_rust-v_frame+padding_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame+padding_api-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame+padding_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame+padding_api-devel}"
SRC_URI[x86_64_v2_rust-v_frame+padding_api-devel.sha256sum] = "263e712ea6e17890988a64132aeca5223a6612983efb0039064689f13fe7185c"

URI_x86_64_v2_rust-v_frame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame-devel}"
SRC_URI[x86_64_v2_rust-v_frame-devel.sha256sum] = "a84888ce45199702a23832a837f852241f4010161ead37eee31f3696dc86dc85"

URI_aarch64_rust-v_frame+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-v_frame+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame+default-devel}"
SRC_URI[aarch64_rust-v_frame+default-devel.sha256sum] = "12b335f89a19f9d818a3b1ef90ffc00a1e4ed1e3bd8718c25d7bdb977c82ad60"

URI_aarch64_rust-v_frame+padding_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame+padding_api-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-v_frame+padding_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame+padding_api-devel}"
SRC_URI[aarch64_rust-v_frame+padding_api-devel.sha256sum] = "2bce8b8ead759668ca2b7f86c3f2841b25152328db08c0b3f3fa708edcaf2090"

URI_aarch64_rust-v_frame-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-v_frame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame-devel}"
SRC_URI[aarch64_rust-v_frame-devel.sha256sum] = "eb5153b70efe403257a521ca6a393ddf7e098994727d9610353b8459906c0af6"

RDEPENDS:rust-v_frame+default-devel = " \
 cargo \
 rust-v_frame-devel \
 "
RDEPENDS:rust-v_frame+padding_api-devel = " \
 cargo \
 rust-v_frame-devel \
 "
RDEPENDS:rust-v_frame-devel = " \
 cargo \
 rust \
 "
