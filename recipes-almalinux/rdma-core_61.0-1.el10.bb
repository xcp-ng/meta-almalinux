# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rdma-core"
PV = "61.0"
PR = "1.el10"
PACKAGES = " \
 ibacm \
 infiniband-diags \
 iwpmd \
 libibumad \
 libibverbs \
 libibverbs-utils \
 librdmacm \
 librdmacm-utils \
 python3-pyverbs \
 rdma-core \
 rdma-core-devel \
 srp_daemon \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rdma-core-61.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f68f1605412820f40c5e9a2358d3e51f5f2ef19dbf9958e014d64283eb7baa7a"

URI_x86_64_v2_ibacm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ibacm-61.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_ibacm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibacm}"
SRC_URI[x86_64_v2_ibacm.sha256sum] = "1a9af8b8257d2a848d0814ad2080cdd1b05d60957657ff1ab5cca8ab699521bd"

URI_x86_64_v2_infiniband-diags = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/infiniband-diags-61.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_infiniband-diags;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_infiniband-diags}"
SRC_URI[x86_64_v2_infiniband-diags.sha256sum] = "11fff79a8609d02bfd77f1268764ceb8520cda02c1d334b118d29a6d400580e7"

URI_x86_64_v2_iwpmd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwpmd-61.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_iwpmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iwpmd}"
SRC_URI[x86_64_v2_iwpmd.sha256sum] = "b1fa032fe3f63353e373aad570127f63db3b644c910d9033239de610dd73b6c7"

URI_x86_64_v2_libibumad = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libibumad-61.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libibumad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libibumad}"
SRC_URI[x86_64_v2_libibumad.sha256sum] = "c500946f94a84f5b0e94d8ff24e4ab5344b349f4a37ecc0799e95eb882c2344c"

URI_x86_64_v2_libibverbs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libibverbs-61.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libibverbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libibverbs}"
SRC_URI[x86_64_v2_libibverbs.sha256sum] = "05b7a94457172516965b0aaa09a7c0fb5c88e718d4c821f2b978c65e26850ab3"

URI_x86_64_v2_libibverbs-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libibverbs-utils-61.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libibverbs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libibverbs-utils}"
SRC_URI[x86_64_v2_libibverbs-utils.sha256sum] = "005c4342b2eda0474dac06d719648de084587d396d3ec70e4bdd878981a80450"

URI_x86_64_v2_librdmacm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/librdmacm-61.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_librdmacm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librdmacm}"
SRC_URI[x86_64_v2_librdmacm.sha256sum] = "af2e44b2b6875be8b28bca98da62e753c3b3828c05c7aa795e14919ae5125c4a"

URI_x86_64_v2_librdmacm-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/librdmacm-utils-61.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_librdmacm-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librdmacm-utils}"
SRC_URI[x86_64_v2_librdmacm-utils.sha256sum] = "7db61662a9147fd9c532ce39ae5553926eeca19e7b40d1c2249cd6b0585c533e"

URI_x86_64_v2_python3-pyverbs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyverbs-61.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pyverbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyverbs}"
SRC_URI[x86_64_v2_python3-pyverbs.sha256sum] = "e7c4ebaa2a89e5675019738606fc6809e6ab410f5d1b580246ccee93f4a2dbd1"

URI_x86_64_v2_rdma-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rdma-core-61.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rdma-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rdma-core}"
SRC_URI[x86_64_v2_rdma-core.sha256sum] = "5f800653ea7c1394cef14eaf42ac8bb1368775f58f93e88a9f1c67bfe1fef61d"

URI_x86_64_v2_rdma-core-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rdma-core-devel-61.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rdma-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rdma-core-devel}"
SRC_URI[x86_64_v2_rdma-core-devel.sha256sum] = "a4cb5d0941a0fce746e7e9b94a4a2ff0ec05abb9ceb08630651396fc14b928ee"

URI_x86_64_v2_srp_daemon = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/srp_daemon-61.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_srp_daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_srp_daemon}"
SRC_URI[x86_64_v2_srp_daemon.sha256sum] = "96298e82cb70bd99009b2fe2b231e2631c07f29ef7707a138adac8dfd99688b8"

URI_aarch64_ibacm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ibacm-61.0-1.el10.aarch64.rpm;name=aarch64_ibacm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibacm}"
SRC_URI[aarch64_ibacm.sha256sum] = "062dd8da869f0d3ba9f0481b4c1fad32ca70335713b6e9b82fefa641cb75b0e2"

URI_aarch64_infiniband-diags = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/infiniband-diags-61.0-1.el10.aarch64.rpm;name=aarch64_infiniband-diags;unpack=0"
SRC_URI:append = " ${URI_aarch64_infiniband-diags}"
SRC_URI[aarch64_infiniband-diags.sha256sum] = "f54b26f6acc84619a4cc86447ea376e81906cef91d865e40864363716715c903"

URI_aarch64_iwpmd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwpmd-61.0-1.el10.aarch64.rpm;name=aarch64_iwpmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_iwpmd}"
SRC_URI[aarch64_iwpmd.sha256sum] = "9f9f024caf047496313925e3e45650c34b46d7cee03c4e7d1220482b117c9ec9"

URI_aarch64_libibumad = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libibumad-61.0-1.el10.aarch64.rpm;name=aarch64_libibumad;unpack=0"
SRC_URI:append = " ${URI_aarch64_libibumad}"
SRC_URI[aarch64_libibumad.sha256sum] = "0575be3f31200b11b408e73c6915b25c523946edc2b04d1aef063facb4b64f33"

URI_aarch64_libibverbs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libibverbs-61.0-1.el10.aarch64.rpm;name=aarch64_libibverbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libibverbs}"
SRC_URI[aarch64_libibverbs.sha256sum] = "0ba60e3743b047510fe0a8a7e919c83116fef09f644266da76eb4251a74b4905"

URI_aarch64_libibverbs-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libibverbs-utils-61.0-1.el10.aarch64.rpm;name=aarch64_libibverbs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libibverbs-utils}"
SRC_URI[aarch64_libibverbs-utils.sha256sum] = "0567886fbf08165ca59da9461b223d8c6526a0a9afce0eb19916677c199f2345"

URI_aarch64_librdmacm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/librdmacm-61.0-1.el10.aarch64.rpm;name=aarch64_librdmacm;unpack=0"
SRC_URI:append = " ${URI_aarch64_librdmacm}"
SRC_URI[aarch64_librdmacm.sha256sum] = "00d86e935a4cbded3e26ea9b775d5df8179f427e74fc8ad405a037bb7aa97939"

URI_aarch64_librdmacm-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/librdmacm-utils-61.0-1.el10.aarch64.rpm;name=aarch64_librdmacm-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_librdmacm-utils}"
SRC_URI[aarch64_librdmacm-utils.sha256sum] = "3b6e5bb59c6bedaf37aacabb3b575b898b5cbe9c89f7b99e4273f019693b1df3"

URI_aarch64_python3-pyverbs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyverbs-61.0-1.el10.aarch64.rpm;name=aarch64_python3-pyverbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyverbs}"
SRC_URI[aarch64_python3-pyverbs.sha256sum] = "cbfad39a8bbe81eeef50c938f1761b76d3537a3b3030c369dc6ec5ba929a306d"

URI_aarch64_rdma-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rdma-core-61.0-1.el10.aarch64.rpm;name=aarch64_rdma-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_rdma-core}"
SRC_URI[aarch64_rdma-core.sha256sum] = "e7f3b09a6bc90651f8e0c94075d780d4383c7d5121850285e047a374c91c1796"

URI_aarch64_rdma-core-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rdma-core-devel-61.0-1.el10.aarch64.rpm;name=aarch64_rdma-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rdma-core-devel}"
SRC_URI[aarch64_rdma-core-devel.sha256sum] = "12cfdf1dc9302d79aa6859c43465cc963cf1e26bd540f6107e51c2d608d0dcad"

URI_aarch64_srp_daemon = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/srp_daemon-61.0-1.el10.aarch64.rpm;name=aarch64_srp_daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_srp_daemon}"
SRC_URI[aarch64_srp_daemon.sha256sum] = "33ad15dc284a94a7a62047856f54b74c7931f14ead63d16d1ef2d1f2013ca01e"

RDEPENDS:ibacm = " \
 bash \
 glibc \
 libibumad \
 libibverbs \
 libnl3 \
 systemd \
 systemd-libs \
 "
RDEPENDS:infiniband-diags = " \
 bash \
 glibc \
 libibumad \
 perl-Getopt-Std \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:iwpmd = " \
 bash \
 glibc \
 libnl3 \
 systemd \
 systemd-libs \
 "
RDEPENDS:libibumad = " \
 glibc \
 "
RDEPENDS:libibverbs = " \
 glibc \
 libnl3 \
 "
RDEPENDS:libibverbs-utils = " \
 glibc \
 libibverbs \
 "
RDEPENDS:librdmacm = " \
 glibc \
 libibverbs \
 libnl3 \
 "
RDEPENDS:librdmacm-utils = " \
 glibc \
 libibverbs \
 librdmacm \
 "
RDEPENDS:python3-pyverbs = " \
 glibc \
 libibverbs \
 librdmacm \
 python3 \
 python3-libs \
 "
RDEPENDS:rdma-core = " \
 bash \
 glibc \
 libnl3 \
 pciutils \
 python3 \
 systemd-libs \
 "
RDEPENDS:rdma-core-devel = " \
 infiniband-diags \
 libibumad \
 libibverbs \
 librdmacm \
 pkgconf-pkg-config \
 rdma-core-devel \
 "
RDEPENDS:srp_daemon = " \
 bash \
 glibc \
 libibumad \
 libibverbs \
 systemd \
 "
