# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-atomic-write"
PV = "0.2.0.7"
PR = "15.el10_0"
PACKAGES = " \
 ghc-atomic-write \
 ghc-atomic-write-devel \
 ghc-atomic-write-doc \
 ghc-atomic-write-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-atomic-write-0.2.0.7-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "307d727728c590b60eaa01ed16039b9391faa326cbb3a6d4e1e521c419990b63"

URI_x86_64_v2_ghc-atomic-write = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-atomic-write-0.2.0.7-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-atomic-write;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-atomic-write}"
SRC_URI[x86_64_v2_ghc-atomic-write.sha256sum] = "0103bb5ff9d890e7eb46fe987dc8efa56a2b6ced1e10c78e9110c97b7a81d9aa"

URI_x86_64_v2_ghc-atomic-write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-atomic-write-devel-0.2.0.7-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-atomic-write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-atomic-write-devel}"
SRC_URI[x86_64_v2_ghc-atomic-write-devel.sha256sum] = "523282e814331d52fb6c46560329fdb7616e4e1c61bd5ab9c9b5641ddf749584"

URI_x86_64_v2_ghc-atomic-write-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-atomic-write-doc-0.2.0.7-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-atomic-write-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-atomic-write-doc}"
SRC_URI[x86_64_v2_ghc-atomic-write-doc.sha256sum] = "e1e5691924603e0ca10351b411abdc8ccc5088572258939534cc6010d21577ab"

URI_x86_64_v2_ghc-atomic-write-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-atomic-write-prof-0.2.0.7-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-atomic-write-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-atomic-write-prof}"
SRC_URI[x86_64_v2_ghc-atomic-write-prof.sha256sum] = "463b99081a232b4f7a5c023ab5cfbf5f1bd05c930169fd3fd8a547ca1591a22a"

URI_aarch64_ghc-atomic-write = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-atomic-write-0.2.0.7-15.el10_0.aarch64.rpm;name=aarch64_ghc-atomic-write;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-atomic-write}"
SRC_URI[aarch64_ghc-atomic-write.sha256sum] = "0d0f1d7dfb2bc266de394c7117eafd9f79a2a1da2f4e462fbe3ae4dee944eb6c"

URI_aarch64_ghc-atomic-write-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-atomic-write-devel-0.2.0.7-15.el10_0.aarch64.rpm;name=aarch64_ghc-atomic-write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-atomic-write-devel}"
SRC_URI[aarch64_ghc-atomic-write-devel.sha256sum] = "07610f4ba2eaef8f7c9fd023337c25ae57c364435eabd8fcb5179249732a2e75"

URI_aarch64_ghc-atomic-write-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-atomic-write-doc-0.2.0.7-15.el10_0.noarch.rpm;name=aarch64_ghc-atomic-write-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-atomic-write-doc}"
SRC_URI[aarch64_ghc-atomic-write-doc.sha256sum] = "a14aed6360118462f024db8e95ba7c51bcdf4d9a1ba2e77ee3c09e2f27f4649e"

URI_aarch64_ghc-atomic-write-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-atomic-write-prof-0.2.0.7-15.el10_0.aarch64.rpm;name=aarch64_ghc-atomic-write-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-atomic-write-prof}"
SRC_URI[aarch64_ghc-atomic-write-prof.sha256sum] = "7f1ad72f611105a54d8457c089815950ca41f61062c001cce43df4de5bab0276"

RDEPENDS:ghc-atomic-write = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-random \
 ghc-splitmix \
 ghc-stm \
 ghc-template-haskell \
 ghc-temporary \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-unix-compat \
 glibc \
 gmp \
 "
RDEPENDS:ghc-atomic-write-devel = " \
 ghc-atomic-write \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-temporary-devel \
 ghc-text-devel \
 ghc-unix-compat-devel \
 "
RDEPENDS:ghc-atomic-write-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-atomic-write-prof = " \
 ghc-atomic-write-devel \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-temporary-prof \
 ghc-text-prof \
 ghc-unix-compat-prof \
 "
