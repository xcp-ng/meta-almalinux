# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "octave"
PE = "6"
PV = "11.1.0"
PR = "2.el10_3"
PACKAGES = " \
 octave \
 octave-devel \
 octave-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/octave-11.1.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5007fa88878893cc27b3d498396d3cb1501e23c36cf4590c0e0c2790113a2318"

URI_x86_64_v2_octave = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/octave-11.1.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_octave;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_octave}"
SRC_URI[x86_64_v2_octave.sha256sum] = "c9fd5f1f40c577e83f026111a8183b4d86a08a5624172e436b58511e4974a236"

URI_x86_64_v2_octave-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/octave-devel-11.1.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_octave-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_octave-devel}"
SRC_URI[x86_64_v2_octave-devel.sha256sum] = "2cf7bc436d1874db6acb4a8e242532672753431e6aaee38c61937a2a55235248"

URI_x86_64_v2_octave-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/octave-doc-11.1.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_octave-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_octave-doc}"
SRC_URI[x86_64_v2_octave-doc.sha256sum] = "4ac3eb9992793ea093fcb3b1687637ed35d4c41376be2eca98303a3fd9aef8b9"

URI_aarch64_octave = "${EPEL_MIRROR}/aarch64/Packages/o/octave-11.1.0-2.el10_3.aarch64.rpm;name=aarch64_octave;unpack=0"
SRC_URI:append = " ${URI_aarch64_octave}"
SRC_URI[aarch64_octave.sha256sum] = "71452eeaa508c34075cdfda435b3030f1023e2b85910fe4c2aeebfbe79ae5044"

URI_aarch64_octave-devel = "${EPEL_MIRROR}/aarch64/Packages/o/octave-devel-11.1.0-2.el10_3.aarch64.rpm;name=aarch64_octave-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_octave-devel}"
SRC_URI[aarch64_octave-devel.sha256sum] = "4cd8e2caa3131734b4a7f5ec3a95eed5888d5557a90c9ab14a6fe6054028aa1e"

URI_aarch64_octave-doc = "${EPEL_MIRROR}/aarch64/Packages/o/octave-doc-11.1.0-2.el10_3.noarch.rpm;name=aarch64_octave-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_octave-doc}"
SRC_URI[aarch64_octave-doc.sha256sum] = "356cc828521d228b1623ecd8fc2c032dbca6134a6b9a333a77b89938a8414780"

RDEPENDS:octave:x86_64_v2 = " \
 GraphicsMagick \
 GraphicsMagick-c++ \
 alsa-lib \
 arpack \
 bash \
 bzip2-libs \
 epstool \
 fftw-libs-double \
 fftw-libs-single \
 flexiblas-netlib \
 fltk \
 fontconfig \
 freetype \
 gl2ps \
 glibc \
 glpk \
 gnuplot-common \
 hdf5 \
 hicolor-icon-theme \
 info \
 java-25-openjdk-headless \
 less \
 libX11 \
 libgcc \
 libgfortran \
 libglvnd-glx \
 libgomp \
 libqhull_r \
 libquadmath \
 libsndfile \
 libstdc++ \
 libwayland-client \
 mesa-libGLU \
 pcre2 \
 portaudio \
 qrupdate \
 qscintilla-qt6 \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-help \
 readline \
 suitesparse \
 sundials \
 texinfo \
 texlive-amsfonts \
 texlive-geometry \
 texlive-graphics \
 texlive-hyperref \
 texlive-listings \
 texlive-lm \
 texlive-mathtools \
 texlive-titlesec \
 texlive-xcolor \
 virtual/gnuplot \
 virtual/libcurl.so.4___64bit_ \
 virtual/tex_fontenc.sty_ \
 virtual/tex_inputenc.sty_ \
 zlib-ng-compat \
"
RDEPENDS:octave:aarch64 = " \
 GraphicsMagick \
 GraphicsMagick-c++ \
 alsa-lib \
 arpack \
 bash \
 bzip2-libs \
 epstool \
 fftw-libs-double \
 fftw-libs-single \
 flexiblas-netlib \
 fltk \
 fontconfig \
 freetype \
 gl2ps \
 glibc \
 glpk \
 gnuplot-common \
 hdf5 \
 hicolor-icon-theme \
 info \
 java-25-openjdk-headless \
 less \
 libX11 \
 libgcc \
 libgfortran \
 libglvnd-glx \
 libgomp \
 libqhull_r \
 libsndfile \
 libstdc++ \
 libwayland-client \
 mesa-libGLU \
 pcre2 \
 portaudio \
 qrupdate \
 qscintilla-qt6 \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-help \
 readline \
 suitesparse \
 sundials \
 texinfo \
 texlive-amsfonts \
 texlive-geometry \
 texlive-graphics \
 texlive-hyperref \
 texlive-listings \
 texlive-lm \
 texlive-mathtools \
 texlive-titlesec \
 texlive-xcolor \
 virtual/gnuplot \
 virtual/libcurl.so.4___64bit_ \
 virtual/tex_fontenc.sty_ \
 virtual/tex_inputenc.sty_ \
 zlib-ng-compat \
"
RDEPENDS:octave-devel = " \
 bash \
 fftw-devel \
 flexiblas-devel \
 gcc-c++ \
 gcc-gfortran \
 hdf5-devel \
 libappstream-glib \
 octave \
 octave-devel \
 pkgconf-pkg-config \
 readline-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:octave-doc = " \
 "
