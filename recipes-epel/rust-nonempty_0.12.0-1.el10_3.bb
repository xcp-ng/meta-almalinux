# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nonempty"
PV = "0.12.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-nonempty+arbitrary-devel \
 rust-nonempty+bincode-devel \
 rust-nonempty+default-devel \
 rust-nonempty+serialize-devel \
 rust-nonempty+std-devel \
 rust-nonempty-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nonempty-0.12.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83053fbeffb6b5fc6cf5378755cda3cc4d788d7722f7a4edc54e446b906a5e94"

URI_x86_64_v2_rust-nonempty+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nonempty+arbitrary-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nonempty+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nonempty+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-nonempty+arbitrary-devel.sha256sum] = "484930821c8937e942c3b4d5f9055d876ad5466902c6841ff45540e2a95f7df3"

URI_x86_64_v2_rust-nonempty+bincode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nonempty+bincode-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nonempty+bincode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nonempty+bincode-devel}"
SRC_URI[x86_64_v2_rust-nonempty+bincode-devel.sha256sum] = "5514fb74315ad3f095b44e8e9deb5b35afaf598f967dd78f7c145ca1c2722ba1"

URI_x86_64_v2_rust-nonempty+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nonempty+default-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nonempty+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nonempty+default-devel}"
SRC_URI[x86_64_v2_rust-nonempty+default-devel.sha256sum] = "081adbb7d2a772ced8b2fee0b407bc9ccf95bbcf4c8193695924ba67c6db6cf9"

URI_x86_64_v2_rust-nonempty+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nonempty+serialize-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nonempty+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nonempty+serialize-devel}"
SRC_URI[x86_64_v2_rust-nonempty+serialize-devel.sha256sum] = "541060d189484ac7a3e5a1dcf555e6b079ae59fe8c8dab4678b0926c53b7e763"

URI_x86_64_v2_rust-nonempty+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nonempty+std-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nonempty+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nonempty+std-devel}"
SRC_URI[x86_64_v2_rust-nonempty+std-devel.sha256sum] = "f33489f07fdcd46ff5b257110d89f13cf6535818ccada2549a355e7157b6d260"

URI_x86_64_v2_rust-nonempty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nonempty-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nonempty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nonempty-devel}"
SRC_URI[x86_64_v2_rust-nonempty-devel.sha256sum] = "a8a5d7983e3873ed6fb27a9a5ff68db052cb455dc9cabe5ec37deb6dc67c7295"

URI_aarch64_rust-nonempty+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nonempty+arbitrary-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-nonempty+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nonempty+arbitrary-devel}"
SRC_URI[aarch64_rust-nonempty+arbitrary-devel.sha256sum] = "b10ecf977ed15d3aaa240e8f6800bf3bcd990d2ca9fc3a81a85258dfcc5d9aed"

URI_aarch64_rust-nonempty+bincode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nonempty+bincode-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-nonempty+bincode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nonempty+bincode-devel}"
SRC_URI[aarch64_rust-nonempty+bincode-devel.sha256sum] = "1c26d6cfffc72b71451af3e8e9b6b89c611fc35dba4e42732238b5f11730230f"

URI_aarch64_rust-nonempty+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nonempty+default-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-nonempty+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nonempty+default-devel}"
SRC_URI[aarch64_rust-nonempty+default-devel.sha256sum] = "0dbc235b94d53e759c5814c67178fd526678d482212963376628997fc83bf90f"

URI_aarch64_rust-nonempty+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nonempty+serialize-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-nonempty+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nonempty+serialize-devel}"
SRC_URI[aarch64_rust-nonempty+serialize-devel.sha256sum] = "b7c5a2f91dc6d558dc43656005f0fb8a4eb88a7ad01b9119fed963763727f73a"

URI_aarch64_rust-nonempty+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nonempty+std-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-nonempty+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nonempty+std-devel}"
SRC_URI[aarch64_rust-nonempty+std-devel.sha256sum] = "841e37f445c805d714c3cf3750e55e0232db3c33121b80af27af3b26b5dce092"

URI_aarch64_rust-nonempty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nonempty-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-nonempty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nonempty-devel}"
SRC_URI[aarch64_rust-nonempty-devel.sha256sum] = "0c9be737b1f5401e258ec1a1df90bd0c4a3c2a87279ae2cdf39a5466a233bce1"

RDEPENDS:rust-nonempty+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-nonempty-devel \
 "
RDEPENDS:rust-nonempty+bincode-devel = " \
 cargo \
 rust-bincode+default-devel \
 rust-nonempty-devel \
 "
RDEPENDS:rust-nonempty+default-devel = " \
 cargo \
 rust-nonempty+std-devel \
 rust-nonempty-devel \
 "
RDEPENDS:rust-nonempty+serialize-devel = " \
 cargo \
 rust-nonempty-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-nonempty+std-devel = " \
 cargo \
 rust-nonempty-devel \
 "
RDEPENDS:rust-nonempty-devel = " \
 cargo \
 "
