# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-camino"
PV = "1.2.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-camino+default-devel \
 rust-camino+proptest1-devel \
 rust-camino+serde1-devel \
 rust-camino-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-camino-1.2.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4de9c61fc387953f7ba236f39692abf23e10be6b4625445af61a8a53b365ce4a"

URI_x86_64_v2_rust-camino+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+default-devel-1.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino+default-devel}"
SRC_URI[x86_64_v2_rust-camino+default-devel.sha256sum] = "5031f3ee41fa5980c0e0aab9dff91bcfe8e81a68583fae0a668a74daa4b42c83"

URI_x86_64_v2_rust-camino+proptest1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+proptest1-devel-1.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino+proptest1-devel}"
SRC_URI[x86_64_v2_rust-camino+proptest1-devel.sha256sum] = "e50a1fcb3cfdab04ca5895824880a9b67bb6742779912ffffe1feb710df81281"

URI_x86_64_v2_rust-camino+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+serde1-devel-1.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino+serde1-devel}"
SRC_URI[x86_64_v2_rust-camino+serde1-devel.sha256sum] = "d3c349fd88172970cc4f281a1d218d683d33872f0d1d0ac917330bca4bf78579"

URI_x86_64_v2_rust-camino-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino-devel-1.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino-devel}"
SRC_URI[x86_64_v2_rust-camino-devel.sha256sum] = "dff60692f7592f274bc192db4696255f9bd3fe6a1a8cbdc77eb5a947b48b8ddd"

URI_aarch64_rust-camino+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+default-devel-1.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-camino+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino+default-devel}"
SRC_URI[aarch64_rust-camino+default-devel.sha256sum] = "a63c2787aa9bcfe0c0e5cbeff964c552a3935fdd25e952562a00c52d1f9b05d5"

URI_aarch64_rust-camino+proptest1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+proptest1-devel-1.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-camino+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino+proptest1-devel}"
SRC_URI[aarch64_rust-camino+proptest1-devel.sha256sum] = "6592a46629be814d6bd61cb5a38e0fe783e66b5d732a18772e88d9981c0c6321"

URI_aarch64_rust-camino+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+serde1-devel-1.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-camino+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino+serde1-devel}"
SRC_URI[aarch64_rust-camino+serde1-devel.sha256sum] = "de13ec91be7d3410cda73fdc12047b749b8d1cb2b10ab61ee316c315d3566f12"

URI_aarch64_rust-camino-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino-devel-1.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-camino-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino-devel}"
SRC_URI[aarch64_rust-camino-devel.sha256sum] = "e7430078d5e35573fc0fe1708468edd1466dbc1e3f86ded2c3e3297494b796e8"

RDEPENDS:rust-camino+default-devel = " \
 cargo \
 rust-camino-devel \
 "
RDEPENDS:rust-camino+proptest1-devel = " \
 cargo \
 rust-camino-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-camino+serde1-devel = " \
 cargo \
 rust-camino-devel \
 rust-serde_core+default-devel \
 "
RDEPENDS:rust-camino-devel = " \
 cargo \
 rust \
 "
