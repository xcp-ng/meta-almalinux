# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "reuse"
PV = "6.2.0"
PR = "4.el10_3"
PACKAGES = " \
 reuse \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/reuse-6.2.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e37a9a1eaee860e7e30d4b0592ba61ef6ae18324cd49dafc8ea1ed495d6a8e9e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/reuse-6.2.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_reuse;unpack=0"
SRC_URI[x86_64_v2_reuse.sha256sum] = "00b540647fd206b15e6ce361934413c1b96ee3a0a1f0841dbcaf849993750143"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/reuse-6.2.0-4.el10_3.noarch.rpm;name=aarch64_reuse;unpack=0"
SRC_URI[aarch64_reuse.sha256sum] = "791d494f61db15cd7812b1dda042ff372e60d6b2d777f783d603221e623ae1ea"

RDEPENDS:reuse = " \
 python3 \
 python3-attrs \
 python3-click \
 python3-debian \
 python3-file-magic \
 python3-jinja2 \
 python3-license-expression \
 python3-tomlkit \
 "
