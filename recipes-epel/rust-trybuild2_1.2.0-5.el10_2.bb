# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trybuild2"
PV = "1.2.0"
PR = "5.el10_2"
PACKAGES = " \
 rust-trybuild2+default-devel \
 rust-trybuild2+diff-devel \
 rust-trybuild2+dissimilar-devel \
 rust-trybuild2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-trybuild2-1.2.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5402e01ae702b131a496d2a5ab054e87dffa36928d63bc74820c4bfe7eb2c8c"

URI_x86_64_v2_rust-trybuild2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild2+default-devel-1.2.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild2+default-devel}"
SRC_URI[x86_64_v2_rust-trybuild2+default-devel.sha256sum] = "7c5dc9df1f3f000c4185832dfb7fb5ac2c0a9ab879e93ebd2890908a6ff13f99"

URI_x86_64_v2_rust-trybuild2+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild2+diff-devel-1.2.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild2+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild2+diff-devel}"
SRC_URI[x86_64_v2_rust-trybuild2+diff-devel.sha256sum] = "141c2c29ee26d24f1d081fab370fd1760cac2bc9ea6d8bc71713f968600ea3f9"

URI_x86_64_v2_rust-trybuild2+dissimilar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild2+dissimilar-devel-1.2.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild2+dissimilar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild2+dissimilar-devel}"
SRC_URI[x86_64_v2_rust-trybuild2+dissimilar-devel.sha256sum] = "049f657a19f9550bf0d4e49f49e6c35fe30b6cc3318d60b255e752975ef85db9"

URI_x86_64_v2_rust-trybuild2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild2-devel-1.2.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild2-devel}"
SRC_URI[x86_64_v2_rust-trybuild2-devel.sha256sum] = "de3829e33d2fec1084a7960dd0ccf185afaaa2e6101a4e738bd411650f842f78"

URI_aarch64_rust-trybuild2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild2+default-devel-1.2.0-5.el10_2.noarch.rpm;name=aarch64_rust-trybuild2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild2+default-devel}"
SRC_URI[aarch64_rust-trybuild2+default-devel.sha256sum] = "b6b55b9008acb4189c4890361e726204ff750514b18dd4ae679d207a61812154"

URI_aarch64_rust-trybuild2+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild2+diff-devel-1.2.0-5.el10_2.noarch.rpm;name=aarch64_rust-trybuild2+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild2+diff-devel}"
SRC_URI[aarch64_rust-trybuild2+diff-devel.sha256sum] = "6705dda8c17e632c86a88e35e6add86b714eb1944eb5a586a77966efea6c3eea"

URI_aarch64_rust-trybuild2+dissimilar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild2+dissimilar-devel-1.2.0-5.el10_2.noarch.rpm;name=aarch64_rust-trybuild2+dissimilar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild2+dissimilar-devel}"
SRC_URI[aarch64_rust-trybuild2+dissimilar-devel.sha256sum] = "26c50b81a1714f4e9efb42be540d35c911a8137eedc2f9ecf6abe692c87cb22a"

URI_aarch64_rust-trybuild2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild2-devel-1.2.0-5.el10_2.noarch.rpm;name=aarch64_rust-trybuild2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild2-devel}"
SRC_URI[aarch64_rust-trybuild2-devel.sha256sum] = "03811040461f2dfaa44a0cc6c186d166c68da95b147a811af586fcf276a22170"

RDEPENDS:rust-trybuild2+default-devel = " \
 cargo \
 rust-trybuild2-devel \
 "
RDEPENDS:rust-trybuild2+diff-devel = " \
 cargo \
 rust-trybuild2+dissimilar-devel \
 rust-trybuild2-devel \
 "
RDEPENDS:rust-trybuild2+dissimilar-devel = " \
 cargo \
 rust-dissimilar+default-devel \
 rust-trybuild2-devel \
 "
RDEPENDS:rust-trybuild2-devel = " \
 cargo \
 rust \
 rust-basic-toml+default-devel \
 rust-glob+default-devel \
 rust-once_cell+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 rust-termcolor+default-devel \
 "
