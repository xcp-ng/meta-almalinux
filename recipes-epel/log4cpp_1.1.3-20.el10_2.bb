# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "log4cpp"
PV = "1.1.3"
PR = "20.el10_2"
PACKAGES = " \
 log4cpp \
 log4cpp-devel \
 log4cpp-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/log4cpp-1.1.3-20.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d157a961166c05da47a3c845821bb437eb9a831dcf5f476b99dcf6c078dc07f"

URI_x86_64_v2_log4cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cpp-1.1.3-20.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cpp}"
SRC_URI[x86_64_v2_log4cpp.sha256sum] = "f898b879e9c6bb0bc5f6d2768f5db3bcfa968b353267f22cc4e22b606cab7e05"

URI_x86_64_v2_log4cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cpp-devel-1.1.3-20.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cpp-devel}"
SRC_URI[x86_64_v2_log4cpp-devel.sha256sum] = "68a6d7513711d4b600c8e1b339b6d7eae1dbdc30d8b54ce5958c211ba6647607"

URI_x86_64_v2_log4cpp-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cpp-doc-1.1.3-20.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cpp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cpp-doc}"
SRC_URI[x86_64_v2_log4cpp-doc.sha256sum] = "568a72d81a0f7547ab35af46773bc8a003bddd03f3b979c8b3a9050cf2ad0d14"

URI_aarch64_log4cpp = "${EPEL_MIRROR}/aarch64/Packages/l/log4cpp-1.1.3-20.el10_2.aarch64.rpm;name=aarch64_log4cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cpp}"
SRC_URI[aarch64_log4cpp.sha256sum] = "b94d949ac76bb41ed9742e617ccb1f9d6f4918a8e22a70a568d72eeafed382ee"

URI_aarch64_log4cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/log4cpp-devel-1.1.3-20.el10_2.aarch64.rpm;name=aarch64_log4cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cpp-devel}"
SRC_URI[aarch64_log4cpp-devel.sha256sum] = "59f0318535af37a5ebe044227b44b868d5bde9449a60c164a5239701cc68b612"

URI_aarch64_log4cpp-doc = "${EPEL_MIRROR}/aarch64/Packages/l/log4cpp-doc-1.1.3-20.el10_2.aarch64.rpm;name=aarch64_log4cpp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cpp-doc}"
SRC_URI[aarch64_log4cpp-doc.sha256sum] = "5ffbdc2061b03773de8a77c07a75d7e6efdc22e03a155da1a4f94a0f183a4e22"

RDEPENDS:log4cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:log4cpp-devel = " \
 bash \
 log4cpp \
 pkgconf-pkg-config \
 "
RDEPENDS:log4cpp-doc = " \
 log4cpp \
 "
