# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-simd-adler32"
PV = "0.3.10"
PR = "1.el10_2"
PACKAGES = " \
 rust-simd-adler32+const-generics-devel \
 rust-simd-adler32+default-devel \
 rust-simd-adler32+nightly-devel \
 rust-simd-adler32+std-devel \
 rust-simd-adler32-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-simd-adler32-0.3.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64ecbd02b16427db9abdaead5b968981fad545baca60febdc9063d3c96c8d98f"

URI_x86_64_v2_rust-simd-adler32+const-generics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+const-generics-devel-0.3.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd-adler32+const-generics-devel}"
SRC_URI[x86_64_v2_rust-simd-adler32+const-generics-devel.sha256sum] = "3fefb61f7b81eb6e4f092687276f7f286fec2c43663c734fcf4fac4676bd1eee"

URI_x86_64_v2_rust-simd-adler32+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+default-devel-0.3.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd-adler32+default-devel}"
SRC_URI[x86_64_v2_rust-simd-adler32+default-devel.sha256sum] = "cfb1627e6092a938523c47ecb15debabdf238046557a087dac3c3df270169638"

URI_x86_64_v2_rust-simd-adler32+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+nightly-devel-0.3.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd-adler32+nightly-devel}"
SRC_URI[x86_64_v2_rust-simd-adler32+nightly-devel.sha256sum] = "a4a849bb1d4a91344869c94fe5f659b0fd5ecd4b7065dba865feb084557a507c"

URI_x86_64_v2_rust-simd-adler32+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+std-devel-0.3.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd-adler32+std-devel}"
SRC_URI[x86_64_v2_rust-simd-adler32+std-devel.sha256sum] = "af05a38b3fa0da5f81bab0382277497c551ba7c6d8468c8b59765c5691d42351"

URI_x86_64_v2_rust-simd-adler32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32-devel-0.3.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd-adler32-devel}"
SRC_URI[x86_64_v2_rust-simd-adler32-devel.sha256sum] = "a7cd0a650a6a690b485d6ccdf6d7a6adc7a92d5b0fb20d9c122e701e2ef6867b"

URI_aarch64_rust-simd-adler32+const-generics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+const-generics-devel-0.3.10-1.el10_2.noarch.rpm;name=aarch64_rust-simd-adler32+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd-adler32+const-generics-devel}"
SRC_URI[aarch64_rust-simd-adler32+const-generics-devel.sha256sum] = "c4da34bbeb31585f6b75205ceddaca8ef35454e3506c3fe0279097aa1dc1bc57"

URI_aarch64_rust-simd-adler32+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+default-devel-0.3.10-1.el10_2.noarch.rpm;name=aarch64_rust-simd-adler32+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd-adler32+default-devel}"
SRC_URI[aarch64_rust-simd-adler32+default-devel.sha256sum] = "f40eb912f24a0764a44bd58fa5ede7423e3a72cc3a049a8d7ad8d3dc8b0a9d8f"

URI_aarch64_rust-simd-adler32+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+nightly-devel-0.3.10-1.el10_2.noarch.rpm;name=aarch64_rust-simd-adler32+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd-adler32+nightly-devel}"
SRC_URI[aarch64_rust-simd-adler32+nightly-devel.sha256sum] = "5d497e9c150d5ba3f43aa78ae8f877000e166dcad58e6128b11dde71488b3c59"

URI_aarch64_rust-simd-adler32+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+std-devel-0.3.10-1.el10_2.noarch.rpm;name=aarch64_rust-simd-adler32+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd-adler32+std-devel}"
SRC_URI[aarch64_rust-simd-adler32+std-devel.sha256sum] = "60a3495bdfe3b4f691a3ed1d3df85ddea4474b3393c37febb457a89a2b67746f"

URI_aarch64_rust-simd-adler32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32-devel-0.3.10-1.el10_2.noarch.rpm;name=aarch64_rust-simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd-adler32-devel}"
SRC_URI[aarch64_rust-simd-adler32-devel.sha256sum] = "a5e78ff4d34df760bbee7694b5aaa11567d14a2792552858ecc64e0441769eea"

RDEPENDS:rust-simd-adler32+const-generics-devel = " \
 cargo \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32+default-devel = " \
 cargo \
 rust-simd-adler32+const-generics-devel \
 rust-simd-adler32+std-devel \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32+nightly-devel = " \
 cargo \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32+std-devel = " \
 cargo \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32-devel = " \
 cargo \
 "
