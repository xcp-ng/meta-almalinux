# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkmahjongg"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 libkmahjongg \
 libkmahjongg-data \
 libkmahjongg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkmahjongg-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70b0baf5f9f11d8230610d954ad72600631fe8ddb60da14e3c40e4d75f0f6296"

URI_x86_64_v2_libkmahjongg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkmahjongg-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkmahjongg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkmahjongg}"
SRC_URI[x86_64_v2_libkmahjongg.sha256sum] = "90017b2b17c8c41e20141fcdd3fdc0be78296051a7506c030e33560e45ed4375"

URI_x86_64_v2_libkmahjongg-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkmahjongg-data-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libkmahjongg-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkmahjongg-data}"
SRC_URI[x86_64_v2_libkmahjongg-data.sha256sum] = "e89b8eb00d6fbaa299bfeffed0e52fe8820882a784a690d564da410820bb46d4"

URI_x86_64_v2_libkmahjongg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkmahjongg-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkmahjongg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkmahjongg-devel}"
SRC_URI[x86_64_v2_libkmahjongg-devel.sha256sum] = "6c7c1b46c2e07cfaee9ada258c41fb85c45ab086235265c6014eef7450354605"

URI_aarch64_libkmahjongg = "${EPEL_MIRROR}/aarch64/Packages/l/libkmahjongg-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkmahjongg;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkmahjongg}"
SRC_URI[aarch64_libkmahjongg.sha256sum] = "1ecbdd36e54a5416cf007fc6eefac7f32fe6be7509d98378cc08b1c8fea1beb1"

URI_aarch64_libkmahjongg-data = "${EPEL_MIRROR}/aarch64/Packages/l/libkmahjongg-data-26.04.3-1.el10_3.noarch.rpm;name=aarch64_libkmahjongg-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkmahjongg-data}"
SRC_URI[aarch64_libkmahjongg-data.sha256sum] = "0b41052be894ea5bff687a1f87b5ed276475b5a5b2a208e441e0fb18e3c3b69d"

URI_aarch64_libkmahjongg-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkmahjongg-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkmahjongg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkmahjongg-devel}"
SRC_URI[aarch64_libkmahjongg-devel.sha256sum] = "f29d69744f5775e8a3f9a1c74a192b7e32439480c7f4c42b996d3cf0ca17e07d"

RDEPENDS:libkmahjongg = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libkmahjongg-data \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:libkmahjongg-data = " \
 "
RDEPENDS:libkmahjongg-devel = " \
 cmake-filesystem \
 kf6-kconfigwidgets-devel \
 libkmahjongg \
 qt6-qtbase-devel \
 "
