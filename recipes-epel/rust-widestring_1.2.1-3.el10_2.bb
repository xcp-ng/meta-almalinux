# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-widestring"
PV = "1.2.1"
PR = "3.el10_2"
PACKAGES = " \
 rust-widestring+alloc-devel \
 rust-widestring+default-devel \
 rust-widestring+std-devel \
 rust-widestring-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-widestring-1.2.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09e5191c54b54be83d004330ecc81b07d185aade406250b367c0432b45b43b0a"

URI_x86_64_v2_rust-widestring+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-widestring+alloc-devel-1.2.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-widestring+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-widestring+alloc-devel}"
SRC_URI[x86_64_v2_rust-widestring+alloc-devel.sha256sum] = "4fd6e71f99617570c652e84debb8b2e0b496a46b7dcdcfbf7c2e58dc2c1b379a"

URI_x86_64_v2_rust-widestring+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-widestring+default-devel-1.2.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-widestring+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-widestring+default-devel}"
SRC_URI[x86_64_v2_rust-widestring+default-devel.sha256sum] = "113e0cb71d4205ce69fd5c680cb34c7586013809183e54cb6486853a8edfcc28"

URI_x86_64_v2_rust-widestring+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-widestring+std-devel-1.2.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-widestring+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-widestring+std-devel}"
SRC_URI[x86_64_v2_rust-widestring+std-devel.sha256sum] = "41341d5e03685e54d088e3fc6108f8fbc805b856ccfd91f74b4b7debf85b0a51"

URI_x86_64_v2_rust-widestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-widestring-devel-1.2.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-widestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-widestring-devel}"
SRC_URI[x86_64_v2_rust-widestring-devel.sha256sum] = "fddb6833a11da34af5b29f179cdc98068264c600afffc8435933403ce93b3bbf"

URI_aarch64_rust-widestring+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-widestring+alloc-devel-1.2.1-3.el10_2.noarch.rpm;name=aarch64_rust-widestring+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-widestring+alloc-devel}"
SRC_URI[aarch64_rust-widestring+alloc-devel.sha256sum] = "2de2c216da82e828a08603a9ab847a74aa872e405bf2e0e68752ae3f423c4319"

URI_aarch64_rust-widestring+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-widestring+default-devel-1.2.1-3.el10_2.noarch.rpm;name=aarch64_rust-widestring+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-widestring+default-devel}"
SRC_URI[aarch64_rust-widestring+default-devel.sha256sum] = "800663a873b50196715456d0ed580d89581a95871ab16f41fc71a3bb2a741808"

URI_aarch64_rust-widestring+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-widestring+std-devel-1.2.1-3.el10_2.noarch.rpm;name=aarch64_rust-widestring+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-widestring+std-devel}"
SRC_URI[aarch64_rust-widestring+std-devel.sha256sum] = "11817175ef6d1eb5c8423226a207ff7f23ba6b2eedb224d70dee430fb245ad55"

URI_aarch64_rust-widestring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-widestring-devel-1.2.1-3.el10_2.noarch.rpm;name=aarch64_rust-widestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-widestring-devel}"
SRC_URI[aarch64_rust-widestring-devel.sha256sum] = "fc7cf31705507c680846ac3c93257b154b04e2e5642abbe7f84714ed262eafde"

RDEPENDS:rust-widestring+alloc-devel = " \
 cargo \
 rust-widestring-devel \
 "
RDEPENDS:rust-widestring+default-devel = " \
 cargo \
 rust-widestring+std-devel \
 rust-widestring-devel \
 "
RDEPENDS:rust-widestring+std-devel = " \
 cargo \
 rust-widestring+alloc-devel \
 rust-widestring-devel \
 "
RDEPENDS:rust-widestring-devel = " \
 cargo \
 rust \
 "
