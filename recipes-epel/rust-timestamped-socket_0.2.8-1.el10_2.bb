# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-timestamped-socket"
PV = "0.2.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-timestamped-socket+default-devel \
 rust-timestamped-socket+serde-devel \
 rust-timestamped-socket-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-timestamped-socket-0.2.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9efb56d46801c9da2e49aeca10bd037571485a68f265e5ecbbd2970de210b91"

URI_x86_64_v2_rust-timestamped-socket+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-timestamped-socket+default-devel-0.2.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-timestamped-socket+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-timestamped-socket+default-devel}"
SRC_URI[x86_64_v2_rust-timestamped-socket+default-devel.sha256sum] = "00a69c5a51cf0cb66d691676ced0338bf5467ecf1a825692c6f2d92000d5facb"

URI_x86_64_v2_rust-timestamped-socket+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-timestamped-socket+serde-devel-0.2.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-timestamped-socket+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-timestamped-socket+serde-devel}"
SRC_URI[x86_64_v2_rust-timestamped-socket+serde-devel.sha256sum] = "5d754bf4b9ce0d575e87962a151e86b30404422f7a5a13b8f3edb96fae0872c0"

URI_x86_64_v2_rust-timestamped-socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-timestamped-socket-devel-0.2.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-timestamped-socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-timestamped-socket-devel}"
SRC_URI[x86_64_v2_rust-timestamped-socket-devel.sha256sum] = "58888c248960fe15f4a28007d0f07abd6e39f13bf9500f65128842922ceece64"

URI_aarch64_rust-timestamped-socket+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-timestamped-socket+default-devel-0.2.8-1.el10_2.noarch.rpm;name=aarch64_rust-timestamped-socket+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-timestamped-socket+default-devel}"
SRC_URI[aarch64_rust-timestamped-socket+default-devel.sha256sum] = "dd0cedacef293b8508c6dd844291c63c74f6338f7b5b575cab57158399cfb3e9"

URI_aarch64_rust-timestamped-socket+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-timestamped-socket+serde-devel-0.2.8-1.el10_2.noarch.rpm;name=aarch64_rust-timestamped-socket+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-timestamped-socket+serde-devel}"
SRC_URI[aarch64_rust-timestamped-socket+serde-devel.sha256sum] = "dafc76c954d649d7946fc9488dbd6c617bc35190aa8ab4f85ce1b0282385253e"

URI_aarch64_rust-timestamped-socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-timestamped-socket-devel-0.2.8-1.el10_2.noarch.rpm;name=aarch64_rust-timestamped-socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-timestamped-socket-devel}"
SRC_URI[aarch64_rust-timestamped-socket-devel.sha256sum] = "5a12cd9483b3a74fc7fa59b64d5cb37a1240f716d604bf6d8b1417cfce8068ea"

RDEPENDS:rust-timestamped-socket+default-devel = " \
 cargo \
 rust-timestamped-socket+serde-devel \
 rust-timestamped-socket-devel \
 "
RDEPENDS:rust-timestamped-socket+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-timestamped-socket-devel \
 "
RDEPENDS:rust-timestamped-socket-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 rust-tokio+default-devel \
 rust-tokio+net-devel \
 rust-tokio+time-devel \
 rust-tracing+log-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
