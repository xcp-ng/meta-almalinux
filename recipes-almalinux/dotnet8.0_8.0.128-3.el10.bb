# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet8.0"
PV = "8.0.128"
PR = "3.el10"
PACKAGES = " \
 aspnetcore-runtime-8.0 \
 aspnetcore-runtime-dbg-8.0 \
 aspnetcore-targeting-pack-8.0 \
 dotnet-apphost-pack-8.0 \
 dotnet-hostfxr-8.0 \
 dotnet-runtime-8.0 \
 dotnet-runtime-dbg-8.0 \
 dotnet-sdk-8.0 \
 dotnet-sdk-8.0-source-built-artifacts \
 dotnet-sdk-dbg-8.0 \
 dotnet-targeting-pack-8.0 \
 dotnet-templates-8.0 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet8.0-8.0.128-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5258a2334423711fa2d601f8a6c37b60e6d636319baeae07e587549dd15227be"

URI_x86_64_v2_aspnetcore-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-8.0-8.0.28-3.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-8.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-8.0.sha256sum] = "61ac76db02389eea1103c8664ca3ce49d65d2188ca0b4a06c71065ccc75aa15e"

URI_x86_64_v2_aspnetcore-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-8.0-8.0.28-3.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-dbg-8.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-8.0.sha256sum] = "0c46b9c869a1a73bfd93839d1042fc295cbb8c078caaa588355c1e148a686198"

URI_x86_64_v2_aspnetcore-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-8.0-8.0.28-3.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-targeting-pack-8.0}"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-8.0.sha256sum] = "e68b88677b49833d111a3ec5fe8c0866cac7ba948fce00e112113077a23a39c4"

URI_x86_64_v2_dotnet-apphost-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-8.0-8.0.28-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-apphost-pack-8.0}"
SRC_URI[x86_64_v2_dotnet-apphost-pack-8.0.sha256sum] = "3ef16563588ba4f76d8ad2ed36943053e914e4619582bae7bc42bf0879074b56"

URI_x86_64_v2_dotnet-hostfxr-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-8.0-8.0.28-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-hostfxr-8.0}"
SRC_URI[x86_64_v2_dotnet-hostfxr-8.0.sha256sum] = "db1df193b8630c7f08a1778658f9f3e8847fd2b99bf058df0185337894a44dcc"

URI_x86_64_v2_dotnet-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-8.0-8.0.28-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-8.0}"
SRC_URI[x86_64_v2_dotnet-runtime-8.0.sha256sum] = "9b7ab7a99677bbd6dfdd32095565c1359fb9c8bdba5814b5b70b775a49da308d"

URI_x86_64_v2_dotnet-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-8.0-8.0.28-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-dbg-8.0}"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-8.0.sha256sum] = "234d816386c2c9094f9e6582943404eb1a133fca34ede249380ef94123613135"

URI_x86_64_v2_dotnet-sdk-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-8.0-8.0.128-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-8.0}"
SRC_URI[x86_64_v2_dotnet-sdk-8.0.sha256sum] = "b7302b855b972be631a7f518194b38dbfbf510155ec92ffa17b31e3744fc69eb"

URI_x86_64_v2_dotnet-sdk-8.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-8.0-source-built-artifacts-8.0.128-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-8.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-8.0-source-built-artifacts}"
SRC_URI[x86_64_v2_dotnet-sdk-8.0-source-built-artifacts.sha256sum] = "6d11e146dc25cc97a20790866dc8824f20b0fdf4523fb3d89a49204243eec3ab"

URI_x86_64_v2_dotnet-sdk-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-8.0-8.0.128-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-dbg-8.0}"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-8.0.sha256sum] = "2a2ebe6d29da935b830c9d5c7e326e4abb409bf8551c8822e1f775790dedfb87"

URI_x86_64_v2_dotnet-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-8.0-8.0.28-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-targeting-pack-8.0}"
SRC_URI[x86_64_v2_dotnet-targeting-pack-8.0.sha256sum] = "2d56e8772e0fd9ce6d06b35a46d240019b9d718a19537c3592f6af37c8d72c9f"

URI_x86_64_v2_dotnet-templates-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-8.0-8.0.128-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-templates-8.0}"
SRC_URI[x86_64_v2_dotnet-templates-8.0.sha256sum] = "9aa9dd89b7fcd50b706e6342e0dbfb85d40581bdee6bcb28df2ae738d258d951"

URI_aarch64_aspnetcore-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-8.0-8.0.28-3.el10.aarch64.rpm;name=aarch64_aspnetcore-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-8.0}"
SRC_URI[aarch64_aspnetcore-runtime-8.0.sha256sum] = "79556f0440f9192bd4bc58c6682d1649f382607dd92e0917a49b46adebf1c561"

URI_aarch64_aspnetcore-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-8.0-8.0.28-3.el10.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-dbg-8.0}"
SRC_URI[aarch64_aspnetcore-runtime-dbg-8.0.sha256sum] = "b6e58692ff14222bdfbd47f42cd25c80d73a7852d8fc6659486ad118ee322583"

URI_aarch64_aspnetcore-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-8.0-8.0.28-3.el10.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-targeting-pack-8.0}"
SRC_URI[aarch64_aspnetcore-targeting-pack-8.0.sha256sum] = "9a8d2d66e60f20a9b3b0cdd6162af26dd4afc6abd4fb10c7336e4bdb3972a8b2"

URI_aarch64_dotnet-apphost-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-8.0-8.0.28-3.el10.aarch64.rpm;name=aarch64_dotnet-apphost-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-apphost-pack-8.0}"
SRC_URI[aarch64_dotnet-apphost-pack-8.0.sha256sum] = "db680e0c16dce32271938edb473de3f55671551222abbdb044d033b3c06dba4f"

URI_aarch64_dotnet-hostfxr-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-8.0-8.0.28-3.el10.aarch64.rpm;name=aarch64_dotnet-hostfxr-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-hostfxr-8.0}"
SRC_URI[aarch64_dotnet-hostfxr-8.0.sha256sum] = "ab2b20090553360b66154ebcf0f7d933a4e2df8ed9f0234a3f333ec25ef7828a"

URI_aarch64_dotnet-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-8.0-8.0.28-3.el10.aarch64.rpm;name=aarch64_dotnet-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-8.0}"
SRC_URI[aarch64_dotnet-runtime-8.0.sha256sum] = "c04b13143f8b0545ee6f0e4bf9d3928e6318af638f1910a8ba0bc593abcdf98b"

URI_aarch64_dotnet-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-8.0-8.0.28-3.el10.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-dbg-8.0}"
SRC_URI[aarch64_dotnet-runtime-dbg-8.0.sha256sum] = "2e570fa3a1f5e47e87f818ca1b51aca0e60c758dd69dffc17f895a16634f41c9"

URI_aarch64_dotnet-sdk-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-8.0-8.0.128-3.el10.aarch64.rpm;name=aarch64_dotnet-sdk-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-8.0}"
SRC_URI[aarch64_dotnet-sdk-8.0.sha256sum] = "960e258fc9260e5ed7b2a4c11a99fd53c5648556ba51f0cb21f970a6c39c7c5c"

URI_aarch64_dotnet-sdk-8.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-8.0-source-built-artifacts-8.0.128-3.el10.aarch64.rpm;name=aarch64_dotnet-sdk-8.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-8.0-source-built-artifacts}"
SRC_URI[aarch64_dotnet-sdk-8.0-source-built-artifacts.sha256sum] = "7d6587802faa519dc92ab97701d24635997e202658745dbc9f4a442c7fe7cbb7"

URI_aarch64_dotnet-sdk-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-8.0-8.0.128-3.el10.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-dbg-8.0}"
SRC_URI[aarch64_dotnet-sdk-dbg-8.0.sha256sum] = "df545347899a7652fd9596cbb844bf32b16c32309caf0f689269db2c5e96fe33"

URI_aarch64_dotnet-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-8.0-8.0.28-3.el10.aarch64.rpm;name=aarch64_dotnet-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-targeting-pack-8.0}"
SRC_URI[aarch64_dotnet-targeting-pack-8.0.sha256sum] = "b4199f649baaaa1bbe252af09c6e58e0411db7bea5775b3bc79b53b255ac0083"

URI_aarch64_dotnet-templates-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-8.0-8.0.128-3.el10.aarch64.rpm;name=aarch64_dotnet-templates-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-templates-8.0}"
SRC_URI[aarch64_dotnet-templates-8.0.sha256sum] = "99898d59dfdb6df1fd0095afd8087d6ec9d5f71391fc2a7945f8b7df3e60da1c"

RDEPENDS:aspnetcore-runtime-8.0 = " \
 dotnet-runtime-8.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-8.0 = " \
 aspnetcore-runtime-8.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-8.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-8.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-hostfxr-8.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-8.0 = " \
 dotnet-hostfxr-8.0 \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-8.0 = " \
 dotnet-runtime-8.0 \
 "
RDEPENDS:dotnet-sdk-8.0 = " \
 aspnetcore-runtime-8.0 \
 aspnetcore-targeting-pack-8.0 \
 dotnet-apphost-pack-8.0 \
 dotnet-runtime-8.0 \
 dotnet-targeting-pack-8.0 \
 dotnet-templates-8.0 \
 glibc \
 libgcc \
 libstdc++ \
 netstandard-targeting-pack-2.1 \
 "
RDEPENDS:dotnet-sdk-8.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-dbg-8.0 = " \
 dotnet-sdk-8.0 \
 "
RDEPENDS:dotnet-targeting-pack-8.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-8.0 = " \
 dotnet-host \
 "
