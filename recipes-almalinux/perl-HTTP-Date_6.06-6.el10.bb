# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Date"
PV = "6.06"
PR = "6.el10"
PACKAGES = " \
 perl-HTTP-Date \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-HTTP-Date-6.06-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "58fa3e1dfcf155092e213f91188a8a022e830b8e0213cac96e8dc114a725bdac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-HTTP-Date-6.06-6.el10.noarch.rpm;name=x86_64_v2_perl-HTTP-Date;unpack=0"
SRC_URI[x86_64_v2_perl-HTTP-Date.sha256sum] = "0cc9443c4ee49bb73d67a5f4d083c1cd7be05f87844db954343c2d2b51f9972b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-HTTP-Date-6.06-6.el10.noarch.rpm;name=aarch64_perl-HTTP-Date;unpack=0"
SRC_URI[aarch64_perl-HTTP-Date.sha256sum] = "0cc9443c4ee49bb73d67a5f4d083c1cd7be05f87844db954343c2d2b51f9972b"

RDEPENDS:perl-HTTP-Date = " \
 perl-Exporter \
 perl-Time-Local \
 perl-TimeDate \
 perl-libs \
 "
