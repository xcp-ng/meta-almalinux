# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mdurl"
PV = "0.1.2"
PR = "8.el10_0"
PACKAGES = " \
 python3-mdurl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mdurl-0.1.2-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f59f557ab483c19beb2b839350df720f76cf364747fec98764db099f020b982"

URI_x86_64_v2_python3-mdurl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mdurl-0.1.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mdurl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mdurl}"
SRC_URI[x86_64_v2_python3-mdurl.sha256sum] = "b0c0197a256caecbcdd54dc8917618219286e32ec5f7ad4c1749b5c5f20fe62c"

URI_aarch64_python3-mdurl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mdurl-0.1.2-8.el10_0.noarch.rpm;name=aarch64_python3-mdurl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mdurl}"
SRC_URI[aarch64_python3-mdurl.sha256sum] = "4c0e5c6994f8d7ff247047c72a0b45aeb71c8bbc2bfdd18f0165cfbae9791485"

RDEPENDS:python3-mdurl = " \
 python3 \
 "
