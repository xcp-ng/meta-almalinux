# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "corrosion"
PV = "0.5.2"
PR = "1.el10_1"
PACKAGES = " \
 corrosion \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/corrosion-0.5.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a291f2c7a434678991af0232440e83915159ce06a527d06d4f991647fa937432"

URI_x86_64_v2_corrosion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/corrosion-0.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_corrosion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_corrosion}"
SRC_URI[x86_64_v2_corrosion.sha256sum] = "b7d5c1d0fb3260f46641f29c65ea5bec2917f4fcb3efdaa9965eb51c10e6c142"

URI_aarch64_corrosion = "${EPEL_MIRROR}/aarch64/Packages/c/corrosion-0.5.2-1.el10_1.aarch64.rpm;name=aarch64_corrosion;unpack=0"
SRC_URI:append = " ${URI_aarch64_corrosion}"
SRC_URI[aarch64_corrosion.sha256sum] = "a41eb4af53e7f9b3accc6146a3facfa1fc657d59516edbf32f272c57ac325a59"

RDEPENDS:corrosion = " \
 cmake \
 cmake-filesystem \
 glibc \
 libgcc \
 "
