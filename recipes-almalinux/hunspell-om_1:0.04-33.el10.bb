# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-om"
PE = "1"
PV = "0.04"
PR = "33.el10"
PACKAGES = " \
 hunspell-om \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-om-0.04-33.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6bf4c96213739b3a5d39f4065e8f0590f479a1018f8beef1f232edff221f4f9f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-om-0.04-33.el10.noarch.rpm;name=x86_64_v2_hunspell-om;unpack=0"
SRC_URI[x86_64_v2_hunspell-om.sha256sum] = "5ca72b922461440c4cb4076197ac214010ffc4fc29fc17e6115686b8be6bc388"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-om-0.04-33.el10.noarch.rpm;name=aarch64_hunspell-om;unpack=0"
SRC_URI[aarch64_hunspell-om.sha256sum] = "5ca72b922461440c4cb4076197ac214010ffc4fc29fc17e6115686b8be6bc388"

RDEPENDS:hunspell-om = " \
 hunspell \
 "
