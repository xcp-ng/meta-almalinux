# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-trait"
PV = "0.1.89"
PR = "1.el10_1"
PACKAGES = " \
 rust-async-trait+default-devel \
 rust-async-trait-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-trait-0.1.89-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78a5e5e1a421bf7cc9acf3c2feda4d38e7d27a2b361a8cc03c305fcb0d55c70f"

URI_x86_64_v2_rust-async-trait+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-trait+default-devel-0.1.89-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-trait+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-trait+default-devel}"
SRC_URI[x86_64_v2_rust-async-trait+default-devel.sha256sum] = "d9e2ef6417681fba92f3be61df5a1c04f17dc929834d3b56f0e3396775b7a94c"

URI_x86_64_v2_rust-async-trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-trait-devel-0.1.89-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-trait-devel}"
SRC_URI[x86_64_v2_rust-async-trait-devel.sha256sum] = "9b2456525377a83023314be97afc5953813b4fe7a228ff7e26c9294aa0b9690f"

URI_aarch64_rust-async-trait+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-trait+default-devel-0.1.89-1.el10_1.noarch.rpm;name=aarch64_rust-async-trait+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-trait+default-devel}"
SRC_URI[aarch64_rust-async-trait+default-devel.sha256sum] = "298132be25b63815eb643a8c04663682b1a6728acd6b04b16681c484807a1bde"

URI_aarch64_rust-async-trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-trait-devel-0.1.89-1.el10_1.noarch.rpm;name=aarch64_rust-async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-trait-devel}"
SRC_URI[aarch64_rust-async-trait-devel.sha256sum] = "c6e6c9beb6ee4cbfd5568a5f5a267e051de159fa158d913561ba6c73d5dc5f76"

RDEPENDS:rust-async-trait+default-devel = " \
 cargo \
 rust-async-trait-devel \
 "
RDEPENDS:rust-async-trait-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "
