# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pim-data-exporter"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 pim-data-exporter \
 pim-data-exporter-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pim-data-exporter-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "887856f8d523f77aa82f46336a6455c59fb9329585e1e7631c92c89dfc3f5477"

URI_x86_64_v2_pim-data-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pim-data-exporter-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pim-data-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pim-data-exporter}"
SRC_URI[x86_64_v2_pim-data-exporter.sha256sum] = "7bcf48dd0b60983b7254111173de88f38193735f43da3f57263e593a42b7bffb"

URI_x86_64_v2_pim-data-exporter-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pim-data-exporter-libs-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pim-data-exporter-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pim-data-exporter-libs}"
SRC_URI[x86_64_v2_pim-data-exporter-libs.sha256sum] = "0d48b054a29857b0f52c57c9ebf97f6eef2c9c0e92232fb17250ccaab2ed2a8d"

URI_aarch64_pim-data-exporter = "${EPEL_MIRROR}/aarch64/Packages/p/pim-data-exporter-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_pim-data-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_pim-data-exporter}"
SRC_URI[aarch64_pim-data-exporter.sha256sum] = "70c63fb4f25b0a353504b93d84fd4fd80811fc31335ee751474479c45fd5efd4"

URI_aarch64_pim-data-exporter-libs = "${EPEL_MIRROR}/aarch64/Packages/p/pim-data-exporter-libs-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_pim-data-exporter-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pim-data-exporter-libs}"
SRC_URI[aarch64_pim-data-exporter-libs.sha256sum] = "c9b4ee93a8a77332f090bd7ddf63b041f2adb07d3752eddc0cb24f957f08e96d"

RDEPENDS:pim-data-exporter = " \
 akonadi-server \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kitemviews \
 kf6-kstatusnotifieritem \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 mailcommon \
 pim-data-exporter-libs \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pim-data-exporter-libs = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kf6-karchive \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kidentitymanagement \
 kmailtransport \
 kmime \
 libgcc \
 libstdc++ \
 mailcommon \
 pim-data-exporter \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
