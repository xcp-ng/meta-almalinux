# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpcap"
PE = "14"
PV = "1.10.4"
PR = "7.el10_2.1"
PACKAGES = " \
 libpcap \
 libpcap-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libpcap-1.10.4-7.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4268f15dc2a1ce672e0740e08fbae4c85e14b76826aac5c9239904ddac0f8096"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpcap-1.10.4-7.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libpcap;unpack=0"
SRC_URI[x86_64_v2_libpcap.sha256sum] = "64158a26d96226b25b6262f7b36091fa0ae0b2a0544a7cd69500f837c1938f9d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libpcap-devel-1.10.4-7.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libpcap-devel;unpack=0"
SRC_URI[x86_64_v2_libpcap-devel.sha256sum] = "09dcbc911fd723af5c17212ba648bf293310c6d19a499a95157edc22cd34d8cc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpcap-1.10.4-7.el10_2.1.aarch64.rpm;name=aarch64_libpcap;unpack=0"
SRC_URI[aarch64_libpcap.sha256sum] = "c90c4848bb6f1d555d464ab6e6440318960e24c2e5e1c34449d91e355a23c007"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libpcap-devel-1.10.4-7.el10_2.1.aarch64.rpm;name=aarch64_libpcap-devel;unpack=0"
SRC_URI[aarch64_libpcap-devel.sha256sum] = "5a5ecd7b71262f5e97de6c48e405c85a8d4e8a640dfa9de1ab8bcbc3d13d74a4"

RDEPENDS:libpcap = " \
 glibc \
 libibverbs \
 "
RDEPENDS:libpcap-devel = " \
 bash \
 libpcap \
 pkgconf-pkg-config \
 rdma-core-devel \
 "
