# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-simple_logger"
PV = "5.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-simple_logger+colored-devel \
 rust-simple_logger+colors-devel \
 rust-simple_logger+default-devel \
 rust-simple_logger+nightly-devel \
 rust-simple_logger+stderr-devel \
 rust-simple_logger+threads-devel \
 rust-simple_logger+time-devel \
 rust-simple_logger+timestamps-devel \
 rust-simple_logger-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-simple_logger-5.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9072e035486f96d76688907fb3fd67be3e9fc817ec1fccf02452698a143d9f75"

URI_x86_64_v2_rust-simple_logger+colored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+colored-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+colored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+colored-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+colored-devel.sha256sum] = "833d2d79ca7ab7f3929f930a121c2ca7a7e3fdc6bd2c9a3fc79a8f339bfee44e"

URI_x86_64_v2_rust-simple_logger+colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+colors-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+colors-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+colors-devel.sha256sum] = "3727e16b7b1fac7fd4d5fc0cfaf344583823278a3ffa45e5183399fd966dc006"

URI_x86_64_v2_rust-simple_logger+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+default-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+default-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+default-devel.sha256sum] = "26ec2971793767d0a525c933802372994a83f5975d338c5f50dd72a3fb9be895"

URI_x86_64_v2_rust-simple_logger+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+nightly-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+nightly-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+nightly-devel.sha256sum] = "6d55b85ed7dd47d7f6c9bfd23a5ad5fb214a9406b9e2a46022e61057dbae71e0"

URI_x86_64_v2_rust-simple_logger+stderr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+stderr-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+stderr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+stderr-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+stderr-devel.sha256sum] = "0cc9c471c2132ea0b3f3c0f25d9d818341217679b2860c794032815dfc0ba997"

URI_x86_64_v2_rust-simple_logger+threads-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+threads-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+threads-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+threads-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+threads-devel.sha256sum] = "66da7cd2edf46e5dafd6ca6cd723ffbaf3b2a8917580da72b60899d89ee670d0"

URI_x86_64_v2_rust-simple_logger+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+time-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+time-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+time-devel.sha256sum] = "393be17c8f5c1fc4eff00a9cec7b187495ae927af884cd1ee8eacfca10f6fd2d"

URI_x86_64_v2_rust-simple_logger+timestamps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+timestamps-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+timestamps-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+timestamps-devel.sha256sum] = "0d615d71d7abb05d35c74764be20dc24c6a58319c19025376a444cf04da4ebfb"

URI_x86_64_v2_rust-simple_logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger-devel-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger-devel}"
SRC_URI[x86_64_v2_rust-simple_logger-devel.sha256sum] = "c6d4366c3cb61c4c679646a274dbe987fc5b2c63c640e11b7bc7f5cbbe82c9dd"

URI_aarch64_rust-simple_logger+colored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+colored-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-simple_logger+colored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+colored-devel}"
SRC_URI[aarch64_rust-simple_logger+colored-devel.sha256sum] = "67d05dd627b1f8b46f7a6832c9c3c3298169948d4f65e15780acb08badbb53f2"

URI_aarch64_rust-simple_logger+colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+colors-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-simple_logger+colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+colors-devel}"
SRC_URI[aarch64_rust-simple_logger+colors-devel.sha256sum] = "f901744d633819ca0fabe6f3ab90681dcc7e8df998f3089db73c902b7308dae5"

URI_aarch64_rust-simple_logger+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+default-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-simple_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+default-devel}"
SRC_URI[aarch64_rust-simple_logger+default-devel.sha256sum] = "dfd53c8da90634c8dc42091adbd2aed451f8044d24881478a9f80b35004ff5c8"

URI_aarch64_rust-simple_logger+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+nightly-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-simple_logger+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+nightly-devel}"
SRC_URI[aarch64_rust-simple_logger+nightly-devel.sha256sum] = "8bcd87240575d6554a034123699366cdc36f7d608170f573ec2107555d582329"

URI_aarch64_rust-simple_logger+stderr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+stderr-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-simple_logger+stderr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+stderr-devel}"
SRC_URI[aarch64_rust-simple_logger+stderr-devel.sha256sum] = "e4fe982747b3cf804345a69bd11933f93995a49b67c871997a49f1559e93a564"

URI_aarch64_rust-simple_logger+threads-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+threads-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-simple_logger+threads-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+threads-devel}"
SRC_URI[aarch64_rust-simple_logger+threads-devel.sha256sum] = "56e59f1d03b408bba212c2ad946be889390f3ec3403c3a803877f4db9a7be439"

URI_aarch64_rust-simple_logger+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+time-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-simple_logger+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+time-devel}"
SRC_URI[aarch64_rust-simple_logger+time-devel.sha256sum] = "fef6a983dba176dae770dde210718a573a75034c9f389e1518137d091a0f4bcd"

URI_aarch64_rust-simple_logger+timestamps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+timestamps-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-simple_logger+timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+timestamps-devel}"
SRC_URI[aarch64_rust-simple_logger+timestamps-devel.sha256sum] = "5a034ab2eca9d89ae50149e2fc4ab964df73d3fb749dbcedebf193f47b86199d"

URI_aarch64_rust-simple_logger-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger-devel-5.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-simple_logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger-devel}"
SRC_URI[aarch64_rust-simple_logger-devel.sha256sum] = "b5c62bff9c67643fa81a95a356632eab186530e27ad391aa8750d46c1fe12469"

RDEPENDS:rust-simple_logger+colored-devel = " \
 cargo \
 rust-colored+default-devel \
 rust-simple_logger-devel \
 "
RDEPENDS:rust-simple_logger+colors-devel = " \
 cargo \
 rust-simple_logger+colored-devel \
 rust-simple_logger-devel \
 "
RDEPENDS:rust-simple_logger+default-devel = " \
 cargo \
 rust-simple_logger+colors-devel \
 rust-simple_logger+timestamps-devel \
 rust-simple_logger-devel \
 "
RDEPENDS:rust-simple_logger+nightly-devel = " \
 cargo \
 rust-simple_logger-devel \
 "
RDEPENDS:rust-simple_logger+stderr-devel = " \
 cargo \
 rust-simple_logger-devel \
 "
RDEPENDS:rust-simple_logger+threads-devel = " \
 cargo \
 rust-simple_logger-devel \
 "
RDEPENDS:rust-simple_logger+time-devel = " \
 cargo \
 rust-simple_logger-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+local-offset-devel \
 rust-time+macros-devel \
 "
RDEPENDS:rust-simple_logger+timestamps-devel = " \
 cargo \
 rust-simple_logger+time-devel \
 rust-simple_logger-devel \
 "
RDEPENDS:rust-simple_logger-devel = " \
 cargo \
 rust-log+default-devel \
 rust-log+std-devel \
 "
