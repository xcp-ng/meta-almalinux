# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "adwaita-icon-theme"
PV = "46.0"
PR = "3.el10"
PACKAGES = " \
 adwaita-cursor-theme \
 adwaita-icon-theme \
 adwaita-icon-theme-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/adwaita-icon-theme-46.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43bd13a54305a57347cbca0f4537d4eee99eb6a98e23287ff0df81097cd53658"

URI_x86_64_v2_adwaita-cursor-theme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/adwaita-cursor-theme-46.0-3.el10.noarch.rpm;name=x86_64_v2_adwaita-cursor-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_adwaita-cursor-theme}"
SRC_URI[x86_64_v2_adwaita-cursor-theme.sha256sum] = "7e25f6824df6fa6ea7b6089ff13f1ccd7ef3144e5468597999f80660e06960cf"

URI_x86_64_v2_adwaita-icon-theme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/adwaita-icon-theme-46.0-3.el10.noarch.rpm;name=x86_64_v2_adwaita-icon-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_adwaita-icon-theme}"
SRC_URI[x86_64_v2_adwaita-icon-theme.sha256sum] = "dd6f404c3762d257d5135e85e4f9dfcbd33fa9d35c276e1a62b84b0abbf40cb9"

URI_x86_64_v2_adwaita-icon-theme-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/adwaita-icon-theme-devel-46.0-3.el10.noarch.rpm;name=x86_64_v2_adwaita-icon-theme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_adwaita-icon-theme-devel}"
SRC_URI[x86_64_v2_adwaita-icon-theme-devel.sha256sum] = "e9551ba09e1a98117e1dcc9156b5f4b6bfc850f7dcd9419e904360a02635d3d2"

URI_aarch64_adwaita-cursor-theme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/adwaita-cursor-theme-46.0-3.el10.noarch.rpm;name=aarch64_adwaita-cursor-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_adwaita-cursor-theme}"
SRC_URI[aarch64_adwaita-cursor-theme.sha256sum] = "7e25f6824df6fa6ea7b6089ff13f1ccd7ef3144e5468597999f80660e06960cf"

URI_aarch64_adwaita-icon-theme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/adwaita-icon-theme-46.0-3.el10.noarch.rpm;name=aarch64_adwaita-icon-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_adwaita-icon-theme}"
SRC_URI[aarch64_adwaita-icon-theme.sha256sum] = "dd6f404c3762d257d5135e85e4f9dfcbd33fa9d35c276e1a62b84b0abbf40cb9"

URI_aarch64_adwaita-icon-theme-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/adwaita-icon-theme-devel-46.0-3.el10.noarch.rpm;name=aarch64_adwaita-icon-theme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_adwaita-icon-theme-devel}"
SRC_URI[aarch64_adwaita-icon-theme-devel.sha256sum] = "e9551ba09e1a98117e1dcc9156b5f4b6bfc850f7dcd9419e904360a02635d3d2"

RDEPENDS:adwaita-cursor-theme = " \
 "
RDEPENDS:adwaita-icon-theme = " \
 adwaita-cursor-theme \
 bash \
 "
RDEPENDS:adwaita-icon-theme-devel = " \
 adwaita-icon-theme \
 pkgconf-pkg-config \
 "
