# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-tklauser-sysconf"
PV = "0.3.14"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-tklauser-sysconf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-tklauser-sysconf-0.3.14-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0957d5c42548d999febcc0c5cf54f249b6b338abc8218dced0f3355fb105e28"

URI_x86_64_v2_golang-github-tklauser-sysconf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-tklauser-sysconf-devel-0.3.14-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-tklauser-sysconf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-tklauser-sysconf-devel}"
SRC_URI[x86_64_v2_golang-github-tklauser-sysconf-devel.sha256sum] = "a90f6f8e74eca3ef380c2f6b72261018a2effa7a987f432bb0b501248e7eebff"

URI_aarch64_golang-github-tklauser-sysconf-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-tklauser-sysconf-devel-0.3.14-2.el10_0.noarch.rpm;name=aarch64_golang-github-tklauser-sysconf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-tklauser-sysconf-devel}"
SRC_URI[aarch64_golang-github-tklauser-sysconf-devel.sha256sum] = "67d96dd78a98deee4c3f30fced63e5067409f61b18fe08e36133f719448a1136"

RDEPENDS:golang-github-tklauser-sysconf-devel = " \
 go-filesystem \
 golang-github-tklauser-numcpus-devel \
 golang-x-sys-devel \
 "
