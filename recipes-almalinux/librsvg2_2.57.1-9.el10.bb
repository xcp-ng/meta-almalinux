# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librsvg2"
PV = "2.57.1"
PR = "9.el10"
PACKAGES = " \
 librsvg2 \
 librsvg2-devel \
 librsvg2-tools \
 rsvg-pixbuf-loader \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/librsvg2-2.57.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf8e430bbd1a01bb9f014111912a396b2b0ee9bb66fc656bb78e3310a814648f"

URI_x86_64_v2_librsvg2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/librsvg2-2.57.1-9.el10.x86_64_v2.rpm;name=x86_64_v2_librsvg2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librsvg2}"
SRC_URI[x86_64_v2_librsvg2.sha256sum] = "83902060805903da8e6bc7eceadb8a62b0542e05bf7ccf6702fde409bd59280e"

URI_x86_64_v2_librsvg2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/librsvg2-devel-2.57.1-9.el10.x86_64_v2.rpm;name=x86_64_v2_librsvg2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librsvg2-devel}"
SRC_URI[x86_64_v2_librsvg2-devel.sha256sum] = "a5035fbd3084df39ceb092cc9485e51a92d52d543bf39d53549e2e051e8441b0"

URI_x86_64_v2_librsvg2-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/librsvg2-tools-2.57.1-9.el10.x86_64_v2.rpm;name=x86_64_v2_librsvg2-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librsvg2-tools}"
SRC_URI[x86_64_v2_librsvg2-tools.sha256sum] = "db7beec29a5627277006e2f9ef13f0787d56c153845155aa918ce3b354e166df"

URI_x86_64_v2_rsvg-pixbuf-loader = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsvg-pixbuf-loader-2.57.1-9.el10.x86_64_v2.rpm;name=x86_64_v2_rsvg-pixbuf-loader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsvg-pixbuf-loader}"
SRC_URI[x86_64_v2_rsvg-pixbuf-loader.sha256sum] = "4dc2cc3db207e6ffa6644fa2afcbc1742244765966a8570919fd8860092c397a"

URI_aarch64_librsvg2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/librsvg2-2.57.1-9.el10.aarch64.rpm;name=aarch64_librsvg2;unpack=0"
SRC_URI:append = " ${URI_aarch64_librsvg2}"
SRC_URI[aarch64_librsvg2.sha256sum] = "2c5d7fbbe34ff20ef29f597fda42c755337816882534dc92e49d9df8b2ba1a55"

URI_aarch64_librsvg2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/librsvg2-devel-2.57.1-9.el10.aarch64.rpm;name=aarch64_librsvg2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librsvg2-devel}"
SRC_URI[aarch64_librsvg2-devel.sha256sum] = "d139276663872314db0778bea1f27b7c5b7147b1db42af9bb8fc11857e56f9cf"

URI_aarch64_librsvg2-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/librsvg2-tools-2.57.1-9.el10.aarch64.rpm;name=aarch64_librsvg2-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_librsvg2-tools}"
SRC_URI[aarch64_librsvg2-tools.sha256sum] = "be903d40356a05782600094fd3fbebaf87d3a3421229616dd7933e589c40b94e"

URI_aarch64_rsvg-pixbuf-loader = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsvg-pixbuf-loader-2.57.1-9.el10.aarch64.rpm;name=aarch64_rsvg-pixbuf-loader;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsvg-pixbuf-loader}"
SRC_URI[aarch64_rsvg-pixbuf-loader.sha256sum] = "544e95b57b69d1b80ece2965a2ac7c901dd8124d6198061835d8cda2b644c95e"

RDEPENDS:librsvg2 = " \
 cairo \
 cairo-gobject \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 harfbuzz \
 libgcc \
 libpng \
 libxml2 \
 pango \
 rsvg-pixbuf-loader \
 "
RDEPENDS:librsvg2-devel = " \
 cairo-devel \
 gdk-pixbuf2-devel \
 glib2-devel \
 librsvg2 \
 pkgconf-pkg-config \
 "
RDEPENDS:librsvg2-tools = " \
 cairo \
 cairo-gobject \
 fontconfig \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libgcc \
 librsvg2 \
 libxml2 \
 pango \
 "
RDEPENDS:rsvg-pixbuf-loader = " \
 cairo \
 cairo-gobject \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 harfbuzz \
 libpng \
 librsvg2 \
 libxml2 \
 pango \
 "
