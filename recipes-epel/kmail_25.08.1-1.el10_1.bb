# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmail"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kmail \
 kmail-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmail-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "288f435217a34b49a8332e6d85fb8debcba5e5ad595b999b2726645c2d30b456"

URI_x86_64_v2_kmail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmail-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmail}"
SRC_URI[x86_64_v2_kmail.sha256sum] = "eb71243dfc305d715770a0db5cecd99999eb83500755b1f1b1287bd0e87cbd65"

URI_x86_64_v2_kmail-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmail-libs-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmail-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmail-libs}"
SRC_URI[x86_64_v2_kmail-libs.sha256sum] = "7ad215eb256f3d5962ba60349fa85b4533966a74e0cde410b97f5d894ce8fcb0"

URI_aarch64_kmail = "${EPEL_MIRROR}/aarch64/Packages/k/kmail-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kmail;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmail}"
SRC_URI[aarch64_kmail.sha256sum] = "6e7c1af989bbed7c1173501e8ca81a2a9f0faade50f04804da45761859ee1117"

URI_aarch64_kmail-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kmail-libs-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kmail-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmail-libs}"
SRC_URI[aarch64_kmail-libs.sha256sum] = "b61363983222c210a503046e616f060d6b8db50ef53d2de520faab518069419b"

RDEPENDS:kmail = " \
 akonadi-import-wizard \
 akonadi-mime \
 akonadi-server \
 glibc \
 grantlee-editor \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kidentitymanagement \
 kmail-account-wizard \
 kmail-libs \
 kmailtransport \
 kmime \
 kontactinterface \
 ktnef \
 libgcc \
 libstdc++ \
 mailcommon \
 messagelib \
 pim-data-exporter \
 pim-sieve-editor \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:kmail-libs = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-search \
 akonadi-server \
 glibc \
 gpgmepp \
 kcalutils \
 kf6-kbookmarks \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 kidentitymanagement \
 kldap \
 kmail \
 kmailtransport \
 kmime \
 kontactinterface \
 kpimtextedit \
 ktextaddons-qt6 \
 libgcc \
 libgpg-error \
 libgravatar \
 libkdepim \
 libkleo \
 libksieve \
 libstdc++ \
 mailcommon \
 messagelib \
 pimcommon \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
