# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-av-scenechange0.14"
PV = "0.14.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-av-scenechange0.14+asm-devel \
 rust-av-scenechange0.14+binary-devel \
 rust-av-scenechange0.14+cc-devel \
 rust-av-scenechange0.14+clap-devel \
 rust-av-scenechange0.14+console-devel \
 rust-av-scenechange0.14+default-devel \
 rust-av-scenechange0.14+devel-devel \
 rust-av-scenechange0.14+fern-devel \
 rust-av-scenechange0.14+libc-devel \
 rust-av-scenechange0.14+nasm-rs-devel \
 rust-av-scenechange0.14+serde-devel \
 rust-av-scenechange0.14+serde_json-devel \
 rust-av-scenechange0.14+serialize-devel \
 rust-av-scenechange0.14+tracing-chrome-devel \
 rust-av-scenechange0.14+tracing-devel \
 rust-av-scenechange0.14+tracing-subscriber-devel \
 rust-av-scenechange0.14-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-av-scenechange0.14-0.14.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "456cb544609c36dab35c057a83a626251ee22d1b7589fcffcef4af4f82e2b7e4"

URI_x86_64_v2_rust-av-scenechange0.14+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+asm-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+asm-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+asm-devel.sha256sum] = "d53a5e8dfd6fa40dceb4f594de33a2a28c6be50ee39e04d50e217ea2c77c1310"

URI_x86_64_v2_rust-av-scenechange0.14+binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+binary-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+binary-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+binary-devel.sha256sum] = "0d59c981f27209a0cf5416ee3fbb36c6da29d946c40bb3dacc24717715141a63"

URI_x86_64_v2_rust-av-scenechange0.14+cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+cc-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+cc-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+cc-devel.sha256sum] = "b413c3072172accc34f56a04fd0146b9ebd6a4b088f4aa91f968df6d8c34c4e1"

URI_x86_64_v2_rust-av-scenechange0.14+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+clap-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+clap-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+clap-devel.sha256sum] = "ccd61827bb4388d8985f7aebe96b88fb2bda86804176271475831ec8d41bbd07"

URI_x86_64_v2_rust-av-scenechange0.14+console-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+console-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+console-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+console-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+console-devel.sha256sum] = "70abde17aeeee243f0bae7376b8ff942a4f5c6ee5deaff93c6af829499ada6a0"

URI_x86_64_v2_rust-av-scenechange0.14+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+default-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+default-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+default-devel.sha256sum] = "e2f6c99ddc5d6191d6d64bf6e4c82585a49ba1a73fe8168613974e7b37dfc0ca"

URI_x86_64_v2_rust-av-scenechange0.14+devel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+devel-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+devel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+devel-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+devel-devel.sha256sum] = "a40b3834082fc66c1be9f1660bef5a43a4fc774193967ddc4a52fbad63d66f48"

URI_x86_64_v2_rust-av-scenechange0.14+fern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+fern-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+fern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+fern-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+fern-devel.sha256sum] = "9f01c33c0edecd5783afbecfa4c9c8f9efb96711b23caf835561531d3325be7f"

URI_x86_64_v2_rust-av-scenechange0.14+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+libc-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+libc-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+libc-devel.sha256sum] = "599ee5f6bff77a6ee32261c4f25a18a2add963e5b5747b16dd8cad3d842b361b"

URI_x86_64_v2_rust-av-scenechange0.14+nasm-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+nasm-rs-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+nasm-rs-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+nasm-rs-devel.sha256sum] = "7a1fb88b86acbe3135b0fe3bd4034bbfbdbf23494b2ecc35ffa7768c08480d05"

URI_x86_64_v2_rust-av-scenechange0.14+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+serde-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+serde-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+serde-devel.sha256sum] = "61e945f0e25230b8c58fdd0fc204bea000fe0bf6ec4ac862ed8715d75250ca60"

URI_x86_64_v2_rust-av-scenechange0.14+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+serde_json-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+serde_json-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+serde_json-devel.sha256sum] = "439ed9685f4503794871b9fa73c245c256db1107ede5495a5dfa6863c00317ba"

URI_x86_64_v2_rust-av-scenechange0.14+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+serialize-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+serialize-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+serialize-devel.sha256sum] = "d168469c3ae683080392ad4f5234360d73d43b092cb08a5855b3dc244310614d"

URI_x86_64_v2_rust-av-scenechange0.14+tracing-chrome-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+tracing-chrome-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+tracing-chrome-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+tracing-chrome-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+tracing-chrome-devel.sha256sum] = "c6d778458f6793b38a639b7913f1a7a54702174cfc0ed3c9399dabd08a10f397"

URI_x86_64_v2_rust-av-scenechange0.14+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+tracing-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+tracing-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+tracing-devel.sha256sum] = "1079a8183f97a7ba17f9f479418668485c2af8abe0f60e651f168ff95005d7c0"

URI_x86_64_v2_rust-av-scenechange0.14+tracing-subscriber-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14+tracing-subscriber-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14+tracing-subscriber-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14+tracing-subscriber-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14+tracing-subscriber-devel.sha256sum] = "0a12aab0e10b8be3d21d5f2dfb4cd5076dad2f804901edbcedd9ba523a1f468f"

URI_x86_64_v2_rust-av-scenechange0.14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange0.14-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange0.14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange0.14-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange0.14-devel.sha256sum] = "f0954c0af39f0e642caae36ca613dcb9e31538c07ae534705c3154caba54c833"

URI_aarch64_rust-av-scenechange0.14+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+asm-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+asm-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+asm-devel.sha256sum] = "25f6359b650fc76cc3475168fba24d5d3c6ab36465a44c2f24c7547f4bf0e28f"

URI_aarch64_rust-av-scenechange0.14+binary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+binary-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+binary-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+binary-devel.sha256sum] = "b141d0e9f70a918eca9790b35293d1c7d2f6b8d268017f403a66e12842493508"

URI_aarch64_rust-av-scenechange0.14+cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+cc-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+cc-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+cc-devel.sha256sum] = "511fdfa6aa8256e1be9aa66f6b6816ff372847e4daad70a93573f096432143d5"

URI_aarch64_rust-av-scenechange0.14+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+clap-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+clap-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+clap-devel.sha256sum] = "eda4360c0b283dc92cc49589b1e313f1bbd34f2b27d32bedfcc6ff7d446cd3f7"

URI_aarch64_rust-av-scenechange0.14+console-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+console-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+console-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+console-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+console-devel.sha256sum] = "f380aa590945d46721eabbf9505f043ca7af5c3d73434851adbad5496af17be2"

URI_aarch64_rust-av-scenechange0.14+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+default-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+default-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+default-devel.sha256sum] = "837896a7166fe24901a398a73eb47a27a68ac1330b61db828cfd4fb58e4ef2fb"

URI_aarch64_rust-av-scenechange0.14+devel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+devel-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+devel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+devel-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+devel-devel.sha256sum] = "cd4b3b6386359f2adf943857b4a54e6d8e8d4094c4be95058b19ff6d5ee1789a"

URI_aarch64_rust-av-scenechange0.14+fern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+fern-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+fern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+fern-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+fern-devel.sha256sum] = "af396e8f2de4c6144a650c02324869e5b5747de0d2a1e43b7c00d436fdb40783"

URI_aarch64_rust-av-scenechange0.14+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+libc-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+libc-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+libc-devel.sha256sum] = "6dd4e706d25a3bc2fa9fe521778517877e006a5e36188775eb576ac088a19883"

URI_aarch64_rust-av-scenechange0.14+nasm-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+nasm-rs-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+nasm-rs-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+nasm-rs-devel.sha256sum] = "0f71646e1d27fde1c04eb9f0b415ec3298993ee38399e461dac3ab01c1fcf9dd"

URI_aarch64_rust-av-scenechange0.14+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+serde-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+serde-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+serde-devel.sha256sum] = "680bb97e76e789490d3d2ca720b7fa1dc5bb8a33ddf4d51e8acf31b316d7b387"

URI_aarch64_rust-av-scenechange0.14+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+serde_json-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+serde_json-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+serde_json-devel.sha256sum] = "14d75c9ab1a1f95cdde3208cc63026adf4c9eabe3ff457f92bfa7f43dba72e07"

URI_aarch64_rust-av-scenechange0.14+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+serialize-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+serialize-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+serialize-devel.sha256sum] = "7ae09439892661c301dcf3772ab7bf5b6037220f1cad444f58e1e630ad0b1b9e"

URI_aarch64_rust-av-scenechange0.14+tracing-chrome-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+tracing-chrome-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+tracing-chrome-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+tracing-chrome-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+tracing-chrome-devel.sha256sum] = "8e9b9e500103586ca1bca9ee1c478a7a9855c8a268969cba815e2f7667f0a92c"

URI_aarch64_rust-av-scenechange0.14+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+tracing-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+tracing-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+tracing-devel.sha256sum] = "5f5e74a699f97b83aab71f30214b26505191d92f31577871544486320dc68677"

URI_aarch64_rust-av-scenechange0.14+tracing-subscriber-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14+tracing-subscriber-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14+tracing-subscriber-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14+tracing-subscriber-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14+tracing-subscriber-devel.sha256sum] = "210a8ae0206f0c48d3a9d281817436b5018bd5e696c7e8c688477df00f3cbe3d"

URI_aarch64_rust-av-scenechange0.14-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange0.14-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange0.14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange0.14-devel}"
SRC_URI[aarch64_rust-av-scenechange0.14-devel.sha256sum] = "d0f4e1ed284eca6983b967615fcb2f951958598a8cb45a82d7011928da2c6b8d"

RDEPENDS:rust-av-scenechange0.14+asm-devel = " \
 cargo \
 rust-av-scenechange0.14+cc-devel \
 rust-av-scenechange0.14+libc-devel \
 rust-av-scenechange0.14+nasm-rs-devel \
 rust-av-scenechange0.14-devel \
 "
RDEPENDS:rust-av-scenechange0.14+binary-devel = " \
 cargo \
 rust-av-scenechange0.14+clap-devel \
 rust-av-scenechange0.14+serialize-devel \
 rust-av-scenechange0.14-devel \
 "
RDEPENDS:rust-av-scenechange0.14+cc-devel = " \
 cargo \
 rust-av-scenechange0.14-devel \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 "
RDEPENDS:rust-av-scenechange0.14+clap-devel = " \
 cargo \
 rust-av-scenechange0.14-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 "
RDEPENDS:rust-av-scenechange0.14+console-devel = " \
 cargo \
 rust-av-scenechange0.14-devel \
 rust-console+default-devel \
 "
RDEPENDS:rust-av-scenechange0.14+default-devel = " \
 cargo \
 rust-av-scenechange0.14+asm-devel \
 rust-av-scenechange0.14+binary-devel \
 rust-av-scenechange0.14-devel \
 "
RDEPENDS:rust-av-scenechange0.14+devel-devel = " \
 cargo \
 rust-av-scenechange0.14+console-devel \
 rust-av-scenechange0.14+fern-devel \
 rust-av-scenechange0.14-devel \
 "
RDEPENDS:rust-av-scenechange0.14+fern-devel = " \
 cargo \
 rust-av-scenechange0.14-devel \
 rust-fern+default-devel \
 "
RDEPENDS:rust-av-scenechange0.14+libc-devel = " \
 cargo \
 rust-av-scenechange0.14-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-av-scenechange0.14+nasm-rs-devel = " \
 cargo \
 rust-av-scenechange0.14-devel \
 rust-nasm-rs+default-devel \
 rust-nasm-rs+parallel-devel \
 "
RDEPENDS:rust-av-scenechange0.14+serde-devel = " \
 cargo \
 rust-av-scenechange0.14-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-av-scenechange0.14+serde_json-devel = " \
 cargo \
 rust-av-scenechange0.14-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-av-scenechange0.14+serialize-devel = " \
 cargo \
 rust-av-scenechange0.14+serde-devel \
 rust-av-scenechange0.14+serde_json-devel \
 rust-av-scenechange0.14-devel \
 "
RDEPENDS:rust-av-scenechange0.14+tracing-chrome-devel = " \
 cargo \
 rust-av-scenechange0.14-devel \
 rust-tracing-chrome+default-devel \
 "
RDEPENDS:rust-av-scenechange0.14+tracing-devel = " \
 cargo \
 rust-av-scenechange0.14+tracing-chrome-devel \
 rust-av-scenechange0.14+tracing-subscriber-devel \
 rust-av-scenechange0.14-devel \
 rust-tracing+default-devel \
 "
RDEPENDS:rust-av-scenechange0.14+tracing-subscriber-devel = " \
 cargo \
 rust-av-scenechange0.14-devel \
 rust-tracing-subscriber+default-devel \
 "
RDEPENDS:rust-av-scenechange0.14-devel = " \
 cargo \
 rust \
 rust-aligned+default-devel \
 rust-anyhow+default-devel \
 rust-arg_enum_proc_macro+default-devel \
 rust-arrayvec+default-devel \
 rust-log+default-devel \
 rust-num-rational-devel \
 rust-num-traits+default-devel \
 rust-pastey+default-devel \
 rust-rayon+default-devel \
 rust-thiserror+default-devel \
 rust-v_frame0.3+default-devel \
 rust-y4m+default-devel \
 "
