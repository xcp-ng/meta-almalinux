# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-resolver0.24"
PV = "0.24.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-hickory-resolver0.24+backtrace-devel \
 rust-hickory-resolver0.24+default-devel \
 rust-hickory-resolver0.24+dns-over-native-tls-devel \
 rust-hickory-resolver0.24+dns-over-openssl-devel \
 rust-hickory-resolver0.24+dns-over-tls-devel \
 rust-hickory-resolver0.24+dnssec-devel \
 rust-hickory-resolver0.24+dnssec-openssl-devel \
 rust-hickory-resolver0.24+resolv-conf-devel \
 rust-hickory-resolver0.24+serde-config-devel \
 rust-hickory-resolver0.24+serde-devel \
 rust-hickory-resolver0.24+system-config-devel \
 rust-hickory-resolver0.24+testing-devel \
 rust-hickory-resolver0.24+tokio-devel \
 rust-hickory-resolver0.24+tokio-native-tls-devel \
 rust-hickory-resolver0.24+tokio-openssl-devel \
 rust-hickory-resolver0.24+tokio-runtime-devel \
 rust-hickory-resolver0.24-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-resolver0.24-0.24.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e91485aea0db140d89fac69b6b2fac79e57b238352e60c753adc8d6000307ce8"

URI_x86_64_v2_rust-hickory-resolver0.24+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+backtrace-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+backtrace-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+backtrace-devel.sha256sum] = "fcc069c327e5eefe05806d1929ac37e53511c5ada190bede32143d8dfd18c122"

URI_x86_64_v2_rust-hickory-resolver0.24+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+default-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+default-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+default-devel.sha256sum] = "e1f2f619bf0c8f6ba097ccac675cf1ece6598b745bbbc76fa3ece1909ef3f083"

URI_x86_64_v2_rust-hickory-resolver0.24+dns-over-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+dns-over-native-tls-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+dns-over-native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+dns-over-native-tls-devel.sha256sum] = "31fb6d1a6cde7061e906d946eed6bd7a6df5eeabd79f2c1646cd058fc3313755"

URI_x86_64_v2_rust-hickory-resolver0.24+dns-over-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+dns-over-openssl-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+dns-over-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+dns-over-openssl-devel.sha256sum] = "0ed477cee45ae7337dd96a7d506007e61d73899fe3a028a71b32e6107a1d5866"

URI_x86_64_v2_rust-hickory-resolver0.24+dns-over-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+dns-over-tls-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+dns-over-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+dns-over-tls-devel.sha256sum] = "7184fc468a1cf671788e32e4c8b84f910af6aca3dde9da313040f30f435357ac"

URI_x86_64_v2_rust-hickory-resolver0.24+dnssec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+dnssec-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+dnssec-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+dnssec-devel.sha256sum] = "924e9511c7cce980ce8703bada127e94bf153780ecc70fc2d40392ece02ec0e6"

URI_x86_64_v2_rust-hickory-resolver0.24+dnssec-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+dnssec-openssl-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+dnssec-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+dnssec-openssl-devel.sha256sum] = "6acd04c0112239f5ca8b61cdf3a4ec1ddb87ccd5f38186853716f5a04cb3d5db"

URI_x86_64_v2_rust-hickory-resolver0.24+resolv-conf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+resolv-conf-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+resolv-conf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+resolv-conf-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+resolv-conf-devel.sha256sum] = "fc5d573ac926ffa8516d5129b2f091144b24bbeb00b923774d50c5d7d1a87906"

URI_x86_64_v2_rust-hickory-resolver0.24+serde-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+serde-config-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+serde-config-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+serde-config-devel.sha256sum] = "979b7315bb0a286e59c030b6b461f834cbd7d588528eccad31f1dd1817591235"

URI_x86_64_v2_rust-hickory-resolver0.24+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+serde-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+serde-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+serde-devel.sha256sum] = "0503412fd68afeeb8daa8b90dbff12b89c4bc5ffc7d245ab765b33318a22e9ef"

URI_x86_64_v2_rust-hickory-resolver0.24+system-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+system-config-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+system-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+system-config-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+system-config-devel.sha256sum] = "6db3e6a629176c5c51f1c3fbdcfbd94e86ea99374db8dee46f3336e57301e444"

URI_x86_64_v2_rust-hickory-resolver0.24+testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+testing-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+testing-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+testing-devel.sha256sum] = "76cbd94094b6a086f1180c990fa3eb0bbe269c65047822c32bdb7b6ae15d8f3c"

URI_x86_64_v2_rust-hickory-resolver0.24+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+tokio-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+tokio-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+tokio-devel.sha256sum] = "10378768257a4d7fbca03c1b1c3c548b7c7554271bea25fe879fbd6074ba6d83"

URI_x86_64_v2_rust-hickory-resolver0.24+tokio-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+tokio-native-tls-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+tokio-native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+tokio-native-tls-devel.sha256sum] = "60bd33c1ffbdf1a78fd42313cf97cbd323fcbb9e14709194913ea0b305a9413b"

URI_x86_64_v2_rust-hickory-resolver0.24+tokio-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+tokio-openssl-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+tokio-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+tokio-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+tokio-openssl-devel.sha256sum] = "decc538aabe006723d966fa85d50e79c62915a87891bc915bd1511274fea4687"

URI_x86_64_v2_rust-hickory-resolver0.24+tokio-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24+tokio-runtime-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24+tokio-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24+tokio-runtime-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24+tokio-runtime-devel.sha256sum] = "c392b25c050048ffc5b6fb78f9c7f412b53776b72184d7bbc91756b2c42163eb"

URI_x86_64_v2_rust-hickory-resolver0.24-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.24-devel-0.24.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.24-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.24-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.24-devel.sha256sum] = "a21cabc01acf0757102b27169e8ea0ce45fc91b0d90aa04ed771a6aa3cbd59d8"

URI_aarch64_rust-hickory-resolver0.24+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+backtrace-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+backtrace-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+backtrace-devel.sha256sum] = "e99dc9a8bb248506e89470c2bf85f1c03c24e5fb008f3fb1bf875c8e805ff2a5"

URI_aarch64_rust-hickory-resolver0.24+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+default-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+default-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+default-devel.sha256sum] = "8b3f6ef9ccee383528366db75ab1c1d36e0ba31421ca80b69042091579a5cffe"

URI_aarch64_rust-hickory-resolver0.24+dns-over-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+dns-over-native-tls-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+dns-over-native-tls-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+dns-over-native-tls-devel.sha256sum] = "364ad5ca6e84db5526bf6be8221912f22ae1ffa6e7798be1f6b72e3c410019d6"

URI_aarch64_rust-hickory-resolver0.24+dns-over-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+dns-over-openssl-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+dns-over-openssl-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+dns-over-openssl-devel.sha256sum] = "ebe33e0cb41ba030cbad0ebc6e4302b2a3a65ec490197ae22d30cedeabf7fdf9"

URI_aarch64_rust-hickory-resolver0.24+dns-over-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+dns-over-tls-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+dns-over-tls-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+dns-over-tls-devel.sha256sum] = "14e8b00e9d730f74d1d6be9b427c19ab5ff68f6b92f9bd44b03cfae76d9e7dd0"

URI_aarch64_rust-hickory-resolver0.24+dnssec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+dnssec-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+dnssec-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+dnssec-devel.sha256sum] = "f4a8adfc75ed6b30de2b0bfefb7171f3dd544a5f2fc1119036f1f166fbbe5695"

URI_aarch64_rust-hickory-resolver0.24+dnssec-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+dnssec-openssl-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+dnssec-openssl-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+dnssec-openssl-devel.sha256sum] = "9613369128d192f0de873bb994231b55e49cb7b3541c9807996980e55d10ae0d"

URI_aarch64_rust-hickory-resolver0.24+resolv-conf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+resolv-conf-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+resolv-conf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+resolv-conf-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+resolv-conf-devel.sha256sum] = "b597423ff92b95e8ab5dfec02ce0688117fcc9620827c05bf52b88ada34cfd4d"

URI_aarch64_rust-hickory-resolver0.24+serde-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+serde-config-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+serde-config-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+serde-config-devel.sha256sum] = "54752021daee8f0b7f48fc0ad464f92e5c7e15f1b4f7c25063ed03b4264357bf"

URI_aarch64_rust-hickory-resolver0.24+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+serde-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+serde-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+serde-devel.sha256sum] = "d1d5bc1533af5d249ad9d5dee35d5538d683e5909596ac42c9f462993832febe"

URI_aarch64_rust-hickory-resolver0.24+system-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+system-config-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+system-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+system-config-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+system-config-devel.sha256sum] = "bb559f3c6b84bc30284185e11907272ee4222d6db9920eebeebbc2784c3fef55"

URI_aarch64_rust-hickory-resolver0.24+testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+testing-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+testing-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+testing-devel.sha256sum] = "43cccf23dca7d120046c3771065cd463832591d3e25a518f17e3e346f688bd33"

URI_aarch64_rust-hickory-resolver0.24+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+tokio-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+tokio-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+tokio-devel.sha256sum] = "f99d16858f075da7e1daf166193433c66d815b3acfb04fbc63a4fa45f27f698b"

URI_aarch64_rust-hickory-resolver0.24+tokio-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+tokio-native-tls-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+tokio-native-tls-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+tokio-native-tls-devel.sha256sum] = "62174259a48b07d2f1c1c86b1f7182f2688e4194e884ff1e81d4e615d0e554aa"

URI_aarch64_rust-hickory-resolver0.24+tokio-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+tokio-openssl-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+tokio-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+tokio-openssl-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+tokio-openssl-devel.sha256sum] = "70d71b4babb6de3f2523749eb874cd631fec6b9907759087d1273fe2efe97118"

URI_aarch64_rust-hickory-resolver0.24+tokio-runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24+tokio-runtime-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24+tokio-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24+tokio-runtime-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24+tokio-runtime-devel.sha256sum] = "ed698cdc44a2ff03a12893e266c775d26e0b05feeeb0245d529110229c976d7a"

URI_aarch64_rust-hickory-resolver0.24-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.24-devel-0.24.4-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver0.24-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.24-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.24-devel.sha256sum] = "c618fc7ad954dddc8ddccaa958fd179446eba88443101ff79cccfd24d4a04a02"

RDEPENDS:rust-hickory-resolver0.24+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-hickory-proto0.24+backtrace-devel \
 rust-hickory-resolver0.24-devel \
 "
RDEPENDS:rust-hickory-resolver0.24+default-devel = " \
 cargo \
 rust-hickory-resolver0.24+system-config-devel \
 rust-hickory-resolver0.24+tokio-runtime-devel \
 rust-hickory-resolver0.24-devel \
 "
RDEPENDS:rust-hickory-resolver0.24+dns-over-native-tls-devel = " \
 cargo \
 rust-hickory-proto0.24+dns-over-native-tls-devel \
 rust-hickory-resolver0.24+dns-over-tls-devel \
 rust-hickory-resolver0.24+tokio-native-tls-devel \
 rust-hickory-resolver0.24-devel \
 "
RDEPENDS:rust-hickory-resolver0.24+dns-over-openssl-devel = " \
 cargo \
 rust-hickory-proto0.24+dns-over-openssl-devel \
 rust-hickory-resolver0.24+dns-over-tls-devel \
 rust-hickory-resolver0.24+tokio-openssl-devel \
 rust-hickory-resolver0.24-devel \
 "
RDEPENDS:rust-hickory-resolver0.24+dns-over-tls-devel = " \
 cargo \
 rust-hickory-resolver0.24+tokio-runtime-devel \
 rust-hickory-resolver0.24-devel \
 "
RDEPENDS:rust-hickory-resolver0.24+dnssec-devel = " \
 cargo \
 rust-hickory-resolver0.24-devel \
 "
RDEPENDS:rust-hickory-resolver0.24+dnssec-openssl-devel = " \
 cargo \
 rust-hickory-proto0.24+dnssec-openssl-devel \
 rust-hickory-resolver0.24+dnssec-devel \
 rust-hickory-resolver0.24-devel \
 "
RDEPENDS:rust-hickory-resolver0.24+resolv-conf-devel = " \
 cargo \
 rust-hickory-resolver0.24-devel \
 rust-resolv-conf+default-devel \
 rust-resolv-conf+system-devel \
 "
RDEPENDS:rust-hickory-resolver0.24+serde-config-devel = " \
 cargo \
 rust-hickory-proto0.24+serde-config-devel \
 rust-hickory-resolver0.24+serde-devel \
 rust-hickory-resolver0.24-devel \
 "
RDEPENDS:rust-hickory-resolver0.24+serde-devel = " \
 cargo \
 rust-hickory-resolver0.24-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-hickory-resolver0.24+system-config-devel = " \
 cargo \
 rust-hickory-resolver0.24+resolv-conf-devel \
 rust-hickory-resolver0.24-devel \
 "
RDEPENDS:rust-hickory-resolver0.24+testing-devel = " \
 cargo \
 rust-hickory-resolver0.24-devel \
 "
RDEPENDS:rust-hickory-resolver0.24+tokio-devel = " \
 cargo \
 rust-hickory-resolver0.24-devel \
 rust-tokio+default-devel \
 "
RDEPENDS:rust-hickory-resolver0.24+tokio-native-tls-devel = " \
 cargo \
 rust-hickory-resolver0.24-devel \
 rust-tokio-native-tls+default-devel \
 "
RDEPENDS:rust-hickory-resolver0.24+tokio-openssl-devel = " \
 cargo \
 rust-hickory-resolver0.24-devel \
 rust-tokio-openssl+default-devel \
 "
RDEPENDS:rust-hickory-resolver0.24+tokio-runtime-devel = " \
 cargo \
 rust-hickory-proto0.24+tokio-runtime-devel \
 rust-hickory-resolver0.24-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 "
RDEPENDS:rust-hickory-resolver0.24-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-hickory-proto0.24-devel \
 rust-lru-cache+default-devel \
 rust-once_cell+default-devel \
 rust-parking_lot+default-devel \
 rust-rand0.8+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror1+default-devel \
 rust-tracing+default-devel \
 "
