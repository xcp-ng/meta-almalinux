# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scsi-target-utils"
PV = "1.0.97"
PR = "5.el10_2"
PACKAGES = " \
 scsi-target-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scsi-target-utils-1.0.97-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6765614806a6e49123f8ba0d783c5e231637b441e00c38a743c6d99563f7b275"

URI_x86_64_v2_scsi-target-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scsi-target-utils-1.0.97-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scsi-target-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scsi-target-utils}"
SRC_URI[x86_64_v2_scsi-target-utils.sha256sum] = "8254fe182b4f59a0019b227e48aa5d02e2eeb375f686663a681c79095c108bed"

URI_aarch64_scsi-target-utils = "${EPEL_MIRROR}/aarch64/Packages/s/scsi-target-utils-1.0.97-5.el10_2.aarch64.rpm;name=aarch64_scsi-target-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_scsi-target-utils}"
SRC_URI[aarch64_scsi-target-utils.sha256sum] = "e686abf824218fda8f028d6b8a2d32957fc9ae2fddf9bfbfbe0e9c33eb9af449"

RDEPENDS:scsi-target-utils = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libibverbs \
 librdmacm \
 lsof \
 perl-Config-General \
 perl-Errno \
 perl-Fcntl \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 sg3_utils \
 systemd \
 systemd-libs \
 "
