# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-DNSBL-Client"
PV = "0.207"
PR = "1.el10_2"
PACKAGES = " \
 perl-Net-DNSBL-Client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-DNSBL-Client-0.207-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ae407b9d59dc3bfaa4608c25c54f9ec32e9bc1d0466566c7205f92e58add62b"

URI_x86_64_v2_perl-Net-DNSBL-Client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-DNSBL-Client-0.207-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-DNSBL-Client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-DNSBL-Client}"
SRC_URI[x86_64_v2_perl-Net-DNSBL-Client.sha256sum] = "24043c13457f61a3d7fb3c8c0063e7edd2eb9244d076cde3d8c568dce9c97f8b"

URI_aarch64_perl-Net-DNSBL-Client = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-DNSBL-Client-0.207-1.el10_2.noarch.rpm;name=aarch64_perl-Net-DNSBL-Client;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-DNSBL-Client}"
SRC_URI[aarch64_perl-Net-DNSBL-Client.sha256sum] = "ab4823550f0beb74ee7b967b69d6c2a31bd5f8bc78210d66172eb1b50e320006"

RDEPENDS:perl-Net-DNSBL-Client = " \
 perl-Carp \
 perl-IO \
 perl-Net-DNS \
 perl-Net-DNSBL-Client \
 perl-interpreter \
 perl-libs \
 "
