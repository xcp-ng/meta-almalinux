# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spdlog"
PV = "1.14.1"
PR = "3.el10_0"
PACKAGES = " \
 spdlog \
 spdlog-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spdlog-1.14.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96ecea3ebf90c63737ddfdbd77fe77d880355cf2a0630b8e8c4d7dae5936bfe6"

URI_x86_64_v2_spdlog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spdlog-1.14.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spdlog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spdlog}"
SRC_URI[x86_64_v2_spdlog.sha256sum] = "61507d0082f70cb1446e2ee27e9d121946442dd86bae9fbf0e5653b8f20da7a6"

URI_x86_64_v2_spdlog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spdlog-devel-1.14.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spdlog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spdlog-devel}"
SRC_URI[x86_64_v2_spdlog-devel.sha256sum] = "2eb625c95ab7c51d99e25d830a927290cbe02612633b74263ea81e221aa92424"

URI_aarch64_spdlog = "${EPEL_MIRROR}/aarch64/Packages/s/spdlog-1.14.1-3.el10_0.aarch64.rpm;name=aarch64_spdlog;unpack=0"
SRC_URI:append = " ${URI_aarch64_spdlog}"
SRC_URI[aarch64_spdlog.sha256sum] = "dba192a8b5fa32df9b00b2fa6e9068a915ae774d5261cbb721232d369c6f33a2"

URI_aarch64_spdlog-devel = "${EPEL_MIRROR}/aarch64/Packages/s/spdlog-devel-1.14.1-3.el10_0.aarch64.rpm;name=aarch64_spdlog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_spdlog-devel}"
SRC_URI[aarch64_spdlog-devel.sha256sum] = "8dd70194b795e67a019900d81e35c2b2561becae5459ff3cf4ceb030cfde1a2d"

RDEPENDS:spdlog = " \
 fmt \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:spdlog-devel = " \
 cmake-filesystem \
 fmt-devel \
 libstdc++-devel \
 pkgconf-pkg-config \
 spdlog \
 "
