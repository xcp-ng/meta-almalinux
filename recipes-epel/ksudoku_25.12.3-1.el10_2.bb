# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksudoku"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 ksudoku \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksudoku-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a33f5e9dfcb7f53a3f5ceaa5da6a7c61890fff8b754da45ceb7a912eddd93d2"

URI_x86_64_v2_ksudoku = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksudoku-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksudoku;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksudoku}"
SRC_URI[x86_64_v2_ksudoku.sha256sum] = "0596f181be2efe1c6ace4f77db70d3db092548d1365afa32ca4e0c65c2d84643"

URI_aarch64_ksudoku = "${EPEL_MIRROR}/aarch64/Packages/k/ksudoku-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ksudoku;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksudoku}"
SRC_URI[aarch64_ksudoku.sha256sum] = "118043c0bb8154003f4308241e5521dc87b726cea109182bbe1d39df2fdbe6b4"

RDEPENDS:ksudoku = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libglvnd-opengl \
 libkdegames \
 libstdc++ \
 mesa-libGLU \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
