# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-PBKDF2"
PV = "0.261630"
PR = "1.el10_2"
PACKAGES = " \
 perl-Crypt-PBKDF2 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-PBKDF2-0.261630-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4f45b1e36f04dbb1c86f86b2f0b5ffb90922ef33ef66ad45085e5e9ae7c9089d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-PBKDF2-0.261630-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-PBKDF2;unpack=0"
SRC_URI[x86_64_v2_perl-Crypt-PBKDF2.sha256sum] = "6f9b0ecab155e738337965787908449455efca75da8af5cd9fdf7316fb2e0e3a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-PBKDF2-0.261630-1.el10_2.noarch.rpm;name=aarch64_perl-Crypt-PBKDF2;unpack=0"
SRC_URI[aarch64_perl-Crypt-PBKDF2.sha256sum] = "77cd944026e15a2574bea16a7de2701e1dca453581bdce3e9b00948b35522036"

RDEPENDS:perl-Crypt-PBKDF2 = " \
 perl-Carp \
 perl-Crypt-URandom \
 perl-Digest \
 perl-Digest-HMAC \
 perl-Digest-SHA \
 perl-Digest-SHA3 \
 perl-MIME-Base64 \
 perl-Module-Runtime \
 perl-Moo \
 perl-Scalar-List-Utils \
 perl-Try-Tiny \
 perl-Type-Tiny \
 perl-libs \
 perl-namespace-autoclean \
 perl-strictures \
 "
