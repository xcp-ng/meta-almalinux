# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-networkmanager-qt"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-networkmanager-qt \
 kf6-networkmanager-qt-devel \
 kf6-networkmanager-qt-doc \
 kf6-networkmanager-qt-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-networkmanager-qt-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f84e354c01559b42b49e75fb67c44e502c7aa7821292ea9564eb2551f69a279"

URI_x86_64_v2_kf6-networkmanager-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-networkmanager-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-networkmanager-qt}"
SRC_URI[x86_64_v2_kf6-networkmanager-qt.sha256sum] = "ab7c91b38379623547359b025904c6542c008da3afc344717573b43e8f2e19a5"

URI_x86_64_v2_kf6-networkmanager-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-networkmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-networkmanager-qt-devel}"
SRC_URI[x86_64_v2_kf6-networkmanager-qt-devel.sha256sum] = "318b1bf3933c588d2c3f2416195aba2f00d2e2346f7fd8fa652095f89e62d429"

URI_x86_64_v2_kf6-networkmanager-qt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-networkmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-networkmanager-qt-doc}"
SRC_URI[x86_64_v2_kf6-networkmanager-qt-doc.sha256sum] = "48c2d93a2b02e7b16c04b115d7c5c0dc66d99730212ceaff519e3ea9ed264d6c"

URI_x86_64_v2_kf6-networkmanager-qt-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-networkmanager-qt-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-networkmanager-qt-html}"
SRC_URI[x86_64_v2_kf6-networkmanager-qt-html.sha256sum] = "661be9fa1034c682e83545fbc5e53103d921aabeefdcb078422a2ea239c137ac"

URI_aarch64_kf6-networkmanager-qt = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-networkmanager-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-networkmanager-qt}"
SRC_URI[aarch64_kf6-networkmanager-qt.sha256sum] = "6e66b79d692ca424c365e2e0b37c8d5ea9fa99ab78b892097b7e2618ed769b4f"

URI_aarch64_kf6-networkmanager-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-networkmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-networkmanager-qt-devel}"
SRC_URI[aarch64_kf6-networkmanager-qt-devel.sha256sum] = "2f158eca3d162436cc3c6b8fe15bdb33cfd616c0e81a3eb272de1b2b8b7ba0cd"

URI_aarch64_kf6-networkmanager-qt-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-networkmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-networkmanager-qt-doc}"
SRC_URI[aarch64_kf6-networkmanager-qt-doc.sha256sum] = "cdf22ccb39d46672a8774e871c37acfc86a0381cd297169c089c187eef69c15e"

URI_aarch64_kf6-networkmanager-qt-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-networkmanager-qt-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-networkmanager-qt-html}"
SRC_URI[aarch64_kf6-networkmanager-qt-html.sha256sum] = "acdfcf389baf3046a2004cf324ed44969f5a97f3bcb2b25172b98b3cc4dbebc8"

RDEPENDS:kf6-networkmanager-qt = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-networkmanager-qt-devel = " \
 NetworkManager-libnm-devel \
 cmake-filesystem \
 kf6-networkmanager-qt \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-networkmanager-qt-doc = " \
 "
RDEPENDS:kf6-networkmanager-qt-html = " \
 "
