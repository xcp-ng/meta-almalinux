# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cadical"
PE = "1"
PV = "2.1.3"
PR = "1.el10_2"
PACKAGES = " \
 cadical \
 cadical-devel \
 cadical-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cadical-2.1.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be394da1f4b6acece3478e677a8fce299bf521b29164c8dc8374d38f07533992"

URI_x86_64_v2_cadical = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cadical-2.1.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cadical;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cadical}"
SRC_URI[x86_64_v2_cadical.sha256sum] = "6bbd1ff7492f003730edb09cbefbd9f718bdc604372e6e34ccf11ff90a28bed2"

URI_x86_64_v2_cadical-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cadical-devel-2.1.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cadical-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cadical-devel}"
SRC_URI[x86_64_v2_cadical-devel.sha256sum] = "519e58f478db29226691523892541b7b3ad2a0d8086acaac219545fce70b3ee7"

URI_x86_64_v2_cadical-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cadical-libs-2.1.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cadical-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cadical-libs}"
SRC_URI[x86_64_v2_cadical-libs.sha256sum] = "54e6aca539e94febdd0dd1e9c010e446b93b04dd063444183b99431ad1c56627"

URI_aarch64_cadical = "${EPEL_MIRROR}/aarch64/Packages/c/cadical-2.1.3-1.el10_2.aarch64.rpm;name=aarch64_cadical;unpack=0"
SRC_URI:append = " ${URI_aarch64_cadical}"
SRC_URI[aarch64_cadical.sha256sum] = "f8d32f708c3c314b8303fd3f29ab84fd5a5f75d881c88cd5764f826e99e043d4"

URI_aarch64_cadical-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cadical-devel-2.1.3-1.el10_2.aarch64.rpm;name=aarch64_cadical-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cadical-devel}"
SRC_URI[aarch64_cadical-devel.sha256sum] = "4d3d6a259ec2fae6c6b5613cc389301589762ef378c2176f86532289f66058eb"

URI_aarch64_cadical-libs = "${EPEL_MIRROR}/aarch64/Packages/c/cadical-libs-2.1.3-1.el10_2.aarch64.rpm;name=aarch64_cadical-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cadical-libs}"
SRC_URI[aarch64_cadical-libs.sha256sum] = "18f4227d2c1872de9aefd50af282cfe6a3e82bba5c9ea096e5f5d4a9139bd41a"

RDEPENDS:cadical = " \
 cadical-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:cadical-devel = " \
 cadical-libs \
 "
RDEPENDS:cadical-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 "
