# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rkyv_derive"
PV = "0.8.18"
PR = "1.el10_3"
PACKAGES = " \
 rust-rkyv_derive+bytecheck-devel \
 rust-rkyv_derive+default-devel \
 rust-rkyv_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rkyv_derive-0.8.18-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af766305e99f5c737d3cb8afab5826c9611674ad0a329d45d921d0275a38542a"

URI_x86_64_v2_rust-rkyv_derive+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive+bytecheck-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive+bytecheck-devel.sha256sum] = "1d9d8a419e4a48ea1c352d259058e12b0e5581255582db8aa5319c052eaefb61"

URI_x86_64_v2_rust-rkyv_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive+default-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive+default-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive+default-devel.sha256sum] = "5f2fac48c8cb2a5924a6ca5bbe07ac8ffbf225fc9618ff29b01c4cc36b61b017"

URI_x86_64_v2_rust-rkyv_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive-devel.sha256sum] = "e547f2780ef7ddccc13fd0272afe2c32b08149fc4a7c9b52b783173c3d0bb62e"

URI_aarch64_rust-rkyv_derive+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive+bytecheck-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv_derive+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive+bytecheck-devel}"
SRC_URI[aarch64_rust-rkyv_derive+bytecheck-devel.sha256sum] = "b83efd7dfe3c4dec1bf6a9aa9fece6703dc939302be0e51d433379be55165edb"

URI_aarch64_rust-rkyv_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive+default-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive+default-devel}"
SRC_URI[aarch64_rust-rkyv_derive+default-devel.sha256sum] = "09b44407bdba307e938d8ab8d0417ebe00f34e9a5be86f42a8c377a890112a8f"

URI_aarch64_rust-rkyv_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive-devel}"
SRC_URI[aarch64_rust-rkyv_derive-devel.sha256sum] = "0b47a50fc4aa35abd5b3b21162aa4fb863b735bb81715fd4dc12850417c410b0"

RDEPENDS:rust-rkyv_derive+bytecheck-devel = " \
 cargo \
 rust-rkyv_derive-devel \
 "
RDEPENDS:rust-rkyv_derive+default-devel = " \
 cargo \
 rust-rkyv_derive-devel \
 "
RDEPENDS:rust-rkyv_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
