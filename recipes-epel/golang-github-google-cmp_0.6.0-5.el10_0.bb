# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-google-cmp"
PV = "0.6.0"
PR = "5.el10_0"
PACKAGES = " \
 golang-github-google-cmp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-google-cmp-0.6.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44302337fc8a3a47c7818694541645f87c75e60694febde1f2b4802c45de4646"

URI_x86_64_v2_golang-github-google-cmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-google-cmp-devel-0.6.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-google-cmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-google-cmp-devel}"
SRC_URI[x86_64_v2_golang-github-google-cmp-devel.sha256sum] = "684cb0e73bdf6c22212de36fe9c2a12f426611e547f9840157d75db6a3666340"

URI_aarch64_golang-github-google-cmp-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-google-cmp-devel-0.6.0-5.el10_0.noarch.rpm;name=aarch64_golang-github-google-cmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-google-cmp-devel}"
SRC_URI[aarch64_golang-github-google-cmp-devel.sha256sum] = "f342f9ac715546b4b4e48ba24d484e6b09ed37a69a4b5f6d2e9e2cd702f16e6f"

RDEPENDS:golang-github-google-cmp-devel = " \
 go-filesystem \
 "
