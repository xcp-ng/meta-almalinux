# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTML-Template"
PV = "2.97"
PR = "25.el10_0"
PACKAGES = " \
 perl-HTML-Template \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTML-Template-2.97-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "befaa90dfa28e6133aa2663be62426de9b10069a711206fe6ca6f8ea7efbbcd4"

URI_x86_64_v2_perl-HTML-Template = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTML-Template-2.97-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTML-Template;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTML-Template}"
SRC_URI[x86_64_v2_perl-HTML-Template.sha256sum] = "07d5cd5591894a9590e4e1d841b36aa3b574d32af78cad0b4354ca694bfc9047"

URI_aarch64_perl-HTML-Template = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTML-Template-2.97-25.el10_0.noarch.rpm;name=aarch64_perl-HTML-Template;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTML-Template}"
SRC_URI[aarch64_perl-HTML-Template.sha256sum] = "7986dd08438b2d0c478dd850a02e814af7eccfe163b5b4c8f2f8c20f8a43b6a4"

RDEPENDS:perl-HTML-Template = " \
 perl-Carp \
 perl-Digest-MD5 \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-vars \
 "
