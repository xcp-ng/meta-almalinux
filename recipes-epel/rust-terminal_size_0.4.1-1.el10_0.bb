# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-terminal_size"
PV = "0.4.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-terminal_size+default-devel \
 rust-terminal_size-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-terminal_size-0.4.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0899e8fa40f97182badd645f6c9d462d2e89fd95566102b8ffb77b356462454"

URI_x86_64_v2_rust-terminal_size+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal_size+default-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal_size+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal_size+default-devel}"
SRC_URI[x86_64_v2_rust-terminal_size+default-devel.sha256sum] = "e2b23380278df90ae39d0285ba7fe82a5f1d9c4cfb9dfb3787df7fcb57c5f936"

URI_x86_64_v2_rust-terminal_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal_size-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal_size-devel}"
SRC_URI[x86_64_v2_rust-terminal_size-devel.sha256sum] = "93cc00027ed944edfd5648a8da1471f26062f90114bce332d86907653d3a1684"

URI_aarch64_rust-terminal_size+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal_size+default-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-terminal_size+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal_size+default-devel}"
SRC_URI[aarch64_rust-terminal_size+default-devel.sha256sum] = "ee6583fe7b56952133ba52ced21b1f0070818416712d3b23fb581c0ed4487cd3"

URI_aarch64_rust-terminal_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal_size-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-terminal_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal_size-devel}"
SRC_URI[aarch64_rust-terminal_size-devel.sha256sum] = "016adae2a690cd48701cff595a8db4cf76430af4b775b97a9adba59d3e66535a"

RDEPENDS:rust-terminal_size+default-devel = " \
 cargo \
 rust-terminal_size-devel \
 "
RDEPENDS:rust-terminal_size-devel = " \
 cargo \
 rust \
 rust-rustix+default-devel \
 rust-rustix+termios-devel \
 "
