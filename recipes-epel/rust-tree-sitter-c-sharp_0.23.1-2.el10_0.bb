# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-c-sharp"
PV = "0.23.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-tree-sitter-c-sharp+default-devel \
 rust-tree-sitter-c-sharp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-c-sharp-0.23.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b9c861a549368f716dce997f73b64521b6c085ac5e0552aa1b4b5f5a181324a"

URI_x86_64_v2_rust-tree-sitter-c-sharp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-c-sharp+default-devel-0.23.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-c-sharp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-c-sharp+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-c-sharp+default-devel.sha256sum] = "64f382708a5ea5be9b4cca9812d7e300713ed68696c7d45156b507fe8d8498c0"

URI_x86_64_v2_rust-tree-sitter-c-sharp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-c-sharp-devel-0.23.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-c-sharp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-c-sharp-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-c-sharp-devel.sha256sum] = "b650bd55daf2c78602b55acc339e209a383643af6f6a3c5b5827a2f93c1483c2"

URI_aarch64_rust-tree-sitter-c-sharp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-c-sharp+default-devel-0.23.1-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-c-sharp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-c-sharp+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-c-sharp+default-devel.sha256sum] = "1d407a7cb8385bba2f4390d3905314dba99f559be907f51ed9c713d38aaa31a5"

URI_aarch64_rust-tree-sitter-c-sharp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-c-sharp-devel-0.23.1-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-c-sharp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-c-sharp-devel}"
SRC_URI[aarch64_rust-tree-sitter-c-sharp-devel.sha256sum] = "db9f057c3dc8c870d1daa30967d160a2da3c5bd7d541eb6d7456b312ab748981"

RDEPENDS:rust-tree-sitter-c-sharp+default-devel = " \
 cargo \
 rust-tree-sitter-c-sharp-devel \
 "
RDEPENDS:rust-tree-sitter-c-sharp-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
