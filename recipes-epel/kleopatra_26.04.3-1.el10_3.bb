# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kleopatra"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kleopatra \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kleopatra-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "782d164d7519fc27ad831bd1f796c54665fb85c7a313e51086aaafa78fa91ef9"

URI_x86_64_v2_kleopatra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kleopatra-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kleopatra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kleopatra}"
SRC_URI[x86_64_v2_kleopatra.sha256sum] = "da2bf763bf118d50503af7cb0f4b29feac498795e237f72a30763dbe6d80d3b2"

URI_aarch64_kleopatra = "${EPEL_MIRROR}/aarch64/Packages/k/kleopatra-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kleopatra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kleopatra}"
SRC_URI[aarch64_kleopatra.sha256sum] = "28e9ef14715b06738a4ea33fa51899264562e8841e737ad2fab048834013fb14"

RDEPENDS:kleopatra = " \
 akonadi-mime \
 glibc \
 gnupg2 \
 gnupg2-smime \
 gpgme2pp \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 kmime \
 libassuan \
 libgcc \
 libgpg-error \
 libkleo \
 libstdc++ \
 mimetreeparser \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
