# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cram"
PV = "0.7"
PR = "22.el10_1"
PACKAGES = " \
 python3-cram \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cram-0.7-22.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb7af7a58ec5a889f6d4cf4885a0b3c8814d366bcf7019281aaafc6b1bddf8a8"

URI_x86_64_v2_python3-cram = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cram-0.7-22.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cram;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cram}"
SRC_URI[x86_64_v2_python3-cram.sha256sum] = "fb675df535a456a89294326616be43bfdc8e94ed36bc72482d1dc99e9e8a1d92"

URI_aarch64_python3-cram = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cram-0.7-22.el10_1.noarch.rpm;name=aarch64_python3-cram;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cram}"
SRC_URI[aarch64_python3-cram.sha256sum] = "6e85adc148a0b6e06e83678b6a79b3d9adb34d01d7e94e75dff75cb53e39915c"

RDEPENDS:python3-cram = " \
 python3 \
 "
