# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "triehash"
PV = "0.3"
PR = "15.el10_1"
PACKAGES = " \
 triehash \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/triehash-0.3-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05a7d526d363a92459c28fe62290aa368503933a3ae4c4e100776d31e01d840e"

URI_x86_64_v2_triehash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/triehash-0.3-15.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_triehash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_triehash}"
SRC_URI[x86_64_v2_triehash.sha256sum] = "48dda1c446a6659163e4983b87b28e951441bbe4f843e0d8090d0f276c33eb52"

URI_aarch64_triehash = "${EPEL_MIRROR}/aarch64/Packages/t/triehash-0.3-15.el10_1.noarch.rpm;name=aarch64_triehash;unpack=0"
SRC_URI:append = " ${URI_aarch64_triehash}"
SRC_URI[aarch64_triehash.sha256sum] = "a5d31be368f569d9622f2ca42d37dddba310230ffa9685e73d839f940436b985"

RDEPENDS:triehash = " \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 "
