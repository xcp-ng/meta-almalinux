# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-format"
PV = "0.4.4"
PR = "6.el10_0"
PACKAGES = " \
 rust-num-format+cfg-if-devel \
 rust-num-format+default-devel \
 rust-num-format+encoding_rs-devel \
 rust-num-format+lazy_static-devel \
 rust-num-format+libc-devel \
 rust-num-format+num-bigint-devel \
 rust-num-format+serde-devel \
 rust-num-format+std-devel \
 rust-num-format+with-num-bigint-devel \
 rust-num-format+with-serde-devel \
 rust-num-format+with-system-locale-devel \
 rust-num-format-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-format-0.4.4-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "723f3b491acc4ae26bed4637933a7ee7a4c4cab0b409461c86c57c371338a6b0"

URI_x86_64_v2_rust-num-format+cfg-if-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-format+cfg-if-devel-0.4.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-format+cfg-if-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-format+cfg-if-devel}"
SRC_URI[x86_64_v2_rust-num-format+cfg-if-devel.sha256sum] = "eae4857bca39063eca53be0688ec91571cce11ba78ae48c4a64e31912582bb9a"

URI_x86_64_v2_rust-num-format+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-format+default-devel-0.4.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-format+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-format+default-devel}"
SRC_URI[x86_64_v2_rust-num-format+default-devel.sha256sum] = "963ddad64e344b39379c8e068486318dfc2ab951dcbdf818bc3f4b3e21e22c4c"

URI_x86_64_v2_rust-num-format+encoding_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-format+encoding_rs-devel-0.4.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-format+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-format+encoding_rs-devel}"
SRC_URI[x86_64_v2_rust-num-format+encoding_rs-devel.sha256sum] = "f8b125580225250d5bc2dc0a53703f932da0ffc2f56f0d0c8422e324925a93ca"

URI_x86_64_v2_rust-num-format+lazy_static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-format+lazy_static-devel-0.4.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-format+lazy_static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-format+lazy_static-devel}"
SRC_URI[x86_64_v2_rust-num-format+lazy_static-devel.sha256sum] = "e7f075ffe2b8064fd02d95fdd9f9e301c5ad02ebbea0fcf945edb173bec5ae65"

URI_x86_64_v2_rust-num-format+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-format+libc-devel-0.4.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-format+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-format+libc-devel}"
SRC_URI[x86_64_v2_rust-num-format+libc-devel.sha256sum] = "80be38d912ab0b1f1454c14f21cfab383424f14636c714c0fc271ca401d6a0ea"

URI_x86_64_v2_rust-num-format+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-format+num-bigint-devel-0.4.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-format+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-format+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-num-format+num-bigint-devel.sha256sum] = "5239c34f2fd51617c60507ecf98cd528d31557a1c6d2daf297d45c0b54850d03"

URI_x86_64_v2_rust-num-format+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-format+serde-devel-0.4.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-format+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-format+serde-devel}"
SRC_URI[x86_64_v2_rust-num-format+serde-devel.sha256sum] = "ac440b2bc2ba073ce29375e3ec2db024e790b67aee2c321ab33ede8d194fbcc3"

URI_x86_64_v2_rust-num-format+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-format+std-devel-0.4.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-format+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-format+std-devel}"
SRC_URI[x86_64_v2_rust-num-format+std-devel.sha256sum] = "ff336e4c48d34a63d583eec0a14fa13783606ed53c1be462e8f64de5d351c34e"

URI_x86_64_v2_rust-num-format+with-num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-format+with-num-bigint-devel-0.4.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-format+with-num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-format+with-num-bigint-devel}"
SRC_URI[x86_64_v2_rust-num-format+with-num-bigint-devel.sha256sum] = "a84660f41643d515258cf587d6eb9cd76269f0dbbf6ce50ed8afdace8a6be30d"

URI_x86_64_v2_rust-num-format+with-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-format+with-serde-devel-0.4.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-format+with-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-format+with-serde-devel}"
SRC_URI[x86_64_v2_rust-num-format+with-serde-devel.sha256sum] = "9e6425425192474b533c1682fa8ef788cb2a8f0d37dae47f1a6325cb9634a16f"

URI_x86_64_v2_rust-num-format+with-system-locale-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-format+with-system-locale-devel-0.4.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-format+with-system-locale-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-format+with-system-locale-devel}"
SRC_URI[x86_64_v2_rust-num-format+with-system-locale-devel.sha256sum] = "d821809b78c71a6e98627a29f8fdcc2fe7b44b076f53a65c8ed9b32a6f5dc724"

URI_x86_64_v2_rust-num-format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-format-devel-0.4.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-format-devel}"
SRC_URI[x86_64_v2_rust-num-format-devel.sha256sum] = "18c92134028af37be44089c77a15739727b1214e788c015906d88134e7387fc5"

URI_aarch64_rust-num-format+cfg-if-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-format+cfg-if-devel-0.4.4-6.el10_0.noarch.rpm;name=aarch64_rust-num-format+cfg-if-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-format+cfg-if-devel}"
SRC_URI[aarch64_rust-num-format+cfg-if-devel.sha256sum] = "6916b3a9dc35457433b132b27dcf170461c16d9dd497b69be2f034f5412bcaad"

URI_aarch64_rust-num-format+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-format+default-devel-0.4.4-6.el10_0.noarch.rpm;name=aarch64_rust-num-format+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-format+default-devel}"
SRC_URI[aarch64_rust-num-format+default-devel.sha256sum] = "e2a2a0c854660d4cc909f455ca28445ad150315704327c2f57d3326852aa488c"

URI_aarch64_rust-num-format+encoding_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-format+encoding_rs-devel-0.4.4-6.el10_0.noarch.rpm;name=aarch64_rust-num-format+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-format+encoding_rs-devel}"
SRC_URI[aarch64_rust-num-format+encoding_rs-devel.sha256sum] = "8773ede4cda069c9669df2e22e6afaa924d07e68f9887f51c52d74f01d531664"

URI_aarch64_rust-num-format+lazy_static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-format+lazy_static-devel-0.4.4-6.el10_0.noarch.rpm;name=aarch64_rust-num-format+lazy_static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-format+lazy_static-devel}"
SRC_URI[aarch64_rust-num-format+lazy_static-devel.sha256sum] = "bd3ec341e00faa9ae77fb56b3279209b60c798676ea49f16b9a5c624c8ab027f"

URI_aarch64_rust-num-format+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-format+libc-devel-0.4.4-6.el10_0.noarch.rpm;name=aarch64_rust-num-format+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-format+libc-devel}"
SRC_URI[aarch64_rust-num-format+libc-devel.sha256sum] = "9fd74e6ba8779d8ed052105ee4af7e93dcf8397814e5c1c520cb867173e657ba"

URI_aarch64_rust-num-format+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-format+num-bigint-devel-0.4.4-6.el10_0.noarch.rpm;name=aarch64_rust-num-format+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-format+num-bigint-devel}"
SRC_URI[aarch64_rust-num-format+num-bigint-devel.sha256sum] = "d40ce056fc895d6c0354b55287b39e6c60c0b84425088ad37664ce2d941e77ec"

URI_aarch64_rust-num-format+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-format+serde-devel-0.4.4-6.el10_0.noarch.rpm;name=aarch64_rust-num-format+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-format+serde-devel}"
SRC_URI[aarch64_rust-num-format+serde-devel.sha256sum] = "176bc3418f374840e384207b4750fcfe1d2625edb7dc50b0edaf6efab4af6629"

URI_aarch64_rust-num-format+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-format+std-devel-0.4.4-6.el10_0.noarch.rpm;name=aarch64_rust-num-format+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-format+std-devel}"
SRC_URI[aarch64_rust-num-format+std-devel.sha256sum] = "665f58edf4fc5e7bf342edc77d06eafec945dccba8b70d281cfd091a44ce0a45"

URI_aarch64_rust-num-format+with-num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-format+with-num-bigint-devel-0.4.4-6.el10_0.noarch.rpm;name=aarch64_rust-num-format+with-num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-format+with-num-bigint-devel}"
SRC_URI[aarch64_rust-num-format+with-num-bigint-devel.sha256sum] = "de106ad31835d9fa8681a5257c298d224d0c09c7a49db15470e49ef95a5e2a2c"

URI_aarch64_rust-num-format+with-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-format+with-serde-devel-0.4.4-6.el10_0.noarch.rpm;name=aarch64_rust-num-format+with-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-format+with-serde-devel}"
SRC_URI[aarch64_rust-num-format+with-serde-devel.sha256sum] = "6bd240b72f622ae3adaba638af047ae1748621058885f47f9e85fb30e5a7b2ad"

URI_aarch64_rust-num-format+with-system-locale-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-format+with-system-locale-devel-0.4.4-6.el10_0.noarch.rpm;name=aarch64_rust-num-format+with-system-locale-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-format+with-system-locale-devel}"
SRC_URI[aarch64_rust-num-format+with-system-locale-devel.sha256sum] = "75a335b731302c4245d2741e2e8828531078ef9495aa32bb234bb4d3dd093cf8"

URI_aarch64_rust-num-format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-format-devel-0.4.4-6.el10_0.noarch.rpm;name=aarch64_rust-num-format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-format-devel}"
SRC_URI[aarch64_rust-num-format-devel.sha256sum] = "40f29af762c2ff36853d04254b8fa9f1937a1e7d1685fd4bec34c85b4d0562b3"

RDEPENDS:rust-num-format+cfg-if-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-num-format-devel \
 "
RDEPENDS:rust-num-format+default-devel = " \
 cargo \
 rust-num-format+std-devel \
 rust-num-format-devel \
 "
RDEPENDS:rust-num-format+encoding_rs-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-num-format-devel \
 "
RDEPENDS:rust-num-format+lazy_static-devel = " \
 cargo \
 rust-lazy_static+default-devel \
 rust-num-format-devel \
 "
RDEPENDS:rust-num-format+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-num-format-devel \
 "
RDEPENDS:rust-num-format+num-bigint-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-num-format-devel \
 "
RDEPENDS:rust-num-format+serde-devel = " \
 cargo \
 rust-num-format-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-num-format+std-devel = " \
 cargo \
 rust-arrayvec+default-devel \
 rust-num-format-devel \
 "
RDEPENDS:rust-num-format+with-num-bigint-devel = " \
 cargo \
 rust-num-format+num-bigint-devel \
 rust-num-format+std-devel \
 rust-num-format-devel \
 "
RDEPENDS:rust-num-format+with-serde-devel = " \
 cargo \
 rust-arrayvec+serde-devel \
 rust-num-format-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-num-format+with-system-locale-devel = " \
 cargo \
 rust-num-format+cfg-if-devel \
 rust-num-format+encoding_rs-devel \
 rust-num-format+lazy_static-devel \
 rust-num-format+libc-devel \
 rust-num-format+std-devel \
 rust-num-format-devel \
 "
RDEPENDS:rust-num-format-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-itoa-devel \
 "
