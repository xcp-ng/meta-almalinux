# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libqalculate"
PV = "5.3.0"
PR = "1.el10_0"
PACKAGES = " \
 libqalculate \
 libqalculate-devel \
 qalculate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libqalculate-5.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c64c2552ff7beeaba51f182200a4d936cf4966d081f0be6f6e95e32fff51047"

URI_x86_64_v2_libqalculate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libqalculate-5.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libqalculate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libqalculate}"
SRC_URI[x86_64_v2_libqalculate.sha256sum] = "03a4c291bf674ecbbdd9040c7ca0aba8c33e01fafbde74e2221ff766318d9402"

URI_x86_64_v2_libqalculate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libqalculate-devel-5.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libqalculate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libqalculate-devel}"
SRC_URI[x86_64_v2_libqalculate-devel.sha256sum] = "39583253b464ba74dc0129a5229f263e1cee109db2adbbf239035cb99a7e2060"

URI_x86_64_v2_qalculate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qalculate-5.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qalculate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qalculate}"
SRC_URI[x86_64_v2_qalculate.sha256sum] = "96a01d0e9b24b0108471442797172f71e2c3a06071d43009ee9f27e898cb1109"

URI_aarch64_libqalculate = "${EPEL_MIRROR}/aarch64/Packages/l/libqalculate-5.3.0-1.el10_0.aarch64.rpm;name=aarch64_libqalculate;unpack=0"
SRC_URI:append = " ${URI_aarch64_libqalculate}"
SRC_URI[aarch64_libqalculate.sha256sum] = "5eaf0c28ec316f320c114532a8f05752a28dc3adab1a7f8a1377effc018725a2"

URI_aarch64_libqalculate-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libqalculate-devel-5.3.0-1.el10_0.aarch64.rpm;name=aarch64_libqalculate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libqalculate-devel}"
SRC_URI[aarch64_libqalculate-devel.sha256sum] = "eccf2188423a907e3d6ce3f173391444ca77a81f11439958db82fb137a0558c9"

URI_aarch64_qalculate = "${EPEL_MIRROR}/aarch64/Packages/q/qalculate-5.3.0-1.el10_0.aarch64.rpm;name=aarch64_qalculate;unpack=0"
SRC_URI:append = " ${URI_aarch64_qalculate}"
SRC_URI[aarch64_qalculate.sha256sum] = "8b700bd711bd84aec8a75e80e27b0e5f9ba965ea6c1d60e41dbcd8d0a13a4eeb"

RDEPENDS:libqalculate = " \
 glibc \
 gmp \
 libgcc \
 libicu \
 libstdc++ \
 libxml2 \
 mpfr \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libqalculate-devel = " \
 cln-devel \
 glib2-devel \
 libqalculate \
 libxml2-devel \
 mpfr-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:qalculate = " \
 glibc \
 libgcc \
 libqalculate \
 libstdc++ \
 pkgconf-pkg-config \
 readline \
 "
