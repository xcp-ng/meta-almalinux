# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_xoshiro0.6"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_xoshiro0.6+default-devel \
 rust-rand_xoshiro0.6+serde-devel \
 rust-rand_xoshiro0.6+serde1-devel \
 rust-rand_xoshiro0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_xoshiro0.6-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b226a025e6f30f23baefdcc4e6292aa9c87115611040115095b0abad30c8b79f"

URI_x86_64_v2_rust-rand_xoshiro0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro0.6+default-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xoshiro0.6+default-devel}"
SRC_URI[x86_64_v2_rust-rand_xoshiro0.6+default-devel.sha256sum] = "d1009074fdfd82caafe17d859d9aa7f05bf59bf5319cf6f19969a1eb271b9654"

URI_x86_64_v2_rust-rand_xoshiro0.6+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro0.6+serde-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro0.6+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xoshiro0.6+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_xoshiro0.6+serde-devel.sha256sum] = "56e9736b2fe86787ea66eee9df12549244039f3c03dc5f63e35a36ef624b50d9"

URI_x86_64_v2_rust-rand_xoshiro0.6+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro0.6+serde1-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro0.6+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xoshiro0.6+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand_xoshiro0.6+serde1-devel.sha256sum] = "65b8e46faf105cb691547243c244ba6d8de40f69041756a24ed69c84925de483"

URI_x86_64_v2_rust-rand_xoshiro0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro0.6-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xoshiro0.6-devel}"
SRC_URI[x86_64_v2_rust-rand_xoshiro0.6-devel.sha256sum] = "bfa76cc6a4a0fc6769feaabff76e653965bb2ecc0c8dda372a6ec354b666b6b0"

URI_aarch64_rust-rand_xoshiro0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro0.6+default-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xoshiro0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xoshiro0.6+default-devel}"
SRC_URI[aarch64_rust-rand_xoshiro0.6+default-devel.sha256sum] = "2bce31db4009243e82f2b5f4489629d526d6f550c1ec274a0db24e1fea8dbea6"

URI_aarch64_rust-rand_xoshiro0.6+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro0.6+serde-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xoshiro0.6+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xoshiro0.6+serde-devel}"
SRC_URI[aarch64_rust-rand_xoshiro0.6+serde-devel.sha256sum] = "c425be0aeba2769174ae7a3d5fddf3bae25f77ad36c04024345d0d7fa096c47e"

URI_aarch64_rust-rand_xoshiro0.6+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro0.6+serde1-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xoshiro0.6+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xoshiro0.6+serde1-devel}"
SRC_URI[aarch64_rust-rand_xoshiro0.6+serde1-devel.sha256sum] = "0b4c0039694b8f945cf3737b873a7ee59bf1f225aa63134f5d94ca3df0ff9470"

URI_aarch64_rust-rand_xoshiro0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro0.6-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xoshiro0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xoshiro0.6-devel}"
SRC_URI[aarch64_rust-rand_xoshiro0.6-devel.sha256sum] = "8bdcee3452c8e39c5e7f71aa73e942c059da9f1cb3833895a222893f0c03cbd2"

RDEPENDS:rust-rand_xoshiro0.6+default-devel = " \
 cargo \
 rust-rand_xoshiro0.6-devel \
 "
RDEPENDS:rust-rand_xoshiro0.6+serde-devel = " \
 cargo \
 rust-rand_xoshiro0.6-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_xoshiro0.6+serde1-devel = " \
 cargo \
 rust-rand_xoshiro0.6+serde-devel \
 rust-rand_xoshiro0.6-devel \
 "
RDEPENDS:rust-rand_xoshiro0.6-devel = " \
 cargo \
 rust-rand_core0.6+default-devel \
 "
