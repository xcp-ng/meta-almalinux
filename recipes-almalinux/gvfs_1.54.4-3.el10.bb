# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gvfs"
PV = "1.54.4"
PR = "3.el10"
PACKAGES = " \
 gvfs \
 gvfs-client \
 gvfs-fuse \
 gvfs-goa \
 gvfs-gphoto2 \
 gvfs-mtp \
 gvfs-smb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gvfs-1.54.4-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0d89a609c158e2ad165f29b1d3133c8ee23e08d4becaec597813e8f7fc25379"

URI_x86_64_v2_gvfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-1.54.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_gvfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvfs}"
SRC_URI[x86_64_v2_gvfs.sha256sum] = "9f959de3526a71c2859308a2ed1b78ff95483594b02ebb9572db2c30d2cdcf5a"

URI_x86_64_v2_gvfs-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-client-1.54.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_gvfs-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvfs-client}"
SRC_URI[x86_64_v2_gvfs-client.sha256sum] = "e9404a532ef0d1bc7c9ef43a646ac9c5beff84dccce0e7796ae9cd85c55037aa"

URI_x86_64_v2_gvfs-fuse = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-fuse-1.54.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_gvfs-fuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvfs-fuse}"
SRC_URI[x86_64_v2_gvfs-fuse.sha256sum] = "34be925a72d8684b7045458b5c58dd52c1094454cc7764544d6364f52e5f9f6c"

URI_x86_64_v2_gvfs-goa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-goa-1.54.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_gvfs-goa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvfs-goa}"
SRC_URI[x86_64_v2_gvfs-goa.sha256sum] = "fb6e57f809b730d1f908788724b590b227ed77c88e9a99e2a6548f72e72bc8dd"

URI_x86_64_v2_gvfs-gphoto2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-gphoto2-1.54.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_gvfs-gphoto2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvfs-gphoto2}"
SRC_URI[x86_64_v2_gvfs-gphoto2.sha256sum] = "17c02f8feb95798749d30f12e85f55d26ed0142f0940484032380c7328ca405c"

URI_x86_64_v2_gvfs-mtp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-mtp-1.54.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_gvfs-mtp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvfs-mtp}"
SRC_URI[x86_64_v2_gvfs-mtp.sha256sum] = "13fe78a1ec1efb4211412bd5be67638048b303b318acf0a0a31b11ceaceec670"

URI_x86_64_v2_gvfs-smb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-smb-1.54.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_gvfs-smb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvfs-smb}"
SRC_URI[x86_64_v2_gvfs-smb.sha256sum] = "6b1e53fab4e89bcbc43671427febb2dfc3035c410483e15f6aa419c8e29e29c6"

URI_aarch64_gvfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-1.54.4-3.el10.aarch64.rpm;name=aarch64_gvfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvfs}"
SRC_URI[aarch64_gvfs.sha256sum] = "683362656459534acbab681c56ef24077ced7e0b688fa208d63f40894ceab995"

URI_aarch64_gvfs-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-client-1.54.4-3.el10.aarch64.rpm;name=aarch64_gvfs-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvfs-client}"
SRC_URI[aarch64_gvfs-client.sha256sum] = "43cc2e9c800172773a333a560f86ae4d8ad595cf46308e92b55c3bcc3e576414"

URI_aarch64_gvfs-fuse = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-fuse-1.54.4-3.el10.aarch64.rpm;name=aarch64_gvfs-fuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvfs-fuse}"
SRC_URI[aarch64_gvfs-fuse.sha256sum] = "33ad0427389b7cfbdfa18479a6169e1d14a2be80a6ea22937c654198c225f69c"

URI_aarch64_gvfs-goa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-goa-1.54.4-3.el10.aarch64.rpm;name=aarch64_gvfs-goa;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvfs-goa}"
SRC_URI[aarch64_gvfs-goa.sha256sum] = "65ea5774635590c2416c6e5ab28702ba60e5143e8a094314af36a41330193902"

URI_aarch64_gvfs-gphoto2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-gphoto2-1.54.4-3.el10.aarch64.rpm;name=aarch64_gvfs-gphoto2;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvfs-gphoto2}"
SRC_URI[aarch64_gvfs-gphoto2.sha256sum] = "90febbd0c92922a5701d54a4e22ea6e273b47a2d84940c7be455c6820bf84759"

URI_aarch64_gvfs-mtp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-mtp-1.54.4-3.el10.aarch64.rpm;name=aarch64_gvfs-mtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvfs-mtp}"
SRC_URI[aarch64_gvfs-mtp.sha256sum] = "0bea88fb7e39605a76905a1d369e6cb9cf4d373aeec184ec2385731d91327aed"

URI_aarch64_gvfs-smb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-smb-1.54.4-3.el10.aarch64.rpm;name=aarch64_gvfs-smb;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvfs-smb}"
SRC_URI[aarch64_gvfs-smb.sha256sum] = "7cb46dc48c0fa18ca7440e0016f99f24fb25ca8654a8e6dfbda947a9d6444291"

RDEPENDS:gvfs = " \
 avahi-glib \
 avahi-libs \
 bash \
 gcr-libs \
 glib2 \
 glibc \
 gsettings-desktop-schemas \
 gvfs-client \
 libgcc \
 libgudev \
 libsecret \
 libsoup3 \
 libudisks2 \
 libxml2 \
 polkit \
 polkit-libs \
 systemd-libs \
 udisks2 \
 wsdd \
 "
RDEPENDS:gvfs-client = " \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:gvfs-fuse = " \
 fuse3 \
 fuse3-libs \
 glib2 \
 glibc \
 gvfs \
 gvfs-client \
 "
RDEPENDS:gvfs-goa = " \
 bash \
 glib2 \
 glibc \
 gnome-online-accounts \
 gvfs \
 gvfs-client \
 "
RDEPENDS:gvfs-gphoto2 = " \
 bash \
 glib2 \
 glibc \
 gvfs \
 gvfs-client \
 libgphoto2 \
 libgudev \
 "
RDEPENDS:gvfs-mtp = " \
 bash \
 glib2 \
 glibc \
 gvfs \
 gvfs-client \
 libgudev \
 libmtp \
 libusb1 \
 "
RDEPENDS:gvfs-smb = " \
 bash \
 glib2 \
 glibc \
 gvfs \
 gvfs-client \
 libgcc \
 libsmbclient \
 "
