# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "abseil-cpp"
PV = "20240722.1"
PR = "1.el10_0"
PACKAGES = " \
 abseil-cpp \
 abseil-cpp-devel \
 abseil-cpp-testing \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/abseil-cpp-20240722.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4497880852272553c48cd3dc0db9dd723cdc11d9026480a32252105ea5adc68"

URI_x86_64_v2_abseil-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/abseil-cpp-20240722.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_abseil-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_abseil-cpp}"
SRC_URI[x86_64_v2_abseil-cpp.sha256sum] = "8638982177511d53237dd78a279c6acaabbdc34ad998e04b6493463b401d684a"

URI_x86_64_v2_abseil-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/abseil-cpp-devel-20240722.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_abseil-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_abseil-cpp-devel}"
SRC_URI[x86_64_v2_abseil-cpp-devel.sha256sum] = "2c7f07b5ff76e9597dece3aaa181a028437fa69d5e518f0eaeab1554672ad71d"

URI_x86_64_v2_abseil-cpp-testing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/abseil-cpp-testing-20240722.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_abseil-cpp-testing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_abseil-cpp-testing}"
SRC_URI[x86_64_v2_abseil-cpp-testing.sha256sum] = "e3eaf7ba5e851ea6556438bef298df00c1a1a16ff4f0b2ce7c2b4aaae36a5fef"

URI_aarch64_abseil-cpp = "${EPEL_MIRROR}/aarch64/Packages/a/abseil-cpp-20240722.1-1.el10_0.aarch64.rpm;name=aarch64_abseil-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_abseil-cpp}"
SRC_URI[aarch64_abseil-cpp.sha256sum] = "cb90ffb88b391598417090f53e25e1513e06ce871f75354e559400bef48098e6"

URI_aarch64_abseil-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/a/abseil-cpp-devel-20240722.1-1.el10_0.aarch64.rpm;name=aarch64_abseil-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_abseil-cpp-devel}"
SRC_URI[aarch64_abseil-cpp-devel.sha256sum] = "c39a908f281801b74314a705600c411f77cb3458a0c9b03b50ed4f7641ea367e"

URI_aarch64_abseil-cpp-testing = "${EPEL_MIRROR}/aarch64/Packages/a/abseil-cpp-testing-20240722.1-1.el10_0.aarch64.rpm;name=aarch64_abseil-cpp-testing;unpack=0"
SRC_URI:append = " ${URI_aarch64_abseil-cpp-testing}"
SRC_URI[aarch64_abseil-cpp-testing.sha256sum] = "699e68feeaf4025bca951b4e04e342d62cd9079b2eabb67ad50d8f79038f5594"

RDEPENDS:abseil-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:abseil-cpp-devel = " \
 abseil-cpp \
 abseil-cpp-testing \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:abseil-cpp-testing = " \
 abseil-cpp \
 glibc \
 gmock \
 gtest \
 libgcc \
 libstdc++ \
 "
