# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dns-lookup"
PV = "3.0.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-dns-lookup+default-devel \
 rust-dns-lookup-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dns-lookup-3.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bce1ae74e15e35e70737dc6523d93c0d124960c67e10b12b68de846a6077ec29"

URI_x86_64_v2_rust-dns-lookup+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dns-lookup+default-devel-3.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dns-lookup+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dns-lookup+default-devel}"
SRC_URI[x86_64_v2_rust-dns-lookup+default-devel.sha256sum] = "21e7c1a960f4d47898d615d2d26d1b6e99ee5f8301cdc34eae5c2882c1fb1712"

URI_x86_64_v2_rust-dns-lookup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dns-lookup-devel-3.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dns-lookup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dns-lookup-devel}"
SRC_URI[x86_64_v2_rust-dns-lookup-devel.sha256sum] = "c4412c2da65fe8b4739e4189084d3b0a2523d3e18f34f624c8b3bc0a42925d80"

URI_aarch64_rust-dns-lookup+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dns-lookup+default-devel-3.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-dns-lookup+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dns-lookup+default-devel}"
SRC_URI[aarch64_rust-dns-lookup+default-devel.sha256sum] = "335621d9d37a8c37c08aede05a202c43dadbdd43e7e4fb6ceece18c1a1a049c7"

URI_aarch64_rust-dns-lookup-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dns-lookup-devel-3.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-dns-lookup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dns-lookup-devel}"
SRC_URI[aarch64_rust-dns-lookup-devel.sha256sum] = "5b0e9b02c98f516d0037e6989a5be245a79c4339c4d672a237dfe065013e2a6b"

RDEPENDS:rust-dns-lookup+default-devel = " \
 cargo \
 rust-dns-lookup-devel \
 "
RDEPENDS:rust-dns-lookup-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-socket2+default-devel \
 "
