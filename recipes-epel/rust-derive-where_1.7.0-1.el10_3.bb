# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derive-where"
PV = "1.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-derive-where+default-devel \
 rust-derive-where+nightly-devel \
 rust-derive-where+safe-devel \
 rust-derive-where+serde-devel \
 rust-derive-where+zeroize-devel \
 rust-derive-where+zeroize-on-drop-devel \
 rust-derive-where-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-derive-where-1.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ab71a671c042f0684b87fa04353e48df364943dd978be2bcaac2c4454d41596e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+default-devel-1.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-derive-where+default-devel.sha256sum] = "39dd6bf4e7ec31ee407c763236b8979604462bd69d3d6980c1f5f9cce67657c4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+nightly-devel-1.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-derive-where+nightly-devel.sha256sum] = "eb70fb34e6c958790c3980a343e883a2c68ec686e663676c0aaac6d2dabc6377"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+safe-devel-1.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+safe-devel;unpack=0"
SRC_URI[x86_64_v2_rust-derive-where+safe-devel.sha256sum] = "c60b9b436a68878d9b0555193763d49341f553a7ef3c27489e3cac6511021168"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+serde-devel-1.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-derive-where+serde-devel.sha256sum] = "ea78b0eae796808660aa4e7b276294ae03a4d071920f14ff10a6f7dc3665df73"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+zeroize-devel-1.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+zeroize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-derive-where+zeroize-devel.sha256sum] = "3272c83d5f53b18f9e81fcb9f10f28531f11a74bd0bc0f0655ac918e8e35c576"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+zeroize-on-drop-devel-1.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+zeroize-on-drop-devel;unpack=0"
SRC_URI[x86_64_v2_rust-derive-where+zeroize-on-drop-devel.sha256sum] = "4d468247ad376e3d7950aa083589dca2a33d0ff4f659d96ecdaa930767ca897a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where-devel-1.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where-devel;unpack=0"
SRC_URI[x86_64_v2_rust-derive-where-devel.sha256sum] = "0128d9cbc65c8e76440ed2684a63bda655edb185e9c19ab46c6a8c845a50f04e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+default-devel-1.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-derive-where+default-devel;unpack=0"
SRC_URI[aarch64_rust-derive-where+default-devel.sha256sum] = "b348b7a6fe56ecd5164791114f03ecec5227fec6388565fa6c9d1317090d05b7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+nightly-devel-1.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-derive-where+nightly-devel;unpack=0"
SRC_URI[aarch64_rust-derive-where+nightly-devel.sha256sum] = "aea377be1b46e5864312085f12932d9f1c6ab5745aa8ea20df8a062f4d2c98ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+safe-devel-1.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-derive-where+safe-devel;unpack=0"
SRC_URI[aarch64_rust-derive-where+safe-devel.sha256sum] = "7a2d2ff2985f091b61c2ab1784791c9716ea9123f09e6e0ea4822cee7e4aa067"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+serde-devel-1.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-derive-where+serde-devel;unpack=0"
SRC_URI[aarch64_rust-derive-where+serde-devel.sha256sum] = "630fb1fc114062ada2048841b0c0d9feda42a057b3eb81e81642489f28dc7459"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+zeroize-devel-1.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-derive-where+zeroize-devel;unpack=0"
SRC_URI[aarch64_rust-derive-where+zeroize-devel.sha256sum] = "4aabbd10ca40850a60944cb44b0132df8cebcda4d89f2917b83246b864d03404"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+zeroize-on-drop-devel-1.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-derive-where+zeroize-on-drop-devel;unpack=0"
SRC_URI[aarch64_rust-derive-where+zeroize-on-drop-devel.sha256sum] = "7afcd0b95f8adc53308c3549c100dfc731c283ad645b27cf502ad40ef74e69d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where-devel-1.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-derive-where-devel;unpack=0"
SRC_URI[aarch64_rust-derive-where-devel.sha256sum] = "4de9758da077c73ffa8c6f4b727ab91ec591804236a73311b14e0fa32dccd056"

RDEPENDS:rust-derive-where+default-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+nightly-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+safe-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+serde-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+zeroize-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+zeroize-on-drop-devel = " \
 cargo \
 rust-derive-where+zeroize-devel \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
