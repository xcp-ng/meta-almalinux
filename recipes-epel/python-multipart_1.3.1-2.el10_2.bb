# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-multipart"
PV = "1.3.1"
PR = "2.el10_2"
PACKAGES = " \
 python3-multipart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-multipart-1.3.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ada6758a714acfa556ec1f0ef4ba0d051156eee8afe7677668781909bcb17679"

URI_x86_64_v2_python3-multipart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-multipart-1.3.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-multipart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-multipart}"
SRC_URI[x86_64_v2_python3-multipart.sha256sum] = "eb0982465f394f69720578ab1d3fe7ec130cc1fa3ba73a19b7e8270b2315583e"

URI_aarch64_python3-multipart = "${EPEL_MIRROR}/aarch64/Packages/p/python3-multipart-1.3.1-2.el10_2.noarch.rpm;name=aarch64_python3-multipart;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-multipart}"
SRC_URI[aarch64_python3-multipart.sha256sum] = "b0ac50fb712b8d12fb69fb01e4fa47257ae9cc1f1f43d410b4c40805d97a6ed9"

RDEPENDS:python3-multipart = " \
 python3 \
 "
