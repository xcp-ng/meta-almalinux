# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-hsb"
PV = "0.20060327.3"
PR = "29.el10"
PACKAGES = " \
 hunspell-hsb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-hsb-0.20060327.3-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f26b18e8c5ced72305cd924de92241c97e24c2d6d13cb54c3d6a2c7fc601b44"

URI_x86_64_v2_hunspell-hsb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-hsb-0.20060327.3-29.el10.noarch.rpm;name=x86_64_v2_hunspell-hsb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-hsb}"
SRC_URI[x86_64_v2_hunspell-hsb.sha256sum] = "e6625b39e2fa099e73ed97d3950cdc1670e82b8080f341769241a040e8b655e6"

URI_aarch64_hunspell-hsb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-hsb-0.20060327.3-29.el10.noarch.rpm;name=aarch64_hunspell-hsb;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-hsb}"
SRC_URI[aarch64_hunspell-hsb.sha256sum] = "e6625b39e2fa099e73ed97d3950cdc1670e82b8080f341769241a040e8b655e6"

RDEPENDS:hunspell-hsb = " \
 hunspell-filesystem \
 "
