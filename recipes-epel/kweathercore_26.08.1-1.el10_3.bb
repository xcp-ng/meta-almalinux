# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kweathercore"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kweathercore \
 kweathercore-devel \
 kweathercore-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kweathercore-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a596a7f1347e710c4ec88101ef2d67840821c2183256149c2bcd959da990e93c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweathercore-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweathercore;unpack=0"
SRC_URI[x86_64_v2_kweathercore.sha256sum] = "4c41e536ca57755a9b811a61426e922da7e14b80eb09a7d8d21871cddf100cd2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweathercore-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweathercore-devel;unpack=0"
SRC_URI[x86_64_v2_kweathercore-devel.sha256sum] = "546063305680b9db26cc3b4930cfd0486eed4e2f6501632bf0bf3714e1982c12"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweathercore-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kweathercore-doc;unpack=0"
SRC_URI[x86_64_v2_kweathercore-doc.sha256sum] = "168a83ee0d0ecc49ca2c20a44c1e0d01e6d9d99419e251019ed616ef5463ff43"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kweathercore-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kweathercore;unpack=0"
SRC_URI[aarch64_kweathercore.sha256sum] = "8b0552b897984f45eb3e2edf79cc000dd40d2e72ee9c9cfd28a00e6de9a8cab2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kweathercore-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kweathercore-devel;unpack=0"
SRC_URI[aarch64_kweathercore-devel.sha256sum] = "0c293a365e109403dbfe89eef1a284539dbd2cdbb9633d979eea02df9eaa0249"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kweathercore-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kweathercore-doc;unpack=0"
SRC_URI[aarch64_kweathercore-doc.sha256sum] = "12254e8b8d9ea0f5e0daedb8e0488437d91d6f877ca4d872582426a8a41981dc"

RDEPENDS:kweathercore = " \
 glibc \
 kf6-kholidays \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 "
RDEPENDS:kweathercore-devel = " \
 cmake-filesystem \
 kweathercore \
 "
RDEPENDS:kweathercore-doc = " \
 "
