# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pystring"
PV = "1.1.4"
PR = "7.20251015gita09708a.el10_2"
PACKAGES = " \
 pystring \
 pystring-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pystring-1.1.4-7.20251015gita09708a.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "258361af8fc519ab55a0b44730b36bfafe1afa824e696f15c32980662543bced"

URI_aarch64_pystring = "${EPEL_MIRROR}/aarch64/Packages/p/pystring-1.1.4-7.20251015gita09708a.el10_2.aarch64.rpm;name=aarch64_pystring;unpack=0"
SRC_URI:append = " ${URI_aarch64_pystring}"
SRC_URI[aarch64_pystring.sha256sum] = "3800cefc608f7e7a8349cd8ec4f426dc96ea0cfffa9b404c057853747e414799"

URI_aarch64_pystring-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pystring-devel-1.1.4-7.20251015gita09708a.el10_2.aarch64.rpm;name=aarch64_pystring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pystring-devel}"
SRC_URI[aarch64_pystring-devel.sha256sum] = "8012258717d417d96917ea6678a54fb0e2b9468a2817fbef00e97fc95e52f2a4"

RDEPENDS:pystring = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:pystring-devel = " \
 pkgconf-pkg-config \
 pystring \
 "
