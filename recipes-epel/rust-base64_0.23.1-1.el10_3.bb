# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-base64"
PV = "0.23.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-base64+alloc-devel \
 rust-base64+default-devel \
 rust-base64+simd-unsafe-devel \
 rust-base64+std-devel \
 rust-base64-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-base64-0.23.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c08846d193ab36e70f3462f43a0a3cfdcb3554f8955de9dc7165224f6e50bd0"

URI_x86_64_v2_rust-base64+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64+alloc-devel-0.23.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64+alloc-devel}"
SRC_URI[x86_64_v2_rust-base64+alloc-devel.sha256sum] = "d053b3e045cf43fd715f7066817ee1739f69df939cc8d95cab7dfb234ee71aa1"

URI_x86_64_v2_rust-base64+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64+default-devel-0.23.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64+default-devel}"
SRC_URI[x86_64_v2_rust-base64+default-devel.sha256sum] = "da4df6c2557944c109c13661bd872aa87da857fd72323d6b7a92d948d3ee1ef9"

URI_x86_64_v2_rust-base64+simd-unsafe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64+simd-unsafe-devel-0.23.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64+simd-unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64+simd-unsafe-devel}"
SRC_URI[x86_64_v2_rust-base64+simd-unsafe-devel.sha256sum] = "ca0c0d67a760fbaf06850b3d77994e59685c4de299e51e45000745be6affb0c5"

URI_x86_64_v2_rust-base64+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64+std-devel-0.23.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64+std-devel}"
SRC_URI[x86_64_v2_rust-base64+std-devel.sha256sum] = "7ec7122c09c4a14a1194d6b1c7672c78fe28ee36ec9320cffbf5ce576a7eb9c0"

URI_x86_64_v2_rust-base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64-devel-0.23.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64-devel}"
SRC_URI[x86_64_v2_rust-base64-devel.sha256sum] = "9b3169dc0faaac965caf5a10da31e96fd12e639c0a341fb7ab9bbb11f6e0e5b0"

URI_aarch64_rust-base64+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64+alloc-devel-0.23.1-1.el10_3.noarch.rpm;name=aarch64_rust-base64+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64+alloc-devel}"
SRC_URI[aarch64_rust-base64+alloc-devel.sha256sum] = "976ef4a47cf29300854cef42eaf06997a6db5fc1f26c9b5c3563a9906a0fa0fd"

URI_aarch64_rust-base64+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64+default-devel-0.23.1-1.el10_3.noarch.rpm;name=aarch64_rust-base64+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64+default-devel}"
SRC_URI[aarch64_rust-base64+default-devel.sha256sum] = "1928210f11c30597cae81df6c4ef937df9019992cb0203baab116ab5995e60d3"

URI_aarch64_rust-base64+simd-unsafe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64+simd-unsafe-devel-0.23.1-1.el10_3.noarch.rpm;name=aarch64_rust-base64+simd-unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64+simd-unsafe-devel}"
SRC_URI[aarch64_rust-base64+simd-unsafe-devel.sha256sum] = "58e2ed03a1e849d8c393c1bce8573ad41e6b2a493aa5f3d81af58da1db376f45"

URI_aarch64_rust-base64+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64+std-devel-0.23.1-1.el10_3.noarch.rpm;name=aarch64_rust-base64+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64+std-devel}"
SRC_URI[aarch64_rust-base64+std-devel.sha256sum] = "67ab431f59fff425f7b2eb5a19e2a4378a2e5d41ff69852fe3bf74d1893b4479"

URI_aarch64_rust-base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64-devel-0.23.1-1.el10_3.noarch.rpm;name=aarch64_rust-base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64-devel}"
SRC_URI[aarch64_rust-base64-devel.sha256sum] = "379df213f6b9705e12f92c9d963be47b18bade57893823d4a0ffc19f7c842c35"

RDEPENDS:rust-base64+alloc-devel = " \
 cargo \
 rust-base64-devel \
 "
RDEPENDS:rust-base64+default-devel = " \
 cargo \
 rust-base64+simd-unsafe-devel \
 rust-base64+std-devel \
 rust-base64-devel \
 "
RDEPENDS:rust-base64+simd-unsafe-devel = " \
 cargo \
 rust-base64-devel \
 "
RDEPENDS:rust-base64+std-devel = " \
 cargo \
 rust-base64+alloc-devel \
 rust-base64-devel \
 "
RDEPENDS:rust-base64-devel = " \
 cargo \
 rust \
 "
