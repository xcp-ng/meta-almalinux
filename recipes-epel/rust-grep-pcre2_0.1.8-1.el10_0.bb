# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-pcre2"
PV = "0.1.8"
PR = "1.el10_0"
PACKAGES = " \
 rust-grep-pcre2+default-devel \
 rust-grep-pcre2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-pcre2-0.1.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "855c4db1350c5f79cc2c6b80f7785cbf3855180e1dcc7fe032f36364c48c0711"

URI_x86_64_v2_rust-grep-pcre2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-pcre2+default-devel-0.1.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-pcre2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-pcre2+default-devel}"
SRC_URI[x86_64_v2_rust-grep-pcre2+default-devel.sha256sum] = "71cc85660b5cf70e43c039b7cd3cfd52152bd03ff81304c665fc1c82f10519f3"

URI_x86_64_v2_rust-grep-pcre2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-pcre2-devel-0.1.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-pcre2-devel}"
SRC_URI[x86_64_v2_rust-grep-pcre2-devel.sha256sum] = "36be5e8755fc49706710a5362c1c215c123e6d3c3b42b10fa54007f442015c7a"

URI_aarch64_rust-grep-pcre2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-pcre2+default-devel-0.1.8-1.el10_0.noarch.rpm;name=aarch64_rust-grep-pcre2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-pcre2+default-devel}"
SRC_URI[aarch64_rust-grep-pcre2+default-devel.sha256sum] = "0df7446aea7822b6448afaaf25fd26e8b2bce3133600e2afb015521ed848dbdb"

URI_aarch64_rust-grep-pcre2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-pcre2-devel-0.1.8-1.el10_0.noarch.rpm;name=aarch64_rust-grep-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-pcre2-devel}"
SRC_URI[aarch64_rust-grep-pcre2-devel.sha256sum] = "38232039f75875d32610ba078beb3b954f5ca2476c8805dea7da3f273ab4c6d5"

RDEPENDS:rust-grep-pcre2+default-devel = " \
 cargo \
 rust-grep-pcre2-devel \
 "
RDEPENDS:rust-grep-pcre2-devel = " \
 cargo \
 rust-grep-matcher+default-devel \
 rust-log+default-devel \
 rust-pcre2+default-devel \
 "
