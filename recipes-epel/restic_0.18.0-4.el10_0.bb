# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "restic"
PV = "0.18.0"
PR = "4.el10_0"
PACKAGES = " \
 restic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/restic-0.18.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7e1d538ffaec41c11ae9f9b328ad30ffcb7eda8f0174ce1cbf29e36975eb594"

URI_x86_64_v2_restic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/restic-0.18.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_restic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_restic}"
SRC_URI[x86_64_v2_restic.sha256sum] = "cdf122db316c09a5a381aa617ecb7c1593971c7e8d24afc48c8d8874ee32fbf1"

URI_aarch64_restic = "${EPEL_MIRROR}/aarch64/Packages/r/restic-0.18.0-4.el10_0.aarch64.rpm;name=aarch64_restic;unpack=0"
SRC_URI:append = " ${URI_aarch64_restic}"
SRC_URI[aarch64_restic.sha256sum] = "7a272342911eabcb57147a0808e6a040195d5fbab2326e18d6734cd24443f25e"

RDEPENDS:restic = " \
 glibc \
 "
