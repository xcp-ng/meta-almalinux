# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbruch"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kbruch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kbruch-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99e8bc2e6da35d39d59380d2e939784d43b4647797be98b49b2f9699aadb02ff"

URI_x86_64_v2_kbruch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbruch-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbruch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbruch}"
SRC_URI[x86_64_v2_kbruch.sha256sum] = "54a826946b06128fd39c198391ce40b9f44194c08c70e55300d7caba1b70623a"

URI_aarch64_kbruch = "${EPEL_MIRROR}/aarch64/Packages/k/kbruch-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kbruch;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbruch}"
SRC_URI[aarch64_kbruch.sha256sum] = "060525e8bc9937fea6c64d5e2eb5fc5c86bce956861801d07fcecbb48eb33f96"

RDEPENDS:kbruch = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
