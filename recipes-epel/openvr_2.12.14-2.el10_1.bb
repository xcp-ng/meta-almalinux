# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openvr"
PV = "2.12.14"
PR = "2.el10_1"
PACKAGES = " \
 openvr-api \
 openvr-devel \
 openvr-doc \
 openvr-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openvr-2.12.14-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "babb7e0b6a176b8f27926af04e7670fd7f10b41ec74a54bc93ecd25558503dd5"

URI_x86_64_v2_openvr-api = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvr-api-2.12.14-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvr-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvr-api}"
SRC_URI[x86_64_v2_openvr-api.sha256sum] = "e1a8f9655b5fb5141652044fad7c18ede0de04316f2d2d7efc103c5a508f2e46"

URI_x86_64_v2_openvr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvr-devel-2.12.14-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvr-devel}"
SRC_URI[x86_64_v2_openvr-devel.sha256sum] = "2ad68d979fb1bb8a96fe03d7e2dedf2670f28b7e8bf13955d1aa0a98513b3093"

URI_x86_64_v2_openvr-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvr-doc-2.12.14-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_openvr-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvr-doc}"
SRC_URI[x86_64_v2_openvr-doc.sha256sum] = "c42bb20764543d546f3d8a280b70b5023b0efcbfa8e6f9039acb6f275abdc71c"

URI_x86_64_v2_openvr-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvr-samples-2.12.14-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvr-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvr-samples}"
SRC_URI[x86_64_v2_openvr-samples.sha256sum] = "d6272281e578cf21eb7ffcb401ec4791c5cc0355672e1093e7d3a84eef9b0591"

URI_aarch64_openvr-api = "${EPEL_MIRROR}/aarch64/Packages/o/openvr-api-2.12.14-2.el10_1.aarch64.rpm;name=aarch64_openvr-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvr-api}"
SRC_URI[aarch64_openvr-api.sha256sum] = "f07ddca50fb0f4e5885780122c7843e2260aa52e93f1d047201732cbffa66fdf"

URI_aarch64_openvr-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openvr-devel-2.12.14-2.el10_1.aarch64.rpm;name=aarch64_openvr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvr-devel}"
SRC_URI[aarch64_openvr-devel.sha256sum] = "682c41ae065033615f133a944f1921cc80efbb5b609eb912156ea886996daae8"

URI_aarch64_openvr-doc = "${EPEL_MIRROR}/aarch64/Packages/o/openvr-doc-2.12.14-2.el10_1.noarch.rpm;name=aarch64_openvr-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvr-doc}"
SRC_URI[aarch64_openvr-doc.sha256sum] = "d541a678e0b743d4b40da014c620ea79e0cece7a0130a3b070cf5b83828304ab"

URI_aarch64_openvr-samples = "${EPEL_MIRROR}/aarch64/Packages/o/openvr-samples-2.12.14-2.el10_1.aarch64.rpm;name=aarch64_openvr-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvr-samples}"
SRC_URI[aarch64_openvr-samples.sha256sum] = "cf25a760a0ab9e749ab4e515858cfdccd57916fce1b2b29308e69afe0abe67c9"

RDEPENDS:openvr-api = " \
 glibc \
 jsoncpp \
 libgcc \
 libstdc++ \
 "
RDEPENDS:openvr-devel = " \
 jsoncpp-devel \
 openvr-api \
 pkgconf-pkg-config \
 "
RDEPENDS:openvr-doc = " \
 "
RDEPENDS:openvr-samples = " \
 glibc \
 libGLEW \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 openvr-api \
 qt5-qtbase \
 qt5-qtbase-gui \
 virtual/libSDL2-2.0.so.0___64bit_ \
 vulkan-loader \
 "
