# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-torch"
PV = "2.9.1"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 python3-torch \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-torch-2.9.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "496f83aa508c26c90bba6a0c453d7dbf96e8a0e92508e1770db8a0f933d1e665"

URI_x86_64_v2_python3-torch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-torch-2.9.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-torch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-torch}"
SRC_URI[x86_64_v2_python3-torch.sha256sum] = "e0885c70a040c1d4314e86ffe363e454e51d726dfaa3a6902cc196a013af854b"

RDEPENDS:python3-torch = " \
 cpuinfo \
 flexiblas-netlib \
 fmt \
 glibc \
 hipblas \
 hipblaslt \
 hipfft \
 hiprand \
 hipsolver \
 hipsparse \
 hipsparselt \
 libgcc \
 libstdc++ \
 magma \
 miopen \
 numactl-libs \
 python3 \
 python3-filelock \
 python3-jinja2 \
 python3-networkx \
 python3-setuptools \
 rocblas \
 rocm-hip \
 rocm-smi \
 rocsolver \
 roctracer \
 sleef \
 virtual/libomp.so_VERSION__64bit_ \
 virtual/libomp.so___64bit_ \
 "
