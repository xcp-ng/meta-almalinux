# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-syntax-highlighting"
PV = "6.28.1"
PR = "1.el10_3"
PACKAGES = " \
 kf6-syntax-highlighting \
 kf6-syntax-highlighting-devel \
 kf6-syntax-highlighting-doc \
 kf6-syntax-highlighting-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-syntax-highlighting-6.28.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4df2f99964d3dbf804007d9a09b2836f3da75df3b6e3de86a9abec532a193531"

URI_x86_64_v2_kf6-syntax-highlighting = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-6.28.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syntax-highlighting;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syntax-highlighting}"
SRC_URI[x86_64_v2_kf6-syntax-highlighting.sha256sum] = "05423937344c5b1d12bd7c559f6a8a178704bb5425753e0eaebdd6ba0f309ff9"

URI_x86_64_v2_kf6-syntax-highlighting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-devel-6.28.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syntax-highlighting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syntax-highlighting-devel}"
SRC_URI[x86_64_v2_kf6-syntax-highlighting-devel.sha256sum] = "39693801a070bdff8e2e475895a5ae051cadebc481457819f7f3694124aba255"

URI_x86_64_v2_kf6-syntax-highlighting-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-doc-6.28.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syntax-highlighting-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syntax-highlighting-doc}"
SRC_URI[x86_64_v2_kf6-syntax-highlighting-doc.sha256sum] = "8331fd2af3e01915584c139d75b823f61c20f929439c7e0d5c40e2864ad76897"

URI_x86_64_v2_kf6-syntax-highlighting-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-html-6.28.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syntax-highlighting-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syntax-highlighting-html}"
SRC_URI[x86_64_v2_kf6-syntax-highlighting-html.sha256sum] = "b1adf4b7b589c4732a9796cf322920d41a356475ea6c8a2228a60c32932bfb6c"

URI_aarch64_kf6-syntax-highlighting = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-6.28.1-1.el10_3.aarch64.rpm;name=aarch64_kf6-syntax-highlighting;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syntax-highlighting}"
SRC_URI[aarch64_kf6-syntax-highlighting.sha256sum] = "976ebc08a7029ea824b2ec4c6b8cf2aff1cce421686ca1e80bf3e8188115b866"

URI_aarch64_kf6-syntax-highlighting-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-devel-6.28.1-1.el10_3.aarch64.rpm;name=aarch64_kf6-syntax-highlighting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syntax-highlighting-devel}"
SRC_URI[aarch64_kf6-syntax-highlighting-devel.sha256sum] = "6ab0dd2b1b68376ac88b35ce8babdb8637f543dd2caa21d0ef3814877c2917d3"

URI_aarch64_kf6-syntax-highlighting-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-doc-6.28.1-1.el10_3.noarch.rpm;name=aarch64_kf6-syntax-highlighting-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syntax-highlighting-doc}"
SRC_URI[aarch64_kf6-syntax-highlighting-doc.sha256sum] = "71ce9130f4f4dd2083d9c346f373bb126893ecb2486b093e1d294dc3fa9a031c"

URI_aarch64_kf6-syntax-highlighting-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-html-6.28.1-1.el10_3.noarch.rpm;name=aarch64_kf6-syntax-highlighting-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syntax-highlighting-html}"
SRC_URI[aarch64_kf6-syntax-highlighting-html.sha256sum] = "0e03cd437fc2b369a721033314d0ea0845e32fc8ed33f2dcbc0209354e74397e"

RDEPENDS:kf6-syntax-highlighting = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-syntax-highlighting-devel = " \
 cmake-filesystem \
 kf6-syntax-highlighting \
 "
RDEPENDS:kf6-syntax-highlighting-doc = " \
 "
RDEPENDS:kf6-syntax-highlighting-html = " \
 "
