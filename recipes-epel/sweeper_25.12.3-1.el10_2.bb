# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sweeper"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 sweeper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sweeper-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfbf425bd9745f51225047c7d09d03ff203778a7a35d95a9340fe46e9bc11db9"

URI_x86_64_v2_sweeper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sweeper-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sweeper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sweeper}"
SRC_URI[x86_64_v2_sweeper.sha256sum] = "fae7406444ee73d0d8b7da4e0490773df2ce1972dc61e9da1782f40780e1698e"

URI_aarch64_sweeper = "${EPEL_MIRROR}/aarch64/Packages/s/sweeper-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_sweeper;unpack=0"
SRC_URI:append = " ${URI_aarch64_sweeper}"
SRC_URI[aarch64_sweeper.sha256sum] = "19b0fb96aaf4c037c36b9c03aaf6a91a04c3d4bacfb36778b4c0b7eb9adafefe"

RDEPENDS:sweeper = " \
 glibc \
 hicolor-icon-theme \
 kf6-kbookmarks \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 plasma-activities-stats \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
