# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-slog-term"
PV = "2.9.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-slog-term+default-devel \
 rust-slog-term+erased-serde-devel \
 rust-slog-term+nested-values-devel \
 rust-slog-term+serde-devel \
 rust-slog-term+serde_json-devel \
 rust-slog-term-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-slog-term-2.9.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a41e13d04beee9a8940a123220204d9ddfdd2d3138e3f40fa40549aa4b1bc8a1"

URI_x86_64_v2_rust-slog-term+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term+default-devel-2.9.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term+default-devel}"
SRC_URI[x86_64_v2_rust-slog-term+default-devel.sha256sum] = "ae16f94f5110ceb92e72eca49d3ba1f60c0350538eabbff93fe12863361bf75b"

URI_x86_64_v2_rust-slog-term+erased-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term+erased-serde-devel-2.9.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term+erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term+erased-serde-devel}"
SRC_URI[x86_64_v2_rust-slog-term+erased-serde-devel.sha256sum] = "d3663ab240c59c990ab1d7ee859badd3a64ff0bcdf0afb41e644ad057b302532"

URI_x86_64_v2_rust-slog-term+nested-values-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term+nested-values-devel-2.9.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term+nested-values-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term+nested-values-devel}"
SRC_URI[x86_64_v2_rust-slog-term+nested-values-devel.sha256sum] = "8bea0b8134c56817d4ef43e20419e5017a6b153a25597a33c4924aff479314c0"

URI_x86_64_v2_rust-slog-term+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term+serde-devel-2.9.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term+serde-devel}"
SRC_URI[x86_64_v2_rust-slog-term+serde-devel.sha256sum] = "193c1ad943eb925a2b2c6356db95390f2c497ef44cab39a23834541faeca621d"

URI_x86_64_v2_rust-slog-term+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term+serde_json-devel-2.9.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term+serde_json-devel}"
SRC_URI[x86_64_v2_rust-slog-term+serde_json-devel.sha256sum] = "3ddd0c2361600a31b61fee7deab75971e021c7bcc0f8cfae20704730b42375ab"

URI_x86_64_v2_rust-slog-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term-devel-2.9.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term-devel}"
SRC_URI[x86_64_v2_rust-slog-term-devel.sha256sum] = "ad18a0c07093787521439e81d984a9e8ef78624aeba2e0c9c6362828e8509ea1"

URI_aarch64_rust-slog-term+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term+default-devel-2.9.1-3.el10_0.noarch.rpm;name=aarch64_rust-slog-term+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term+default-devel}"
SRC_URI[aarch64_rust-slog-term+default-devel.sha256sum] = "b4a39f40d023b8df1e8dd930c1def06d3ed68e5ce46db0dcdd5289246f98b8da"

URI_aarch64_rust-slog-term+erased-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term+erased-serde-devel-2.9.1-3.el10_0.noarch.rpm;name=aarch64_rust-slog-term+erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term+erased-serde-devel}"
SRC_URI[aarch64_rust-slog-term+erased-serde-devel.sha256sum] = "a50fccf9c5d45b91aabb2821d5bb26645e035c080f5e1ddee100a62250d9f073"

URI_aarch64_rust-slog-term+nested-values-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term+nested-values-devel-2.9.1-3.el10_0.noarch.rpm;name=aarch64_rust-slog-term+nested-values-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term+nested-values-devel}"
SRC_URI[aarch64_rust-slog-term+nested-values-devel.sha256sum] = "fc7a4738810fb5e4fb6140e6f4fcfca589f97c3226e44aa3e07a5e070bc8233d"

URI_aarch64_rust-slog-term+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term+serde-devel-2.9.1-3.el10_0.noarch.rpm;name=aarch64_rust-slog-term+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term+serde-devel}"
SRC_URI[aarch64_rust-slog-term+serde-devel.sha256sum] = "f7669f132ed9ba3d6ca0332650e76fb5a1cb24231835dc787f345cbca1d05ee4"

URI_aarch64_rust-slog-term+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term+serde_json-devel-2.9.1-3.el10_0.noarch.rpm;name=aarch64_rust-slog-term+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term+serde_json-devel}"
SRC_URI[aarch64_rust-slog-term+serde_json-devel.sha256sum] = "0978798d250c4ce703989d7c5019fa918d1c3f99f45a48069476a2903869d82a"

URI_aarch64_rust-slog-term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term-devel-2.9.1-3.el10_0.noarch.rpm;name=aarch64_rust-slog-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term-devel}"
SRC_URI[aarch64_rust-slog-term-devel.sha256sum] = "c614628cc073077393879254b2075c9f0940dbe1ce9cc47987bf527d31da3437"

RDEPENDS:rust-slog-term+default-devel = " \
 cargo \
 rust-slog-term-devel \
 "
RDEPENDS:rust-slog-term+erased-serde-devel = " \
 cargo \
 rust-erased-serde0.3+default-devel \
 rust-slog-term-devel \
 "
RDEPENDS:rust-slog-term+nested-values-devel = " \
 cargo \
 rust-slog+nested-values-devel \
 rust-slog-term+erased-serde-devel \
 rust-slog-term+serde-devel \
 rust-slog-term+serde_json-devel \
 rust-slog-term-devel \
 "
RDEPENDS:rust-slog-term+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-slog-term-devel \
 "
RDEPENDS:rust-slog-term+serde_json-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-slog-term-devel \
 "
RDEPENDS:rust-slog-term-devel = " \
 cargo \
 rust \
 rust-is-terminal+default-devel \
 rust-slog+default-devel \
 rust-term+default-devel \
 rust-thread_local+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time-devel \
 "
