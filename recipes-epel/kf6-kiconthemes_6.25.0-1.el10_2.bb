# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kiconthemes"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kiconthemes \
 kf6-kiconthemes-devel \
 kf6-kiconthemes-doc \
 kf6-kiconthemes-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kiconthemes-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6145e722149520b461cdd93ea2325d03803ea828f775887eab10a7ec42e2bd3c"

URI_x86_64_v2_kf6-kiconthemes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kiconthemes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kiconthemes}"
SRC_URI[x86_64_v2_kf6-kiconthemes.sha256sum] = "0e78237cf0907a1ad8e7f2b428df2d18f1b99c61789faffceca2ac59f6dc2217"

URI_x86_64_v2_kf6-kiconthemes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kiconthemes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kiconthemes-devel}"
SRC_URI[x86_64_v2_kf6-kiconthemes-devel.sha256sum] = "a96681fd4cf344e1481d02289956b7b341bf42bd2b82f626d27b1eccfc5b7c57"

URI_x86_64_v2_kf6-kiconthemes-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kiconthemes-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kiconthemes-doc}"
SRC_URI[x86_64_v2_kf6-kiconthemes-doc.sha256sum] = "c4dc6b41a2d634d0f6c0c9b4d0a1ed0e8c985f6a590f18f5911daa2d199f0b8c"

URI_x86_64_v2_kf6-kiconthemes-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kiconthemes-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kiconthemes-html}"
SRC_URI[x86_64_v2_kf6-kiconthemes-html.sha256sum] = "33a72d0870a36dc31c8633dfb0f4b8ce1fc84204cc795ad0f7ef8172008512dd"

URI_aarch64_kf6-kiconthemes = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kiconthemes;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kiconthemes}"
SRC_URI[aarch64_kf6-kiconthemes.sha256sum] = "8d17f080332e62e24358ab3b33f06a75b0070078120c7be9ef4a30e53aa700ba"

URI_aarch64_kf6-kiconthemes-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kiconthemes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kiconthemes-devel}"
SRC_URI[aarch64_kf6-kiconthemes-devel.sha256sum] = "fb541156afd2f9c8cf99daa0a219420a142eaddc4e291b03605600acab519ee9"

URI_aarch64_kf6-kiconthemes-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kiconthemes-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kiconthemes-doc}"
SRC_URI[aarch64_kf6-kiconthemes-doc.sha256sum] = "81060aec441404bfc569a36b0b40cd8b8154ed8a9159b0787216ea5fdda042fd"

URI_aarch64_kf6-kiconthemes-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kiconthemes-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kiconthemes-html}"
SRC_URI[aarch64_kf6-kiconthemes-html.sha256sum] = "010435f02236070fe2013fd3f91100c81249e8c5343c7f53f7efab7ddb93a3c3"

RDEPENDS:kf6-kiconthemes = " \
 glibc \
 hicolor-icon-theme \
 kf6-breeze-icons \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kiconthemes-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kiconthemes \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kiconthemes-doc = " \
 "
RDEPENDS:kf6-kiconthemes-html = " \
 "
