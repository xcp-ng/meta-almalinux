# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-timer"
PV = "3.0.3"
PR = "2.el10_0"
PACKAGES = " \
 rust-futures-timer+default-devel \
 rust-futures-timer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-timer-3.0.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8b2ec05540e64fcac7cf51c78633cea2f68f058d96428d1b26b23b8c0a644ca"

URI_x86_64_v2_rust-futures-timer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-timer+default-devel-3.0.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-timer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-timer+default-devel}"
SRC_URI[x86_64_v2_rust-futures-timer+default-devel.sha256sum] = "69cd90bf90853f7c1bf6e2716f0e56532fc6e538cf8c05c0e85b06af547ad0de"

URI_x86_64_v2_rust-futures-timer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-timer-devel-3.0.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-timer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-timer-devel}"
SRC_URI[x86_64_v2_rust-futures-timer-devel.sha256sum] = "cad5a13274d602e9827b29acf37f0ebae97e16b2c66b5b97d3f49f71e0f43238"

URI_aarch64_rust-futures-timer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-timer+default-devel-3.0.3-2.el10_0.noarch.rpm;name=aarch64_rust-futures-timer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-timer+default-devel}"
SRC_URI[aarch64_rust-futures-timer+default-devel.sha256sum] = "72a81873a359ea8f061d303a9d8562aeaa086772053c2a2fd00254af002836bb"

URI_aarch64_rust-futures-timer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-timer-devel-3.0.3-2.el10_0.noarch.rpm;name=aarch64_rust-futures-timer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-timer-devel}"
SRC_URI[aarch64_rust-futures-timer-devel.sha256sum] = "19ca01695fdc81dfd939391b6fbeb39c0257754b3badba1a9c6a1b59076b2bf6"

RDEPENDS:rust-futures-timer+default-devel = " \
 cargo \
 rust-futures-timer-devel \
 "
RDEPENDS:rust-futures-timer-devel = " \
 cargo \
 "
