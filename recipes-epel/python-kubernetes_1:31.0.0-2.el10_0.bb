# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-kubernetes"
PE = "1"
PV = "31.0.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-kubernetes \
 python3-kubernetes-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-kubernetes-31.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eef9d979826bb7b30c9862180a2774b7037ed0ead4024017c551c7dc7f316916"

URI_x86_64_v2_python3-kubernetes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kubernetes-31.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kubernetes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kubernetes}"
SRC_URI[x86_64_v2_python3-kubernetes.sha256sum] = "ccecf3e27dded00c15e7bd2710415ffb224a9923cc8fd2ffe3952126c66c6d79"

URI_x86_64_v2_python3-kubernetes-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kubernetes-tests-31.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kubernetes-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kubernetes-tests}"
SRC_URI[x86_64_v2_python3-kubernetes-tests.sha256sum] = "0c892f667f389fe69b6820290a49624af02508b67c07765d4179a7d58d28d5e3"

URI_aarch64_python3-kubernetes = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kubernetes-31.0.0-2.el10_0.noarch.rpm;name=aarch64_python3-kubernetes;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kubernetes}"
SRC_URI[aarch64_python3-kubernetes.sha256sum] = "1b98085b3e2a8aaf5612ba2b92df9421b1a47ddb5ebcd6999d11b9d962e5ea5c"

URI_aarch64_python3-kubernetes-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kubernetes-tests-31.0.0-2.el10_0.noarch.rpm;name=aarch64_python3-kubernetes-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kubernetes-tests}"
SRC_URI[aarch64_python3-kubernetes-tests.sha256sum] = "e2580d9f833dbeabded0e393506e2b429cf3cbca3e097875afe68ddecde943ef"

RDEPENDS:python3-kubernetes = " \
 python3 \
 python3-certifi \
 python3-dateutil \
 python3-durationpy \
 python3-google-auth \
 python3-oauthlib \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-six \
 python3-urllib3 \
 python3-websocket-client \
 "
RDEPENDS:python3-kubernetes-tests = " \
 python3 \
 python3-kubernetes \
 "
