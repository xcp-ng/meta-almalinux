# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtwayland"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtwayland \
 qt5-qtwayland-devel \
 qt5-qtwayland-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtwayland-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8002806dae02ca112f0dc961886d0d36ef7d12e3bf9c397faa52662928f68c25"

URI_x86_64_v2_qt5-qtwayland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwayland-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwayland}"
SRC_URI[x86_64_v2_qt5-qtwayland.sha256sum] = "af71ddcc685ef7d1ff0473b72aec6e50a76614f2abbccac73ebbdde02a6a6c42"

URI_x86_64_v2_qt5-qtwayland-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwayland-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwayland-devel}"
SRC_URI[x86_64_v2_qt5-qtwayland-devel.sha256sum] = "07ec364a7e28e6c6fa5ee4f9ff6deab772b4db68103c384df20d457cadc01d72"

URI_x86_64_v2_qt5-qtwayland-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwayland-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwayland-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwayland-examples}"
SRC_URI[x86_64_v2_qt5-qtwayland-examples.sha256sum] = "04ab38ccf5ef8676b150a169fddd0dfeffd25fa2bd6b5cd49814812acdeeebe5"

URI_aarch64_qt5-qtwayland = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwayland-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtwayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwayland}"
SRC_URI[aarch64_qt5-qtwayland.sha256sum] = "bcfa68c3a47a45199b479b730e79751a0e376d5d016aac950cf1433b6c46fd69"

URI_aarch64_qt5-qtwayland-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwayland-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtwayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwayland-devel}"
SRC_URI[aarch64_qt5-qtwayland-devel.sha256sum] = "7e3d789af3d570dcda0e6e4234171ba10d6551408372db0e75a74e5a0f979a2d"

URI_aarch64_qt5-qtwayland-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwayland-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtwayland-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwayland-examples}"
SRC_URI[aarch64_qt5-qtwayland-examples.sha256sum] = "d5627cade1027528134a8db12823cdf5db7ba899752f6d019e469b2c23ffc0cb"

RDEPENDS:qt5-qtwayland = " \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 libX11 \
 libXcomposite \
 libglvnd-egl \
 libglvnd-glx \
 libstdc++ \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libwayland-server \
 libxkbcommon \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtwayland-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtwayland \
 "
RDEPENDS:qt5-qtwayland-examples = " \
 glibc \
 libglvnd-glx \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtwayland \
 "
