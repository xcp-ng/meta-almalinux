# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "SDL2_ttf"
PV = "2.24.0"
PR = "1.el10_1"
PACKAGES = " \
 SDL2_ttf \
 SDL2_ttf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/SDL2_ttf-2.24.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f39e71affabfa9ab3aea3bc2727f7883a8c9982bcaec6630b6119c9b4d83f3c"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - SDL2_ttf-devel: SDL2-devel(x86-64)
# - SDL2_ttf-devel: pkgconfig(sdl2) >= 2.0.10

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - SDL2_ttf-devel: SDL2-devel(aarch-64)
# - SDL2_ttf-devel: pkgconfig(sdl2) >= 2.0.10

URI_x86_64_v2_SDL2_ttf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SDL2_ttf-2.24.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SDL2_ttf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL2_ttf}"
SRC_URI[x86_64_v2_SDL2_ttf.sha256sum] = "67c090d4a5f20229dc350e31eeb3cfd00752bbdd8618f9fb53f71535d14c6af8"

URI_x86_64_v2_SDL2_ttf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SDL2_ttf-devel-2.24.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SDL2_ttf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL2_ttf-devel}"
SRC_URI[x86_64_v2_SDL2_ttf-devel.sha256sum] = "733359389357b60800bbd773ef50c4c8a3a6f7e4eff597f4a29e5295a6584805"

URI_aarch64_SDL2_ttf = "${EPEL_MIRROR}/aarch64/Packages/s/SDL2_ttf-2.24.0-1.el10_1.aarch64.rpm;name=aarch64_SDL2_ttf;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL2_ttf}"
SRC_URI[aarch64_SDL2_ttf.sha256sum] = "963c2f0b9ce75c3f5db872d04b958b17596619f2dba7dc57eb8bf6125d048db0"

URI_aarch64_SDL2_ttf-devel = "${EPEL_MIRROR}/aarch64/Packages/s/SDL2_ttf-devel-2.24.0-1.el10_1.aarch64.rpm;name=aarch64_SDL2_ttf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL2_ttf-devel}"
SRC_URI[aarch64_SDL2_ttf-devel.sha256sum] = "3d5eee8d02b23619fdd85ce8e28377d4d83d4ba39b3b6d01d013989e81ddbc3b"

RDEPENDS:SDL2_ttf = " \
 freetype \
 glibc \
 harfbuzz \
 sdl2-compat \
 "
RDEPENDS:SDL2_ttf-devel = " \
 SDL2_ttf \
 cmake-filesystem \
 freetype-devel \
 harfbuzz-devel \
 pkgconf-pkg-config \
 "
