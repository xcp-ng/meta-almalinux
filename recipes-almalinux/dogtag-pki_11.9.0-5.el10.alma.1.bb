# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dogtag-pki"
PV = "11.9.0"
PR = "5.el10.alma.1"
PACKAGES = " \
 idm-pki-acme \
 idm-pki-base \
 idm-pki-ca \
 idm-pki-java \
 idm-pki-kra \
 idm-pki-server \
 idm-pki-tools \
 python3-idm-pki \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dogtag-pki-11.9.0-5.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d727b6e4118210038720038b2b73925cf82690f7740f1cc843ee4ef8ce7f22c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-acme-11.9.0-5.el10.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-acme;unpack=0"
SRC_URI[x86_64_v2_idm-pki-acme.sha256sum] = "c07d276b2009e07e802cfc8dea6e7930f70074f5dbcc7ccffaa56db84a0febdd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-base-11.9.0-5.el10.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-base;unpack=0"
SRC_URI[x86_64_v2_idm-pki-base.sha256sum] = "c4ae42a3fe27329102bba76b90a9cd735f1320f7d739f4c7c0a8dcdb995aa51b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-ca-11.9.0-5.el10.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-ca;unpack=0"
SRC_URI[x86_64_v2_idm-pki-ca.sha256sum] = "bd64b77b016a95ac417548773de76798bc9ee7597699cf27da5c7e6913b492a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-java-11.9.0-5.el10.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-java;unpack=0"
SRC_URI[x86_64_v2_idm-pki-java.sha256sum] = "b24db83561dd975e8da8aedeec1b6c8e424af682f2b4c3b78268d2dfccd49f76"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-kra-11.9.0-5.el10.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-kra;unpack=0"
SRC_URI[x86_64_v2_idm-pki-kra.sha256sum] = "6731ece63dc5158f232fc4aef61d3748a5cf19e01121d311b68f7099cdd44c61"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-server-11.9.0-5.el10.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-server;unpack=0"
SRC_URI[x86_64_v2_idm-pki-server.sha256sum] = "04c3aaa2d3703cd5ca986fe42c41cd0af5f74a91ce76051b9a5bfce7bd499102"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-tools-11.9.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_idm-pki-tools;unpack=0"
SRC_URI[x86_64_v2_idm-pki-tools.sha256sum] = "50b98c8c403d06ad7677615f5b527a17b878bc35aa4330accf6fd1408f4b1707"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-idm-pki-11.9.0-5.el10.alma.1.noarch.rpm;name=x86_64_v2_python3-idm-pki;unpack=0"
SRC_URI[x86_64_v2_python3-idm-pki.sha256sum] = "8436427875a219fa16eeb5f32e7e213c301ddc424c2f443098c1fef0acf34c00"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-acme-11.9.0-5.el10.alma.1.noarch.rpm;name=aarch64_idm-pki-acme;unpack=0"
SRC_URI[aarch64_idm-pki-acme.sha256sum] = "c07d276b2009e07e802cfc8dea6e7930f70074f5dbcc7ccffaa56db84a0febdd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-base-11.9.0-5.el10.alma.1.noarch.rpm;name=aarch64_idm-pki-base;unpack=0"
SRC_URI[aarch64_idm-pki-base.sha256sum] = "c4ae42a3fe27329102bba76b90a9cd735f1320f7d739f4c7c0a8dcdb995aa51b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-ca-11.9.0-5.el10.alma.1.noarch.rpm;name=aarch64_idm-pki-ca;unpack=0"
SRC_URI[aarch64_idm-pki-ca.sha256sum] = "bd64b77b016a95ac417548773de76798bc9ee7597699cf27da5c7e6913b492a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-java-11.9.0-5.el10.alma.1.noarch.rpm;name=aarch64_idm-pki-java;unpack=0"
SRC_URI[aarch64_idm-pki-java.sha256sum] = "b24db83561dd975e8da8aedeec1b6c8e424af682f2b4c3b78268d2dfccd49f76"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-kra-11.9.0-5.el10.alma.1.noarch.rpm;name=aarch64_idm-pki-kra;unpack=0"
SRC_URI[aarch64_idm-pki-kra.sha256sum] = "6731ece63dc5158f232fc4aef61d3748a5cf19e01121d311b68f7099cdd44c61"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-server-11.9.0-5.el10.alma.1.noarch.rpm;name=aarch64_idm-pki-server;unpack=0"
SRC_URI[aarch64_idm-pki-server.sha256sum] = "04c3aaa2d3703cd5ca986fe42c41cd0af5f74a91ce76051b9a5bfce7bd499102"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-tools-11.9.0-5.el10.alma.1.aarch64.rpm;name=aarch64_idm-pki-tools;unpack=0"
SRC_URI[aarch64_idm-pki-tools.sha256sum] = "8dddc86fc548cb581a128384969a213d76fd2bc8859909a25aa2dac1a227e379"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-idm-pki-11.9.0-5.el10.alma.1.noarch.rpm;name=aarch64_python3-idm-pki;unpack=0"
SRC_URI[aarch64_python3-idm-pki.sha256sum] = "8436427875a219fa16eeb5f32e7e213c301ddc424c2f443098c1fef0acf34c00"

RDEPENDS:idm-pki-acme = " \
 bash \
 idm-pki-server \
 "
RDEPENDS:idm-pki-base = " \
 bash \
 nss \
 python3-idm-pki \
 "
RDEPENDS:idm-pki-ca = " \
 bash \
 idm-pki-server \
 systemd \
 "
RDEPENDS:idm-pki-java = " \
 apache-commons-cli \
 apache-commons-codec \
 apache-commons-io \
 apache-commons-lang3 \
 apache-commons-logging \
 apache-commons-net \
 httpcomponents-client \
 idm-jss \
 idm-ldapjdk \
 idm-pki-base \
 java-21-openjdk-headless \
 slf4j \
 slf4j-jdk14 \
 "
RDEPENDS:idm-pki-kra = " \
 bash \
 idm-pki-server \
 systemd \
 "
RDEPENDS:idm-pki-server = " \
 bash \
 hostname \
 idm-jss-tomcat \
 idm-pki-tools \
 ipa-healthcheck-core \
 java-21-openjdk-headless \
 keyutils \
 openldap-clients \
 openssl \
 policycoreutils \
 policycoreutils-python-utils \
 procps-ng \
 python3 \
 python3-libselinux \
 python3-lxml \
 python3-policycoreutils \
 selinux-policy-targeted \
 shadow-utils \
 systemd \
 tomcat \
 unzip \
 "
RDEPENDS:idm-pki-tools = " \
 bash \
 file \
 glibc \
 idm-pki-java \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 nss-tools \
 openldap \
 openldap-clients \
 openssl \
 p11-kit-trust \
 "
RDEPENDS:python3-idm-pki = " \
 idm-pki-base \
 python3 \
 python3-cryptography \
 python3-ldap \
 python3-lxml \
 python3-requests \
 python3-six \
 "
