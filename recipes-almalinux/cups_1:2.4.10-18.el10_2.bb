# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cups"
PE = "1"
PV = "2.4.10"
PR = "18.el10_2"
PACKAGES = " \
 cups \
 cups-client \
 cups-devel \
 cups-filesystem \
 cups-ipptool \
 cups-libs \
 cups-lpd \
 cups-printerapp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cups-2.4.10-18.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75b946ac55c727468369432fc41b7e2290f43bc3f88c5150fea0bebe1b3d76d7"

URI_x86_64_v2_cups = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-2.4.10-18.el10_2.x86_64_v2.rpm;name=x86_64_v2_cups;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups}"
SRC_URI[x86_64_v2_cups.sha256sum] = "b3b673987c8ecfa27357f873b93120b39231c081129efcc46e24cdb0c2f3c159"

URI_x86_64_v2_cups-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-client-2.4.10-18.el10_2.x86_64_v2.rpm;name=x86_64_v2_cups-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-client}"
SRC_URI[x86_64_v2_cups-client.sha256sum] = "0accd6275be42ffe6394fa9d3ca1e6a905844e9481e5b3d4b1e0548672a3793d"

URI_x86_64_v2_cups-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-devel-2.4.10-18.el10_2.x86_64_v2.rpm;name=x86_64_v2_cups-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-devel}"
SRC_URI[x86_64_v2_cups-devel.sha256sum] = "e8901fc973ec37afb159a9c4cb75bce71ac04c4d589bbf5d8acf9119c43cb8b5"

URI_x86_64_v2_cups-filesystem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cups-filesystem-2.4.10-18.el10_2.noarch.rpm;name=x86_64_v2_cups-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-filesystem}"
SRC_URI[x86_64_v2_cups-filesystem.sha256sum] = "6f5fd910d9c2ae41a126bace532550a15272499b3d9cafba9217092283b872ff"

URI_x86_64_v2_cups-ipptool = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-ipptool-2.4.10-18.el10_2.x86_64_v2.rpm;name=x86_64_v2_cups-ipptool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-ipptool}"
SRC_URI[x86_64_v2_cups-ipptool.sha256sum] = "9dbbe06af9aa38dc10f4a1081f4c80414dd4f5c13b77211dafd641033e03d9e7"

URI_x86_64_v2_cups-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cups-libs-2.4.10-18.el10_2.x86_64_v2.rpm;name=x86_64_v2_cups-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-libs}"
SRC_URI[x86_64_v2_cups-libs.sha256sum] = "4d561d4b2d2bc139554de05a629b5f79d95a0c05d9b33b1003ddac00db4e13d2"

URI_x86_64_v2_cups-lpd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-lpd-2.4.10-18.el10_2.x86_64_v2.rpm;name=x86_64_v2_cups-lpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-lpd}"
SRC_URI[x86_64_v2_cups-lpd.sha256sum] = "d04e6afa6daa7639465e73572a5788943be2aefb2e6e610712428258a0437a56"

URI_x86_64_v2_cups-printerapp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-printerapp-2.4.10-18.el10_2.x86_64_v2.rpm;name=x86_64_v2_cups-printerapp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-printerapp}"
SRC_URI[x86_64_v2_cups-printerapp.sha256sum] = "76d2bac4bf175154ba7237c800d3e0fa31f17ccf80477692ba086853ebf831a9"

URI_aarch64_cups = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-2.4.10-18.el10_2.aarch64.rpm;name=aarch64_cups;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups}"
SRC_URI[aarch64_cups.sha256sum] = "17564567df6667cce2a007362bd80164e11c6934c3d4f753880ecceae427a338"

URI_aarch64_cups-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-client-2.4.10-18.el10_2.aarch64.rpm;name=aarch64_cups-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-client}"
SRC_URI[aarch64_cups-client.sha256sum] = "84f08d5e0575ec30584e6df4436cba9dac35c9e1ab78ad1568bda41a22b83335"

URI_aarch64_cups-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-devel-2.4.10-18.el10_2.aarch64.rpm;name=aarch64_cups-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-devel}"
SRC_URI[aarch64_cups-devel.sha256sum] = "cd036a7cc316addacb8d92a0bd439a71ecafb3294e26688a068998d83abfc6c7"

URI_aarch64_cups-filesystem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cups-filesystem-2.4.10-18.el10_2.noarch.rpm;name=aarch64_cups-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-filesystem}"
SRC_URI[aarch64_cups-filesystem.sha256sum] = "6f5fd910d9c2ae41a126bace532550a15272499b3d9cafba9217092283b872ff"

URI_aarch64_cups-ipptool = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-ipptool-2.4.10-18.el10_2.aarch64.rpm;name=aarch64_cups-ipptool;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-ipptool}"
SRC_URI[aarch64_cups-ipptool.sha256sum] = "c0ca59a9b5e8d2ecd8dc6941c250f18be0f16cbbaaee048336907fcb0a731146"

URI_aarch64_cups-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cups-libs-2.4.10-18.el10_2.aarch64.rpm;name=aarch64_cups-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-libs}"
SRC_URI[aarch64_cups-libs.sha256sum] = "3a1744a8c553c07fff24890b21587d7ae018322efd6afb4f19439304a4259b94"

URI_aarch64_cups-lpd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-lpd-2.4.10-18.el10_2.aarch64.rpm;name=aarch64_cups-lpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-lpd}"
SRC_URI[aarch64_cups-lpd.sha256sum] = "fb91a2702fd2311d39cc4afcfd03a29a5e17b7f58a203fb5802690af15a72920"

URI_aarch64_cups-printerapp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-printerapp-2.4.10-18.el10_2.aarch64.rpm;name=aarch64_cups-printerapp;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-printerapp}"
SRC_URI[aarch64_cups-printerapp.sha256sum] = "9b736169c77a3a9495411b58a197ee1e8c576d5415f0cc6163f24255f611eaf7"

RDEPENDS:cups = " \
 acl \
 audit-libs \
 avahi-libs \
 bash \
 cups-client \
 cups-filesystem \
 cups-filters \
 cups-libs \
 dbus \
 dbus-libs \
 glibc \
 grep \
 krb5-libs \
 libacl \
 libgcc \
 libselinux \
 libstdc++ \
 libusb1 \
 pam-libs \
 python3 \
 sed \
 systemd \
 systemd-libs \
 "
RDEPENDS:cups-client = " \
 alternatives \
 bash \
 cups-libs \
 glibc \
 "
RDEPENDS:cups-devel = " \
 avahi-devel \
 bash \
 cups-libs \
 gnutls-devel \
 krb5-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:cups-filesystem = " \
 "
RDEPENDS:cups-ipptool = " \
 avahi \
 avahi-libs \
 cups-libs \
 glibc \
 "
RDEPENDS:cups-libs = " \
 avahi-libs \
 cups-filesystem \
 glibc \
 gnutls \
 krb5-libs \
 zlib-ng-compat \
 "
RDEPENDS:cups-lpd = " \
 bash \
 cups \
 cups-libs \
 glibc \
 "
RDEPENDS:cups-printerapp = " \
 avahi \
 avahi-libs \
 cups-libs \
 glibc \
 pam-libs \
 "
