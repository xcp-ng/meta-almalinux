# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-protocols"
PV = "0.32.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-wayland-protocols+client-devel \
 rust-wayland-protocols+default-devel \
 rust-wayland-protocols+server-devel \
 rust-wayland-protocols+staging-devel \
 rust-wayland-protocols+unstable-devel \
 rust-wayland-protocols+wayland-client-devel \
 rust-wayland-protocols+wayland-server-devel \
 rust-wayland-protocols-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-protocols-0.32.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32b04c21d025bb932298eec1b35797cc948bbc3639fe23348ad01c23bb809101"

URI_x86_64_v2_rust-wayland-protocols+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+client-devel-0.32.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+client-devel.sha256sum] = "e6e3193059a584ae9c7f80f9adfccefcfdaaf81f84a3b79fc7489f733abd0c98"

URI_x86_64_v2_rust-wayland-protocols+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+default-devel-0.32.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+default-devel.sha256sum] = "b883dd7ffd46c50e13ad0398499cb9ae807399e6a97aa3cd748c298ea735102f"

URI_x86_64_v2_rust-wayland-protocols+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+server-devel-0.32.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+server-devel.sha256sum] = "9685db8d853c8d0f85e9b793d337b29267947da20082ebe2b550149990b857b4"

URI_x86_64_v2_rust-wayland-protocols+staging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+staging-devel-0.32.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+staging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+staging-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+staging-devel.sha256sum] = "ad4883aa499a73d2fe9325f6b0c8bb76a7bcdf1b55834b02f06c79dbf87badec"

URI_x86_64_v2_rust-wayland-protocols+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+unstable-devel-0.32.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+unstable-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+unstable-devel.sha256sum] = "942ba276ae861b1db4cca97aaa20380367c7df4925fd99cc4ece69fe207e4a99"

URI_x86_64_v2_rust-wayland-protocols+wayland-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+wayland-client-devel-0.32.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+wayland-client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+wayland-client-devel.sha256sum] = "92c2b4dc8ca5d9b7b0855cad2da176deab497699a9194ec14b00fffd164b3109"

URI_x86_64_v2_rust-wayland-protocols+wayland-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+wayland-server-devel-0.32.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+wayland-server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+wayland-server-devel.sha256sum] = "71e7bcab30c5761737053a41010879129237d0de6d4ae84cb9e33458efc87f0c"

URI_x86_64_v2_rust-wayland-protocols-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-devel-0.32.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-devel.sha256sum] = "96065d7aa15053417d8ba255573ac778bcac50abbc2ba5488c4b84041420f457"

URI_aarch64_rust-wayland-protocols+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+client-devel-0.32.10-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-protocols+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+client-devel}"
SRC_URI[aarch64_rust-wayland-protocols+client-devel.sha256sum] = "405fa5bcbc08aed4814fb2788a02b15dab66f48e69c17c46c86d207830c9d38f"

URI_aarch64_rust-wayland-protocols+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+default-devel-0.32.10-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-protocols+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+default-devel}"
SRC_URI[aarch64_rust-wayland-protocols+default-devel.sha256sum] = "afd8310f058a63dd4fb9549a78d8d48a819f31e1c8a0339d90aaef3de6587d47"

URI_aarch64_rust-wayland-protocols+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+server-devel-0.32.10-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-protocols+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+server-devel}"
SRC_URI[aarch64_rust-wayland-protocols+server-devel.sha256sum] = "4c0ba35b7df30bfc3a301d15e3c7dafda8ca14151439e7d7ce2973c5b66b660c"

URI_aarch64_rust-wayland-protocols+staging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+staging-devel-0.32.10-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-protocols+staging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+staging-devel}"
SRC_URI[aarch64_rust-wayland-protocols+staging-devel.sha256sum] = "64f7da7e422aab50be399d42ea2972fd8eb0861784a8335e29069bcb509213b9"

URI_aarch64_rust-wayland-protocols+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+unstable-devel-0.32.10-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-protocols+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+unstable-devel}"
SRC_URI[aarch64_rust-wayland-protocols+unstable-devel.sha256sum] = "40de1daae9267daf168302ab8a1486d1928ef5b64732826c5d3836fdd1504431"

URI_aarch64_rust-wayland-protocols+wayland-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+wayland-client-devel-0.32.10-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-protocols+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+wayland-client-devel}"
SRC_URI[aarch64_rust-wayland-protocols+wayland-client-devel.sha256sum] = "53335dc6865c3ee9d86bc6da04fb61f9793cd020e8d466584d2a736623c93e32"

URI_aarch64_rust-wayland-protocols+wayland-server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+wayland-server-devel-0.32.10-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-protocols+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+wayland-server-devel}"
SRC_URI[aarch64_rust-wayland-protocols+wayland-server-devel.sha256sum] = "cee6e075fe9a4a4bdc87b0ada6be5682661fbd4ed183a6adfa33066020e6af10"

URI_aarch64_rust-wayland-protocols-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-devel-0.32.10-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-devel}"
SRC_URI[aarch64_rust-wayland-protocols-devel.sha256sum] = "723ebef26881397c63c877c35c852a3ac9a3727351dc0444ee0a2268874bd77a"

RDEPENDS:rust-wayland-protocols+client-devel = " \
 cargo \
 rust-wayland-protocols+wayland-client-devel \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+default-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+server-devel = " \
 cargo \
 rust-wayland-protocols+wayland-server-devel \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+staging-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+unstable-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+wayland-client-devel = " \
 cargo \
 rust-wayland-client+default-devel \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+wayland-server-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 rust-wayland-server+default-devel \
 "
RDEPENDS:rust-wayland-protocols-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-scanner+default-devel \
 "
