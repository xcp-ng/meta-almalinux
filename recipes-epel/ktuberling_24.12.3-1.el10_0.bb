# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktuberling"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 ktuberling \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktuberling-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3dbb2cc73fae4e558a2e769c896a6d06657139db2ccd3678a545df800360fa88"

URI_x86_64_v2_ktuberling = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktuberling-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktuberling;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktuberling}"
SRC_URI[x86_64_v2_ktuberling.sha256sum] = "98acdfe64b3ccad11a7f909c8c68ec5f6614d1064419d3208d798290f15901b3"

URI_aarch64_ktuberling = "${EPEL_MIRROR}/aarch64/Packages/k/ktuberling-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ktuberling;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktuberling}"
SRC_URI[aarch64_ktuberling.sha256sum] = "0c21cd23afa1510432439229da3b131fd4086e0dd56ad371ba5fa6d1c4ddd9be"

RDEPENDS:ktuberling = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
