# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-haskell-lexer"
PV = "1.1.1"
PR = "7.el10_0"
PACKAGES = " \
 ghc-haskell-lexer \
 ghc-haskell-lexer-devel \
 ghc-haskell-lexer-doc \
 ghc-haskell-lexer-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-haskell-lexer-1.1.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f10d41ddc1c9846238469dba6a2e457409c1d124ca20c3d682fd1c2bfc7371b"

URI_x86_64_v2_ghc-haskell-lexer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskell-lexer-1.1.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haskell-lexer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskell-lexer}"
SRC_URI[x86_64_v2_ghc-haskell-lexer.sha256sum] = "bb2363d4b31de4f741a865c8d38cb5ee69e3f4948bf8b261673d4510f432a5e4"

URI_x86_64_v2_ghc-haskell-lexer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskell-lexer-devel-1.1.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haskell-lexer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskell-lexer-devel}"
SRC_URI[x86_64_v2_ghc-haskell-lexer-devel.sha256sum] = "714acada4696b3a66ae672aedf14aa14a04d5b04ee55dae3e0fc1cc36bfc2ede"

URI_x86_64_v2_ghc-haskell-lexer-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskell-lexer-doc-1.1.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-haskell-lexer-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskell-lexer-doc}"
SRC_URI[x86_64_v2_ghc-haskell-lexer-doc.sha256sum] = "5ca731e935a9e6d1bca857bbbe9ce237fc08ebc52f40ad03a5d72a540a062a24"

URI_x86_64_v2_ghc-haskell-lexer-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskell-lexer-prof-1.1.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haskell-lexer-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskell-lexer-prof}"
SRC_URI[x86_64_v2_ghc-haskell-lexer-prof.sha256sum] = "743cf119e800cd4cd1f5a6c5999d752437c81faf3a9a6b3be7486920d1905e4a"

URI_aarch64_ghc-haskell-lexer = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskell-lexer-1.1.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-haskell-lexer;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskell-lexer}"
SRC_URI[aarch64_ghc-haskell-lexer.sha256sum] = "eb2ea07131d8e7a1da591a47150557aa6fc3e14337119575780cb72cf56e92a6"

URI_aarch64_ghc-haskell-lexer-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskell-lexer-devel-1.1.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-haskell-lexer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskell-lexer-devel}"
SRC_URI[aarch64_ghc-haskell-lexer-devel.sha256sum] = "993458a59206d3e4b8b0d6fc50ec5fdc4ac33c08fc7b2414f121e927550c1960"

URI_aarch64_ghc-haskell-lexer-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskell-lexer-doc-1.1.1-7.el10_0.noarch.rpm;name=aarch64_ghc-haskell-lexer-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskell-lexer-doc}"
SRC_URI[aarch64_ghc-haskell-lexer-doc.sha256sum] = "b48a648a1ea9b6a0666a6cb7aac42823d863eacc5f2b6dd17aa5cecbbb4980b3"

URI_aarch64_ghc-haskell-lexer-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskell-lexer-prof-1.1.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-haskell-lexer-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskell-lexer-prof}"
SRC_URI[aarch64_ghc-haskell-lexer-prof.sha256sum] = "6bf77272021b20eb29556513ac70d52cf02e4b3a8c1849c840bd595edb840da6"

RDEPENDS:ghc-haskell-lexer = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-haskell-lexer-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-haskell-lexer \
 "
RDEPENDS:ghc-haskell-lexer-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-haskell-lexer-prof = " \
 ghc-base-prof \
 ghc-haskell-lexer-devel \
 "
