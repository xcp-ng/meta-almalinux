# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcontacts"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kcontacts \
 kf6-kcontacts-devel \
 kf6-kcontacts-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcontacts-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "744899b70a0e4246b5312696e6f3e981d7dc41891651bd6f95df1d0f8295efbe"

URI_x86_64_v2_kf6-kcontacts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcontacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcontacts}"
SRC_URI[x86_64_v2_kf6-kcontacts.sha256sum] = "1c863aea1696fefaf18a6e954b954b7e44fca6184ec6a8f196e99bb67d5cbcf7"

URI_x86_64_v2_kf6-kcontacts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcontacts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcontacts-devel}"
SRC_URI[x86_64_v2_kf6-kcontacts-devel.sha256sum] = "67d5606a0427bdb5b6e1e81f0675cb4e1544ab1d1e3bda8fe5da906f346aaa12"

URI_x86_64_v2_kf6-kcontacts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcontacts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcontacts-doc}"
SRC_URI[x86_64_v2_kf6-kcontacts-doc.sha256sum] = "9e1e5613011b07b35b5e8b7357ec3e9af6a28da3894af45837f16742ed23d997"

URI_aarch64_kf6-kcontacts = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcontacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcontacts}"
SRC_URI[aarch64_kf6-kcontacts.sha256sum] = "2236783dfbbb9e5629b240e36faeee952d089e4f4dafb2cfa649391de631a575"

URI_aarch64_kf6-kcontacts-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcontacts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcontacts-devel}"
SRC_URI[aarch64_kf6-kcontacts-devel.sha256sum] = "fbdac7b90a31b55793e1076f94fc0e0711ef28cd155877b251bcf4aacf92d6a3"

URI_aarch64_kf6-kcontacts-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kcontacts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcontacts-doc}"
SRC_URI[aarch64_kf6-kcontacts-doc.sha256sum] = "9ccf4bc73acf322b5623c448122f5da6fedb3f4c5ec7617fe7712184eedd6961"

RDEPENDS:kf6-kcontacts = " \
 glibc \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcontacts-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kcodecs-devel \
 kf6-kcontacts \
 kf6-kcoreaddons-devel \
 kf6-ki18n-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcontacts-doc = " \
 "
