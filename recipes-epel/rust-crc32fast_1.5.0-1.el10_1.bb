# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crc32fast"
PV = "1.5.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-crc32fast+default-devel \
 rust-crc32fast+nightly-devel \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crc32fast-1.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72bd101d6638b1f9211732dc35fbb7747a0968e39801ceec591fc6e941741c46"

URI_x86_64_v2_rust-crc32fast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast+default-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc32fast+default-devel}"
SRC_URI[x86_64_v2_rust-crc32fast+default-devel.sha256sum] = "129506532f060c5c89364d408fcb9e6552c0b45375c97250c20d57a7775d1c9e"

URI_x86_64_v2_rust-crc32fast+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast+nightly-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc32fast+nightly-devel}"
SRC_URI[x86_64_v2_rust-crc32fast+nightly-devel.sha256sum] = "1919b5ca2f988a98064a5067dc982fb8e3ae6eec2d077a093e7f7c88f74dd804"

URI_x86_64_v2_rust-crc32fast+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast+std-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc32fast+std-devel}"
SRC_URI[x86_64_v2_rust-crc32fast+std-devel.sha256sum] = "871a13101c08fea662cc6bdb14f060f2c74d808820dad2c47f9a8c4d2d5309c2"

URI_x86_64_v2_rust-crc32fast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc32fast-devel}"
SRC_URI[x86_64_v2_rust-crc32fast-devel.sha256sum] = "6bed6ac5d1a515ee52d5e3dad48267f4ab7d85494eca7feb1154d9b6115cfa39"

URI_aarch64_rust-crc32fast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast+default-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-crc32fast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc32fast+default-devel}"
SRC_URI[aarch64_rust-crc32fast+default-devel.sha256sum] = "8b5e9ae1dd597f181abd672ddd0b369f0444d0af551b075efd6782a6978c2ba0"

URI_aarch64_rust-crc32fast+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast+nightly-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-crc32fast+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc32fast+nightly-devel}"
SRC_URI[aarch64_rust-crc32fast+nightly-devel.sha256sum] = "8e3bc172ebb93c32347ad7cabf5905a713b0cb6b2e2d33d04e4680d50e9de934"

URI_aarch64_rust-crc32fast+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast+std-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-crc32fast+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc32fast+std-devel}"
SRC_URI[aarch64_rust-crc32fast+std-devel.sha256sum] = "8de3f1da9351f79e2a61c0958f4b5ea07bdb69b2b3ea4121802e3517e346889f"

URI_aarch64_rust-crc32fast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-crc32fast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc32fast-devel}"
SRC_URI[aarch64_rust-crc32fast-devel.sha256sum] = "35ecca634463f6af985a5e8bdbf9df4058c6352cfa6b8404ea32440e58000c55"

RDEPENDS:rust-crc32fast+default-devel = " \
 cargo \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 "
RDEPENDS:rust-crc32fast+nightly-devel = " \
 cargo \
 rust-crc32fast-devel \
 "
RDEPENDS:rust-crc32fast+std-devel = " \
 cargo \
 rust-crc32fast-devel \
 "
RDEPENDS:rust-crc32fast-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 "
