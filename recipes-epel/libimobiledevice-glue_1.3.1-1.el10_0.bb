# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libimobiledevice-glue"
PV = "1.3.1"
PR = "1.el10_0"
PACKAGES = " \
 libimobiledevice-glue \
 libimobiledevice-glue-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libimobiledevice-glue-1.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d89ccb57850757bbdf25f68fc047f9d311bb4a19ff601eb4ec8b72213e9f795a"

URI_x86_64_v2_libimobiledevice-glue = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libimobiledevice-glue-1.3.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libimobiledevice-glue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libimobiledevice-glue}"
SRC_URI[x86_64_v2_libimobiledevice-glue.sha256sum] = "a4fc2f89cd867eca62b6994c5fdce8476efb5491e04cb10876c4a0b12ba9c093"

URI_x86_64_v2_libimobiledevice-glue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libimobiledevice-glue-devel-1.3.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libimobiledevice-glue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libimobiledevice-glue-devel}"
SRC_URI[x86_64_v2_libimobiledevice-glue-devel.sha256sum] = "686a4ef4d34309c2b8c11fbabf09d922be3f2441c98e61d2538d832d8bfb1ea1"

URI_aarch64_libimobiledevice-glue = "${EPEL_MIRROR}/aarch64/Packages/l/libimobiledevice-glue-1.3.1-1.el10_0.aarch64.rpm;name=aarch64_libimobiledevice-glue;unpack=0"
SRC_URI:append = " ${URI_aarch64_libimobiledevice-glue}"
SRC_URI[aarch64_libimobiledevice-glue.sha256sum] = "5b427771cd58e4023a6112c602004c771e8c50ad50dbc14edb655d475e89d318"

URI_aarch64_libimobiledevice-glue-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libimobiledevice-glue-devel-1.3.1-1.el10_0.aarch64.rpm;name=aarch64_libimobiledevice-glue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libimobiledevice-glue-devel}"
SRC_URI[aarch64_libimobiledevice-glue-devel.sha256sum] = "bba7a72825563eae3cf59b531839eb35fc7ab5d0ec2efd3a6690327bda89c322"

RDEPENDS:libimobiledevice-glue = " \
 glibc \
 libplist \
 "
RDEPENDS:libimobiledevice-glue-devel = " \
 libimobiledevice-glue \
 libplist-devel \
 pkgconf-pkg-config \
 "
