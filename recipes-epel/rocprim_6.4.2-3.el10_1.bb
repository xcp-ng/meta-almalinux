# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocprim"
PV = "6.4.2"
PR = "3.el10_1"
PACKAGES:x86_64_v2 = " \
 rocprim-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocprim-6.4.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d4b950ee430938e75d228f676e332ec57bfb970cbe4e29eef8788df726e4112"

URI_x86_64_v2_rocprim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocprim-devel-6.4.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rocprim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocprim-devel}"
SRC_URI[x86_64_v2_rocprim-devel.sha256sum] = "3a8ff610870016f0a19e0b79b8ac44d13efd29995f7e3dba6228a8bb1abf3840"

RDEPENDS:rocprim-devel = " \
 cmake-filesystem \
 "
