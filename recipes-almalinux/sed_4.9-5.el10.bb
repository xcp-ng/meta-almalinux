# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sed"
PV = "4.9"
PR = "5.el10"
PACKAGES = " \
 sed \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sed-4.9-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27aace64083b0f1de1f2d461a119378f650cdef4255de998c66c837fdfb38967"

URI_x86_64_v2_sed = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sed-4.9-5.el10.x86_64_v2.rpm;name=x86_64_v2_sed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sed}"
SRC_URI[x86_64_v2_sed.sha256sum] = "ceb561c43c39f0534795e2169972170f7e5dcd7e5d23b5ff8714b71a2f4ec3d5"

URI_aarch64_sed = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sed-4.9-5.el10.aarch64.rpm;name=aarch64_sed;unpack=0"
SRC_URI:append = " ${URI_aarch64_sed}"
SRC_URI[aarch64_sed.sha256sum] = "0868ca8ad17b5d571b6ac037fdd3bcf5025a2538703477e77068175ff880d7ab"

RDEPENDS:sed = " \
 glibc \
 libacl \
 libselinux \
 "
