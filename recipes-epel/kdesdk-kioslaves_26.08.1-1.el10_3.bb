# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdesdk-kioslaves"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kdesdk-kioslaves \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdesdk-kioslaves-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ef1403b9d247079210509b82ea3e7f955393bbf2e5a16591e91f74b3c0200070"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdesdk-kioslaves-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdesdk-kioslaves;unpack=0"
SRC_URI[x86_64_v2_kdesdk-kioslaves.sha256sum] = "70240d6719548beaeef6197184c90e31998234d8cf1d90a380b92eb1ff6f8d91"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdesdk-kioslaves-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdesdk-kioslaves;unpack=0"
SRC_URI[aarch64_kdesdk-kioslaves.sha256sum] = "01aa08db31691a69baa72a900ba617f76eb1c59b8ef447286bb9fea31f82edd8"

RDEPENDS:kdesdk-kioslaves = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 perl-Carp \
 perl-English \
 perl-Pod-Parser \
 perl-base \
 perl-interpreter \
 perl-libs \
 qt6-qtbase \
 "
