# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lemonldap-ng"
PV = "2.23.3"
PR = "1.el10_2"
PACKAGES = " \
 lemonldap-ng \
 lemonldap-ng-common \
 lemonldap-ng-doc \
 lemonldap-ng-fastcgi-server \
 lemonldap-ng-handler \
 lemonldap-ng-manager \
 lemonldap-ng-portal \
 lemonldap-ng-selinux \
 lemonldap-ng-test \
 lemonldap-ng-uwsgi-app \
 perl-Lemonldap-NG-SSOaaS-Apache-Client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lemonldap-ng-2.23.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0e5d9f344e084b979cbbbec2bd6360922bcafd36e9e1bffa9f74df9b3405e65"

URI_x86_64_v2_lemonldap-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-2.23.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng}"
SRC_URI[x86_64_v2_lemonldap-ng.sha256sum] = "0175336246a354d9dcbebcc3cc1ccad394be302b78ceb191dfaf9e05e4a5da3a"

URI_x86_64_v2_lemonldap-ng-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-common-2.23.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-common}"
SRC_URI[x86_64_v2_lemonldap-ng-common.sha256sum] = "e20f9ca660c8c08d3ca369f7d69f455de7ca12e59e88c3543f144aa4cb9b78be"
RPROVIDES:lemonldap-ng-common:x86_64_v2 = "virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

URI_x86_64_v2_lemonldap-ng-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-doc-2.23.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-doc}"
SRC_URI[x86_64_v2_lemonldap-ng-doc.sha256sum] = "3336ba3b6cc0c45acc067762aec24bef590dc628b1e6c4b9aa4a694df141fdd3"

URI_x86_64_v2_lemonldap-ng-fastcgi-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-fastcgi-server-2.23.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-fastcgi-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-fastcgi-server}"
SRC_URI[x86_64_v2_lemonldap-ng-fastcgi-server.sha256sum] = "4d6fec2d39583fd045d202997776f28489802ddc6ebd429fae1b6ec8e2bb642a"

URI_x86_64_v2_lemonldap-ng-handler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-handler-2.23.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-handler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-handler}"
SRC_URI[x86_64_v2_lemonldap-ng-handler.sha256sum] = "e1e1dc3d1948c9782fe4f3e3020c0c4b089fe7ce7c28242686f7390d1fb7d05c"

URI_x86_64_v2_lemonldap-ng-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-manager-2.23.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-manager}"
SRC_URI[x86_64_v2_lemonldap-ng-manager.sha256sum] = "0a6e7afd5ca06c6a4167f33ec5e4ae06d1ed7645f829be8b18c111610dd52429"
RPROVIDES:lemonldap-ng-manager:x86_64_v2 = "virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

URI_x86_64_v2_lemonldap-ng-portal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-portal-2.23.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-portal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-portal}"
SRC_URI[x86_64_v2_lemonldap-ng-portal.sha256sum] = "f5c8f88ec6405b1008deb645991e7c7bab524738cd277ba4812b4357dc2769b9"

URI_x86_64_v2_lemonldap-ng-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-selinux-2.23.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-selinux}"
SRC_URI[x86_64_v2_lemonldap-ng-selinux.sha256sum] = "963436e8bf8462a73348196a3cd63a3e3c71bf74b71560a9cab4f32cd475750c"

URI_x86_64_v2_lemonldap-ng-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-test-2.23.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-test}"
SRC_URI[x86_64_v2_lemonldap-ng-test.sha256sum] = "abe3dc083d9161b129aa3dc0ff2e48e82a25470951aaff3e9a7433e4bbf6a491"

URI_x86_64_v2_lemonldap-ng-uwsgi-app = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-uwsgi-app-2.23.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-uwsgi-app;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-uwsgi-app}"
SRC_URI[x86_64_v2_lemonldap-ng-uwsgi-app.sha256sum] = "799ab5434b9992d176c3ea7c95022fb81c5da50d8aadbac1c7ee3718437fffac"

URI_x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Lemonldap-NG-SSOaaS-Apache-Client-2.23.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client}"
SRC_URI[x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client.sha256sum] = "7430338ed8b005dcc8a68ff0f355b81f72aeb014e096488421a546b4fb5ec6ad"

URI_aarch64_lemonldap-ng = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-2.23.3-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng}"
SRC_URI[aarch64_lemonldap-ng.sha256sum] = "8c48f27f184a98563662b033041b872a030f6088551bf4e9a557c30448286841"

URI_aarch64_lemonldap-ng-common = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-common-2.23.3-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-common}"
SRC_URI[aarch64_lemonldap-ng-common.sha256sum] = "a2fc2c8c479ee276234439972df0363d35177e3491f9e4833017d6395bc60251"
RPROVIDES:lemonldap-ng-common:aarch64 = "virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

URI_aarch64_lemonldap-ng-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-doc-2.23.3-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-doc}"
SRC_URI[aarch64_lemonldap-ng-doc.sha256sum] = "ae6d72a71cc3ed850e6c87a3e2458ce129579eeedd062d26f1b10a6fd9db0fba"

URI_aarch64_lemonldap-ng-fastcgi-server = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-fastcgi-server-2.23.3-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-fastcgi-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-fastcgi-server}"
SRC_URI[aarch64_lemonldap-ng-fastcgi-server.sha256sum] = "611c500b18954b455cde26889211999a41f1a8bf733f83478eb77e73c652723a"

URI_aarch64_lemonldap-ng-handler = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-handler-2.23.3-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-handler;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-handler}"
SRC_URI[aarch64_lemonldap-ng-handler.sha256sum] = "eea5e6cad80b944c66ee72bbd8f2219dc24ecfa0378e4adb87f05540c553181c"

URI_aarch64_lemonldap-ng-manager = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-manager-2.23.3-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-manager}"
SRC_URI[aarch64_lemonldap-ng-manager.sha256sum] = "f8320b0ba91a08166b348b1169f95facb66b38ae35c3e1a3afcfb8bff29f99fe"
RPROVIDES:lemonldap-ng-manager:aarch64 = "virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

URI_aarch64_lemonldap-ng-portal = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-portal-2.23.3-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-portal;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-portal}"
SRC_URI[aarch64_lemonldap-ng-portal.sha256sum] = "c29461cb62240b616252ca872fc5f43137d2be46c0500854171c249841c19541"

URI_aarch64_lemonldap-ng-selinux = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-selinux-2.23.3-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-selinux}"
SRC_URI[aarch64_lemonldap-ng-selinux.sha256sum] = "49f9826d061435a6aa57846ff412ea1e22dbcba23dd282c2a0cc14aae480e940"

URI_aarch64_lemonldap-ng-test = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-test-2.23.3-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-test}"
SRC_URI[aarch64_lemonldap-ng-test.sha256sum] = "d705be1c7d7b6cc6be6093c328d7d725d3d1bd0ae98aa2d02799b7f2ad27bea7"

URI_aarch64_lemonldap-ng-uwsgi-app = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-uwsgi-app-2.23.3-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-uwsgi-app;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-uwsgi-app}"
SRC_URI[aarch64_lemonldap-ng-uwsgi-app.sha256sum] = "3fe7ae698bed117ba0c3b95055ee19e48aa2f670b15271d2772866813d92762d"

URI_aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Lemonldap-NG-SSOaaS-Apache-Client-2.23.3-1.el10_2.noarch.rpm;name=aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client}"
SRC_URI[aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client.sha256sum] = "7ca8e5becc1b26cdf70c7a556d670a4472b975893b541ec83f54c00c81feafad"

RDEPENDS:lemonldap-ng = " \
 lemonldap-ng-common \
 lemonldap-ng-doc \
 lemonldap-ng-handler \
 lemonldap-ng-manager \
 lemonldap-ng-portal \
 lemonldap-ng-selinux \
 lemonldap-ng-test \
 "
RDEPENDS:lemonldap-ng-common = " \
 bash \
 httpd-filesystem \
 lemonldap-ng-common \
 mod_fcgid \
 mod_perl \
 nginx-filesystem \
 perl-Apache-Session \
 perl-Apache-Session-Browseable \
 perl-AutoLoader \
 perl-Cache-Cache \
 perl-Config-IniFiles \
 perl-Convert-Base32 \
 perl-Convert-PEM \
 perl-Crypt-OpenSSL-RSA \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-Rijndael \
 perl-Crypt-URandom \
 perl-DBI \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Email-Date-Format \
 perl-Email-Sender \
 perl-Encode \
 perl-Exporter \
 perl-Getopt-Long \
 perl-HTML-Template \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Socket-SSL \
 perl-IO-String \
 perl-JSON \
 perl-JSON-XS \
 perl-LDAP \
 perl-Log-Log4perl \
 perl-MIME-Base64 \
 perl-MIME-tools \
 perl-Mouse \
 perl-Net-CIDR \
 perl-Net-SSLeay \
 perl-POSIX \
 perl-Plack \
 perl-Pod-Usage \
 perl-SOAP-Lite \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Sentry-Raven \
 perl-String-Random \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-TimeDate \
 perl-URI \
 perl-XML-LibXML \
 perl-YAML \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 virtual/httpd_or_nginx \
 virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_ \
 "
RDEPENDS:lemonldap-ng-doc = " \
 lemonldap-ng-common \
 "
RDEPENDS:lemonldap-ng-fastcgi-server = " \
 bash \
 lemonldap-ng-common \
 lemonldap-ng-handler \
 mod_fcgid \
 perl-FCGI-ProcManager \
 perl-Getopt-Long \
 perl-POSIX \
 perl-Plack \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:lemonldap-ng-handler = " \
 bash \
 lemonldap-ng-common \
 lemonldap-ng-handler \
 mod_perl \
 perl-Apache-Session \
 perl-AutoLoader \
 perl-Cache-Memcached \
 perl-Digest-SHA \
 perl-Exporter \
 perl-Getopt-Std \
 perl-HTTP-Message \
 perl-JSON \
 perl-MIME-Base64 \
 perl-Mouse \
 perl-Plack \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Time-HiRes \
 perl-URI \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:lemonldap-ng-manager = " \
 lemonldap-ng-common \
 lemonldap-ng-handler \
 lemonldap-ng-manager \
 lemonldap-ng-portal \
 perl-Crypt-URandom \
 perl-Data-Dumper \
 perl-English \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-Hash-Merge-Simple \
 perl-Hash-MultiValue \
 perl-IO-String \
 perl-JSON \
 perl-MIME-Base64 \
 perl-Mouse \
 perl-POSIX \
 perl-PathTools \
 perl-Plack-Handler-FCGI \
 perl-Pod-Usage \
 perl-Regexp-Assemble \
 perl-Regexp-Common \
 perl-Safe \
 perl-Storable \
 perl-URI \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:lemonldap-ng-portal = " \
 bash \
 lemonldap-ng-common \
 lemonldap-ng-portal \
 perl-Authen-PAM \
 perl-Authen-Radius \
 perl-Cache-Cache \
 perl-Carp \
 perl-Clone \
 perl-Crypt-JWT \
 perl-Crypt-OpenSSL-RSA \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-URandom \
 perl-DBI \
 perl-DateTime-Format-RFC3339 \
 perl-Digest-SHA \
 perl-Email-Date-Format \
 perl-Email-Sender \
 perl-Encode \
 perl-Exporter \
 perl-File-Temp \
 perl-GD-SecurityImage \
 perl-GSSAPI \
 perl-Getopt-Long \
 perl-HTML-FormatText-WithLinks \
 perl-HTML-Parser \
 perl-HTML-Template \
 perl-HTTP-Message \
 perl-Hash-MultiValue \
 perl-IO-Socket-Timeout \
 perl-IO-String \
 perl-IPC-Run \
 perl-JSON \
 perl-LDAP \
 perl-List-MoreUtils \
 perl-MIME-Base64 \
 perl-MIME-tools \
 perl-Mouse \
 perl-Net-CIDR \
 perl-Net-OpenID-Server \
 perl-Net-SSLeay \
 perl-POSIX \
 perl-Plack-Handler-FCGI \
 perl-Pod-Usage \
 perl-Regexp-Assemble \
 perl-SOAP-Lite \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-String-Random \
 perl-Text-Unidecode \
 perl-Time-Local \
 perl-TimeDate \
 perl-URI \
 perl-Web-ID \
 perl-XML-LibXML \
 perl-XML-LibXSLT \
 perl-base \
 perl-constant \
 perl-fields \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:lemonldap-ng-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:lemonldap-ng-test = " \
 lemonldap-ng-common \
 perl-CGI \
 perl-Data-Dumper \
 perl-Digest-SHA \
 perl-JSON \
 perl-MIME-Base64 \
 perl-URI \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:lemonldap-ng-uwsgi-app = " \
 uwsgi-plugin-psgi \
 "
RDEPENDS:perl-Lemonldap-NG-SSOaaS-Apache-Client = " \
 perl-FCGI-Client \
 perl-IO \
 perl-URI \
 perl-constant \
 perl-libs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

PROVIDES:append:aarch64 = " rpm/virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"
