# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iverilog"
PV = "13.0"
PR = "4.el10_1"
PACKAGES = " \
 iverilog \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/iverilog-13.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9722e565c73f734bc8f07dc43a7a5477fc55a28f78c193676adb15af02e8c691"

URI_x86_64_v2_iverilog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/iverilog-13.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_iverilog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iverilog}"
SRC_URI[x86_64_v2_iverilog.sha256sum] = "254e9e0108839a5ec4dcbe1defcc3231b79d7ed5ea0d6d4a587708d17b806b05"

URI_aarch64_iverilog = "${EPEL_MIRROR}/aarch64/Packages/i/iverilog-13.0-4.el10_1.aarch64.rpm;name=aarch64_iverilog;unpack=0"
SRC_URI:append = " ${URI_aarch64_iverilog}"
SRC_URI[aarch64_iverilog.sha256sum] = "63ee877b2a9a775f034072d5db128c2b08a2ec910ff37938e9b401523f2ef3b1"

RDEPENDS:iverilog = " \
 bash \
 bzip2-libs \
 glibc \
 libgcc \
 libstdc++ \
 readline \
 zlib-ng-compat \
 "
