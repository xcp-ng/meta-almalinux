# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-async"
PV = "2.2.5"
PR = "1.el10_0"
PACKAGES = " \
 ghc-async \
 ghc-async-devel \
 ghc-async-doc \
 ghc-async-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-async-2.2.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99128fa3a8d4d301b48f5e1e584c8b827f37f01bd018872e53c6fb658a91b8dd"

URI_x86_64_v2_ghc-async = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-async-2.2.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-async;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-async}"
SRC_URI[x86_64_v2_ghc-async.sha256sum] = "ea68f5bc7ddd3350e9f2b2dd8f313105cc0a20bf7b8e3c036251b0eb0f4a1da7"

URI_x86_64_v2_ghc-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-async-devel-2.2.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-async-devel}"
SRC_URI[x86_64_v2_ghc-async-devel.sha256sum] = "4ea2613b755afc4ab50a73e5f1e23992524407a7361cc9b24b19cd9306e9d767"

URI_x86_64_v2_ghc-async-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-async-doc-2.2.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-async-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-async-doc}"
SRC_URI[x86_64_v2_ghc-async-doc.sha256sum] = "306f72f98c72a6391287c615137bded30aeca96eb59d2f86624960fc571a0766"

URI_x86_64_v2_ghc-async-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-async-prof-2.2.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-async-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-async-prof}"
SRC_URI[x86_64_v2_ghc-async-prof.sha256sum] = "9ad3d7166078eb27f3100ebdd5650fb12960e929eee4be2d6c7dab24092e07b7"

URI_aarch64_ghc-async = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-async-2.2.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-async;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-async}"
SRC_URI[aarch64_ghc-async.sha256sum] = "6b4a956b1420d82d36afc237e2bf266c32842dace007c6e95532f6d2cd849026"

URI_aarch64_ghc-async-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-async-devel-2.2.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-async-devel}"
SRC_URI[aarch64_ghc-async-devel.sha256sum] = "e65c0fb192ef5952efabd7a396ce9f2bc421667aadd666647b23da3aaea50704"

URI_aarch64_ghc-async-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-async-doc-2.2.5-1.el10_0.noarch.rpm;name=aarch64_ghc-async-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-async-doc}"
SRC_URI[aarch64_ghc-async-doc.sha256sum] = "19bafde6505b3377b51ab248d7a1fd2979e211a88c9eeac751d57e3663893cb8"

URI_aarch64_ghc-async-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-async-prof-2.2.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-async-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-async-prof}"
SRC_URI[aarch64_ghc-async-prof.sha256sum] = "13a4397355356c22898b16efd66ddd7df7e68756928252232b92e52b873bf324"

RDEPENDS:ghc-async = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-async-devel = " \
 ghc-async \
 ghc-base-devel \
 ghc-compiler \
 ghc-hashable-devel \
 ghc-stm-devel \
 "
RDEPENDS:ghc-async-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-async-prof = " \
 ghc-async-devel \
 ghc-base-prof \
 ghc-hashable-prof \
 ghc-stm-prof \
 "
