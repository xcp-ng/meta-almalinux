# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "layer-shell-qt"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 layer-shell-qt \
 layer-shell-qt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/layer-shell-qt-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4eed98a8935fa4d39706bdf4bdc07be031f03508f413b1bc5995514cc6519405"

URI_x86_64_v2_layer-shell-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/layer-shell-qt-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_layer-shell-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_layer-shell-qt}"
SRC_URI[x86_64_v2_layer-shell-qt.sha256sum] = "17da288ffce58aa3c13d25cf41fde08629b29515e24b3334080bb3c5ee1fec39"

URI_x86_64_v2_layer-shell-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/layer-shell-qt-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_layer-shell-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_layer-shell-qt-devel}"
SRC_URI[x86_64_v2_layer-shell-qt-devel.sha256sum] = "b8c7a2e515a21d3a7ef54531a9ccfc7e900e2c1a2eadedaf404707458c4e9a3b"

URI_aarch64_layer-shell-qt = "${EPEL_MIRROR}/aarch64/Packages/l/layer-shell-qt-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_layer-shell-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_layer-shell-qt}"
SRC_URI[aarch64_layer-shell-qt.sha256sum] = "63bf90010619c702786f63aaeb52121c27196d8172d33068e78183cbb4155641"

URI_aarch64_layer-shell-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/layer-shell-qt-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_layer-shell-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_layer-shell-qt-devel}"
SRC_URI[aarch64_layer-shell-qt-devel.sha256sum] = "490c6486f3d4efe1f9d4ec97cbf0c3b83b0b2906bc777e2e8df7eba831dead2a"

RDEPENDS:layer-shell-qt = " \
 glibc \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:layer-shell-qt-devel = " \
 cmake-filesystem \
 layer-shell-qt \
 qt6-qtbase-devel \
 "
