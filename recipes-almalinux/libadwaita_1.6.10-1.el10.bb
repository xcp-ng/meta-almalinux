# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libadwaita"
PV = "1.6.10"
PR = "1.el10"
PACKAGES = " \
 libadwaita \
 libadwaita-devel \
 libadwaita-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libadwaita-1.6.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9dfa3be1d78c6aaec5c887a2beae6dbe352e5775168b4b047ad65e7602b5ba8e"

URI_x86_64_v2_libadwaita = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libadwaita-1.6.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libadwaita;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libadwaita}"
SRC_URI[x86_64_v2_libadwaita.sha256sum] = "3756ce975fdcef4fa197078ed8dcc269f3b101d3f0308efb18d82a7a5dfb0692"

URI_x86_64_v2_libadwaita-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libadwaita-devel-1.6.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libadwaita-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libadwaita-devel}"
SRC_URI[x86_64_v2_libadwaita-devel.sha256sum] = "eb1545212a7be0fc323e62879093952d9c218fff20e89f8b1da2605e2e79f887"

URI_x86_64_v2_libadwaita-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libadwaita-doc-1.6.10-1.el10.noarch.rpm;name=x86_64_v2_libadwaita-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libadwaita-doc}"
SRC_URI[x86_64_v2_libadwaita-doc.sha256sum] = "908533c37500d06ba4bf5a2deb8c6ed9df3f8666efa0c57bfb54868fcee4b7e1"

URI_aarch64_libadwaita = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libadwaita-1.6.10-1.el10.aarch64.rpm;name=aarch64_libadwaita;unpack=0"
SRC_URI:append = " ${URI_aarch64_libadwaita}"
SRC_URI[aarch64_libadwaita.sha256sum] = "b2c1828ae511e1f15529cc3cbaf728250e7547a455496a3053f42972fe4d90af"

URI_aarch64_libadwaita-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libadwaita-devel-1.6.10-1.el10.aarch64.rpm;name=aarch64_libadwaita-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libadwaita-devel}"
SRC_URI[aarch64_libadwaita-devel.sha256sum] = "b767f6f49e033eea3815d456cb3362f31d3f3c2f9143cde8434e1cfbfca4e5ba"

URI_aarch64_libadwaita-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libadwaita-doc-1.6.10-1.el10.noarch.rpm;name=aarch64_libadwaita-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libadwaita-doc}"
SRC_URI[aarch64_libadwaita-doc.sha256sum] = "908533c37500d06ba4bf5a2deb8c6ed9df3f8666efa0c57bfb54868fcee4b7e1"

RDEPENDS:libadwaita = " \
 appstream \
 fribidi \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 pango \
 "
RDEPENDS:libadwaita-devel = " \
 appstream-devel \
 fribidi-devel \
 glib2-devel \
 gtk4-devel \
 libadwaita \
 pkgconf-pkg-config \
 vala \
 "
RDEPENDS:libadwaita-doc = " \
 "
