# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oidc-agent"
PV = "5.3.6"
PR = "1.el10_3"
PACKAGES = " \
 oidc-agent-cli \
 oidc-agent-desktop \
 oidc-agent-devel \
 oidc-agent-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/oidc-agent-5.3.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30359bc824f3ea751884f4b2d9a80d6eebc8aa67676622970811d2c747bb03cd"

URI_x86_64_v2_oidc-agent-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-cli-5.3.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-cli}"
SRC_URI[x86_64_v2_oidc-agent-cli.sha256sum] = "e586ff278a42d09f45c8b456c8031322344ae61cf6a6a5087c99a058d2c749ee"

URI_x86_64_v2_oidc-agent-desktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-desktop-5.3.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-desktop}"
SRC_URI[x86_64_v2_oidc-agent-desktop.sha256sum] = "5a2abfd94a0c6c68ff775c3c99f33d52848c20bc4dc2faab0756d538d7b018bf"

URI_x86_64_v2_oidc-agent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-devel-5.3.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-devel}"
SRC_URI[x86_64_v2_oidc-agent-devel.sha256sum] = "a242dab73869201066da431ea8e779cf82135398aceab0c0a06a858727d84500"

URI_x86_64_v2_oidc-agent-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-libs-5.3.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-libs}"
SRC_URI[x86_64_v2_oidc-agent-libs.sha256sum] = "6a0e5fc42b280c03d2b58756fe44894a549d186cb28882214b77bd40e7c92516"

URI_aarch64_oidc-agent-cli = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-cli-5.3.6-1.el10_3.aarch64.rpm;name=aarch64_oidc-agent-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-cli}"
SRC_URI[aarch64_oidc-agent-cli.sha256sum] = "787a8d21aa3a21544719d14122ac96df07ae1cf33680368a191032bac242b5b1"

URI_aarch64_oidc-agent-desktop = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-desktop-5.3.6-1.el10_3.aarch64.rpm;name=aarch64_oidc-agent-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-desktop}"
SRC_URI[aarch64_oidc-agent-desktop.sha256sum] = "fc2283065d8ad635f3ccdcda1f95a28bf2f4631b08ec9ed429284780815ad154"

URI_aarch64_oidc-agent-devel = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-devel-5.3.6-1.el10_3.aarch64.rpm;name=aarch64_oidc-agent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-devel}"
SRC_URI[aarch64_oidc-agent-devel.sha256sum] = "c947907e5648a068d1d840c8373ad49c305f139b7a7e9d894a6df32f21f78b11"

URI_aarch64_oidc-agent-libs = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-libs-5.3.6-1.el10_3.aarch64.rpm;name=aarch64_oidc-agent-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-libs}"
SRC_URI[aarch64_oidc-agent-libs.sha256sum] = "9daafdb78d522fc26c2d62851670c329a92d94813d747df839dfa417a350fe04"

RDEPENDS:oidc-agent-cli = " \
 bash \
 cjson \
 clibs-list \
 glibc \
 libmicrohttpd \
 libsodium \
 oidc-agent-libs \
 qrencode-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:oidc-agent-desktop = " \
 cjson \
 clibs-list \
 glib2 \
 glibc \
 gtk3 \
 javascriptcoregtk4.1 \
 libgcc \
 libsodium \
 libstdc++ \
 oidc-agent-cli \
 oidc-agent-libs \
 webkit2gtk4.1 \
 "
RDEPENDS:oidc-agent-devel = " \
 oidc-agent-libs \
 "
RDEPENDS:oidc-agent-libs = " \
 cjson \
 clibs-list \
 glibc \
 libsodium \
 "
