# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kapidox"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kapidox \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kapidox-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c72b705f4fa468e717880389dabd33ca8d5efe0df0ed6764c97ff4fa49044875"

URI_x86_64_v2_kf6-kapidox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kapidox-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kapidox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kapidox}"
SRC_URI[x86_64_v2_kf6-kapidox.sha256sum] = "b00fca3cec2adb701d257e148c35347e6514ef64537d4aa9a9b2f26f2d1a40d9"

URI_aarch64_kf6-kapidox = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kapidox-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kapidox;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kapidox}"
SRC_URI[aarch64_kf6-kapidox.sha256sum] = "277412fc039534d3a5fbf5d13bed9deeafba67d918a739f121722d32698cf80a"

RDEPENDS:kf6-kapidox = " \
 bash \
 doxygen \
 kf6-filesystem \
 python3 \
 python3-doxypypy \
 python3-doxyqml \
 python3-jinja2 \
 python3-pyyaml \
 python3-requests \
 qt6-doc-devel \
 "
