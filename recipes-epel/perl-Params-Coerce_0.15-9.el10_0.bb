# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Params-Coerce"
PV = "0.15"
PR = "9.el10_0"
PACKAGES = " \
 perl-Params-Coerce \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Params-Coerce-0.15-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b971e02e80b83a01dcd2795a274b815c98219eca70612402d33abce1e4be765e"

URI_x86_64_v2_perl-Params-Coerce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Params-Coerce-0.15-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Params-Coerce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Params-Coerce}"
SRC_URI[x86_64_v2_perl-Params-Coerce.sha256sum] = "7bf6cc0d4f403fdcc24605a2c78c1f10911c8ab137c0a13eeb3a803f72c3ee85"

URI_aarch64_perl-Params-Coerce = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Params-Coerce-0.15-9.el10_0.noarch.rpm;name=aarch64_perl-Params-Coerce;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Params-Coerce}"
SRC_URI[aarch64_perl-Params-Coerce.sha256sum] = "cb6ac1ddc5cc4009c3a99601d82e1e28f4f2e476d660425e0fcc159fb08b2706"

RDEPENDS:perl-Params-Coerce = " \
 perl-Carp \
 perl-Params-Util \
 perl-Scalar-List-Utils \
 perl-libs \
 "
