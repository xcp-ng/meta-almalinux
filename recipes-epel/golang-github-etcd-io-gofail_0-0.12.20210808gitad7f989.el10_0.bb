# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-etcd-io-gofail"
PV = "0"
PR = "0.12.20210808gitad7f989.el10_0"
PACKAGES = " \
 golang-github-etcd-io-gofail \
 golang-github-etcd-io-gofail-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-etcd-io-gofail-0-0.12.20210808gitad7f989.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6e3c557dae0205c18541707cb7e8377e24cf34d4dce2c4d4b58088c51fdc82be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-etcd-io-gofail-0-0.12.20210808gitad7f989.el10_0.aarch64.rpm;name=aarch64_golang-github-etcd-io-gofail;unpack=0"
SRC_URI[aarch64_golang-github-etcd-io-gofail.sha256sum] = "b28136a0a47c7f54945673eb047ff1d36e4ca554687b3668675c103a3b401438"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-etcd-io-gofail-devel-0-0.12.20210808gitad7f989.el10_0.noarch.rpm;name=aarch64_golang-github-etcd-io-gofail-devel;unpack=0"
SRC_URI[aarch64_golang-github-etcd-io-gofail-devel.sha256sum] = "19e7fd53fa43b057e7543872be3fccb68e84e696968fac5eca97d63e4f6d23d9"

RDEPENDS:golang-github-etcd-io-gofail = " \
 glibc \
 "
RDEPENDS:golang-github-etcd-io-gofail-devel = " \
 go-filesystem \
 "
