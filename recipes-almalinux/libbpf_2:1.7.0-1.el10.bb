# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libbpf"
PE = "2"
PV = "1.7.0"
PR = "1.el10"
PACKAGES = " \
 libbpf \
 libbpf-devel \
 libbpf-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libbpf-1.7.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21d6f1ea2cba190096ef5141fdb7e4ceefe1514eb92b4e3dc5feb4044172d1d9"

URI_x86_64_v2_libbpf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libbpf-1.7.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libbpf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbpf}"
SRC_URI[x86_64_v2_libbpf.sha256sum] = "2e635e399f4cf9e445b130d66c3df2452a79d708b72f78dc8ba559bcc6074b59"

URI_x86_64_v2_libbpf-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libbpf-devel-1.7.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libbpf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbpf-devel}"
SRC_URI[x86_64_v2_libbpf-devel.sha256sum] = "40d27b415618d0c94fa4621bf1894fc23e6890efcfcc66c3d1988e05fe091a4c"

URI_x86_64_v2_libbpf-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libbpf-static-1.7.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libbpf-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbpf-static}"
SRC_URI[x86_64_v2_libbpf-static.sha256sum] = "c9735fa01cabfad51a2e1d836f1d3d9b23ce150c2609c3164671ea3bc89ef964"

URI_aarch64_libbpf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libbpf-1.7.0-1.el10.aarch64.rpm;name=aarch64_libbpf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbpf}"
SRC_URI[aarch64_libbpf.sha256sum] = "5eb5d31a65f36d653225ddf15469dab408aab51aee02630b83f9da584b41f7fb"

URI_aarch64_libbpf-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libbpf-devel-1.7.0-1.el10.aarch64.rpm;name=aarch64_libbpf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbpf-devel}"
SRC_URI[aarch64_libbpf-devel.sha256sum] = "90130184819e9bad15dc40e64956658f3100db5334d9187720ce6a4bf977e80f"

URI_aarch64_libbpf-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libbpf-static-1.7.0-1.el10.aarch64.rpm;name=aarch64_libbpf-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbpf-static}"
SRC_URI[aarch64_libbpf-static.sha256sum] = "ba4a5997bddac772e9cbbaf9786157afec06394fcc6048d48b3dccf55c38af28"

RDEPENDS:libbpf = " \
 elfutils-libelf \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:libbpf-devel = " \
 elfutils-libelf-devel \
 kernel-headers \
 libbpf \
 pkgconf-pkg-config \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:libbpf-static = " \
 libbpf-devel \
 "
