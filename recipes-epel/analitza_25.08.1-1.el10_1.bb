# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "analitza"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 analitza \
 analitza-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/analitza-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc5e3230d7cff165591be551fcc70b109b38442b49eec7373907126aeb549259"

URI_x86_64_v2_analitza = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/analitza-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_analitza;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_analitza}"
SRC_URI[x86_64_v2_analitza.sha256sum] = "2c0838c326787e957284f4e3766f358e15d43b5db965a43adb53c4358fa42b94"

URI_x86_64_v2_analitza-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/analitza-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_analitza-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_analitza-devel}"
SRC_URI[x86_64_v2_analitza-devel.sha256sum] = "552bc7e414a537dae2d2b525dc0b804c8cf1710fe06164d910f24325983c1222"

URI_aarch64_analitza = "${EPEL_MIRROR}/aarch64/Packages/a/analitza-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_analitza;unpack=0"
SRC_URI:append = " ${URI_aarch64_analitza}"
SRC_URI[aarch64_analitza.sha256sum] = "ec055e8a072422118f778610e3f61be2daf325f497ac3e166189a5680d61bcc1"

URI_aarch64_analitza-devel = "${EPEL_MIRROR}/aarch64/Packages/a/analitza-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_analitza-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_analitza-devel}"
SRC_URI[aarch64_analitza-devel.sha256sum] = "5fb9fd2f284ed7329ac5fd7ae7037bf04d994586d962ec9a4b2d6063d0605606"

RDEPENDS:analitza = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:analitza-devel = " \
 analitza \
 cmake-filesystem \
 "
