# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-jonboulle-clockwork"
PV = "0.2.2"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-jonboulle-clockwork-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-jonboulle-clockwork-0.2.2-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6989b2d29aa4e0bb5b4db9ba05cfe21595d7ed60561ffbba2ac799f2907a99de"

URI_x86_64_v2_golang-github-jonboulle-clockwork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-jonboulle-clockwork-devel-0.2.2-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-jonboulle-clockwork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-jonboulle-clockwork-devel}"
SRC_URI[x86_64_v2_golang-github-jonboulle-clockwork-devel.sha256sum] = "a412cb060c15fe2139cfd3162d987ae523933b91fa3b3567332c6614e6cc8f9f"

URI_aarch64_golang-github-jonboulle-clockwork-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-jonboulle-clockwork-devel-0.2.2-13.el10_0.noarch.rpm;name=aarch64_golang-github-jonboulle-clockwork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-jonboulle-clockwork-devel}"
SRC_URI[aarch64_golang-github-jonboulle-clockwork-devel.sha256sum] = "2829f1e1bda9b8ecb027fbf050a99249395fd80832a5c666f1d978cc6c8e3252"

RDEPENDS:golang-github-jonboulle-clockwork-devel = " \
 go-filesystem \
 "
