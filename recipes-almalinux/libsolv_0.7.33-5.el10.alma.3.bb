# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsolv"
PV = "0.7.33"
PR = "5.el10.alma.3"
PACKAGES = " \
 libsolv \
 libsolv-devel \
 libsolv-tools \
 libsolv-tools-base \
 python3-solv \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libsolv-0.7.33-5.el10.alma.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a57aee0442e30487c44d1356078c2481266e92c27ebc4b2406abb706ef48e4b"

URI_x86_64_v2_libsolv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsolv-0.7.33-5.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_libsolv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsolv}"
SRC_URI[x86_64_v2_libsolv.sha256sum] = "e092933146f2ba15361f42e269df1d29dc9629acea9a159b2564d3bfbbaecb2e"

URI_x86_64_v2_libsolv-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsolv-devel-0.7.33-5.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_libsolv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsolv-devel}"
SRC_URI[x86_64_v2_libsolv-devel.sha256sum] = "a982f57697d84fd4487eb9f30df95cd98db2776f8188b724d7887d173110a349"

URI_x86_64_v2_libsolv-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsolv-tools-0.7.33-5.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_libsolv-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsolv-tools}"
SRC_URI[x86_64_v2_libsolv-tools.sha256sum] = "4744b8672f0c84f55f27a76e424928e1ade598687f8a4cb5fe68db412397ed0f"

URI_x86_64_v2_libsolv-tools-base = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsolv-tools-base-0.7.33-5.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_libsolv-tools-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsolv-tools-base}"
SRC_URI[x86_64_v2_libsolv-tools-base.sha256sum] = "173654b03e6807273c4e4889432e10d7c035f86197e12e096ccdf7a570876401"

URI_x86_64_v2_python3-solv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-solv-0.7.33-5.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_python3-solv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-solv}"
SRC_URI[x86_64_v2_python3-solv.sha256sum] = "1eb456e69ea100cd3706834f2fb0e347a103f3dd524217b0e15afd1d69402197"

URI_aarch64_libsolv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsolv-0.7.33-5.el10.alma.3.aarch64.rpm;name=aarch64_libsolv;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsolv}"
SRC_URI[aarch64_libsolv.sha256sum] = "4f5c90d3a8b71ac4487a0b27ccc8ec036ce4732bf380ef45b98bcf2a3d8796d2"

URI_aarch64_libsolv-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsolv-devel-0.7.33-5.el10.alma.3.aarch64.rpm;name=aarch64_libsolv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsolv-devel}"
SRC_URI[aarch64_libsolv-devel.sha256sum] = "feb1bcceb4d697a41e9de6d975ba09251a22efe10690543cab64d34745197274"

URI_aarch64_libsolv-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsolv-tools-0.7.33-5.el10.alma.3.aarch64.rpm;name=aarch64_libsolv-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsolv-tools}"
SRC_URI[aarch64_libsolv-tools.sha256sum] = "d0f12db69da58831df1396eaa7ca09fd84583414e244ecf6eaf42fe788fc41a6"

URI_aarch64_libsolv-tools-base = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsolv-tools-base-0.7.33-5.el10.alma.3.aarch64.rpm;name=aarch64_libsolv-tools-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsolv-tools-base}"
SRC_URI[aarch64_libsolv-tools-base.sha256sum] = "cfa267560d081effd3e62dd38d8abf232e523db81d19577d8ba4e17609c792ce"

URI_aarch64_python3-solv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-solv-0.7.33-5.el10.alma.3.aarch64.rpm;name=aarch64_python3-solv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-solv}"
SRC_URI[aarch64_python3-solv.sha256sum] = "0a512ed89e86897de957694570241ba10adc06f767c783b12ff2d95539e39d8f"

RDEPENDS:libsolv = " \
 bzip2-libs \
 glibc \
 libxml2 \
 libzstd \
 openssl-libs \
 rpm-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libsolv-devel = " \
 libsolv \
 libsolv-devel \
 pkgconf-pkg-config \
 rpm-devel \
 "
RDEPENDS:libsolv-tools = " \
 glibc \
 libsolv \
 libsolv-tools-base \
 "
RDEPENDS:libsolv-tools-base = " \
 glibc \
 libsolv \
 rpm-libs \
 "
RDEPENDS:python3-solv = " \
 glibc \
 libsolv \
 python3 \
 "
