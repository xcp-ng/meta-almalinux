# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-import-wizard"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 akonadi-import-wizard \
 akonadi-import-wizard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-import-wizard-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42d1c63f45d57e0d6035fbf368eac0c859a43359f619c370601d45d2733a57e9"

URI_x86_64_v2_akonadi-import-wizard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-import-wizard-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-import-wizard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-import-wizard}"
SRC_URI[x86_64_v2_akonadi-import-wizard.sha256sum] = "ed9a605575e2d8b161919f6880575e251479fca6a8219554870cccb46add6002"

URI_x86_64_v2_akonadi-import-wizard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-import-wizard-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-import-wizard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-import-wizard-devel}"
SRC_URI[x86_64_v2_akonadi-import-wizard-devel.sha256sum] = "db7ab02bed81184f8665d83e4ec9fe7dd62060559d355c673087962e2d392470"

URI_aarch64_akonadi-import-wizard = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-import-wizard-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akonadi-import-wizard;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-import-wizard}"
SRC_URI[aarch64_akonadi-import-wizard.sha256sum] = "dfabbc5966b663254df15fe8cae31386b4b8e6a2824cc6d9f0c80ef21dab47d8"

URI_aarch64_akonadi-import-wizard-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-import-wizard-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akonadi-import-wizard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-import-wizard-devel}"
SRC_URI[aarch64_akonadi-import-wizard-devel.sha256sum] = "16e2ae44efbb50671ceac68f00a0af5c954c438e0072ba5d02e3bab244564c9d"

RDEPENDS:akonadi-import-wizard = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 libgcc \
 libstdc++ \
 mailcommon \
 mailimporter \
 mailimporter-akonadi \
 messagelib \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:akonadi-import-wizard-devel = " \
 akonadi-import-wizard \
 cmake-filesystem \
 kmailtransport-devel \
 "
