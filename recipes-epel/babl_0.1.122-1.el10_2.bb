# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "babl"
PV = "0.1.122"
PR = "1.el10_2"
PACKAGES = " \
 babl \
 babl-devel \
 babl-devel-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/babl-0.1.122-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33aae3212bade313335c80a0120182be16d649dbee4faa523c9b165724ac18c4"

URI_x86_64_v2_babl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/babl-0.1.122-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_babl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_babl}"
SRC_URI[x86_64_v2_babl.sha256sum] = "800d1768c7d059a7f6e32a1375509faa5ce51eb7cacf8d3d6a13e910d1a65cb8"

URI_x86_64_v2_babl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/babl-devel-0.1.122-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_babl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_babl-devel}"
SRC_URI[x86_64_v2_babl-devel.sha256sum] = "bd975463751ba82ae985e7dccc81df5f3a6599e469064ee7889300283b187420"

URI_x86_64_v2_babl-devel-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/babl-devel-docs-0.1.122-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_babl-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_babl-devel-docs}"
SRC_URI[x86_64_v2_babl-devel-docs.sha256sum] = "95a89e1ec81db94a49f2938199ab97fd1095cc896ac4b7bc1a9268e80c70a55b"

URI_aarch64_babl = "${EPEL_MIRROR}/aarch64/Packages/b/babl-0.1.122-1.el10_2.aarch64.rpm;name=aarch64_babl;unpack=0"
SRC_URI:append = " ${URI_aarch64_babl}"
SRC_URI[aarch64_babl.sha256sum] = "5bdc145ae04afb10e5b803d685be5e07b610a2b0c6cfb7af935ea2599474f5de"

URI_aarch64_babl-devel = "${EPEL_MIRROR}/aarch64/Packages/b/babl-devel-0.1.122-1.el10_2.aarch64.rpm;name=aarch64_babl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_babl-devel}"
SRC_URI[aarch64_babl-devel.sha256sum] = "f122ee04811e59b379f94e345876c998ae2bb6d4ec47ee37d68bfc37b2fdb70e"

URI_aarch64_babl-devel-docs = "${EPEL_MIRROR}/aarch64/Packages/b/babl-devel-docs-0.1.122-1.el10_2.noarch.rpm;name=aarch64_babl-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_babl-devel-docs}"
SRC_URI[aarch64_babl-devel-docs.sha256sum] = "e1dd32a62ae5265144417291dabde9222ed79cee5ee04f1d8b6f41a57f2b7ecd"

RDEPENDS:babl = " \
 glibc \
 lcms2 \
 "
RDEPENDS:babl-devel = " \
 babl \
 lcms2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:babl-devel-docs = " \
 babl-devel \
 "
