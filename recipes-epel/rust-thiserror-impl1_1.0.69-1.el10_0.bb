# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thiserror-impl1"
PV = "1.0.69"
PR = "1.el10_0"
PACKAGES = " \
 rust-thiserror-impl1+default-devel \
 rust-thiserror-impl1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thiserror-impl1-1.0.69-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24d8a25d46498bbbe039f40013231811da9c2b737ce5d4923a699ebe9c2e8629"

URI_x86_64_v2_rust-thiserror-impl1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror-impl1+default-devel-1.0.69-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror-impl1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror-impl1+default-devel}"
SRC_URI[x86_64_v2_rust-thiserror-impl1+default-devel.sha256sum] = "a0a6967015b982b523a7b124d70c31958f497f29ad5a9fc2a4adcb43865bd406"

URI_x86_64_v2_rust-thiserror-impl1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror-impl1-devel-1.0.69-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror-impl1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror-impl1-devel}"
SRC_URI[x86_64_v2_rust-thiserror-impl1-devel.sha256sum] = "4becb9183707b2618513596821a53170daeac9cd7c0cd23935cd84783e95d5ab"

URI_aarch64_rust-thiserror-impl1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror-impl1+default-devel-1.0.69-1.el10_0.noarch.rpm;name=aarch64_rust-thiserror-impl1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror-impl1+default-devel}"
SRC_URI[aarch64_rust-thiserror-impl1+default-devel.sha256sum] = "569c6426941e0410b0cd72526813ce649e50315531d3fc935884bedf18a96960"

URI_aarch64_rust-thiserror-impl1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror-impl1-devel-1.0.69-1.el10_0.noarch.rpm;name=aarch64_rust-thiserror-impl1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror-impl1-devel}"
SRC_URI[aarch64_rust-thiserror-impl1-devel.sha256sum] = "04e51b38201dc33e85661a9c8b080d5bbca4a181d95116f3b918b02d84d65c67"

RDEPENDS:rust-thiserror-impl1+default-devel = " \
 cargo \
 rust-thiserror-impl1-devel \
 "
RDEPENDS:rust-thiserror-impl1-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
