# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytelines"
PV = "2.5.0"
PR = "6.el10_3"
PACKAGES = " \
 rust-bytelines+default-devel \
 rust-bytelines+futures-util-devel \
 rust-bytelines+tokio-devel \
 rust-bytelines-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytelines-2.5.0-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c63081fe69415b14eed0f8f08ff64b55ba059c3d9d02a659da4de736fad5d258"

URI_x86_64_v2_rust-bytelines+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytelines+default-devel-2.5.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytelines+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytelines+default-devel}"
SRC_URI[x86_64_v2_rust-bytelines+default-devel.sha256sum] = "0341dd856ee0ac241f145e5d85c2ed36bec3f514ab01f1421753c582bd790fd3"

URI_x86_64_v2_rust-bytelines+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytelines+futures-util-devel-2.5.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytelines+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytelines+futures-util-devel}"
SRC_URI[x86_64_v2_rust-bytelines+futures-util-devel.sha256sum] = "fdd5a91a1e0d3eec590c27a335c80d8f9d4ae99dd52c81e117a137072659e44b"

URI_x86_64_v2_rust-bytelines+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytelines+tokio-devel-2.5.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytelines+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytelines+tokio-devel}"
SRC_URI[x86_64_v2_rust-bytelines+tokio-devel.sha256sum] = "f6d5d2af41cddf62dbe123d23c466e8a7eb86426ba39f1f00b837536a808701f"

URI_x86_64_v2_rust-bytelines-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytelines-devel-2.5.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytelines-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytelines-devel}"
SRC_URI[x86_64_v2_rust-bytelines-devel.sha256sum] = "27bb83908d567fc63b3f57c4c61e520fcfa51ac96356cfc5f98f44ea3b251e13"

URI_aarch64_rust-bytelines+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytelines+default-devel-2.5.0-6.el10_3.noarch.rpm;name=aarch64_rust-bytelines+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytelines+default-devel}"
SRC_URI[aarch64_rust-bytelines+default-devel.sha256sum] = "e6a3d213f314b59e3521ff8dadbe4b6131e63a23e3586d20f08f376e26f06dcd"

URI_aarch64_rust-bytelines+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytelines+futures-util-devel-2.5.0-6.el10_3.noarch.rpm;name=aarch64_rust-bytelines+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytelines+futures-util-devel}"
SRC_URI[aarch64_rust-bytelines+futures-util-devel.sha256sum] = "292f506997cc52d9128a70b9b54a3926590d5fcbd540ff7e08c40d64626c3e16"

URI_aarch64_rust-bytelines+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytelines+tokio-devel-2.5.0-6.el10_3.noarch.rpm;name=aarch64_rust-bytelines+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytelines+tokio-devel}"
SRC_URI[aarch64_rust-bytelines+tokio-devel.sha256sum] = "a03926459ff1e597b0c7d40f26b586b088a10efdfb87406aed5fc2d5bd02579f"

URI_aarch64_rust-bytelines-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytelines-devel-2.5.0-6.el10_3.noarch.rpm;name=aarch64_rust-bytelines-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytelines-devel}"
SRC_URI[aarch64_rust-bytelines-devel.sha256sum] = "4e906b6ee536f366649897076138e52235ed5b47f49045355c208a0ae6720f64"

RDEPENDS:rust-bytelines+default-devel = " \
 cargo \
 rust-bytelines+tokio-devel \
 rust-bytelines-devel \
 "
RDEPENDS:rust-bytelines+futures-util-devel = " \
 cargo \
 rust-bytelines-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-bytelines+tokio-devel = " \
 cargo \
 rust-bytelines+futures-util-devel \
 rust-bytelines-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 "
RDEPENDS:rust-bytelines-devel = " \
 cargo \
 "
