# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fatrace"
PV = "0.18.0"
PR = "2.el10_1"
PACKAGES = " \
 fatrace \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fatrace-0.18.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "857acbdd6b7300e6cea33f20784f13475049457480c6b1437693fba821e53bdd"

URI_x86_64_v2_fatrace = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fatrace-0.18.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fatrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fatrace}"
SRC_URI[x86_64_v2_fatrace.sha256sum] = "e3a48486e9326a9104794ca66253702aecc251caf518c463254c9ca5e40b4865"

URI_aarch64_fatrace = "${EPEL_MIRROR}/aarch64/Packages/f/fatrace-0.18.0-2.el10_1.aarch64.rpm;name=aarch64_fatrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_fatrace}"
SRC_URI[aarch64_fatrace.sha256sum] = "4ea87c47781e17c811454631001b49b5c7b88f1084eaf2c17f25736c8c30c6b2"

RDEPENDS:fatrace = " \
 glibc \
 python3 \
 "
