# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-containers-podman"
PV = "1.16.3"
PR = "7.el10_0"
PACKAGES = " \
 ansible-collection-containers-podman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-collection-containers-podman-1.16.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f40077b2abe7c925945cc2c43a63a1cb58fa2d17c321e61a7b8c5f63d6b6c42"

URI_x86_64_v2_ansible-collection-containers-podman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-collection-containers-podman-1.16.3-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-collection-containers-podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-containers-podman}"
SRC_URI[x86_64_v2_ansible-collection-containers-podman.sha256sum] = "b0ae5a85f8532ebeaa93368c79b1f4583911990134716ebc2a0ccffb5e48ea8c"

URI_aarch64_ansible-collection-containers-podman = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-collection-containers-podman-1.16.3-7.el10_0.noarch.rpm;name=aarch64_ansible-collection-containers-podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-containers-podman}"
SRC_URI[aarch64_ansible-collection-containers-podman.sha256sum] = "ee6dd44ae96312f3569e73b7fbfb307bbcc54a969e9a937b4be8ea3d6835b425"

RDEPENDS:ansible-collection-containers-podman = " \
 ansible-core \
 "
