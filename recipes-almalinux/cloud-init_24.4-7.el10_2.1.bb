# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cloud-init"
PV = "24.4"
PR = "7.el10_2.1"
PACKAGES = " \
 cloud-init \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cloud-init-24.4-7.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72d1afbd2cf01bcfbe1f34325d57a8b7c005c4cb4222747bd9ea6b005d71eb8a"

URI_x86_64_v2_cloud-init = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cloud-init-24.4-7.el10_2.1.noarch.rpm;name=x86_64_v2_cloud-init;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cloud-init}"
SRC_URI[x86_64_v2_cloud-init.sha256sum] = "4332463c477260ee5b1a219a64c57e775ae5c3a11de2bfdd75a3956f0181ba3e"

URI_aarch64_cloud-init = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cloud-init-24.4-7.el10_2.1.noarch.rpm;name=aarch64_cloud-init;unpack=0"
SRC_URI:append = " ${URI_aarch64_cloud-init}"
SRC_URI[aarch64_cloud-init.sha256sum] = "4332463c477260ee5b1a219a64c57e775ae5c3a11de2bfdd75a3956f0181ba3e"

RDEPENDS:cloud-init = " \
 bash \
 dhcpcd \
 e2fsprogs \
 hostname \
 iproute \
 openssl \
 procps-ng \
 python3 \
 python3-configobj \
 python3-jinja2 \
 python3-jsonpatch \
 python3-libselinux \
 python3-oauthlib \
 python3-policycoreutils \
 python3-pyserial \
 python3-pyyaml \
 python3-requests \
 shadow-utils \
 systemd \
 util-linux \
 xfsprogs \
 "
