# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sbsigntools"
PV = "0.9.5"
PR = "10.el10_1"
PACKAGES = " \
 sbsigntools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sbsigntools-0.9.5-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2e80f03eaaed799ef1989b8c22b49e08382f744e3fe97c8a2d9b95b9abcf01b"

URI_x86_64_v2_sbsigntools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sbsigntools-0.9.5-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sbsigntools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sbsigntools}"
SRC_URI[x86_64_v2_sbsigntools.sha256sum] = "6abeb18dca2a7a2efd963770a8c4db75c72b6c0f72240da952abf4100c81cff8"

URI_aarch64_sbsigntools = "${EPEL_MIRROR}/aarch64/Packages/s/sbsigntools-0.9.5-10.el10_1.aarch64.rpm;name=aarch64_sbsigntools;unpack=0"
SRC_URI:append = " ${URI_aarch64_sbsigntools}"
SRC_URI[aarch64_sbsigntools.sha256sum] = "c244e1f656ed9ffe136b2a1db092b144d23e031c698aeb78e23cbb874f686330"

RDEPENDS:sbsigntools = " \
 glibc \
 libuuid \
 openssl-libs \
 "
