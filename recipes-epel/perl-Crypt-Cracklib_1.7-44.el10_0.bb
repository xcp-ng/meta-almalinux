# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-Cracklib"
PV = "1.7"
PR = "44.el10_0"
PACKAGES = " \
 perl-Crypt-Cracklib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-Cracklib-1.7-44.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2cd4a66b7947e467791b83683d74a7d2b0466cb3833229b26e608991d7ec15a"

URI_x86_64_v2_perl-Crypt-Cracklib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-Cracklib-1.7-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-Cracklib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-Cracklib}"
SRC_URI[x86_64_v2_perl-Crypt-Cracklib.sha256sum] = "0049a15fa3bdc18bf05e6e393c3153ec569b9a0d60f77c6b9e18a4639e44c865"

URI_aarch64_perl-Crypt-Cracklib = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-Cracklib-1.7-44.el10_0.aarch64.rpm;name=aarch64_perl-Crypt-Cracklib;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-Cracklib}"
SRC_URI[aarch64_perl-Crypt-Cracklib.sha256sum] = "6d5da8742cf3447539fad411923c505d3a0b1fa15bfc58f6499718bcc5f36c31"

RDEPENDS:perl-Crypt-Cracklib = " \
 cracklib \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
