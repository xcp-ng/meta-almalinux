# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcron"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kcron \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcron-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0385d1335e0b2699c3ef612b4a8c10dd06eca517eb953b364ba7764e21f0232"

URI_x86_64_v2_kcron = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcron-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcron}"
SRC_URI[x86_64_v2_kcron.sha256sum] = "fcd595e7857dd008e25d52e0a440e266ae79f14ca7853003bdf5fe9c4b5b7c49"

URI_aarch64_kcron = "${EPEL_MIRROR}/aarch64/Packages/k/kcron-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kcron;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcron}"
SRC_URI[aarch64_kcron.sha256sum] = "7b175cf9ce29646d03b02902e70e5b9907bed30d0fdca517c7c0ee1340f1190f"

RDEPENDS:kcron = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
