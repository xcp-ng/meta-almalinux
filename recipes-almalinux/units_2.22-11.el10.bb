# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "units"
PV = "2.22"
PR = "11.el10"
PACKAGES = " \
 units \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/units-2.22-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be84cd06bfe38362bef56d929a86fb70f935289902c15bcd02740d6450e5eaf9"

URI_x86_64_v2_units = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/units-2.22-11.el10.x86_64_v2.rpm;name=x86_64_v2_units;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_units}"
SRC_URI[x86_64_v2_units.sha256sum] = "28f31e080214e4d83f877856c0f2371cdb73754ac5b9aad7816bbc6076eaf3d1"

URI_aarch64_units = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/units-2.22-11.el10.aarch64.rpm;name=aarch64_units;unpack=0"
SRC_URI:append = " ${URI_aarch64_units}"
SRC_URI[aarch64_units.sha256sum] = "3680d8e8f2e2b00f5c8e450d47e2998e380e15dd84d603458c432bd6ba9b9a87"

RDEPENDS:units = " \
 bash \
 glibc \
 python3 \
 readline \
 "
