# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-croniter"
PV = "6.2.2"
PR = "3.el10_2"
PACKAGES = " \
 python3-croniter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-croniter-6.2.2-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "155d4a4ee7325496f64e629d1898c15dd5cd1c23efc1adb6d5f864fe9a195692"

URI_x86_64_v2_python3-croniter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-croniter-6.2.2-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-croniter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-croniter}"
SRC_URI[x86_64_v2_python3-croniter.sha256sum] = "6a47603cf97024d62aa473629c9f42c2d216a2b25460d0b04e03ad2af2ca24d6"

URI_aarch64_python3-croniter = "${EPEL_MIRROR}/aarch64/Packages/p/python3-croniter-6.2.2-3.el10_2.noarch.rpm;name=aarch64_python3-croniter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-croniter}"
SRC_URI[aarch64_python3-croniter.sha256sum] = "65429f5240cec40e2a0de23d5f1b0a144ba10339517e42fe252bccbde679105d"

RDEPENDS:python3-croniter = " \
 python3 \
 python3-dateutil \
 "
