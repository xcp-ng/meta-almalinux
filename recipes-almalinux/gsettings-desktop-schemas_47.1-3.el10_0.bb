# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gsettings-desktop-schemas"
PV = "47.1"
PR = "3.el10_0"
PACKAGES = " \
 gsettings-desktop-schemas \
 gsettings-desktop-schemas-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gsettings-desktop-schemas-47.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f2f3d208a1fdcbe76b4ed4469ac19fc2191abc768223d2f4359254354377b21"

URI_x86_64_v2_gsettings-desktop-schemas = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gsettings-desktop-schemas-47.1-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_gsettings-desktop-schemas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsettings-desktop-schemas}"
SRC_URI[x86_64_v2_gsettings-desktop-schemas.sha256sum] = "0dcc64d00ea4f74dff45bb93695b15a17a886dd070ce8f95a4c22b123e0a6c83"

URI_x86_64_v2_gsettings-desktop-schemas-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gsettings-desktop-schemas-devel-47.1-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_gsettings-desktop-schemas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsettings-desktop-schemas-devel}"
SRC_URI[x86_64_v2_gsettings-desktop-schemas-devel.sha256sum] = "ae1ee769859f03697d51d7708432ad75f67402d1b9576166022544810c23961d"

URI_aarch64_gsettings-desktop-schemas = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gsettings-desktop-schemas-47.1-3.el10_0.aarch64.rpm;name=aarch64_gsettings-desktop-schemas;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsettings-desktop-schemas}"
SRC_URI[aarch64_gsettings-desktop-schemas.sha256sum] = "c2da2ac13444e55914146a72922fe9a4a257d451b483070fd0362359a7810493"

URI_aarch64_gsettings-desktop-schemas-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gsettings-desktop-schemas-devel-47.1-3.el10_0.aarch64.rpm;name=aarch64_gsettings-desktop-schemas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsettings-desktop-schemas-devel}"
SRC_URI[aarch64_gsettings-desktop-schemas-devel.sha256sum] = "e1318298f471613449500e5421f09211fb7e0c43d072f966ea0e5b8a6292e890"

RDEPENDS:gsettings-desktop-schemas = " \
 glib2 \
 "
RDEPENDS:gsettings-desktop-schemas-devel = " \
 gsettings-desktop-schemas \
 pkgconf-pkg-config \
 "
