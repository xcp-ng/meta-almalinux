# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lz4"
PV = "1.28.1"
PR = "7.el10_2"
PACKAGES = " \
 rust-lz4+default-devel \
 rust-lz4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lz4-1.28.1-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af7ad4cb1a33c7b00882d3be7919bf7a90168db0036bb6e5203e49c70a329710"

URI_x86_64_v2_rust-lz4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lz4+default-devel-1.28.1-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lz4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lz4+default-devel}"
SRC_URI[x86_64_v2_rust-lz4+default-devel.sha256sum] = "e574c0ee09d260f7e018cc712f403170bdfea5120034cbe532598f5ef8e12e61"

URI_x86_64_v2_rust-lz4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lz4-devel-1.28.1-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lz4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lz4-devel}"
SRC_URI[x86_64_v2_rust-lz4-devel.sha256sum] = "a0e8e7535f815eb087350fdef1523e567206ee899437361d3964f94452352990"

URI_aarch64_rust-lz4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lz4+default-devel-1.28.1-7.el10_2.noarch.rpm;name=aarch64_rust-lz4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lz4+default-devel}"
SRC_URI[aarch64_rust-lz4+default-devel.sha256sum] = "2cd1a140bfac6ceac67e67325610a65d1d495c014b0c5de093f5706fdc531c7d"

URI_aarch64_rust-lz4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lz4-devel-1.28.1-7.el10_2.noarch.rpm;name=aarch64_rust-lz4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lz4-devel}"
SRC_URI[aarch64_rust-lz4-devel.sha256sum] = "5085ca0e44cbee363a6da4751c2d91ce70b1a06fc1d40da21459d0af4709a531"

RDEPENDS:rust-lz4+default-devel = " \
 cargo \
 rust-lz4-devel \
 "
RDEPENDS:rust-lz4-devel = " \
 cargo \
 rust-lz4-sys+default-devel \
 "
