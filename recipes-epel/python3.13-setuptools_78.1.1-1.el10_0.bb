# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.13-setuptools"
PV = "78.1.1"
PR = "1.el10_0"
PACKAGES = " \
 python3.13-setuptools \
 python3.13-setuptools-wheel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3.13-setuptools-78.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69f151ffffde8dd7714c3c7edc9433198d3c24496cce9293879cbb3bed33fc3a"

URI_x86_64_v2_python3.13-setuptools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-setuptools-78.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3.13-setuptools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-setuptools}"
SRC_URI[x86_64_v2_python3.13-setuptools.sha256sum] = "bbdd797fe4fba106766a415bbef91573b4b131b9a4b0cb0f08e8e93969e45312"

URI_x86_64_v2_python3.13-setuptools-wheel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-setuptools-wheel-78.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3.13-setuptools-wheel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-setuptools-wheel}"
SRC_URI[x86_64_v2_python3.13-setuptools-wheel.sha256sum] = "a3a73aa6812f6f6d03d22f6b7906e8b0a98b19351e11e0d6030095b17f7725a0"

URI_aarch64_python3.13-setuptools = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-setuptools-78.1.1-1.el10_0.noarch.rpm;name=aarch64_python3.13-setuptools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-setuptools}"
SRC_URI[aarch64_python3.13-setuptools.sha256sum] = "e7d8cec3b3c9efffa9d06e8dc1b6dfc1f39267bf49d1c8d78a431c38c2db2d1e"

URI_aarch64_python3.13-setuptools-wheel = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-setuptools-wheel-78.1.1-1.el10_0.noarch.rpm;name=aarch64_python3.13-setuptools-wheel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-setuptools-wheel}"
SRC_URI[aarch64_python3.13-setuptools-wheel.sha256sum] = "eca508880622c4f99a758e8b062702f57c381375d286fadc0c7cb313404ec4a5"

RDEPENDS:python3.13-setuptools = " \
 python3.13 \
 "
RDEPENDS:python3.13-setuptools-wheel = " \
 "
