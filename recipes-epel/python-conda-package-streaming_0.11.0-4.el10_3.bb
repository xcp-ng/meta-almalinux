# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-conda-package-streaming"
PV = "0.11.0"
PR = "4.el10_3"
PACKAGES = " \
 python3-conda-package-streaming \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-conda-package-streaming-0.11.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85d1291dd5fbf7849f74248b6a913b98353ad1c209f938cb704828c47377dd70"

URI_x86_64_v2_python3-conda-package-streaming = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-conda-package-streaming-0.11.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-conda-package-streaming;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-conda-package-streaming}"
SRC_URI[x86_64_v2_python3-conda-package-streaming.sha256sum] = "556ad4c5a56ed09e53665e23002bf4464166a886b711f9b94ce2d7427792a164"

URI_aarch64_python3-conda-package-streaming = "${EPEL_MIRROR}/aarch64/Packages/p/python3-conda-package-streaming-0.11.0-4.el10_3.noarch.rpm;name=aarch64_python3-conda-package-streaming;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-conda-package-streaming}"
SRC_URI[aarch64_python3-conda-package-streaming.sha256sum] = "58f82c6064703ceff0cea73614a48be03222a05078e01794757413e8875b4f5d"

RDEPENDS:python3-conda-package-streaming = " \
 python3 \
 python3-requests \
 python3-zstandard \
 "
