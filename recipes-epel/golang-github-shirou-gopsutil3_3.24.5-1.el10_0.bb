# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-shirou-gopsutil3"
PV = "3.24.5"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-shirou-gopsutil3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-shirou-gopsutil3-3.24.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ebde243c659bacf04cf40dfdac4598f4cc064f1444225f049c64255aab84a91"

URI_x86_64_v2_golang-github-shirou-gopsutil3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-shirou-gopsutil3-devel-3.24.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-shirou-gopsutil3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-shirou-gopsutil3-devel}"
SRC_URI[x86_64_v2_golang-github-shirou-gopsutil3-devel.sha256sum] = "04aa69864e593a9ed87f1e990f849f9e630a07760c8cba3dc87b12cdd558afa2"

URI_aarch64_golang-github-shirou-gopsutil3-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-shirou-gopsutil3-devel-3.24.5-1.el10_0.noarch.rpm;name=aarch64_golang-github-shirou-gopsutil3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-shirou-gopsutil3-devel}"
SRC_URI[aarch64_golang-github-shirou-gopsutil3-devel.sha256sum] = "739b7bcc647a86fffb22adc144b066931540b08fb588db3fb2065f83df25e5c5"

RDEPENDS:golang-github-shirou-gopsutil3-devel = " \
 go-filesystem \
 golang-github-tklauser-sysconf-devel \
 golang-x-sys-devel \
 "
