# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-file_diff"
PV = "1.0.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-file_diff+default-devel \
 rust-file_diff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-file_diff-1.0.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f68f2f427d5feaa51267f80f9a55ea6fc2b83d5782d5188482ccd65e91c0230"

URI_x86_64_v2_rust-file_diff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-file_diff+default-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-file_diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-file_diff+default-devel}"
SRC_URI[x86_64_v2_rust-file_diff+default-devel.sha256sum] = "159ec0a7c4d4fb28f203b652a7037a61dd74e792f98db10a4ca3b1dddad70b81"

URI_x86_64_v2_rust-file_diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-file_diff-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-file_diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-file_diff-devel}"
SRC_URI[x86_64_v2_rust-file_diff-devel.sha256sum] = "716e25ef5fcf1aee2316806b953225776a7cdb36e2425323553bbcb483cb6532"

URI_aarch64_rust-file_diff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-file_diff+default-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-file_diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-file_diff+default-devel}"
SRC_URI[aarch64_rust-file_diff+default-devel.sha256sum] = "d0567893a456bcf704a9c4df870c373ddb017067e2b4886d1b482fe485bc7a9f"

URI_aarch64_rust-file_diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-file_diff-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-file_diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-file_diff-devel}"
SRC_URI[aarch64_rust-file_diff-devel.sha256sum] = "00d705474e5a3ef3a071a80815b16c8d143f87236f981d3835849105bdf9803f"

RDEPENDS:rust-file_diff+default-devel = " \
 cargo \
 rust-file_diff-devel \
 "
RDEPENDS:rust-file_diff-devel = " \
 cargo \
 "
