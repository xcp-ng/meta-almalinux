# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kirigami"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kirigami \
 kf6-kirigami-devel \
 kf6-kirigami-doc \
 kf6-kirigami-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kirigami-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a1f89812edc7c75d94bc23a4eecf802b730273956fa85e9d1f56c549f468307"

URI_x86_64_v2_kf6-kirigami = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami}"
SRC_URI[x86_64_v2_kf6-kirigami.sha256sum] = "f9ce073ebd37132041087dd56c6b22a89ba122d6b7f41a9a4bc550511cbacbdc"

URI_x86_64_v2_kf6-kirigami-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-devel}"
SRC_URI[x86_64_v2_kf6-kirigami-devel.sha256sum] = "fd11bea458baf7f3b5024196f60db6939a212a940fcd7c03f9d37d558385c8bb"

URI_x86_64_v2_kf6-kirigami-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kirigami-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-doc}"
SRC_URI[x86_64_v2_kf6-kirigami-doc.sha256sum] = "8f3d0ca33e156cb75644ba145b6f36bb903c2f115c84c379dead0e050f5212c9"

URI_x86_64_v2_kf6-kirigami-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kirigami-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-html}"
SRC_URI[x86_64_v2_kf6-kirigami-html.sha256sum] = "43367a6916cffd680aab3116e9a20a7481447f67b2186d600b28ed31c0f5a175"

URI_aarch64_kf6-kirigami = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kirigami;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami}"
SRC_URI[aarch64_kf6-kirigami.sha256sum] = "c2ffd96e11c39dc96ab77cc52cf1665670790fe65b959d379730432a9f03beea"

URI_aarch64_kf6-kirigami-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kirigami-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-devel}"
SRC_URI[aarch64_kf6-kirigami-devel.sha256sum] = "7bf15efdccd00aa63f8dc8a50303c1aa967105261dbeade7c9becac48346b023"

URI_aarch64_kf6-kirigami-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kirigami-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-doc}"
SRC_URI[aarch64_kf6-kirigami-doc.sha256sum] = "67588932072bfbf9d5539b85bcb7f511206bf3e819d22269026e6947339bb1fd"

URI_aarch64_kf6-kirigami-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kirigami-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-html}"
SRC_URI[aarch64_kf6-kirigami-html.sha256sum] = "1849de15802b655b3e42933f93d676725658b811b2084aac8e412a14b46cd92e"

RDEPENDS:kf6-kirigami = " \
 glibc \
 libgomp \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kirigami-devel = " \
 cmake-filesystem \
 kf6-kirigami \
 "
RDEPENDS:kf6-kirigami-doc = " \
 "
RDEPENDS:kf6-kirigami-html = " \
 "
