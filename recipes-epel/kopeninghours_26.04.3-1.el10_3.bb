# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kopeninghours"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kopeninghours \
 kopeninghours-devel \
 kopeninghours-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kopeninghours-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92545a42c72c7c1a1836ddb2c55a30276ac565ca3b5ec67bf0b69fdae99fc6f0"

URI_x86_64_v2_kopeninghours = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kopeninghours-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kopeninghours;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kopeninghours}"
SRC_URI[x86_64_v2_kopeninghours.sha256sum] = "aab914002dcbca9c9734e97974896764edf6daacdd685dfa07e4d36e6c049d15"

URI_x86_64_v2_kopeninghours-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kopeninghours-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kopeninghours-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kopeninghours-devel}"
SRC_URI[x86_64_v2_kopeninghours-devel.sha256sum] = "d5e36b8df37a2846e9c6171580e6c33b8d6ea5af408ed9084f6400b2c817f640"

URI_x86_64_v2_kopeninghours-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kopeninghours-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kopeninghours-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kopeninghours-doc}"
SRC_URI[x86_64_v2_kopeninghours-doc.sha256sum] = "c0593b395e1fc0261a61cb6787054ac874041889cdf29fc571351f13286e0ad1"

URI_aarch64_kopeninghours = "${EPEL_MIRROR}/aarch64/Packages/k/kopeninghours-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kopeninghours;unpack=0"
SRC_URI:append = " ${URI_aarch64_kopeninghours}"
SRC_URI[aarch64_kopeninghours.sha256sum] = "6e4c55cc118d5401d91baae741dbb74fe5c8381fd5c7fd665706839f6b13d601"

URI_aarch64_kopeninghours-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kopeninghours-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kopeninghours-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kopeninghours-devel}"
SRC_URI[aarch64_kopeninghours-devel.sha256sum] = "08c866681badaf10631d703810e365dbcfa3301061314d1e009a0f573f3a5288"

URI_aarch64_kopeninghours-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kopeninghours-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kopeninghours-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kopeninghours-doc}"
SRC_URI[aarch64_kopeninghours-doc.sha256sum] = "7c8afbb3a311e105b1253a0700a9b5f63d1c9eb3af57a588c259e065ecdb459d"

RDEPENDS:kopeninghours = " \
 boost-python3 \
 glibc \
 kf6-filesystem \
 kf6-kholidays \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kopeninghours-devel = " \
 cmake-filesystem \
 kopeninghours \
 "
RDEPENDS:kopeninghours-doc = " \
 "
