# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pikepdf"
PV = "8.8.0"
PR = "4.el10_0"
PACKAGES = " \
 python3-pikepdf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pikepdf-8.8.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "338281e945b9ba392c4cbdceeff5ed87ac148229e44b1d4159a366cbfb668013"

URI_x86_64_v2_python3-pikepdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pikepdf-8.8.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pikepdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pikepdf}"
SRC_URI[x86_64_v2_python3-pikepdf.sha256sum] = "5369d2aac851477a51b650f66213f63a149fc75e077238ddd444af1d44770bc6"

URI_aarch64_python3-pikepdf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pikepdf-8.8.0-4.el10_0.aarch64.rpm;name=aarch64_python3-pikepdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pikepdf}"
SRC_URI[aarch64_python3-pikepdf.sha256sum] = "b42780a803770b5b4f98b0176ba468e14508b37900a224b14921859ccb1f9f4e"

RDEPENDS:python3-pikepdf = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-deprecated \
 python3-lxml \
 python3-packaging \
 python3-pillow \
 qpdf-libs \
 "
