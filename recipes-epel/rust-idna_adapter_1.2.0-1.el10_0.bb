# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-idna_adapter"
PV = "1.2.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-idna_adapter+compiled_data-devel \
 rust-idna_adapter+default-devel \
 rust-idna_adapter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-idna_adapter-1.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fdc6c09505f33d34a7c8228fea75e519aab8a3814e885851e8c34af891709f4"

URI_x86_64_v2_rust-idna_adapter+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna_adapter+compiled_data-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna_adapter+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna_adapter+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-idna_adapter+compiled_data-devel.sha256sum] = "ae348796e85c85f68fc93a163ddf8a4abbd29acf12fb6dd1c796d8846704b0d7"

URI_x86_64_v2_rust-idna_adapter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna_adapter+default-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna_adapter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna_adapter+default-devel}"
SRC_URI[x86_64_v2_rust-idna_adapter+default-devel.sha256sum] = "e749753f30c12c43c5aa6906e5819e2a4442e43f73a5211d7f9824f2ad16dc76"

URI_x86_64_v2_rust-idna_adapter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna_adapter-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna_adapter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna_adapter-devel}"
SRC_URI[x86_64_v2_rust-idna_adapter-devel.sha256sum] = "92b1a477211788ad05eaa25441356b862bfa5d3464ca3967db1c1925b523eeab"

URI_aarch64_rust-idna_adapter+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna_adapter+compiled_data-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-idna_adapter+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna_adapter+compiled_data-devel}"
SRC_URI[aarch64_rust-idna_adapter+compiled_data-devel.sha256sum] = "462a1e98ce5a94daa7e5b1a782d883be02d81537b3157e10928d35514ba15d41"

URI_aarch64_rust-idna_adapter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna_adapter+default-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-idna_adapter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna_adapter+default-devel}"
SRC_URI[aarch64_rust-idna_adapter+default-devel.sha256sum] = "b33cffd0bcb3e2b903a97ca60bf31f9b3b418cf05ca727c7b2a2ca7e64e9d952"

URI_aarch64_rust-idna_adapter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna_adapter-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-idna_adapter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna_adapter-devel}"
SRC_URI[aarch64_rust-idna_adapter-devel.sha256sum] = "2b293f9a378151a13da2a94248df0b159287a5ba37fd93831d839a2a6039be80"

RDEPENDS:rust-idna_adapter+compiled_data-devel = " \
 cargo \
 rust-icu_normalizer+compiled_data-devel \
 rust-icu_properties+compiled_data-devel \
 rust-idna_adapter-devel \
 "
RDEPENDS:rust-idna_adapter+default-devel = " \
 cargo \
 rust-idna_adapter-devel \
 "
RDEPENDS:rust-idna_adapter-devel = " \
 cargo \
 rust \
 rust-icu_normalizer+default-devel \
 rust-icu_properties+default-devel \
 "
