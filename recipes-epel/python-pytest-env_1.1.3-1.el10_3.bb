# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-env"
PV = "1.1.3"
PR = "1.el10_3"
PACKAGES = " \
 python3-pytest-env \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-env-1.1.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44735951e012f648e2f6359c597592681027859c872117b22b189601fa1c9ac9"

URI_x86_64_v2_python3-pytest-env = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-env-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-env;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-env}"
SRC_URI[x86_64_v2_python3-pytest-env.sha256sum] = "fc4aed853b614e0b773a156c95a39f1fc5716340635eef2adb8bb168c2359573"

URI_aarch64_python3-pytest-env = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-env-1.1.3-1.el10_3.noarch.rpm;name=aarch64_python3-pytest-env;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-env}"
SRC_URI[aarch64_python3-pytest-env.sha256sum] = "6b4b35361d34475c5e0f19ae42b602b4878076fc4b274f89502008fb28b6ec71"

RDEPENDS:python3-pytest-env = " \
 python3 \
 python3-pytest \
 "
