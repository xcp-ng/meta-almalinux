# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdkimpp"
PV = "2.4.1"
PR = "1.el10_3"
PACKAGES = " \
 libdkimpp \
 libdkimpp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdkimpp-2.4.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5c29a2c3d17aa49c5a635bceeecfcbd150ceb5c5f51b592a8ab3a4aa1e67cf9"

URI_x86_64_v2_libdkimpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdkimpp-2.4.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdkimpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdkimpp}"
SRC_URI[x86_64_v2_libdkimpp.sha256sum] = "d4779ae98137a41d8e304ed18203b1647c963981ac883d91b8f9bc42330d8112"

URI_x86_64_v2_libdkimpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdkimpp-devel-2.4.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdkimpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdkimpp-devel}"
SRC_URI[x86_64_v2_libdkimpp-devel.sha256sum] = "e10fda8d4a7541bcddebccef64d8a3b7245e532115b4d2e4ae808bee0624bbc5"

URI_aarch64_libdkimpp = "${EPEL_MIRROR}/aarch64/Packages/l/libdkimpp-2.4.1-1.el10_3.aarch64.rpm;name=aarch64_libdkimpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdkimpp}"
SRC_URI[aarch64_libdkimpp.sha256sum] = "22fb980b99584085eb27851800d7f5f85457bf40886d74c94806724977b083a2"

URI_aarch64_libdkimpp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdkimpp-devel-2.4.1-1.el10_3.aarch64.rpm;name=aarch64_libdkimpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdkimpp-devel}"
SRC_URI[aarch64_libdkimpp-devel.sha256sum] = "49eaf127b312758699e4ebf523a5d3a3144688e188a09b19100bc00532b5d666"

RDEPENDS:libdkimpp = " \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 openssl-libs \
 "
RDEPENDS:libdkimpp-devel = " \
 libdkimpp \
 pkgconf-pkg-config \
 "
