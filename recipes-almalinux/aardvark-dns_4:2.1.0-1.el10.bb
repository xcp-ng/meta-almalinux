# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aardvark-dns"
PE = "4"
PV = "2.1.0"
PR = "1.el10"
PACKAGES = " \
 aardvark-dns \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/aardvark-dns-2.1.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0e69313a7ba70835ba75b33854b8cc71c5af6f870cfb481a70897eea8e5fa595"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aardvark-dns-2.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_aardvark-dns;unpack=0"
SRC_URI[x86_64_v2_aardvark-dns.sha256sum] = "e35e8d4c9cfee46367d0505ea2b1e28da46bfc833a828f268f8da8baf30c358a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aardvark-dns-2.1.0-1.el10.aarch64.rpm;name=aarch64_aardvark-dns;unpack=0"
SRC_URI[aarch64_aardvark-dns.sha256sum] = "ef46799171f9e0dff2c5a23c6b7c649ecf28de76ef665f32197dc549b8eac67e"

RDEPENDS:aardvark-dns = " \
 glibc \
 libgcc \
 "
