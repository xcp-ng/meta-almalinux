# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num_enum"
PV = "0.5.11"
PR = "4.el10_0"
PACKAGES = " \
 rust-num_enum+complex-expressions-devel \
 rust-num_enum+default-devel \
 rust-num_enum+external_doc-devel \
 rust-num_enum+std-devel \
 rust-num_enum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num_enum-0.5.11-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f15ccf7fa85179d45acc6d50bcd49bad623355fa268a7ac03267b61aa577c6f1"

URI_x86_64_v2_rust-num_enum+complex-expressions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum+complex-expressions-devel-0.5.11-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum+complex-expressions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum+complex-expressions-devel}"
SRC_URI[x86_64_v2_rust-num_enum+complex-expressions-devel.sha256sum] = "7bf17097bc5097e7fcf2bb00dd14b907a9b90fbd3ff166d47b7e44329aeb7bb1"

URI_x86_64_v2_rust-num_enum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum+default-devel-0.5.11-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum+default-devel}"
SRC_URI[x86_64_v2_rust-num_enum+default-devel.sha256sum] = "e2859a91bcca5e7c7366b7ca98851c9c7bd5cb496f7dabd2fea7fa7587c61a0c"

URI_x86_64_v2_rust-num_enum+external_doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum+external_doc-devel-0.5.11-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum+external_doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum+external_doc-devel}"
SRC_URI[x86_64_v2_rust-num_enum+external_doc-devel.sha256sum] = "c9759bf72ef4795814ee1b4f7aa2a953610c4cdf33f452980b00324bd38bad41"

URI_x86_64_v2_rust-num_enum+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum+std-devel-0.5.11-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum+std-devel}"
SRC_URI[x86_64_v2_rust-num_enum+std-devel.sha256sum] = "d42f1c5553e7587f319153d3978efc145976034c24f2374b5855f7216ab2e9d3"

URI_x86_64_v2_rust-num_enum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum-devel-0.5.11-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum-devel}"
SRC_URI[x86_64_v2_rust-num_enum-devel.sha256sum] = "1020b4174870a7a46a72c1aa0bff4192dfe98b2741866162cedee8fc46b4432c"

URI_aarch64_rust-num_enum+complex-expressions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum+complex-expressions-devel-0.5.11-4.el10_0.noarch.rpm;name=aarch64_rust-num_enum+complex-expressions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum+complex-expressions-devel}"
SRC_URI[aarch64_rust-num_enum+complex-expressions-devel.sha256sum] = "0d0ccda3ddeec7586e95ef71b8fe773556ca38b990ef7ae7930c5fc7a9c9ad4b"

URI_aarch64_rust-num_enum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum+default-devel-0.5.11-4.el10_0.noarch.rpm;name=aarch64_rust-num_enum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum+default-devel}"
SRC_URI[aarch64_rust-num_enum+default-devel.sha256sum] = "6a451a0087baa054c886dc73f75d9e96d38fa54afa0f94526df363beca5562e0"

URI_aarch64_rust-num_enum+external_doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum+external_doc-devel-0.5.11-4.el10_0.noarch.rpm;name=aarch64_rust-num_enum+external_doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum+external_doc-devel}"
SRC_URI[aarch64_rust-num_enum+external_doc-devel.sha256sum] = "f1955044e47b6493b18f2e13e83c5cc1acd6659740d6cd42b327abea8cba5fa4"

URI_aarch64_rust-num_enum+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum+std-devel-0.5.11-4.el10_0.noarch.rpm;name=aarch64_rust-num_enum+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum+std-devel}"
SRC_URI[aarch64_rust-num_enum+std-devel.sha256sum] = "c18768803c0094f25bbed3903654f7ca5d71827cc9bff6ac49a6c721d25cd1e2"

URI_aarch64_rust-num_enum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum-devel-0.5.11-4.el10_0.noarch.rpm;name=aarch64_rust-num_enum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum-devel}"
SRC_URI[aarch64_rust-num_enum-devel.sha256sum] = "dcd45b64fa6aed7d67b1fd763bce0dac5dced80a3ef9a0d707a41c6da68f0c88"

RDEPENDS:rust-num_enum+complex-expressions-devel = " \
 cargo \
 rust-num_enum-devel \
 rust-num_enum_derive+complex-expressions-devel \
 "
RDEPENDS:rust-num_enum+default-devel = " \
 cargo \
 rust-num_enum+std-devel \
 rust-num_enum-devel \
 "
RDEPENDS:rust-num_enum+external_doc-devel = " \
 cargo \
 rust-num_enum-devel \
 "
RDEPENDS:rust-num_enum+std-devel = " \
 cargo \
 rust-num_enum-devel \
 rust-num_enum_derive+std-devel \
 "
RDEPENDS:rust-num_enum-devel = " \
 cargo \
 rust-num_enum_derive-devel \
 "
