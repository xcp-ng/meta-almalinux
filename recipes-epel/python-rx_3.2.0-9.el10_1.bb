# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rx"
PV = "3.2.0"
PR = "9.el10_1"
PACKAGES = " \
 python3-rx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rx-3.2.0-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ef9f9ca159b2acaa2404546ab7d65e0491eec3b99cae45f7d59e2cff2a37d24"

URI_x86_64_v2_python3-rx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rx-3.2.0-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rx}"
SRC_URI[x86_64_v2_python3-rx.sha256sum] = "96e24beea69c593e5c424f751c3a62d6b5484b785cd289645b72d180781271e4"

URI_aarch64_python3-rx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rx-3.2.0-9.el10_1.noarch.rpm;name=aarch64_python3-rx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rx}"
SRC_URI[aarch64_python3-rx.sha256sum] = "22484ed0d62c9eee1d4e976cd1780b9b51d82a36508d2b41cde0b92adfa67056"

RDEPENDS:python3-rx = " \
 python3 \
 "
