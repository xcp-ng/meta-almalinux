# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lcmaps"
PV = "1.6.7"
PR = "1.el10_3"
PACKAGES = " \
 lcmaps \
 lcmaps-common-devel \
 lcmaps-devel \
 lcmaps-without-gsi \
 lcmaps-without-gsi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lcmaps-1.6.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "893d7f9568a5f5a658ad99a24270de8c642f080d668ab1db147ad26960c77207"

URI_x86_64_v2_lcmaps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lcmaps-1.6.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lcmaps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lcmaps}"
SRC_URI[x86_64_v2_lcmaps.sha256sum] = "638db8db246f3103df21a85120182f9b7dad9a9e576973c7682b5e2785192a1c"

URI_x86_64_v2_lcmaps-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lcmaps-common-devel-1.6.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lcmaps-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lcmaps-common-devel}"
SRC_URI[x86_64_v2_lcmaps-common-devel.sha256sum] = "d15f589dbbbffd181f01f62e529e61fc726912a644b5adc5b7b4d8b02e51752f"

URI_x86_64_v2_lcmaps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lcmaps-devel-1.6.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lcmaps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lcmaps-devel}"
SRC_URI[x86_64_v2_lcmaps-devel.sha256sum] = "e21b436b19562962735139eb8e2ffdf6196477219037c10ec38093081023b6d5"

URI_x86_64_v2_lcmaps-without-gsi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lcmaps-without-gsi-1.6.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lcmaps-without-gsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lcmaps-without-gsi}"
SRC_URI[x86_64_v2_lcmaps-without-gsi.sha256sum] = "4aebb0125d5bcd3aa4e1b30f21e958eac63118184351964c32d27f30e9ec7193"

URI_x86_64_v2_lcmaps-without-gsi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lcmaps-without-gsi-devel-1.6.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lcmaps-without-gsi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lcmaps-without-gsi-devel}"
SRC_URI[x86_64_v2_lcmaps-without-gsi-devel.sha256sum] = "9c60b17428d3d5d232805e73d19c6953db1868870b97382721f9ad65264b1063"

URI_aarch64_lcmaps = "${EPEL_MIRROR}/aarch64/Packages/l/lcmaps-1.6.7-1.el10_3.aarch64.rpm;name=aarch64_lcmaps;unpack=0"
SRC_URI:append = " ${URI_aarch64_lcmaps}"
SRC_URI[aarch64_lcmaps.sha256sum] = "0619c18422034cfce3b2f837b4dd2b9a9b72df95b59ccebc3815fe82fa4f6ab0"

URI_aarch64_lcmaps-common-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lcmaps-common-devel-1.6.7-1.el10_3.aarch64.rpm;name=aarch64_lcmaps-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lcmaps-common-devel}"
SRC_URI[aarch64_lcmaps-common-devel.sha256sum] = "503223bb12b8ea3df052cb7ffb0ee97885f234eb21bbab24ada7b03f2a834e3f"

URI_aarch64_lcmaps-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lcmaps-devel-1.6.7-1.el10_3.aarch64.rpm;name=aarch64_lcmaps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lcmaps-devel}"
SRC_URI[aarch64_lcmaps-devel.sha256sum] = "a17b511c7bf16d4345ac288dd5e7f5da1aeefacd2814e20b291527c5fee8c8e2"

URI_aarch64_lcmaps-without-gsi = "${EPEL_MIRROR}/aarch64/Packages/l/lcmaps-without-gsi-1.6.7-1.el10_3.aarch64.rpm;name=aarch64_lcmaps-without-gsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_lcmaps-without-gsi}"
SRC_URI[aarch64_lcmaps-without-gsi.sha256sum] = "c3ad4beb7ccdc7085d7d78682f1651b042b3518fff8fbe11556a8e18c31c94de"

URI_aarch64_lcmaps-without-gsi-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lcmaps-without-gsi-devel-1.6.7-1.el10_3.aarch64.rpm;name=aarch64_lcmaps-without-gsi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lcmaps-without-gsi-devel}"
SRC_URI[aarch64_lcmaps-without-gsi-devel.sha256sum] = "4bd3d6e05ccfd9a4d4c7f01c7050419c47a66237f1f5882066f00f9c30001b51"

RDEPENDS:lcmaps = " \
 glibc \
 globus-common \
 globus-gsi-credential \
 globus-gss-assist \
 globus-gssapi-gsi \
 openssl-libs \
 voms \
 "
RDEPENDS:lcmaps-common-devel = " \
 pkgconf-pkg-config \
 "
RDEPENDS:lcmaps-devel = " \
 globus-gsi-cert-utils-devel \
 globus-gss-assist-devel \
 globus-gssapi-gsi-devel \
 lcmaps \
 lcmaps-common-devel \
 lcmaps-devel \
 openssl-devel \
 pkgconf-pkg-config \
 voms-devel \
 "
RDEPENDS:lcmaps-without-gsi = " \
 glibc \
 "
RDEPENDS:lcmaps-without-gsi-devel = " \
 lcmaps-common-devel \
 lcmaps-without-gsi \
 lcmaps-without-gsi-devel \
 pkgconf-pkg-config \
 "
