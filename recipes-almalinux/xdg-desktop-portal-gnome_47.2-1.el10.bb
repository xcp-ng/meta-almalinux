# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-desktop-portal-gnome"
PV = "47.2"
PR = "1.el10"
PACKAGES = " \
 xdg-desktop-portal-gnome \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xdg-desktop-portal-gnome-47.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0395d2f1c879556480958c57ae485f9977a6057ff95a1f1c5a8c44fb482de66"

URI_x86_64_v2_xdg-desktop-portal-gnome = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xdg-desktop-portal-gnome-47.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_xdg-desktop-portal-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-desktop-portal-gnome}"
SRC_URI[x86_64_v2_xdg-desktop-portal-gnome.sha256sum] = "3d923247b16a6f3676ee349c3ffb9c95edcf7d95cfd0aea67b4c8d7c23e64c1b"

URI_aarch64_xdg-desktop-portal-gnome = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xdg-desktop-portal-gnome-47.2-1.el10.aarch64.rpm;name=aarch64_xdg-desktop-portal-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-desktop-portal-gnome}"
SRC_URI[aarch64_xdg-desktop-portal-gnome.sha256sum] = "4f1252bd44dafa40525f93700459a0a987b027f8250682439719ebc59fad8891"

RDEPENDS:xdg-desktop-portal-gnome = " \
 bash \
 cairo \
 dbus \
 dbus-common \
 fontconfig \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-desktop4 \
 graphene \
 gtk4 \
 libX11 \
 libadwaita \
 libgcc \
 libwayland-client \
 xdg-desktop-portal \
 "
