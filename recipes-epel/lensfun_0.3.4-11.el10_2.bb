# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lensfun"
PV = "0.3.4"
PR = "11.el10_2"
PACKAGES = " \
 lensfun \
 lensfun-devel \
 lensfun-tools \
 python3-lensfun \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lensfun-0.3.4-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3aa14c4f22229d46877b80623403c57e58771562366d97b1f4e085dbf2ff7d94"

URI_x86_64_v2_lensfun = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lensfun-0.3.4-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lensfun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lensfun}"
SRC_URI[x86_64_v2_lensfun.sha256sum] = "19ed3ba56b886e98ef4ef0348363852b66e282cf5bdeaadcb6e341912db0fa2b"

URI_x86_64_v2_lensfun-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lensfun-devel-0.3.4-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lensfun-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lensfun-devel}"
SRC_URI[x86_64_v2_lensfun-devel.sha256sum] = "5087938d4461677008269be848b637d6b7d52a74586cf4bf9856e223550736e8"

URI_x86_64_v2_lensfun-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lensfun-tools-0.3.4-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lensfun-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lensfun-tools}"
SRC_URI[x86_64_v2_lensfun-tools.sha256sum] = "a70a97e9aa9dfaa76e06c64e763253a2fbd7835f0a566956d065fe4bdd74ae28"

URI_x86_64_v2_python3-lensfun = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lensfun-0.3.4-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lensfun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lensfun}"
SRC_URI[x86_64_v2_python3-lensfun.sha256sum] = "4e6504290c6f6386d953385e59a932b4c1dc665d26b535e237906a4a877a4d25"

URI_aarch64_lensfun = "${EPEL_MIRROR}/aarch64/Packages/l/lensfun-0.3.4-11.el10_2.aarch64.rpm;name=aarch64_lensfun;unpack=0"
SRC_URI:append = " ${URI_aarch64_lensfun}"
SRC_URI[aarch64_lensfun.sha256sum] = "0b4d5a365bbd0e33e8ee3eba330335265e640e30a6f09fd76955964292f9d819"

URI_aarch64_lensfun-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lensfun-devel-0.3.4-11.el10_2.aarch64.rpm;name=aarch64_lensfun-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lensfun-devel}"
SRC_URI[aarch64_lensfun-devel.sha256sum] = "292f0d604ed2f79e1415f13c9ab9fdbcf4d6fa62aa7664a4e5e4af93d18344cb"

URI_aarch64_lensfun-tools = "${EPEL_MIRROR}/aarch64/Packages/l/lensfun-tools-0.3.4-11.el10_2.aarch64.rpm;name=aarch64_lensfun-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_lensfun-tools}"
SRC_URI[aarch64_lensfun-tools.sha256sum] = "07e2e7d9e9878aec805bf01bf75ccea7e37eb16bed9c8b4bf728fbe8132c539e"

URI_aarch64_python3-lensfun = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lensfun-0.3.4-11.el10_2.aarch64.rpm;name=aarch64_python3-lensfun;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lensfun}"
SRC_URI[aarch64_python3-lensfun.sha256sum] = "129e64ebe2eefc78dc5e21f0a8afec8d2e7c77f242f7933dc74e153ec2644d03"

RDEPENDS:lensfun = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:lensfun-devel = " \
 glib2-devel \
 lensfun \
 pkgconf-pkg-config \
 "
RDEPENDS:lensfun-tools = " \
 python3 \
 python3-lensfun \
 "
RDEPENDS:python3-lensfun = " \
 lensfun \
 python3 \
 "
