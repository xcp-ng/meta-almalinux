# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jsonpath-rw"
PV = "1.4.0"
PR = "22.el10_1"
PACKAGES = " \
 python3-jsonpath-rw \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jsonpath-rw-1.4.0-22.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a5147e359ebfd6fdb653afe441501de16f04cc83931433ae5ea199aa8a5e2bc"

URI_x86_64_v2_python3-jsonpath-rw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jsonpath-rw-1.4.0-22.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jsonpath-rw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jsonpath-rw}"
SRC_URI[x86_64_v2_python3-jsonpath-rw.sha256sum] = "d8ddb0558e70286c73b7863a754db9ccc73aa4f83ad9efd06c2bedaccc610e5e"

URI_aarch64_python3-jsonpath-rw = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jsonpath-rw-1.4.0-22.el10_1.noarch.rpm;name=aarch64_python3-jsonpath-rw;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jsonpath-rw}"
SRC_URI[aarch64_python3-jsonpath-rw.sha256sum] = "1d608b544a05657135d0cda8cbc221cd8d0a0fd2caaac75351e9db493fe16988"

RDEPENDS:python3-jsonpath-rw = " \
 python3 \
 python3-decorator \
 python3-ply \
 python3-six \
 "
