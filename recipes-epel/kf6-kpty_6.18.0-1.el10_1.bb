# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kpty"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kpty \
 kf6-kpty-devel \
 kf6-kpty-doc \
 kf6-kpty-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kpty-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb6452535661fc8a41f69d151400338d70f1a55bd81b08fb53161f47e111732b"

URI_x86_64_v2_kf6-kpty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpty-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpty}"
SRC_URI[x86_64_v2_kf6-kpty.sha256sum] = "0aaaab154d2a70071a087f5e3b0f652338115ce7fb2126ef4c1750f54ab59707"

URI_x86_64_v2_kf6-kpty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpty-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpty-devel}"
SRC_URI[x86_64_v2_kf6-kpty-devel.sha256sum] = "a30a2259c99cda174e561894566a423cb1c45f12abed6c570d0036dbbbaf3a27"

URI_x86_64_v2_kf6-kpty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpty-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpty-doc}"
SRC_URI[x86_64_v2_kf6-kpty-doc.sha256sum] = "2c586e1679a191465b59f1206d42805c95242bad36c291d14c283a60bb4ef78b"

URI_x86_64_v2_kf6-kpty-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpty-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpty-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpty-html}"
SRC_URI[x86_64_v2_kf6-kpty-html.sha256sum] = "e38ac7eb35e6bf5b7c62701813dcd0e344fd9c2fe80b224a38aec6497a281270"

URI_aarch64_kf6-kpty = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpty-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kpty;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpty}"
SRC_URI[aarch64_kf6-kpty.sha256sum] = "a4738777e3ccd0c63677925fa5aaafd07258449286a6bae0d3b58383d3e859f1"

URI_aarch64_kf6-kpty-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpty-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kpty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpty-devel}"
SRC_URI[aarch64_kf6-kpty-devel.sha256sum] = "88d18c052a67542ba045610fcacef524584a640ec18288dd038c5217f24826d5"

URI_aarch64_kf6-kpty-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpty-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kpty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpty-doc}"
SRC_URI[aarch64_kf6-kpty-doc.sha256sum] = "b8a1fe0fd2f4606a7ae80514823d8a3a89576ce4dd5ebbf0802c99c02afe12b9"

URI_aarch64_kf6-kpty-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpty-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kpty-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpty-html}"
SRC_URI[aarch64_kf6-kpty-html.sha256sum] = "e4eea54fe9605185fd36261c16939caebda8fac48b83d4de652667c51c3ad7c7"

RDEPENDS:kf6-kpty = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 libutempter \
 qt6-qtbase \
 "
RDEPENDS:kf6-kpty-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kpty \
 "
RDEPENDS:kf6-kpty-doc = " \
 "
RDEPENDS:kf6-kpty-html = " \
 "
