# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ntlm-auth"
PV = "1.5.0"
PR = "11.el10_0"
PACKAGES = " \
 python3-ntlm-auth \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ntlm-auth-1.5.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52b99a29198101dfb86a39d7c0714e13c6469054fcff19a7ac4d7e6a6bb3e245"

URI_x86_64_v2_python3-ntlm-auth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ntlm-auth-1.5.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ntlm-auth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ntlm-auth}"
SRC_URI[x86_64_v2_python3-ntlm-auth.sha256sum] = "f02df024e199594966bbc1941f5ba0f1ec2a81c61c1eef7382afa0b24423bb36"

URI_aarch64_python3-ntlm-auth = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ntlm-auth-1.5.0-11.el10_0.noarch.rpm;name=aarch64_python3-ntlm-auth;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ntlm-auth}"
SRC_URI[aarch64_python3-ntlm-auth.sha256sum] = "887cbbb533b707e142760cc73418848c86e4990203b646bde28312f9d166d07a"

RDEPENDS:python3-ntlm-auth = " \
 python3 \
 "
