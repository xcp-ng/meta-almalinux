# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "svt-av1"
PV = "2.3.0"
PR = "1.el10_0"
PACKAGES = " \
 gstreamer1-svt-av1 \
 svt-av1 \
 svt-av1-devel \
 svt-av1-devel-docs \
 svt-av1-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/svt-av1-2.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94f7993f1f8ea6e88407e37150463344a8e9926bee584839e4a6ee2799235a41"

URI_x86_64_v2_gstreamer1-svt-av1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gstreamer1-svt-av1-2.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-svt-av1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-svt-av1}"
SRC_URI[x86_64_v2_gstreamer1-svt-av1.sha256sum] = "fc67957513cb9ca0d6701de25cd3a3e140dec8c5766550a2b6a488995d096077"

URI_x86_64_v2_svt-av1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/svt-av1-2.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_svt-av1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_svt-av1}"
SRC_URI[x86_64_v2_svt-av1.sha256sum] = "5d825e69feb073bad9657c7bab72b15e0b33a55d17f56d4f5a9be2b428bf2f78"

URI_x86_64_v2_svt-av1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/svt-av1-devel-2.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_svt-av1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_svt-av1-devel}"
SRC_URI[x86_64_v2_svt-av1-devel.sha256sum] = "fb3cf9f23b3d9cb51c566144c042e0832ae425d7549bb478994fe11bcd2b706c"

URI_x86_64_v2_svt-av1-devel-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/svt-av1-devel-docs-2.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_svt-av1-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_svt-av1-devel-docs}"
SRC_URI[x86_64_v2_svt-av1-devel-docs.sha256sum] = "4f15f81465f1c261c4b501b166bb19ab465241f2b236f1ceed5c17820c30bc12"

URI_x86_64_v2_svt-av1-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/svt-av1-libs-2.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_svt-av1-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_svt-av1-libs}"
SRC_URI[x86_64_v2_svt-av1-libs.sha256sum] = "767e3a4fe4c8a9ed9423efe90b3acff32ce423741e552d65758aa0c030573a9e"

URI_aarch64_gstreamer1-svt-av1 = "${EPEL_MIRROR}/aarch64/Packages/g/gstreamer1-svt-av1-2.3.0-1.el10_0.aarch64.rpm;name=aarch64_gstreamer1-svt-av1;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-svt-av1}"
SRC_URI[aarch64_gstreamer1-svt-av1.sha256sum] = "ec4540ee7bdac22dd8af260572bc99861f08b6afdd185e3f74f1df8b796f91a1"

URI_aarch64_svt-av1 = "${EPEL_MIRROR}/aarch64/Packages/s/svt-av1-2.3.0-1.el10_0.aarch64.rpm;name=aarch64_svt-av1;unpack=0"
SRC_URI:append = " ${URI_aarch64_svt-av1}"
SRC_URI[aarch64_svt-av1.sha256sum] = "448f076d2c4cb2e761bae4c9aa34b50d39f37b8051200fc64e128bf79090524a"

URI_aarch64_svt-av1-devel = "${EPEL_MIRROR}/aarch64/Packages/s/svt-av1-devel-2.3.0-1.el10_0.aarch64.rpm;name=aarch64_svt-av1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_svt-av1-devel}"
SRC_URI[aarch64_svt-av1-devel.sha256sum] = "8db6696c3b1fbcb584a45ff1b2caf46aa8dda6f6e3f251043b1ea9efaf6a7769"

URI_aarch64_svt-av1-devel-docs = "${EPEL_MIRROR}/aarch64/Packages/s/svt-av1-devel-docs-2.3.0-1.el10_0.noarch.rpm;name=aarch64_svt-av1-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_svt-av1-devel-docs}"
SRC_URI[aarch64_svt-av1-devel-docs.sha256sum] = "24a7451ecd9bf066ee4084fe8c27b6d7c898fbd181b960b50ccec18538a63059"

URI_aarch64_svt-av1-libs = "${EPEL_MIRROR}/aarch64/Packages/s/svt-av1-libs-2.3.0-1.el10_0.aarch64.rpm;name=aarch64_svt-av1-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_svt-av1-libs}"
SRC_URI[aarch64_svt-av1-libs.sha256sum] = "705ac7221ad0b407d9429c92459eba8f3ba9c17fe24c0896dd5a682c06a23f3e"

RDEPENDS:gstreamer1-svt-av1 = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 svt-av1-libs \
 "
RDEPENDS:svt-av1 = " \
 glibc \
 svt-av1-libs \
 "
RDEPENDS:svt-av1-devel = " \
 pkgconf-pkg-config \
 svt-av1-libs \
 "
RDEPENDS:svt-av1-devel-docs = " \
 "
RDEPENDS:svt-av1-libs:x86_64_v2 = " \
 cpuinfo \
 glibc \
"
RDEPENDS:svt-av1-libs:aarch64 = " \
 glibc \
"
