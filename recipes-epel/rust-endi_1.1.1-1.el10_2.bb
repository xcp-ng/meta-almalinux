# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-endi"
PV = "1.1.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-endi+default-devel \
 rust-endi+std-devel \
 rust-endi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-endi-1.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c56c4abc7c5827d531cb523a9714aed05b1dd1e1b5d30c488e1fd4dd2f862a96"

URI_x86_64_v2_rust-endi+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-endi+default-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-endi+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-endi+default-devel}"
SRC_URI[x86_64_v2_rust-endi+default-devel.sha256sum] = "229ff4f95b4be3992c18b51758eef3c346c6cc086ca2d3ae6e6cd32f09b7c4a6"

URI_x86_64_v2_rust-endi+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-endi+std-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-endi+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-endi+std-devel}"
SRC_URI[x86_64_v2_rust-endi+std-devel.sha256sum] = "af11caceddf9514245e24a10b3c7b9cfeb3a77390c4b2df4b3afae20d87d670a"

URI_x86_64_v2_rust-endi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-endi-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-endi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-endi-devel}"
SRC_URI[x86_64_v2_rust-endi-devel.sha256sum] = "f9b7d647b378efa4ac2a84d4d92d03dc38efdaada4be315b96753d2015d835eb"

URI_aarch64_rust-endi+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-endi+default-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-endi+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-endi+default-devel}"
SRC_URI[aarch64_rust-endi+default-devel.sha256sum] = "06a01573941cbf209b064884bde27970420f2c48df46a86dc5fa8594520b2acb"

URI_aarch64_rust-endi+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-endi+std-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-endi+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-endi+std-devel}"
SRC_URI[aarch64_rust-endi+std-devel.sha256sum] = "0a40fa85aaca1a933fbcb9bfaf48f24268c28e0cf18306fd4509e22cdd8c5956"

URI_aarch64_rust-endi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-endi-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-endi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-endi-devel}"
SRC_URI[aarch64_rust-endi-devel.sha256sum] = "46ba0cf7025d9da43da10058c9d57c26749c8bb55e530f5de69c4a877f5d9443"

RDEPENDS:rust-endi+default-devel = " \
 cargo \
 rust-endi+std-devel \
 rust-endi-devel \
 "
RDEPENDS:rust-endi+std-devel = " \
 cargo \
 rust-endi-devel \
 "
RDEPENDS:rust-endi-devel = " \
 cargo \
 rust \
 "
