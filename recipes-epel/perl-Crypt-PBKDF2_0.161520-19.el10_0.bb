# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-PBKDF2"
PV = "0.161520"
PR = "19.el10_0"
PACKAGES = " \
 perl-Crypt-PBKDF2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-PBKDF2-0.161520-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97712db62895902c228cc8853c9464ff067026fd5dc5a04b0ac268c6a883414e"

URI_x86_64_v2_perl-Crypt-PBKDF2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-PBKDF2-0.161520-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-PBKDF2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-PBKDF2}"
SRC_URI[x86_64_v2_perl-Crypt-PBKDF2.sha256sum] = "268222f7a12165868dc2f3df13d776f0125aa4fb6a51ea5b7bfe7ea9dbbbc410"

URI_aarch64_perl-Crypt-PBKDF2 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-PBKDF2-0.161520-19.el10_0.noarch.rpm;name=aarch64_perl-Crypt-PBKDF2;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-PBKDF2}"
SRC_URI[aarch64_perl-Crypt-PBKDF2.sha256sum] = "42bc263b0babb5301b63fb75625d8a5246e5b26d7c40f411fd65a4e4b7dba94f"

RDEPENDS:perl-Crypt-PBKDF2 = " \
 perl-Carp \
 perl-Digest \
 perl-Digest-HMAC \
 perl-Digest-SHA \
 perl-Digest-SHA3 \
 perl-MIME-Base64 \
 perl-Module-Runtime \
 perl-Moo \
 perl-Scalar-List-Utils \
 perl-Try-Tiny \
 perl-Type-Tiny \
 perl-libs \
 perl-namespace-autoclean \
 perl-strictures \
 "
