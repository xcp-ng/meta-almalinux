# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Guard"
PV = "1.023"
PR = "26.el10_0"
PACKAGES = " \
 perl-Guard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Guard-1.023-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68a7b1b0a3a2b20d910b37775828656fe6446138961b0e5b2ce3875a7a8eef78"

URI_x86_64_v2_perl-Guard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Guard-1.023-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Guard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Guard}"
SRC_URI[x86_64_v2_perl-Guard.sha256sum] = "d42cce1946782100c30770d887359d686a610b692c42205ab8b838eaa842d508"

URI_aarch64_perl-Guard = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Guard-1.023-26.el10_0.aarch64.rpm;name=aarch64_perl-Guard;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Guard}"
SRC_URI[aarch64_perl-Guard.sha256sum] = "2a2dc39a83e7fb24285d91d6f0077a837d6ab81cd8b9ddc528edfe26e792f4ae"

RDEPENDS:perl-Guard = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
