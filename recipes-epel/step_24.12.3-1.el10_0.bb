# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "step"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 step \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/step-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b41ed65029ccb322eabb9e08dbb79d075e42f4dc6c19396f879bffbc8992106d"

URI_x86_64_v2_step = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/step-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_step;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_step}"
SRC_URI[x86_64_v2_step.sha256sum] = "94d6c960b9c4c6ff339b834c7950ec9a8102256a2705c176711a89e8618dfe16"

URI_aarch64_step = "${EPEL_MIRROR}/aarch64/Packages/s/step-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_step;unpack=0"
SRC_URI:append = " ${URI_aarch64_step}"
SRC_URI[aarch64_step.sha256sum] = "726063d0f1cbfcf6e0cef9b6d82853eb6c0e1566a90e2606c8f53f5fd1f85db2"

RDEPENDS:step = " \
 glibc \
 gsl \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-knewstuff \
 kf6-kplotting \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libqalculate \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
