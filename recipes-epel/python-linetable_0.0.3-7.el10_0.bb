# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-linetable"
PV = "0.0.3"
PR = "7.el10_0"
PACKAGES = " \
 python3-linetable \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-linetable-0.0.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e66186e63d35908cc8d5cde0e732caf4e647666115bcd10342c0a9ad8522e567"

URI_x86_64_v2_python3-linetable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-linetable-0.0.3-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-linetable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-linetable}"
SRC_URI[x86_64_v2_python3-linetable.sha256sum] = "2bf6288ffcc59183436f308c9a7e860e948f532dfcbc442bbae38bb4aa8f137d"

URI_aarch64_python3-linetable = "${EPEL_MIRROR}/aarch64/Packages/p/python3-linetable-0.0.3-7.el10_0.noarch.rpm;name=aarch64_python3-linetable;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-linetable}"
SRC_URI[aarch64_python3-linetable.sha256sum] = "3962f88df9cb5421186e461714dc48e0c9a72d53efc228bbd3110e3bd1704150"

RDEPENDS:python3-linetable = " \
 python3 \
 "
