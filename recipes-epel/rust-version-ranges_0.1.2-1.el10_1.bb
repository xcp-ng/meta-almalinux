# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-version-ranges"
PV = "0.1.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-version-ranges+default-devel \
 rust-version-ranges+proptest-devel \
 rust-version-ranges+serde-devel \
 rust-version-ranges-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-version-ranges-0.1.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9687adabb056ed9c289031f3920f94f16f551d523e0588d54b2ae035a9b81b9a"

URI_x86_64_v2_rust-version-ranges+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges+default-devel-0.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges+default-devel}"
SRC_URI[x86_64_v2_rust-version-ranges+default-devel.sha256sum] = "708cd685192ed799cf63037d72b458db0896b70092f828889db56eb5e05e51ca"

URI_x86_64_v2_rust-version-ranges+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges+proptest-devel-0.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges+proptest-devel}"
SRC_URI[x86_64_v2_rust-version-ranges+proptest-devel.sha256sum] = "01968fea085c1b4c4dca032ef584f9d5fa4df7fb1f19da655ca7148c2a156094"

URI_x86_64_v2_rust-version-ranges+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges+serde-devel-0.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges+serde-devel}"
SRC_URI[x86_64_v2_rust-version-ranges+serde-devel.sha256sum] = "d6dd811bf906c1d266794bc81bcd2031b0579dffa3fcedfadce3232b8314e64a"

URI_x86_64_v2_rust-version-ranges-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges-devel-0.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges-devel}"
SRC_URI[x86_64_v2_rust-version-ranges-devel.sha256sum] = "0792db66156d6517c63d93459ba3dd8969b6254fbb8d8524face6417594d1068"

URI_aarch64_rust-version-ranges+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges+default-devel-0.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-version-ranges+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges+default-devel}"
SRC_URI[aarch64_rust-version-ranges+default-devel.sha256sum] = "106aca14d54c2fe5764e6417a743a76aba07b7539bfd3fedbbe1dec6afdf6d88"

URI_aarch64_rust-version-ranges+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges+proptest-devel-0.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-version-ranges+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges+proptest-devel}"
SRC_URI[aarch64_rust-version-ranges+proptest-devel.sha256sum] = "b6c036c14c115199ef48a439f6fcfee1aa7db658cc2f9210f143cd47e3b6fa01"

URI_aarch64_rust-version-ranges+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges+serde-devel-0.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-version-ranges+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges+serde-devel}"
SRC_URI[aarch64_rust-version-ranges+serde-devel.sha256sum] = "235d0b96dd58ba30856d4c01db9637389215e307a7a902d4e6f8aeeb96a5f85c"

URI_aarch64_rust-version-ranges-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges-devel-0.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-version-ranges-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges-devel}"
SRC_URI[aarch64_rust-version-ranges-devel.sha256sum] = "79a7121b057a83a4adefc7a5fc2a15eff7bdb7ed22c73ab2d3f5aa02f652b67c"

RDEPENDS:rust-version-ranges+default-devel = " \
 cargo \
 rust-version-ranges-devel \
 "
RDEPENDS:rust-version-ranges+proptest-devel = " \
 cargo \
 rust-proptest+default-devel \
 rust-version-ranges-devel \
 "
RDEPENDS:rust-version-ranges+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-smallvec+serde-devel \
 rust-version-ranges-devel \
 "
RDEPENDS:rust-version-ranges-devel = " \
 cargo \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 "
