# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glslang"
PV = "15.3.0"
PR = "1.el10"
PACKAGES = " \
 glslang \
 glslang-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/glslang-15.3.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f472c5b964eec605c46b003f2ef9bcafe7c5012a74c557580d7b54e748e69fa2"

URI_x86_64_v2_glslang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glslang-15.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_glslang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glslang}"
SRC_URI[x86_64_v2_glslang.sha256sum] = "4bd0746976ebe7ec2427a9be35d9284c5774fba09906bd7011d93477f731318d"

URI_x86_64_v2_glslang-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glslang-devel-15.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_glslang-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glslang-devel}"
SRC_URI[x86_64_v2_glslang-devel.sha256sum] = "e93bd4d70b925b9be0e5fddbd774a5a0d8ff58d722eb17ef52031e1255629d7b"

URI_aarch64_glslang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glslang-15.3.0-1.el10.aarch64.rpm;name=aarch64_glslang;unpack=0"
SRC_URI:append = " ${URI_aarch64_glslang}"
SRC_URI[aarch64_glslang.sha256sum] = "93bb420cb4526e4dd1bee2f5a2eae8fe572dd23d6b3c750f42e402c93b81aa86"

URI_aarch64_glslang-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glslang-devel-15.3.0-1.el10.aarch64.rpm;name=aarch64_glslang-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glslang-devel}"
SRC_URI[aarch64_glslang-devel.sha256sum] = "33fc59061cae324bc501e8931a20aeb61d3c5e63c167ad1858559f4386a46fc7"

RDEPENDS:glslang = " \
 glibc \
 libstdc++ \
 spirv-tools-libs \
 "
RDEPENDS:glslang-devel = " \
 cmake-filesystem \
 glslang \
 pkgconf-pkg-config \
 "
