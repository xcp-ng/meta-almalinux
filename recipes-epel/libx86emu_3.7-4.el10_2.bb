# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libx86emu"
PV = "3.7"
PR = "4.el10_2"
PACKAGES = " \
 libx86emu \
 libx86emu-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libx86emu-3.7-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0ccc1bc277d97e2d18b26a9520278815c319412a6ab3d341309a7368392bf79d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libx86emu-3.7-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libx86emu;unpack=0"
SRC_URI[x86_64_v2_libx86emu.sha256sum] = "56840aa75dae9bf2ead11b64ae1b8b72a76b4dd875ac8b4a9cdac669f98d54dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libx86emu-devel-3.7-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libx86emu-devel;unpack=0"
SRC_URI[x86_64_v2_libx86emu-devel.sha256sum] = "1a7e498647e4da3c9d64644b30cb05e4df2fbec37126d51937de149b7d7f1e4f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libx86emu-3.7-4.el10_2.aarch64.rpm;name=aarch64_libx86emu;unpack=0"
SRC_URI[aarch64_libx86emu.sha256sum] = "8f15b5b79acb6f568bd98bf03807487ce5a4d21d7efa74f3874526db1c285fb9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libx86emu-devel-3.7-4.el10_2.aarch64.rpm;name=aarch64_libx86emu-devel;unpack=0"
SRC_URI[aarch64_libx86emu-devel.sha256sum] = "48d9ca6db94636d617ad3682ecb545280312d7c32f71c63b4f1b6b821dc4cf1b"

RDEPENDS:libx86emu = " \
 glibc \
 "
RDEPENDS:libx86emu-devel = " \
 libx86emu \
 "
