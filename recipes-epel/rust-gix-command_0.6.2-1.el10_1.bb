# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-command"
PV = "0.6.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-command+default-devel \
 rust-gix-command-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-command-0.6.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df3bf8b64a3717d72ebcdbb7746e5c313ad0882b759a8ba2e71dab2f9513c2d3"

URI_x86_64_v2_rust-gix-command+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-command+default-devel-0.6.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-command+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-command+default-devel}"
SRC_URI[x86_64_v2_rust-gix-command+default-devel.sha256sum] = "914e6cfbd6e0c0bec87d18a361a4880aea425d13fdbc64b53edb82066267f65c"

URI_x86_64_v2_rust-gix-command-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-command-devel-0.6.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-command-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-command-devel}"
SRC_URI[x86_64_v2_rust-gix-command-devel.sha256sum] = "255e1c4b4b87efd7b3b100893b1cfae07ccc9a45e1dda8502e5dc6b4f27ef03c"

URI_aarch64_rust-gix-command+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-command+default-devel-0.6.2-1.el10_1.noarch.rpm;name=aarch64_rust-gix-command+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-command+default-devel}"
SRC_URI[aarch64_rust-gix-command+default-devel.sha256sum] = "430ab29e14c6d1fd982eb7d1ba06475527b0f1c7d0b5cf8d2855c3fb4ea4acc4"

URI_aarch64_rust-gix-command-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-command-devel-0.6.2-1.el10_1.noarch.rpm;name=aarch64_rust-gix-command-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-command-devel}"
SRC_URI[aarch64_rust-gix-command-devel.sha256sum] = "5123302e5c15b10d134b33932c98c967d39ac2883abc7311c892b6fd1e27ddfc"

RDEPENDS:rust-gix-command+default-devel = " \
 cargo \
 rust-gix-command-devel \
 "
RDEPENDS:rust-gix-command-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-trace+default-devel \
 rust-shell-words+default-devel \
 "
