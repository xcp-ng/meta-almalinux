# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ratatui"
PV = "0.30.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-ratatui+all-widgets-devel \
 rust-ratatui+crossterm-devel \
 rust-ratatui+crossterm_0_29-devel \
 rust-ratatui+default-devel \
 rust-ratatui+document-features-devel \
 rust-ratatui+layout-cache-devel \
 rust-ratatui+macros-devel \
 rust-ratatui+palette-devel \
 rust-ratatui+portable-atomic-devel \
 rust-ratatui+scrolling-regions-devel \
 rust-ratatui+serde-devel \
 rust-ratatui+std-devel \
 rust-ratatui+termion-devel \
 rust-ratatui+underline-color-devel \
 rust-ratatui+unstable-backend-writer-devel \
 rust-ratatui+unstable-devel \
 rust-ratatui+unstable-rendered-line-info-devel \
 rust-ratatui+unstable-widget-ref-devel \
 rust-ratatui+widget-calendar-devel \
 rust-ratatui-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ratatui-0.30.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "700b0ecaaac231b7ee546e11a5b37589bd61df5c54088019c82764adea73e053"

URI_x86_64_v2_rust-ratatui+all-widgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+all-widgets-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+all-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+all-widgets-devel}"
SRC_URI[x86_64_v2_rust-ratatui+all-widgets-devel.sha256sum] = "55ad3e9248136614451a142f3d6bfe16e2964c217da5d9db347428a04a247792"

URI_x86_64_v2_rust-ratatui+crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+crossterm-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+crossterm-devel}"
SRC_URI[x86_64_v2_rust-ratatui+crossterm-devel.sha256sum] = "0fd2ed9a42c9ae4fc670081ada4623d7d5d64ece9d5f69cbb6ac416536be5a26"

URI_x86_64_v2_rust-ratatui+crossterm_0_29-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+crossterm_0_29-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+crossterm_0_29-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+crossterm_0_29-devel}"
SRC_URI[x86_64_v2_rust-ratatui+crossterm_0_29-devel.sha256sum] = "eb2f8c886a9c2b141b8ab2dca9114623514a3969efa419e165c266273a07617c"

URI_x86_64_v2_rust-ratatui+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+default-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+default-devel}"
SRC_URI[x86_64_v2_rust-ratatui+default-devel.sha256sum] = "1ee56bc6f8e244ffc5c9ed5ca54216acf93ed6fd232567909c2d8a9ac4b72daa"

URI_x86_64_v2_rust-ratatui+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+document-features-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+document-features-devel}"
SRC_URI[x86_64_v2_rust-ratatui+document-features-devel.sha256sum] = "0a16ed561c56f45188c912522c44bf3af38904644b7a6811ab61506494fc8de5"

URI_x86_64_v2_rust-ratatui+layout-cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+layout-cache-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+layout-cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+layout-cache-devel}"
SRC_URI[x86_64_v2_rust-ratatui+layout-cache-devel.sha256sum] = "dfb12014e5f194f44721d4bcd20e6acb9ef4909a4cddca82357a08feef679e49"

URI_x86_64_v2_rust-ratatui+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+macros-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+macros-devel}"
SRC_URI[x86_64_v2_rust-ratatui+macros-devel.sha256sum] = "3c9f244d7c3a8d881a89e48ae8914e3b2c3fcc48e176f5ac5cb53d38e71fff2d"

URI_x86_64_v2_rust-ratatui+palette-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+palette-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+palette-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+palette-devel}"
SRC_URI[x86_64_v2_rust-ratatui+palette-devel.sha256sum] = "cf400a2c086e0af8127ea30a3c70d8d286b39f0c529c11bcedb2d863328f6622"

URI_x86_64_v2_rust-ratatui+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+portable-atomic-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-ratatui+portable-atomic-devel.sha256sum] = "0c9c87e6e7afe2cc6d55e3ef1cb8deef0081bc4cadd989b8e6359cd6a47f54b4"

URI_x86_64_v2_rust-ratatui+scrolling-regions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+scrolling-regions-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+scrolling-regions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+scrolling-regions-devel}"
SRC_URI[x86_64_v2_rust-ratatui+scrolling-regions-devel.sha256sum] = "36108fe21bfee9d00ff7972c0c57c47d30d7c66520ae018ec1e9dbfe11b3dcab"

URI_x86_64_v2_rust-ratatui+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+serde-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+serde-devel}"
SRC_URI[x86_64_v2_rust-ratatui+serde-devel.sha256sum] = "b7db63992937a46773a4ba513890dd629f93297c13bc5e7e9fd875eb362ef9b8"

URI_x86_64_v2_rust-ratatui+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+std-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+std-devel}"
SRC_URI[x86_64_v2_rust-ratatui+std-devel.sha256sum] = "b10246f8e197a97f090617bf6d48c90174783fcf7e105e6e5cb943bf6cab684b"

URI_x86_64_v2_rust-ratatui+termion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+termion-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+termion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+termion-devel}"
SRC_URI[x86_64_v2_rust-ratatui+termion-devel.sha256sum] = "299dbf6016d0df8c939121bb11a82a9de99c6d5632c1ae86fb323db471c65fc1"

URI_x86_64_v2_rust-ratatui+underline-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+underline-color-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+underline-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+underline-color-devel}"
SRC_URI[x86_64_v2_rust-ratatui+underline-color-devel.sha256sum] = "f725025970752546d0068111f287446d68c8b1af8b840a1d89144088dd4e3fa9"

URI_x86_64_v2_rust-ratatui+unstable-backend-writer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+unstable-backend-writer-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+unstable-backend-writer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+unstable-backend-writer-devel}"
SRC_URI[x86_64_v2_rust-ratatui+unstable-backend-writer-devel.sha256sum] = "8259c4998ce3d6fc385491f6a1030614f3e12d2097f2af25c639d36b30820949"

URI_x86_64_v2_rust-ratatui+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+unstable-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+unstable-devel}"
SRC_URI[x86_64_v2_rust-ratatui+unstable-devel.sha256sum] = "63b2545d9096503844358c50b20b1257788c3e4c820a3361901914b76d42ea0e"

URI_x86_64_v2_rust-ratatui+unstable-rendered-line-info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+unstable-rendered-line-info-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+unstable-rendered-line-info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+unstable-rendered-line-info-devel}"
SRC_URI[x86_64_v2_rust-ratatui+unstable-rendered-line-info-devel.sha256sum] = "6764135ff5879b9fe5659f5b043ba4d3eaecc391dbf373a42ad43d049a294eb8"

URI_x86_64_v2_rust-ratatui+unstable-widget-ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+unstable-widget-ref-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+unstable-widget-ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+unstable-widget-ref-devel}"
SRC_URI[x86_64_v2_rust-ratatui+unstable-widget-ref-devel.sha256sum] = "f80dc4008218ea6eb1438889bb94ff6cf146c6503818c18381109acf3b7d39ad"

URI_x86_64_v2_rust-ratatui+widget-calendar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+widget-calendar-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+widget-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+widget-calendar-devel}"
SRC_URI[x86_64_v2_rust-ratatui+widget-calendar-devel.sha256sum] = "e498ad39034f432fa983c26f7da39471b11657850997e44a85a3b4e6c28b38d4"

URI_x86_64_v2_rust-ratatui-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-devel-0.30.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-devel}"
SRC_URI[x86_64_v2_rust-ratatui-devel.sha256sum] = "e9fa4ed538b9fdad152b7ddf62552446693a7e2568a42ead871df64c306eb60e"

URI_aarch64_rust-ratatui+all-widgets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+all-widgets-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+all-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+all-widgets-devel}"
SRC_URI[aarch64_rust-ratatui+all-widgets-devel.sha256sum] = "63210712ae7f433334d3e01ee53f8ef50342a597451e068b39ca369687796f0f"

URI_aarch64_rust-ratatui+crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+crossterm-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+crossterm-devel}"
SRC_URI[aarch64_rust-ratatui+crossterm-devel.sha256sum] = "c2ae335846cc3ad324952c04ee5e77cee532bf44ee204df9461bec0ef49c5f52"

URI_aarch64_rust-ratatui+crossterm_0_29-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+crossterm_0_29-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+crossterm_0_29-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+crossterm_0_29-devel}"
SRC_URI[aarch64_rust-ratatui+crossterm_0_29-devel.sha256sum] = "226ba4594be2126a2ac0a3a83069e61f442ca82e2a21d031051a163bdfffc649"

URI_aarch64_rust-ratatui+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+default-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+default-devel}"
SRC_URI[aarch64_rust-ratatui+default-devel.sha256sum] = "d3b25bc58a0ff50b53ed979edd72cb75691fb72e2a7e1e6e9701d2e4ebb1fe4e"

URI_aarch64_rust-ratatui+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+document-features-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+document-features-devel}"
SRC_URI[aarch64_rust-ratatui+document-features-devel.sha256sum] = "d2a289ed184ad35e421d5e9822539d2c223c196c4bacd1ba2617bdf807b3812f"

URI_aarch64_rust-ratatui+layout-cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+layout-cache-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+layout-cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+layout-cache-devel}"
SRC_URI[aarch64_rust-ratatui+layout-cache-devel.sha256sum] = "5dc3c0bf8475325270f6fe5642f917a12562c81abcb1a4054c9e5dd273dc1976"

URI_aarch64_rust-ratatui+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+macros-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+macros-devel}"
SRC_URI[aarch64_rust-ratatui+macros-devel.sha256sum] = "521efb12658c35c3792bccd0388e4ccb4a6726db89b5d0ebdd89a0b914e7eea6"

URI_aarch64_rust-ratatui+palette-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+palette-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+palette-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+palette-devel}"
SRC_URI[aarch64_rust-ratatui+palette-devel.sha256sum] = "3352a56b87b927b9cd12bc504c5562f8fdbb665f8afe4f66610440bcac8fc568"

URI_aarch64_rust-ratatui+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+portable-atomic-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+portable-atomic-devel}"
SRC_URI[aarch64_rust-ratatui+portable-atomic-devel.sha256sum] = "285f64561518461e542c416d5b56409ecf8231316ee33d51451199a83f34bd56"

URI_aarch64_rust-ratatui+scrolling-regions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+scrolling-regions-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+scrolling-regions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+scrolling-regions-devel}"
SRC_URI[aarch64_rust-ratatui+scrolling-regions-devel.sha256sum] = "3cf03321f76b3b90a14bb25a71ed15cacdab35ce5082ea70e9ee56fbddb84afb"

URI_aarch64_rust-ratatui+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+serde-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+serde-devel}"
SRC_URI[aarch64_rust-ratatui+serde-devel.sha256sum] = "7f6935cf68456900bfe536daed875355733fcedf61b94a23ff777e37f9ae2516"

URI_aarch64_rust-ratatui+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+std-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+std-devel}"
SRC_URI[aarch64_rust-ratatui+std-devel.sha256sum] = "1ba7afcb7732ec95adde0a3e8ef80bc5ff5cefe159b40e997b70aae341eab1da"

URI_aarch64_rust-ratatui+termion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+termion-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+termion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+termion-devel}"
SRC_URI[aarch64_rust-ratatui+termion-devel.sha256sum] = "abf130185e6d55f6892ff19d00f3d728735a032a01fb9bb43a3b962849e34b15"

URI_aarch64_rust-ratatui+underline-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+underline-color-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+underline-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+underline-color-devel}"
SRC_URI[aarch64_rust-ratatui+underline-color-devel.sha256sum] = "14eb8578de0e62ebee85d725bfdffe97df9562f2a9625e4bc17ef6686d9675f1"

URI_aarch64_rust-ratatui+unstable-backend-writer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+unstable-backend-writer-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+unstable-backend-writer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+unstable-backend-writer-devel}"
SRC_URI[aarch64_rust-ratatui+unstable-backend-writer-devel.sha256sum] = "44a1c91d8d2715e1e4f82326c60ef954c283aba2499ee22fa8b50c9cea65debe"

URI_aarch64_rust-ratatui+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+unstable-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+unstable-devel}"
SRC_URI[aarch64_rust-ratatui+unstable-devel.sha256sum] = "2e2f8274971024326260ec93d715779195c716fc430c8167acde4fc51269d105"

URI_aarch64_rust-ratatui+unstable-rendered-line-info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+unstable-rendered-line-info-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+unstable-rendered-line-info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+unstable-rendered-line-info-devel}"
SRC_URI[aarch64_rust-ratatui+unstable-rendered-line-info-devel.sha256sum] = "9cd28f112dee1b87a24a6ab7ad139e323c210d27bb2d3885f4ca584aae0b85cc"

URI_aarch64_rust-ratatui+unstable-widget-ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+unstable-widget-ref-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+unstable-widget-ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+unstable-widget-ref-devel}"
SRC_URI[aarch64_rust-ratatui+unstable-widget-ref-devel.sha256sum] = "f54fb81c5222a6fdd1b4165b9d921df5acd3a5b3bc35eb592518c9779448c7c2"

URI_aarch64_rust-ratatui+widget-calendar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+widget-calendar-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui+widget-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+widget-calendar-devel}"
SRC_URI[aarch64_rust-ratatui+widget-calendar-devel.sha256sum] = "015d72306263e0ad83f9195e109e40a87ae5a1aba292927b9e77a7e84c28dcd1"

URI_aarch64_rust-ratatui-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-devel-0.30.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-devel}"
SRC_URI[aarch64_rust-ratatui-devel.sha256sum] = "9f0d9a6442e5a0bc099682900f8afba6e1af4cb590be6ff9ae64a34e96a24bfa"

RDEPENDS:rust-ratatui+all-widgets-devel = " \
 cargo \
 rust-ratatui+widget-calendar-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+crossterm-devel = " \
 cargo \
 rust-ratatui+std-devel \
 rust-ratatui-crossterm+default-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+crossterm_0_29-devel = " \
 cargo \
 rust-ratatui+crossterm-devel \
 rust-ratatui-crossterm+crossterm_0_29-devel \
 rust-ratatui-crossterm+default-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+default-devel = " \
 cargo \
 rust-ratatui+all-widgets-devel \
 rust-ratatui+crossterm-devel \
 rust-ratatui+layout-cache-devel \
 rust-ratatui+macros-devel \
 rust-ratatui+underline-color-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+layout-cache-devel = " \
 cargo \
 rust-ratatui+std-devel \
 rust-ratatui-core+layout-cache-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+macros-devel = " \
 cargo \
 rust-ratatui-devel \
 rust-ratatui-macros+default-devel \
 "
RDEPENDS:rust-ratatui+palette-devel = " \
 cargo \
 rust-palette+default-devel \
 rust-ratatui+std-devel \
 rust-ratatui-core+palette-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+portable-atomic-devel = " \
 cargo \
 rust-ratatui-core+portable-atomic-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+scrolling-regions-devel = " \
 cargo \
 rust-ratatui-core+scrolling-regions-devel \
 rust-ratatui-crossterm+default-devel \
 rust-ratatui-crossterm+scrolling-regions-devel \
 rust-ratatui-devel \
 rust-ratatui-termion+default-devel \
 rust-ratatui-termion+scrolling-regions-devel \
 "
RDEPENDS:rust-ratatui+serde-devel = " \
 cargo \
 rust-ratatui+std-devel \
 rust-ratatui-core+serde-devel \
 rust-ratatui-crossterm+default-devel \
 rust-ratatui-crossterm+serde-devel \
 rust-ratatui-devel \
 rust-ratatui-termion+default-devel \
 rust-ratatui-termion+serde-devel \
 rust-ratatui-widgets+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-ratatui+std-devel = " \
 cargo \
 rust-ratatui-core+std-devel \
 rust-ratatui-devel \
 rust-ratatui-widgets+std-devel \
 "
RDEPENDS:rust-ratatui+termion-devel = " \
 cargo \
 rust-ratatui+std-devel \
 rust-ratatui-devel \
 rust-ratatui-termion+default-devel \
 "
RDEPENDS:rust-ratatui+underline-color-devel = " \
 cargo \
 rust-ratatui-core+underline-color-devel \
 rust-ratatui-crossterm+default-devel \
 rust-ratatui-crossterm+underline-color-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+unstable-backend-writer-devel = " \
 cargo \
 rust-ratatui-crossterm+default-devel \
 rust-ratatui-crossterm+unstable-backend-writer-devel \
 rust-ratatui-devel \
 rust-ratatui-termion+default-devel \
 rust-ratatui-termion+unstable-backend-writer-devel \
 "
RDEPENDS:rust-ratatui+unstable-devel = " \
 cargo \
 rust-ratatui+unstable-backend-writer-devel \
 rust-ratatui+unstable-rendered-line-info-devel \
 rust-ratatui+unstable-widget-ref-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+unstable-rendered-line-info-devel = " \
 cargo \
 rust-ratatui-devel \
 rust-ratatui-widgets+unstable-rendered-line-info-devel \
 "
RDEPENDS:rust-ratatui+unstable-widget-ref-devel = " \
 cargo \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+widget-calendar-devel = " \
 cargo \
 rust-ratatui-devel \
 rust-ratatui-widgets+calendar-devel \
 "
RDEPENDS:rust-ratatui-devel = " \
 cargo \
 rust \
 rust-instability+default-devel \
 rust-ratatui-core+default-devel \
 rust-ratatui-widgets+default-devel \
 "
