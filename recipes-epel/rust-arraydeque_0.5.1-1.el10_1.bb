# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arraydeque"
PV = "0.5.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-arraydeque+default-devel \
 rust-arraydeque+std-devel \
 rust-arraydeque-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arraydeque-0.5.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00f2617092acc6dbc8d70597675f0720e7ea77fbc7c1962b6d366b42876c36ae"

URI_x86_64_v2_rust-arraydeque+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arraydeque+default-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arraydeque+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arraydeque+default-devel}"
SRC_URI[x86_64_v2_rust-arraydeque+default-devel.sha256sum] = "e965cd0e6a2fd8ee01e919cb609c97af01e06c7c9a169bf8d4bd7d7587a4b982"

URI_x86_64_v2_rust-arraydeque+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arraydeque+std-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arraydeque+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arraydeque+std-devel}"
SRC_URI[x86_64_v2_rust-arraydeque+std-devel.sha256sum] = "12566fd4da5b3ac3cfff77f5ac859e273acb9ca7657ce6b6ff0a7573a426a794"

URI_x86_64_v2_rust-arraydeque-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arraydeque-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arraydeque-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arraydeque-devel}"
SRC_URI[x86_64_v2_rust-arraydeque-devel.sha256sum] = "a632b229204849985bb4a4f2dd7177aa51c94998604248a90165e2b0c3dc204e"

URI_aarch64_rust-arraydeque+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arraydeque+default-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-arraydeque+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arraydeque+default-devel}"
SRC_URI[aarch64_rust-arraydeque+default-devel.sha256sum] = "0ed0757ad1fc0f32488d1c55fbbdf521b12e205cc2396afe846d2928c6415741"

URI_aarch64_rust-arraydeque+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arraydeque+std-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-arraydeque+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arraydeque+std-devel}"
SRC_URI[aarch64_rust-arraydeque+std-devel.sha256sum] = "2adf4cc46dbcfe1e4f016ec6b8331786c1b3c9163754630264336a6359411b0c"

URI_aarch64_rust-arraydeque-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arraydeque-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-arraydeque-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arraydeque-devel}"
SRC_URI[aarch64_rust-arraydeque-devel.sha256sum] = "2a4f242017446bbf93f47d4d90e6e1a74d13644a27d9f0161656bf130abe898f"

RDEPENDS:rust-arraydeque+default-devel = " \
 cargo \
 rust-arraydeque+std-devel \
 rust-arraydeque-devel \
 "
RDEPENDS:rust-arraydeque+std-devel = " \
 cargo \
 rust-arraydeque-devel \
 "
RDEPENDS:rust-arraydeque-devel = " \
 cargo \
 "
