# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libssh2-sys"
PV = "0.3.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-libssh2-sys+default-devel \
 rust-libssh2-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libssh2-sys-0.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f23c45cfdec48e347e2524042160d80c2541574a732e698b85993096b91e0da5"

URI_x86_64_v2_rust-libssh2-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libssh2-sys+default-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libssh2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libssh2-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libssh2-sys+default-devel.sha256sum] = "4c1c37df5a2fa53e14c703efc766e32b3a2b18983c6d053c443db0d9280589ee"

URI_x86_64_v2_rust-libssh2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libssh2-sys-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libssh2-sys-devel}"
SRC_URI[x86_64_v2_rust-libssh2-sys-devel.sha256sum] = "c8dd9829ea17639d3d9c32985137b4515aa3c65e6bf7a6656871eca098a3c19c"

URI_aarch64_rust-libssh2-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libssh2-sys+default-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-libssh2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libssh2-sys+default-devel}"
SRC_URI[aarch64_rust-libssh2-sys+default-devel.sha256sum] = "7d57dcb66c5d8bf5080555544ce15282501cc695c429893ba05b03ce5ad45fff"

URI_aarch64_rust-libssh2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libssh2-sys-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libssh2-sys-devel}"
SRC_URI[aarch64_rust-libssh2-sys-devel.sha256sum] = "2f28a2f52a1c2f1c1cbb1aaf9380c312acf341bc4529e12194f7af56c1d23075"

RDEPENDS:rust-libssh2-sys+default-devel = " \
 cargo \
 rust-libssh2-sys-devel \
 "
RDEPENDS:rust-libssh2-sys-devel = " \
 cargo \
 libssh2-devel \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys-devel \
 rust-openssl-sys+default-devel \
 rust-pkg-config+default-devel \
 "
