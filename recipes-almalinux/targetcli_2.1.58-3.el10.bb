# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "targetcli"
PV = "2.1.58"
PR = "3.el10"
PACKAGES = " \
 targetcli \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/targetcli-2.1.58-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bc29c438db0f68b559539011ed097841d8d7b936e29231466c1153575882b7af"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/targetcli-2.1.58-3.el10.noarch.rpm;name=x86_64_v2_targetcli;unpack=0"
SRC_URI[x86_64_v2_targetcli.sha256sum] = "a150aafa6e8256d088d2a7d38e5c8a32261f7a8c7603c768adf047f70a69ecc6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/targetcli-2.1.58-3.el10.noarch.rpm;name=aarch64_targetcli;unpack=0"
SRC_URI[aarch64_targetcli.sha256sum] = "a150aafa6e8256d088d2a7d38e5c8a32261f7a8c7603c768adf047f70a69ecc6"

RDEPENDS:targetcli = " \
 python3 \
 python3-configshell \
 python3-dbus \
 python3-gobject-base \
 python3-rtslib \
 python3-six \
 target-restore \
 "
