# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cachedir"
PV = "0.3.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-cachedir+default-devel \
 rust-cachedir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cachedir-0.3.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf557d791691c7c04efbe569caf472a581769d3c8e2ca8ed5111970f4a41bef3"

URI_x86_64_v2_rust-cachedir+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cachedir+default-devel-0.3.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cachedir+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cachedir+default-devel}"
SRC_URI[x86_64_v2_rust-cachedir+default-devel.sha256sum] = "818879e2fc55dc1c4967c532aee0c7c796860e538a7514acf37d2dd3274f988e"

URI_x86_64_v2_rust-cachedir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cachedir-devel-0.3.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cachedir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cachedir-devel}"
SRC_URI[x86_64_v2_rust-cachedir-devel.sha256sum] = "64dfc8d3eb2fef204768d7c3cbf3c7ede6b929f35b7642a152585de407634adb"

URI_aarch64_rust-cachedir+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cachedir+default-devel-0.3.1-4.el10_0.noarch.rpm;name=aarch64_rust-cachedir+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cachedir+default-devel}"
SRC_URI[aarch64_rust-cachedir+default-devel.sha256sum] = "543e27c73e22e45996b0b96d2947c1b1826922fd7ef807551dcc91d4b7106e59"

URI_aarch64_rust-cachedir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cachedir-devel-0.3.1-4.el10_0.noarch.rpm;name=aarch64_rust-cachedir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cachedir-devel}"
SRC_URI[aarch64_rust-cachedir-devel.sha256sum] = "6f99af641aec1cdeed61471d483aa168dc350bd651f07e6743f870bcb235d508"

RDEPENDS:rust-cachedir+default-devel = " \
 cargo \
 rust-cachedir-devel \
 "
RDEPENDS:rust-cachedir-devel = " \
 cargo \
 rust-tempfile+default-devel \
 "
