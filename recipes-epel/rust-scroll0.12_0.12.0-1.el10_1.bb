# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scroll0.12"
PV = "0.12.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-scroll0.12+default-devel \
 rust-scroll0.12+derive-devel \
 rust-scroll0.12+std-devel \
 rust-scroll0.12-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scroll0.12-0.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "778a31166674b41da2db5682136634250e9c4f2d93e163e2226c30455bec6c5e"

URI_x86_64_v2_rust-scroll0.12+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll0.12+default-devel-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll0.12+default-devel}"
SRC_URI[x86_64_v2_rust-scroll0.12+default-devel.sha256sum] = "87ea665a836c914b7a6f6e894f42c847c6c658590a5b8ac929cd4afcf6ac5328"

URI_x86_64_v2_rust-scroll0.12+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll0.12+derive-devel-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll0.12+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll0.12+derive-devel}"
SRC_URI[x86_64_v2_rust-scroll0.12+derive-devel.sha256sum] = "28749335c2ad077830c6bfa3778bbd732bfb8a544729d7b177eb2dddab696345"

URI_x86_64_v2_rust-scroll0.12+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll0.12+std-devel-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll0.12+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll0.12+std-devel}"
SRC_URI[x86_64_v2_rust-scroll0.12+std-devel.sha256sum] = "24fb078407db99801c88921e29abfb1706b61a3e7c10e23b6fe3b467c931cbbf"

URI_x86_64_v2_rust-scroll0.12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll0.12-devel-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll0.12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll0.12-devel}"
SRC_URI[x86_64_v2_rust-scroll0.12-devel.sha256sum] = "509de9ea9c3fa78239ca20530855cbdde0652ce8d26f126b65bf504dc00e3a2d"

URI_aarch64_rust-scroll0.12+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll0.12+default-devel-0.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-scroll0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll0.12+default-devel}"
SRC_URI[aarch64_rust-scroll0.12+default-devel.sha256sum] = "9e09e54a0612a92ec20982c14e70effe96980bca1cb543ae62083d4830cbeffe"

URI_aarch64_rust-scroll0.12+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll0.12+derive-devel-0.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-scroll0.12+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll0.12+derive-devel}"
SRC_URI[aarch64_rust-scroll0.12+derive-devel.sha256sum] = "60d2b8c986083b34401849711a3784e5695089c1dfa1082ba3a0cf60314e5467"

URI_aarch64_rust-scroll0.12+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll0.12+std-devel-0.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-scroll0.12+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll0.12+std-devel}"
SRC_URI[aarch64_rust-scroll0.12+std-devel.sha256sum] = "ee2241e28857a83e1c77ef70539fdc9d54fb7fca0005f0d7f8c7d02fae90f90e"

URI_aarch64_rust-scroll0.12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll0.12-devel-0.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-scroll0.12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll0.12-devel}"
SRC_URI[aarch64_rust-scroll0.12-devel.sha256sum] = "d1f0cd06c60a07b8d1b715e0bbb7064e514c5b6517e890bfa6c42e0adf9fc673"

RDEPENDS:rust-scroll0.12+default-devel = " \
 cargo \
 rust-scroll0.12+std-devel \
 rust-scroll0.12-devel \
 "
RDEPENDS:rust-scroll0.12+derive-devel = " \
 cargo \
 rust-scroll0.12-devel \
 rust-scroll_derive0.12+default-devel \
 "
RDEPENDS:rust-scroll0.12+std-devel = " \
 cargo \
 rust-scroll0.12-devel \
 "
RDEPENDS:rust-scroll0.12-devel = " \
 cargo \
 rust \
 "
