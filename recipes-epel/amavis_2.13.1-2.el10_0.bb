# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "amavis"
PV = "2.13.1"
PR = "2.el10_0"
PACKAGES = " \
 amavis \
 amavis-doc \
 amavis-snmp \
 perl-Amavis \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/amavis-2.13.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "394a6a57825ba2752b05b5b969f61496d2d3c67228ba9b3fa30ef06fea67de4f"

URI_x86_64_v2_amavis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amavis-2.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_amavis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amavis}"
SRC_URI[x86_64_v2_amavis.sha256sum] = "5e255d87ae9b0f003d58201608df9b82e15cab370a0b8712982b87c000b66dad"

URI_x86_64_v2_amavis-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amavis-doc-2.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_amavis-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amavis-doc}"
SRC_URI[x86_64_v2_amavis-doc.sha256sum] = "48c3de719d3542f4b4ab9d846a2e377df0f7d8cbe2320213f18f739efcc936e6"

URI_x86_64_v2_amavis-snmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amavis-snmp-2.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_amavis-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amavis-snmp}"
SRC_URI[x86_64_v2_amavis-snmp.sha256sum] = "1c97ebaacdc97f472a00e567aac2cad6d0f85a5b43fb900fa5fb68c65bad5b3c"

URI_x86_64_v2_perl-Amavis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Amavis-2.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Amavis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Amavis}"
SRC_URI[x86_64_v2_perl-Amavis.sha256sum] = "2d71233a3e20a3cb42e0d3c542e7dcd454dae9d140ba4c3e5052afbb08241d89"

URI_aarch64_amavis = "${EPEL_MIRROR}/aarch64/Packages/a/amavis-2.13.1-2.el10_0.noarch.rpm;name=aarch64_amavis;unpack=0"
SRC_URI:append = " ${URI_aarch64_amavis}"
SRC_URI[aarch64_amavis.sha256sum] = "e6abc179d16407d877bcbb9ebf42097f866514f94afe891c284e1aa56da97857"

URI_aarch64_amavis-doc = "${EPEL_MIRROR}/aarch64/Packages/a/amavis-doc-2.13.1-2.el10_0.noarch.rpm;name=aarch64_amavis-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_amavis-doc}"
SRC_URI[aarch64_amavis-doc.sha256sum] = "5fc27d52fbc3f541111117b8b82e921ae1a5b95bcccaf39e9e18a370a8366f81"

URI_aarch64_amavis-snmp = "${EPEL_MIRROR}/aarch64/Packages/a/amavis-snmp-2.13.1-2.el10_0.noarch.rpm;name=aarch64_amavis-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_amavis-snmp}"
SRC_URI[aarch64_amavis-snmp.sha256sum] = "c33e0105ad801e0f9bc79e1ec63bc7af68c202ef4544559873772ddbb1fa9772"

URI_aarch64_perl-Amavis = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Amavis-2.13.1-2.el10_0.noarch.rpm;name=aarch64_perl-Amavis;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Amavis}"
SRC_URI[aarch64_perl-Amavis.sha256sum] = "4a24c658783978675babf10a4828a836a0b38235c0b6ebc87dc4c850fd075bea"

RDEPENDS:amavis = " \
 altermime \
 bash \
 clamav-filesystem \
 file \
 perl-Amavis \
 perl-Archive-Tar \
 perl-Authen-SASL \
 perl-BerkeleyDB \
 perl-Compress-Raw-Zlib \
 perl-Errno \
 perl-File-LibMagic \
 perl-File-Temp \
 perl-IO \
 perl-IO-Socket-IP \
 perl-MIME-Base64 \
 perl-MIME-tools \
 perl-Mail-DKIM \
 perl-Mail-SPF \
 perl-MailTools \
 perl-Net-DNS \
 perl-Net-LibIDN2 \
 perl-Net-SSLeay \
 perl-Net-Server \
 perl-NetAddr-IP \
 perl-POSIX \
 perl-Razor-Agent \
 perl-Socket \
 perl-Sys-Syslog \
 perl-Time-HiRes \
 perl-URI \
 perl-interpreter \
 perl-libs \
 perl-sigtrap \
 perl-vars \
 "
RDEPENDS:amavis-doc = " \
 "
RDEPENDS:amavis-snmp = " \
 amavis \
 bash \
 net-snmp-perl-module \
 perl-BerkeleyDB \
 perl-Errno \
 perl-IO \
 perl-POSIX \
 perl-Time-HiRes \
 perl-Unix-Syslog \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Amavis = " \
 perl-Amavis \
 perl-Archive-Zip \
 perl-BerkeleyDB \
 perl-Carp \
 perl-Crypt-OpenSSL-RSA \
 perl-DBI \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Encode \
 perl-Errno \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Temp \
 perl-FileHandle \
 perl-IO \
 perl-IO-Compress \
 perl-IO-Socket-SSL \
 perl-JSON \
 perl-LDAP \
 perl-MIME-Base64 \
 perl-MIME-tools \
 perl-Mail-DKIM \
 perl-Net-DNS \
 perl-Net-Server \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-Socket \
 perl-Time-HiRes \
 perl-Unix-Syslog \
 perl-constant \
 perl-libs \
 perl-libwww-perl \
 perl-subs \
 perl-vars \
 spamassassin \
 "
