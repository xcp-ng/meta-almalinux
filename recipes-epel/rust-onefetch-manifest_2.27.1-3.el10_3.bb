# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onefetch-manifest"
PV = "2.27.1"
PR = "3.el10_3"
PACKAGES = " \
 rust-onefetch-manifest+default-devel \
 rust-onefetch-manifest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onefetch-manifest-2.27.1-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e6fc7124f4c0f476e1e416cbf1f7082a6bd4f1a7fef413adc8fdc6c990d67cc"

URI_x86_64_v2_rust-onefetch-manifest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-manifest+default-devel-2.27.1-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-manifest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-manifest+default-devel}"
SRC_URI[x86_64_v2_rust-onefetch-manifest+default-devel.sha256sum] = "1c69ec159b4c4fd50cefaf829a1932ab71e0878f89dffb35711f1778f6cabebd"

URI_x86_64_v2_rust-onefetch-manifest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-manifest-devel-2.27.1-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-manifest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-manifest-devel}"
SRC_URI[x86_64_v2_rust-onefetch-manifest-devel.sha256sum] = "152121e1d4f95355e109c350eefd6d02c55fbe37f15057c5a9ea22416ea5197d"

URI_aarch64_rust-onefetch-manifest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-manifest+default-devel-2.27.1-3.el10_3.noarch.rpm;name=aarch64_rust-onefetch-manifest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-manifest+default-devel}"
SRC_URI[aarch64_rust-onefetch-manifest+default-devel.sha256sum] = "996ab21226b2eb0f74983b5bcd5bb28eaf551ff7f45414766dc00fe565e8b8bd"

URI_aarch64_rust-onefetch-manifest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-manifest-devel-2.27.1-3.el10_3.noarch.rpm;name=aarch64_rust-onefetch-manifest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-manifest-devel}"
SRC_URI[aarch64_rust-onefetch-manifest-devel.sha256sum] = "5fb0342dd1a98741821a001d33d1ce7a19f2c28bad0ee32c62cea40b3297f482"

RDEPENDS:rust-onefetch-manifest+default-devel = " \
 cargo \
 rust-onefetch-manifest-devel \
 "
RDEPENDS:rust-onefetch-manifest-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-cargo_toml+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-strum+default-devel \
 rust-strum+derive-devel \
 "
