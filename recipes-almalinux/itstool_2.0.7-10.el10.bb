# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "itstool"
PV = "2.0.7"
PR = "10.el10"
PACKAGES = " \
 itstool \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/itstool-2.0.7-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7f5bc8c61b1049fa98f3142ce255ad9a6a83bda09cdb5ff14151cf01688b5ac"

URI_x86_64_v2_itstool = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/itstool-2.0.7-10.el10.noarch.rpm;name=x86_64_v2_itstool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_itstool}"
SRC_URI[x86_64_v2_itstool.sha256sum] = "e28c95c6d9ed65a6162a1d7de8000cfe0989749a3f3b3db64d369ae59dadfa3c"

URI_aarch64_itstool = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/itstool-2.0.7-10.el10.noarch.rpm;name=aarch64_itstool;unpack=0"
SRC_URI:append = " ${URI_aarch64_itstool}"
SRC_URI[aarch64_itstool.sha256sum] = "e28c95c6d9ed65a6162a1d7de8000cfe0989749a3f3b3db64d369ae59dadfa3c"

RDEPENDS:itstool = " \
 python3 \
 python3-libxml2 \
 "
