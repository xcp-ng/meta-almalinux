# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-asn1-rs"
PV = "0.6.2"
PR = "5.el10_1"
PACKAGES = " \
 rust-asn1-rs+bigint-devel \
 rust-asn1-rs+bits-devel \
 rust-asn1-rs+bitvec-devel \
 rust-asn1-rs+colored-devel \
 rust-asn1-rs+cookie-factory-devel \
 rust-asn1-rs+datetime-devel \
 rust-asn1-rs+debug-devel \
 rust-asn1-rs+default-devel \
 rust-asn1-rs+num-bigint-devel \
 rust-asn1-rs+serialize-devel \
 rust-asn1-rs+std-devel \
 rust-asn1-rs+time-devel \
 rust-asn1-rs+trace-devel \
 rust-asn1-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-asn1-rs-0.6.2-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e01eb1b86e9859feeed28697833bc55d0d19ffc9ae7e0e1c7115085be2d4a86"

URI_x86_64_v2_rust-asn1-rs+bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+bigint-devel-0.6.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+bigint-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+bigint-devel.sha256sum] = "d2e68fb9357ce1f2a601dcb89dd343f847c7a7e78dfc12df7fa4262614550f31"

URI_x86_64_v2_rust-asn1-rs+bits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+bits-devel-0.6.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+bits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+bits-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+bits-devel.sha256sum] = "61e2dde1a7e5b9369e95f68f43b7d48bf5e34cc247e07382b0f9095a092254a0"

URI_x86_64_v2_rust-asn1-rs+bitvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+bitvec-devel-0.6.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+bitvec-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+bitvec-devel.sha256sum] = "d692c59e953fe2f801351bda7627ff77a433252fc099f8cd0a7fd8c61ca9bc0a"

URI_x86_64_v2_rust-asn1-rs+colored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+colored-devel-0.6.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+colored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+colored-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+colored-devel.sha256sum] = "c373bdb674b3a90d199345905d46e453a76037c369f46a7148b651c53448b820"

URI_x86_64_v2_rust-asn1-rs+cookie-factory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+cookie-factory-devel-0.6.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+cookie-factory-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+cookie-factory-devel.sha256sum] = "289ea42956b6d2e2c574d12478efb80940ce3dc9f64bdb75f8e4f9f2c34fe557"

URI_x86_64_v2_rust-asn1-rs+datetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+datetime-devel-0.6.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+datetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+datetime-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+datetime-devel.sha256sum] = "e01ce1cb65ea2ec9262a77314b12423cc422c30d5df435d5d6e7a8422570faee"

URI_x86_64_v2_rust-asn1-rs+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+debug-devel-0.6.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+debug-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+debug-devel.sha256sum] = "1ab82fd0f636dba7e46f6720597f3cfccdc77cdd26d187e6ac2adc398096cf5a"

URI_x86_64_v2_rust-asn1-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+default-devel-0.6.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+default-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+default-devel.sha256sum] = "d9b326d7f9863198245fc82f33dec97c34ced780b3565bdc0ba9bd1f91f5efcc"

URI_x86_64_v2_rust-asn1-rs+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+num-bigint-devel-0.6.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+num-bigint-devel.sha256sum] = "06d87a8959caf0e3dc4f918ef1ebf9a6e7d7ebdbe1a310d125afe5b5e2f3bb03"

URI_x86_64_v2_rust-asn1-rs+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+serialize-devel-0.6.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+serialize-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+serialize-devel.sha256sum] = "55a1a84499993bfb60126124801beefb5b4249eb9cb75a8af682fdc8c4ac6ce1"

URI_x86_64_v2_rust-asn1-rs+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+std-devel-0.6.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+std-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+std-devel.sha256sum] = "00f9db025b5df9e1c95802b66034597120017e432e7dcbce44d3deaa87140a7c"

URI_x86_64_v2_rust-asn1-rs+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+time-devel-0.6.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+time-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+time-devel.sha256sum] = "7f7e4507d1436acf2a3204118cbac101666f9c0227fa19941f9c69599fa09a69"

URI_x86_64_v2_rust-asn1-rs+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+trace-devel-0.6.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+trace-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+trace-devel.sha256sum] = "6899b0899f491287d9256b033c032465ab1596137a06ff19dac8dcab16632434"

URI_x86_64_v2_rust-asn1-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs-devel-0.6.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs-devel.sha256sum] = "24680fc5a9af2b14459cee879cd8f38ec680d74cf3fb3d6ba9f33c572189c2eb"

URI_aarch64_rust-asn1-rs+bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+bigint-devel-0.6.2-5.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs+bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+bigint-devel}"
SRC_URI[aarch64_rust-asn1-rs+bigint-devel.sha256sum] = "4a1c427759ffb7e327717df21c3c7ce196fcaa86514eac09a9b923930b2cd726"

URI_aarch64_rust-asn1-rs+bits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+bits-devel-0.6.2-5.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs+bits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+bits-devel}"
SRC_URI[aarch64_rust-asn1-rs+bits-devel.sha256sum] = "60302e8328019bab2e7ac2a7b339affc90d81cc949b1e5cf01bd20fca7850c4b"

URI_aarch64_rust-asn1-rs+bitvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+bitvec-devel-0.6.2-5.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+bitvec-devel}"
SRC_URI[aarch64_rust-asn1-rs+bitvec-devel.sha256sum] = "b398022771e7ff7ca55a8e832cbd2455c73e878cc6b6616949e0bd9e59481b96"

URI_aarch64_rust-asn1-rs+colored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+colored-devel-0.6.2-5.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs+colored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+colored-devel}"
SRC_URI[aarch64_rust-asn1-rs+colored-devel.sha256sum] = "90d3194d4f738e9e184b2bf84245bab83dfeaea8aa498dca1685e315e619c3bd"

URI_aarch64_rust-asn1-rs+cookie-factory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+cookie-factory-devel-0.6.2-5.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs+cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+cookie-factory-devel}"
SRC_URI[aarch64_rust-asn1-rs+cookie-factory-devel.sha256sum] = "d4461aa97b73de6c4fd2389ba6af886c8bf11dcfa65c4d50630d30b87fe75eae"

URI_aarch64_rust-asn1-rs+datetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+datetime-devel-0.6.2-5.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs+datetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+datetime-devel}"
SRC_URI[aarch64_rust-asn1-rs+datetime-devel.sha256sum] = "ff84f1cb8e656254e7ddfbb3c39efdb892387fea3650df88c2fdb68156e7a375"

URI_aarch64_rust-asn1-rs+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+debug-devel-0.6.2-5.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+debug-devel}"
SRC_URI[aarch64_rust-asn1-rs+debug-devel.sha256sum] = "d8bb95ff09cb9af4a7dc8f0f25826c8eac1d31d99100a15c3c1a7f35de255742"

URI_aarch64_rust-asn1-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+default-devel-0.6.2-5.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+default-devel}"
SRC_URI[aarch64_rust-asn1-rs+default-devel.sha256sum] = "ca4d56e09052135e45538e746e0fcc3188d0f91368accdc982eff490e845c5a2"

URI_aarch64_rust-asn1-rs+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+num-bigint-devel-0.6.2-5.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+num-bigint-devel}"
SRC_URI[aarch64_rust-asn1-rs+num-bigint-devel.sha256sum] = "97803410efbd367051995b25da784a15d9452de0117e1d5014237d3cf2869f33"

URI_aarch64_rust-asn1-rs+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+serialize-devel-0.6.2-5.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+serialize-devel}"
SRC_URI[aarch64_rust-asn1-rs+serialize-devel.sha256sum] = "ecd6649628cef26c1286f9c694a395e390fa76e09c4f1f3970820680cc10e131"

URI_aarch64_rust-asn1-rs+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+std-devel-0.6.2-5.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+std-devel}"
SRC_URI[aarch64_rust-asn1-rs+std-devel.sha256sum] = "659e6e02747453bd101c4a80961e7987b466e645fbac0971b1714431d00a00de"

URI_aarch64_rust-asn1-rs+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+time-devel-0.6.2-5.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+time-devel}"
SRC_URI[aarch64_rust-asn1-rs+time-devel.sha256sum] = "d6e2c19cb87175047218aab149cd31b01ee14f9f1706a98f5c90c79c7373436e"

URI_aarch64_rust-asn1-rs+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+trace-devel-0.6.2-5.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+trace-devel}"
SRC_URI[aarch64_rust-asn1-rs+trace-devel.sha256sum] = "2e8d284a4ed825e749173c450bac4bee5a8c8bb8e027a75dc3ece054ed7af802"

URI_aarch64_rust-asn1-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs-devel-0.6.2-5.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs-devel}"
SRC_URI[aarch64_rust-asn1-rs-devel.sha256sum] = "7d451f229c6aa53b4b17dce2a378b0f342eb9e45a95fa7eef15a439593396383"

RDEPENDS:rust-asn1-rs+bigint-devel = " \
 cargo \
 rust-asn1-rs+num-bigint-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+bits-devel = " \
 cargo \
 rust-asn1-rs+bitvec-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+bitvec-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-bitvec+default-devel \
 "
RDEPENDS:rust-asn1-rs+colored-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-colored2+default-devel \
 "
RDEPENDS:rust-asn1-rs+cookie-factory-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-cookie-factory+default-devel \
 "
RDEPENDS:rust-asn1-rs+datetime-devel = " \
 cargo \
 rust-asn1-rs+time-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+debug-devel = " \
 cargo \
 rust-asn1-rs+colored-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+default-devel = " \
 cargo \
 rust-asn1-rs+std-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+num-bigint-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-num-bigint+default-devel \
 "
RDEPENDS:rust-asn1-rs+serialize-devel = " \
 cargo \
 rust-asn1-rs+cookie-factory-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+std-devel = " \
 cargo \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+time-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-asn1-rs+trace-devel = " \
 cargo \
 rust-asn1-rs+debug-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs-devel = " \
 cargo \
 rust \
 rust-asn1-rs-derive+default-devel \
 rust-asn1-rs-impl+default-devel \
 rust-displaydoc+default-devel \
 rust-nom7+std-devel \
 rust-nom7-devel \
 rust-num-traits+default-devel \
 rust-rusticata-macros+default-devel \
 rust-thiserror1+default-devel \
 "
