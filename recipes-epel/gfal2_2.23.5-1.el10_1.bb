# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gfal2"
PV = "2.23.5"
PR = "1.el10_1"
PACKAGES = " \
 gfal2 \
 gfal2-all \
 gfal2-devel \
 gfal2-doc \
 gfal2-plugin-file \
 gfal2-plugin-http \
 gfal2-plugin-mock \
 gfal2-plugin-srm \
 gfal2-plugin-xrootd \
 gfal2-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gfal2-2.23.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be2a5ccebb23443563e008bb6da6f922eff684d89e704b580adf934e08616bc5"

URI_x86_64_v2_gfal2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-2.23.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2}"
SRC_URI[x86_64_v2_gfal2.sha256sum] = "ed1136b4bb740cacba4e66b000f0e31d21abfdfef130955c11e5979ab84ebda9"

URI_x86_64_v2_gfal2-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-all-2.23.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-all}"
SRC_URI[x86_64_v2_gfal2-all.sha256sum] = "d5b46cb035e1befd55888a137e2cc93561662d0f5ebadd061b86e26866ee524a"

URI_x86_64_v2_gfal2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-devel-2.23.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-devel}"
SRC_URI[x86_64_v2_gfal2-devel.sha256sum] = "4a775c4f48435c6b792c13518113692bb3be0c88980d625a842a32d8fd287b4f"

URI_x86_64_v2_gfal2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-doc-2.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gfal2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-doc}"
SRC_URI[x86_64_v2_gfal2-doc.sha256sum] = "85a160c25c2d1f6cf2c06aa9c15de57b50b9b2dc8987f9452edf6be0d5612731"

URI_x86_64_v2_gfal2-plugin-file = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-file-2.23.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-file}"
SRC_URI[x86_64_v2_gfal2-plugin-file.sha256sum] = "f93fbd5d88a5e0b74299e2736a120d21e0d4c80f3956f19e4c7325125483c985"

URI_x86_64_v2_gfal2-plugin-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-http-2.23.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-http}"
SRC_URI[x86_64_v2_gfal2-plugin-http.sha256sum] = "fc9ed0a0bc91f61aad129c8061a242bda660fab9b509c9f1252020cd02d5be05"

URI_x86_64_v2_gfal2-plugin-mock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-mock-2.23.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-mock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-mock}"
SRC_URI[x86_64_v2_gfal2-plugin-mock.sha256sum] = "3194bfb156df255fbe23a8494b28af3e8b3cc58990ecf0bcdbd8d7da14633fec"

URI_x86_64_v2_gfal2-plugin-srm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-srm-2.23.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-srm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-srm}"
SRC_URI[x86_64_v2_gfal2-plugin-srm.sha256sum] = "b5c332f069cf59dd883d415740e2eb0b4e917ddb0c8ba57f5d472a5db15bc9fc"

URI_x86_64_v2_gfal2-plugin-xrootd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-xrootd-2.23.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-xrootd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-xrootd}"
SRC_URI[x86_64_v2_gfal2-plugin-xrootd.sha256sum] = "515acea5fc6755e10dfdd7da5f1271e58626f5bdbb63f54843702f347c7acede"

URI_x86_64_v2_gfal2-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-tests-2.23.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-tests}"
SRC_URI[x86_64_v2_gfal2-tests.sha256sum] = "0403aaaa0910d099c929b843509ee7d3a4189606353f694366af2a2bfd91333f"

URI_aarch64_gfal2 = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-2.23.5-1.el10_1.aarch64.rpm;name=aarch64_gfal2;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2}"
SRC_URI[aarch64_gfal2.sha256sum] = "a5f6edcaac8ed5ef1e5d7e8641a1264baae1a4b7d0c272469ece30f24bed6d72"

URI_aarch64_gfal2-all = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-all-2.23.5-1.el10_1.aarch64.rpm;name=aarch64_gfal2-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-all}"
SRC_URI[aarch64_gfal2-all.sha256sum] = "97afd831036e77efe84f5716459e44d253f50745f13719d955499fe39afaa0c3"

URI_aarch64_gfal2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-devel-2.23.5-1.el10_1.aarch64.rpm;name=aarch64_gfal2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-devel}"
SRC_URI[aarch64_gfal2-devel.sha256sum] = "288f6c750ab5ebcbb066742c9ff2523c5bb178454f99659d4489fcd5101f81dc"

URI_aarch64_gfal2-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-doc-2.23.5-1.el10_1.noarch.rpm;name=aarch64_gfal2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-doc}"
SRC_URI[aarch64_gfal2-doc.sha256sum] = "ab528321eddf2fc45b836b93280207f4ff1251288349fd89a1c45463bee0913c"

URI_aarch64_gfal2-plugin-file = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-file-2.23.5-1.el10_1.aarch64.rpm;name=aarch64_gfal2-plugin-file;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-file}"
SRC_URI[aarch64_gfal2-plugin-file.sha256sum] = "3cca49f7e036e25e3a156671d9aa627f302cc154e6421996215d098e3af9ccae"

URI_aarch64_gfal2-plugin-http = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-http-2.23.5-1.el10_1.aarch64.rpm;name=aarch64_gfal2-plugin-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-http}"
SRC_URI[aarch64_gfal2-plugin-http.sha256sum] = "1dafafb903d191a451a88ccd890992bb29663b0d6a3c0ac43db8b0dd3b8cee7f"

URI_aarch64_gfal2-plugin-mock = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-mock-2.23.5-1.el10_1.aarch64.rpm;name=aarch64_gfal2-plugin-mock;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-mock}"
SRC_URI[aarch64_gfal2-plugin-mock.sha256sum] = "339e027ee61a55247a66e55d546df24e5a9d05150a3022ff9e7b8265785c14fe"

URI_aarch64_gfal2-plugin-srm = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-srm-2.23.5-1.el10_1.aarch64.rpm;name=aarch64_gfal2-plugin-srm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-srm}"
SRC_URI[aarch64_gfal2-plugin-srm.sha256sum] = "57994d526c25d0c5ca473908ef9411180ceb11c935e89aab4e74bdea781b9046"

URI_aarch64_gfal2-plugin-xrootd = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-xrootd-2.23.5-1.el10_1.aarch64.rpm;name=aarch64_gfal2-plugin-xrootd;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-xrootd}"
SRC_URI[aarch64_gfal2-plugin-xrootd.sha256sum] = "fe177baa42560b6b058d647d1ce024cafec7ac007a1b12bdcc634b81914c047d"

URI_aarch64_gfal2-tests = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-tests-2.23.5-1.el10_1.aarch64.rpm;name=aarch64_gfal2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-tests}"
SRC_URI[aarch64_gfal2-tests.sha256sum] = "5f651c400cb8ef74adfa64edfc064685fb1bb489450ead7a97f8b04fff31a571"

RDEPENDS:gfal2 = " \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 openldap \
 pugixml \
 "
RDEPENDS:gfal2-all = " \
 gfal2 \
 gfal2-plugin-file \
 gfal2-plugin-http \
 gfal2-plugin-srm \
 gfal2-plugin-xrootd \
 "
RDEPENDS:gfal2-devel = " \
 gfal2 \
 gfal2-devel \
 glib2-devel \
 libattr-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gfal2-doc = " \
 "
RDEPENDS:gfal2-plugin-file = " \
 gfal2 \
 glib2 \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:gfal2-plugin-http = " \
 cryptopp \
 davix-libs \
 gfal2 \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gfal2-plugin-mock = " \
 gfal2 \
 glib2 \
 glibc \
 libuuid \
 "
RDEPENDS:gfal2-plugin-srm = " \
 gfal2 \
 glib2 \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 srm-ifce \
 "
RDEPENDS:gfal2-plugin-xrootd = " \
 gfal2 \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 xrootd-client-libs \
 "
RDEPENDS:gfal2-tests = " \
 cryptopp \
 davix-libs \
 gfal2 \
 gfal2-all \
 gfal2-plugin-mock \
 glib2 \
 glibc \
 gtest \
 json-c \
 libgcc \
 libstdc++ \
 "
