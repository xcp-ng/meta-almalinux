# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-UNIVERSAL-ref"
PV = "0.14"
PR = "45.el10_0"
PACKAGES = " \
 perl-UNIVERSAL-ref \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-UNIVERSAL-ref-0.14-45.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42c5e2b3b09aabcd741d13e63127c5e93573d26d95fdb26ac9dd7f953e84f30d"

URI_x86_64_v2_perl-UNIVERSAL-ref = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-UNIVERSAL-ref-0.14-45.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-UNIVERSAL-ref;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-UNIVERSAL-ref}"
SRC_URI[x86_64_v2_perl-UNIVERSAL-ref.sha256sum] = "4fcea9b6681aed3f8204152b58354845f67b8f796fee5ba0a6ddecbec6a65ac5"

URI_aarch64_perl-UNIVERSAL-ref = "${EPEL_MIRROR}/aarch64/Packages/p/perl-UNIVERSAL-ref-0.14-45.el10_0.aarch64.rpm;name=aarch64_perl-UNIVERSAL-ref;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-UNIVERSAL-ref}"
SRC_URI[aarch64_perl-UNIVERSAL-ref.sha256sum] = "3b67aea7f00dce1a98ac4b5a55a51b9903555669e8cbf8aa2d385ced484c4c1f"

RDEPENDS:perl-UNIVERSAL-ref = " \
 glibc \
 perl-B \
 perl-B-Utils \
 perl-libs \
 "
