# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "trademgen"
PV = "1.00.13"
PR = "1.el10_2"
PACKAGES = " \
 python3-trademgen \
 trademgen \
 trademgen-devel \
 trademgen-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/trademgen-1.00.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "391ee238d2963a23d85f85cd259278b1b08bf520efad25348edcaea40bd731d0"

URI_x86_64_v2_python3-trademgen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-trademgen-1.00.13-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-trademgen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-trademgen}"
SRC_URI[x86_64_v2_python3-trademgen.sha256sum] = "5d30ce0ebe814990e35f6b7b6adc8a7f80554716ea7762928a85005c7fb4509f"

URI_x86_64_v2_trademgen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trademgen-1.00.13-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_trademgen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_trademgen}"
SRC_URI[x86_64_v2_trademgen.sha256sum] = "b11e998fc4af5b13f1ddd3741d0629b414893d0dc24443c7d8cbe1f472f3bbc0"

URI_x86_64_v2_trademgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trademgen-devel-1.00.13-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_trademgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_trademgen-devel}"
SRC_URI[x86_64_v2_trademgen-devel.sha256sum] = "c3c60a3319483a9139550baa1b984a0a338981d06f7ba10b9eed4904070eb4b1"

URI_x86_64_v2_trademgen-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trademgen-doc-1.00.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_trademgen-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_trademgen-doc}"
SRC_URI[x86_64_v2_trademgen-doc.sha256sum] = "64e247c66d9ed8970813576c0370ce92b9cb9f2f4af0f9988eb467ac60a479eb"

URI_aarch64_python3-trademgen = "${EPEL_MIRROR}/aarch64/Packages/p/python3-trademgen-1.00.13-1.el10_2.aarch64.rpm;name=aarch64_python3-trademgen;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-trademgen}"
SRC_URI[aarch64_python3-trademgen.sha256sum] = "12c6995bd83c524496b2dfaced16e7c734f0d191c8a612d36fe1926a509d8b6e"

URI_aarch64_trademgen = "${EPEL_MIRROR}/aarch64/Packages/t/trademgen-1.00.13-1.el10_2.aarch64.rpm;name=aarch64_trademgen;unpack=0"
SRC_URI:append = " ${URI_aarch64_trademgen}"
SRC_URI[aarch64_trademgen.sha256sum] = "12a7f1247f65b01b47b9219fb6f061aa0bf1181bb45997a713297209064991c9"

URI_aarch64_trademgen-devel = "${EPEL_MIRROR}/aarch64/Packages/t/trademgen-devel-1.00.13-1.el10_2.aarch64.rpm;name=aarch64_trademgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_trademgen-devel}"
SRC_URI[aarch64_trademgen-devel.sha256sum] = "e6561b22c179a85b8183981c2fa7d44460c03c4e36949bcaa51eafed27442568"

URI_aarch64_trademgen-doc = "${EPEL_MIRROR}/aarch64/Packages/t/trademgen-doc-1.00.13-1.el10_2.noarch.rpm;name=aarch64_trademgen-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_trademgen-doc}"
SRC_URI[aarch64_trademgen-doc.sha256sum] = "4ef26fc45fccb1077cc061dc24351b90312434bc6ed7db40cc8a0191a43b3c6f"

RDEPENDS:python3-trademgen = " \
 boost-python3 \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 stdair \
 trademgen \
 "
RDEPENDS:trademgen = " \
 bash \
 boost-program-options \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 readline \
 sevmgr \
 soci \
 stdair \
 "
RDEPENDS:trademgen-devel = " \
 bash \
 cmake-filesystem \
 pkgconf-pkg-config \
 trademgen \
 "
RDEPENDS:trademgen-doc = " \
 "
