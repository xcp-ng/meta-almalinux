# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-is-docker"
PV = "0.2.0"
PR = "5.el10_0"
PACKAGES = " \
 rust-is-docker+default-devel \
 rust-is-docker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-is-docker-0.2.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a15b4e41e351211737dfa5803c0d580fe36363695b006601876ffdf81081252a"

URI_x86_64_v2_rust-is-docker+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-docker+default-devel-0.2.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-docker+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is-docker+default-devel}"
SRC_URI[x86_64_v2_rust-is-docker+default-devel.sha256sum] = "aa9bbacb5300ff2890cd32b57b0f9e1bbaf2629dd127e05b87d821e7388281b2"

URI_x86_64_v2_rust-is-docker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-docker-devel-0.2.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-docker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is-docker-devel}"
SRC_URI[x86_64_v2_rust-is-docker-devel.sha256sum] = "bbec7c086a960a2cc357b31294ec6b6670980f4146d45a43961eacb17343ffcf"

URI_aarch64_rust-is-docker+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is-docker+default-devel-0.2.0-5.el10_0.noarch.rpm;name=aarch64_rust-is-docker+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is-docker+default-devel}"
SRC_URI[aarch64_rust-is-docker+default-devel.sha256sum] = "e84c5f6da621a421aa3d38d137fb6fbfe7a043a4d47555d53c4604bf01316f2b"

URI_aarch64_rust-is-docker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is-docker-devel-0.2.0-5.el10_0.noarch.rpm;name=aarch64_rust-is-docker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is-docker-devel}"
SRC_URI[aarch64_rust-is-docker-devel.sha256sum] = "0e4322da054a6554e754d4c68995a39b1670a8fd12ff53c635f5b3b2fc0d14b5"

RDEPENDS:rust-is-docker+default-devel = " \
 cargo \
 rust-is-docker-devel \
 "
RDEPENDS:rust-is-docker-devel = " \
 cargo \
 rust-once_cell+default-devel \
 "
