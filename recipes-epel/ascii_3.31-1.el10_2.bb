# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ascii"
PV = "3.31"
PR = "1.el10_2"
PACKAGES = " \
 ascii \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ascii-3.31-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db0d027d61c3418551f1bd7751d62e440e81a5b0832372b3e7fe0bc68d76b1e1"

URI_x86_64_v2_ascii = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ascii-3.31-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ascii;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ascii}"
SRC_URI[x86_64_v2_ascii.sha256sum] = "cff94dfeeca574283d0ed3be7b9bd29ff64aa8cc57c34c79db5daf37d80f2a70"

URI_aarch64_ascii = "${EPEL_MIRROR}/aarch64/Packages/a/ascii-3.31-1.el10_2.aarch64.rpm;name=aarch64_ascii;unpack=0"
SRC_URI:append = " ${URI_aarch64_ascii}"
SRC_URI[aarch64_ascii.sha256sum] = "b7cfa358c54d0f1a63bd656b00570df473c05ec1199889ecf59241199e903591"

RDEPENDS:ascii = " \
 glibc \
 "
