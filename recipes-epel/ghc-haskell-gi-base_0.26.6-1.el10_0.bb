# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-haskell-gi-base"
PV = "0.26.6"
PR = "1.el10_0"
PACKAGES = " \
 ghc-haskell-gi-base \
 ghc-haskell-gi-base-devel \
 ghc-haskell-gi-base-doc \
 ghc-haskell-gi-base-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-haskell-gi-base-0.26.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff0a09b58bf7a08612aad0a51f8e8ae624e26cee1b167c03d85bc7d9d6f7ed59"

URI_x86_64_v2_ghc-haskell-gi-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskell-gi-base-0.26.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haskell-gi-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskell-gi-base}"
SRC_URI[x86_64_v2_ghc-haskell-gi-base.sha256sum] = "138843962cd24b14b288c079a7cf9382b2426a5c6c5d97ec8756b44a89d11420"

URI_x86_64_v2_ghc-haskell-gi-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskell-gi-base-devel-0.26.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haskell-gi-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskell-gi-base-devel}"
SRC_URI[x86_64_v2_ghc-haskell-gi-base-devel.sha256sum] = "3c1f94931def3fce3c5bb5fcdb2754a6e67222c18eb4afa36cd0913c41268a81"

URI_x86_64_v2_ghc-haskell-gi-base-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskell-gi-base-doc-0.26.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-haskell-gi-base-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskell-gi-base-doc}"
SRC_URI[x86_64_v2_ghc-haskell-gi-base-doc.sha256sum] = "625c0dbf5927af6a5293c02540624194ee1686f4ea04cc359d760e15478f34a6"

URI_x86_64_v2_ghc-haskell-gi-base-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskell-gi-base-prof-0.26.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haskell-gi-base-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskell-gi-base-prof}"
SRC_URI[x86_64_v2_ghc-haskell-gi-base-prof.sha256sum] = "aeea0893c6af9c236a85a425e30f473b8288a62c8990358df1703ae78e4a94b1"

URI_aarch64_ghc-haskell-gi-base = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskell-gi-base-0.26.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-haskell-gi-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskell-gi-base}"
SRC_URI[aarch64_ghc-haskell-gi-base.sha256sum] = "74b50c0a7c4c7e3c5a197127b272df61f3c653a473ecd263b9f6c9f12172a628"

URI_aarch64_ghc-haskell-gi-base-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskell-gi-base-devel-0.26.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-haskell-gi-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskell-gi-base-devel}"
SRC_URI[aarch64_ghc-haskell-gi-base-devel.sha256sum] = "02b72ff39db9ceaf8cbc1b4ba9a39022e490c8de4636e334aae47e8ba23ca4b6"

URI_aarch64_ghc-haskell-gi-base-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskell-gi-base-doc-0.26.6-1.el10_0.noarch.rpm;name=aarch64_ghc-haskell-gi-base-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskell-gi-base-doc}"
SRC_URI[aarch64_ghc-haskell-gi-base-doc.sha256sum] = "b5001caa8c3026e19a60481feeba176f70bbf5912618d2b81a92e83ac4796e50"

URI_aarch64_ghc-haskell-gi-base-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskell-gi-base-prof-0.26.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-haskell-gi-base-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskell-gi-base-prof}"
SRC_URI[aarch64_ghc-haskell-gi-base-prof.sha256sum] = "8517a541addf6388766beb2873f0cb6f8deedb74134777227d85e1e37d87c76f"

RDEPENDS:ghc-haskell-gi-base = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glib2 \
 glibc \
 gmp \
 "
RDEPENDS:ghc-haskell-gi-base-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-haskell-gi-base \
 ghc-text-devel \
 glib2-devel \
 "
RDEPENDS:ghc-haskell-gi-base-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-haskell-gi-base-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-haskell-gi-base-devel \
 ghc-text-prof \
 "
