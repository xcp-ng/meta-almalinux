# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "py-radix"
PV = "1.1.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-py-radix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/py-radix-1.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3193e80418f1698b8b7a9abf25d86bf40b4d014592f868651a2f1feec417d443"

URI_x86_64_v2_python3-py-radix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-py-radix-1.1.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-py-radix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-py-radix}"
SRC_URI[x86_64_v2_python3-py-radix.sha256sum] = "0dfe0bd38aa407d40cf463e6129bae091b6205de9fa5dac39aac3c6ade7b1bd2"

URI_aarch64_python3-py-radix = "${EPEL_MIRROR}/aarch64/Packages/p/python3-py-radix-1.1.0-1.el10_3.aarch64.rpm;name=aarch64_python3-py-radix;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-py-radix}"
SRC_URI[aarch64_python3-py-radix.sha256sum] = "3f23bcf36a5d5411879cc7685a2ad56b76b355b38cbd2c1d9ce7a0fa29a1a581"

RDEPENDS:python3-py-radix = " \
 glibc \
 python3 \
 "
