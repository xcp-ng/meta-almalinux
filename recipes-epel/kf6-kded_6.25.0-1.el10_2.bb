# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kded"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kded \
 kf6-kded-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kded-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25a74875d3f272e068477ede5204c922046b1e8ac0720b7c40bcadf02540081a"

URI_x86_64_v2_kf6-kded = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kded-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kded}"
SRC_URI[x86_64_v2_kf6-kded.sha256sum] = "5ed1be0e0f1f695c8dba493e866229abf7f4560c16c867f6d5838b40d4134758"

URI_x86_64_v2_kf6-kded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kded-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kded-devel}"
SRC_URI[x86_64_v2_kf6-kded-devel.sha256sum] = "dcda5c8d4a3eaffcf4074fdab21ba66b6e0f50902bdd25c1a587d9379cc773ae"

URI_aarch64_kf6-kded = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kded-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kded;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kded}"
SRC_URI[aarch64_kf6-kded.sha256sum] = "8b97a898ab58362bb73e757c863ed3434ba8467b5cfc015663322bae1e826f39"

URI_aarch64_kf6-kded-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kded-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kded-devel}"
SRC_URI[aarch64_kf6-kded-devel.sha256sum] = "3ce78ce020aaca57d9a36d4b243149b1ae36f8b764aefc9e7643f98e93899046"

RDEPENDS:kf6-kded = " \
 bash \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kded-devel = " \
 cmake-filesystem \
 kf6-kded \
 "
