# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-common"
PV = "0.12.2"
PR = "2.el10_0"
PACKAGES = " \
 aws-c-common \
 aws-c-common-devel \
 aws-c-common-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-common-0.12.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f1c4a3efd3d20bf805647cc90ff7486b5241f49071c122cc8fb2e5860627a5b"

URI_x86_64_v2_aws-c-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-common-0.12.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-common}"
SRC_URI[x86_64_v2_aws-c-common.sha256sum] = "a5bb1db94830b69e294d4071ec62f3d3b83f04f4cb3cfdcb8a3a7392363c3935"

URI_x86_64_v2_aws-c-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-common-devel-0.12.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-common-devel}"
SRC_URI[x86_64_v2_aws-c-common-devel.sha256sum] = "af835b746f8c067a71e04c3f4948dde1c95f21de02220c4aed034e14d7aa9b5b"

URI_x86_64_v2_aws-c-common-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-common-libs-0.12.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-common-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-common-libs}"
SRC_URI[x86_64_v2_aws-c-common-libs.sha256sum] = "17ce3ee09dccfd4eea4fd12a4730f255eda97a29b34b072fa780dd3d81b8d346"

URI_aarch64_aws-c-common = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-common-0.12.2-2.el10_0.aarch64.rpm;name=aarch64_aws-c-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-common}"
SRC_URI[aarch64_aws-c-common.sha256sum] = "b89538951ab3f67bfc55450229367fe178a86bddce54337662807024f8828fb0"

URI_aarch64_aws-c-common-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-common-devel-0.12.2-2.el10_0.aarch64.rpm;name=aarch64_aws-c-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-common-devel}"
SRC_URI[aarch64_aws-c-common-devel.sha256sum] = "12e7c0d4f36684d240c4b94a4bd65905ede573f51a44aa88604ed2b8494f218d"

URI_aarch64_aws-c-common-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-common-libs-0.12.2-2.el10_0.aarch64.rpm;name=aarch64_aws-c-common-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-common-libs}"
SRC_URI[aarch64_aws-c-common-libs.sha256sum] = "cd41ec6c917ff5f298cb8e5ddd492348920309887adb153f4d4a8fd9bb22ed73"

RDEPENDS:aws-c-common = " \
 aws-c-common-libs \
 "
RDEPENDS:aws-c-common-devel = " \
 aws-c-common-libs \
 cmake-filesystem \
 "
RDEPENDS:aws-c-common-libs = " \
 aws-c-common \
 glibc \
 "
