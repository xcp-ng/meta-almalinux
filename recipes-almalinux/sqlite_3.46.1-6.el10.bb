# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sqlite"
PV = "3.46.1"
PR = "6.el10"
PACKAGES = " \
 sqlite \
 sqlite-devel \
 sqlite-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sqlite-3.46.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bf5bc98ee2462784d46ecfb768db6ce64a48c68c585845660aebf6ef64af23d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sqlite-3.46.1-6.el10.x86_64_v2.rpm;name=x86_64_v2_sqlite;unpack=0"
SRC_URI[x86_64_v2_sqlite.sha256sum] = "c1a4bb9d15fa33e75068f682dbcc6033805fa16fd4a59254b6fb41cc9b6112ca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sqlite-devel-3.46.1-6.el10.x86_64_v2.rpm;name=x86_64_v2_sqlite-devel;unpack=0"
SRC_URI[x86_64_v2_sqlite-devel.sha256sum] = "fd6a28479420d3be977637a3ec1b2c3b542641a87d3b053d919e48e638d95823"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sqlite-libs-3.46.1-6.el10.x86_64_v2.rpm;name=x86_64_v2_sqlite-libs;unpack=0"
SRC_URI[x86_64_v2_sqlite-libs.sha256sum] = "b4eaab9fe14926e80ff1bc7b504776c65828cc98387eb2deea3fba44491f7656"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sqlite-3.46.1-6.el10.aarch64.rpm;name=aarch64_sqlite;unpack=0"
SRC_URI[aarch64_sqlite.sha256sum] = "5c8bd8684505a226bc5ab3555da8e8cc16be7cd562627a4904d01c53c0ad4b84"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sqlite-devel-3.46.1-6.el10.aarch64.rpm;name=aarch64_sqlite-devel;unpack=0"
SRC_URI[aarch64_sqlite-devel.sha256sum] = "8f94aa08b32435bd24d955264dba3ec8405ead6624a609d41ee78b07ee84346c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sqlite-libs-3.46.1-6.el10.aarch64.rpm;name=aarch64_sqlite-libs;unpack=0"
SRC_URI[aarch64_sqlite-libs.sha256sum] = "0560f9f47014536b017055ce7521ed12872b334eb98438b57e5950981569b5a1"

RDEPENDS:sqlite = " \
 glibc \
 readline \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:sqlite-devel = " \
 pkgconf-pkg-config \
 sqlite \
 sqlite-libs \
 "
RDEPENDS:sqlite-libs = " \
 glibc \
 zlib-ng-compat \
 "
