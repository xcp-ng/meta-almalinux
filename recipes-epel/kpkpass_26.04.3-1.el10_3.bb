# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpkpass"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kpkpass \
 kpkpass-devel \
 kpkpass-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpkpass-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33636fce7bce7427ee52607e609873af59b97ef5671a83cbf2a285efb1b0a9a0"

URI_x86_64_v2_kpkpass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpkpass-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpkpass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpkpass}"
SRC_URI[x86_64_v2_kpkpass.sha256sum] = "1aff085f507d033ca41537d4fff50cb8192d23215cea06d8896f7b0806d93e5d"

URI_x86_64_v2_kpkpass-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpkpass-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpkpass-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpkpass-devel}"
SRC_URI[x86_64_v2_kpkpass-devel.sha256sum] = "bfa5d1fdd570a55caac555f42344ba7a0959816087b383b9789b219ded20d6a0"

URI_x86_64_v2_kpkpass-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpkpass-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kpkpass-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpkpass-doc}"
SRC_URI[x86_64_v2_kpkpass-doc.sha256sum] = "4bcd4ce4db04f356cc25896d4ea6de3fd12b8317d257f75d7a3db664d4ae27dd"

URI_aarch64_kpkpass = "${EPEL_MIRROR}/aarch64/Packages/k/kpkpass-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kpkpass;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpkpass}"
SRC_URI[aarch64_kpkpass.sha256sum] = "daf9f929055835884592c6be5efb36d1556815276134694109a4d370e102a13f"

URI_aarch64_kpkpass-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpkpass-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kpkpass-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpkpass-devel}"
SRC_URI[aarch64_kpkpass-devel.sha256sum] = "507956c8afa9ee691469c800d1c061dc45ac5b39b13e210b79f7ecfa6695ba66"

URI_aarch64_kpkpass-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kpkpass-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kpkpass-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpkpass-doc}"
SRC_URI[aarch64_kpkpass-doc.sha256sum] = "1803654a92f8765032337a8e8fb6095c22b82001a38fff4f19538004e7c2352a"

RDEPENDS:kpkpass = " \
 glibc \
 kf6-karchive \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kpkpass-devel = " \
 cmake-filesystem \
 kf6-karchive-devel \
 kpkpass \
 "
RDEPENDS:kpkpass-doc = " \
 "
