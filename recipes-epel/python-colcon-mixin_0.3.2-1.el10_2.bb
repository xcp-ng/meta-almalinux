# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-mixin"
PV = "0.3.2"
PR = "1.el10_2"
PACKAGES = " \
 python3-colcon-mixin \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-mixin-0.3.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5ac49ec690d9de39e282fefeca9a2f568943e44912bacd46c2b7f34df05e54f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-mixin-0.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-mixin;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-mixin.sha256sum] = "f80acd5dbb3dfaef33493d553f544c8227aebd9e74376515d7878f42c922a8e1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-mixin-0.3.2-1.el10_2.noarch.rpm;name=aarch64_python3-colcon-mixin;unpack=0"
SRC_URI[aarch64_python3-colcon-mixin.sha256sum] = "806a49cd58fcf67c91039d118c78c0ebe9a24df9ab98fa1cc01cae4ee13e66a3"

RDEPENDS:python3-colcon-mixin = " \
 python3 \
 python3-colcon-core \
 python3-pyyaml \
 "
