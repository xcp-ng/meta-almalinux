# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.12"
PV = "3.12.12"
PR = "3.el10_1.3"
PACKAGES = " \
 python-unversioned-command \
 python3 \
 python3-debug \
 python3-devel \
 python3-idle \
 python3-libs \
 python3-test \
 python3-tkinter \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python3.12-3.12.12-3.el10_1.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2869c85333d1089a746c1b99954eb41670d5d75651f1a21d2e3f82f527bb58c"

URI_x86_64_v2_python-unversioned-command = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-unversioned-command-3.12.12-3.el10_1.3.noarch.rpm;name=x86_64_v2_python-unversioned-command;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-unversioned-command}"
SRC_URI[x86_64_v2_python-unversioned-command.sha256sum] = "1648f21c7e84cd179e052045ebd518ab6fde3150a166a356b0303c8f51145f70"

URI_x86_64_v2_python3 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-3.12.12-3.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3}"
SRC_URI[x86_64_v2_python3.sha256sum] = "358b3e24a23de9cb89ee2d52cfb2d94b78e0724f96b385458776d221c1a19f69"

URI_x86_64_v2_python3-debug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-debug-3.12.12-3.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_python3-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-debug}"
SRC_URI[x86_64_v2_python3-debug.sha256sum] = "adb7fef493de8a0c61d4026352d4b905c3b62645d76692f73fd34ce5dfc8f918"

URI_x86_64_v2_python3-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-devel-3.12.12-3.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_python3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-devel}"
SRC_URI[x86_64_v2_python3-devel.sha256sum] = "1994d4bca82b57de9b71424ac3d0be080ca23c4075d1a6ff101b5500f52f7ead"

URI_x86_64_v2_python3-idle = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-idle-3.12.12-3.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_python3-idle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-idle}"
SRC_URI[x86_64_v2_python3-idle.sha256sum] = "8869f204358fd5b1941aa012769fb95f42cbc128f7f33a4fb33dde0d25cd5ef6"

URI_x86_64_v2_python3-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libs-3.12.12-3.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_python3-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libs}"
SRC_URI[x86_64_v2_python3-libs.sha256sum] = "a5fcbd4c05981cfb92a49f4369ee70bc9abebe27aab3e34dfa839b27498697ec"

URI_x86_64_v2_python3-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-test-3.12.12-3.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_python3-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-test}"
SRC_URI[x86_64_v2_python3-test.sha256sum] = "3a0a0b4e21a2f3bc739722e7e31a5b3836b94e57a85ddbbc6d4d32338ffde861"

URI_x86_64_v2_python3-tkinter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tkinter-3.12.12-3.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_python3-tkinter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tkinter}"
SRC_URI[x86_64_v2_python3-tkinter.sha256sum] = "5057c60f5be90ee5f620a6e94f251671c06d53901de0adb8b04e0da80b870066"

URI_aarch64_python-unversioned-command = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-unversioned-command-3.12.12-3.el10_1.3.noarch.rpm;name=aarch64_python-unversioned-command;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-unversioned-command}"
SRC_URI[aarch64_python-unversioned-command.sha256sum] = "1648f21c7e84cd179e052045ebd518ab6fde3150a166a356b0303c8f51145f70"

URI_aarch64_python3 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-3.12.12-3.el10_1.3.aarch64.rpm;name=aarch64_python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3}"
SRC_URI[aarch64_python3.sha256sum] = "c510dc33e8dbcd5107c242ee9bd7cb89236745aa0530e64f84f747abbb7d338b"

URI_aarch64_python3-debug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-debug-3.12.12-3.el10_1.3.aarch64.rpm;name=aarch64_python3-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-debug}"
SRC_URI[aarch64_python3-debug.sha256sum] = "9177bcdf414cf321f91000259499ea315794e056dfeb3cb83b17088a14e9ba83"

URI_aarch64_python3-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-devel-3.12.12-3.el10_1.3.aarch64.rpm;name=aarch64_python3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-devel}"
SRC_URI[aarch64_python3-devel.sha256sum] = "a57dacd30b38b940e6370e19b7363d7f8d3b94c3dc3e37fbadfa495957f02554"

URI_aarch64_python3-idle = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-idle-3.12.12-3.el10_1.3.aarch64.rpm;name=aarch64_python3-idle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-idle}"
SRC_URI[aarch64_python3-idle.sha256sum] = "5f5f23938320a6313f295da6bebfc0401c5aca8bdc27a910840c43bf084e0ed2"

URI_aarch64_python3-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libs-3.12.12-3.el10_1.3.aarch64.rpm;name=aarch64_python3-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libs}"
SRC_URI[aarch64_python3-libs.sha256sum] = "88bfb3aac51de52015cb24e92d959502e6801eaf5b87c075911d656a5129d172"

URI_aarch64_python3-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-test-3.12.12-3.el10_1.3.aarch64.rpm;name=aarch64_python3-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-test}"
SRC_URI[aarch64_python3-test.sha256sum] = "4094f2d6b1245a10a9fb7a7fe12067036004e9ad88c528d55db95d8a6931b131"

URI_aarch64_python3-tkinter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tkinter-3.12.12-3.el10_1.3.aarch64.rpm;name=aarch64_python3-tkinter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tkinter}"
SRC_URI[aarch64_python3-tkinter.sha256sum] = "f6f6b9fc532b4452fbc61720ddb1608825b7fdcd37388a3a575629074888ec36"

RDEPENDS:python-unversioned-command = " \
 python3 \
 "
RDEPENDS:python3 = " \
 glibc \
 python3-libs \
 "
RDEPENDS:python3-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libxcrypt \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3 \
 python3-devel \
 python3-idle \
 python3-libs \
 python3-test \
 python3-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-devel = " \
 bash \
 pkgconf-pkg-config \
 python-rpm-macros \
 python3 \
 python3-libs \
 python3-rpm-generators \
 python3-rpm-macros \
 "
RDEPENDS:python3-idle = " \
 python3 \
 python3-tkinter \
 "
RDEPENDS:python3-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libxcrypt \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-test = " \
 bash \
 glibc \
 python3 \
 python3-libs \
 python3-setuptools-wheel \
 python3-wheel-wheel \
 "
RDEPENDS:python3-tkinter = " \
 glibc \
 python3 \
 tcl \
 tk \
 "
