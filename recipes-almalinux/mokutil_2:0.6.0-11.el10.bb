# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mokutil"
PE = "2"
PV = "0.6.0"
PR = "11.el10"
PACKAGES = " \
 mokutil \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mokutil-0.6.0-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fa5c771cb23229076c92fdfcb81a2c4fc9de2cc2638add7da5329e80b4682c6"

URI_x86_64_v2_mokutil = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mokutil-0.6.0-11.el10.x86_64_v2.rpm;name=x86_64_v2_mokutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mokutil}"
SRC_URI[x86_64_v2_mokutil.sha256sum] = "2d47b76bafc7e6992d1ad4c7f74e1bc922ddf140c50f802295f8ca779392b55c"

URI_aarch64_mokutil = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mokutil-0.6.0-11.el10.aarch64.rpm;name=aarch64_mokutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_mokutil}"
SRC_URI[aarch64_mokutil.sha256sum] = "feca622c2e10d61c15ff427718f88c25bbba08c62ba0f7fc57d5df6be04d12f2"

RDEPENDS:mokutil = " \
 efivar-libs \
 glibc \
 keyutils-libs \
 libxcrypt \
 openssl-libs \
 "
