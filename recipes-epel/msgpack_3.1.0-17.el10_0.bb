# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "msgpack"
PV = "3.1.0"
PR = "17.el10_0"
PACKAGES = " \
 msgpack \
 msgpack-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/msgpack-3.1.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37f95a5f6846a8ab6850cc2be9d41133621e7cbef284013104f3ed14709bb65d"

URI_x86_64_v2_msgpack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/msgpack-3.1.0-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_msgpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_msgpack}"
SRC_URI[x86_64_v2_msgpack.sha256sum] = "52a6390e639ef2ce4afd5f1a66b7d53c5c66e214bd97f59cb913e03c17a6cb87"

URI_x86_64_v2_msgpack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/msgpack-devel-3.1.0-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_msgpack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_msgpack-devel}"
SRC_URI[x86_64_v2_msgpack-devel.sha256sum] = "010082397bc28129d5d735d78bc57f0ccff8df10ae64d89dd3dd92e0c2f6dc9d"

URI_aarch64_msgpack = "${EPEL_MIRROR}/aarch64/Packages/m/msgpack-3.1.0-17.el10_0.aarch64.rpm;name=aarch64_msgpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_msgpack}"
SRC_URI[aarch64_msgpack.sha256sum] = "27a43fa99c2dd5cac49e3f0df1059a7e917ccdf3e0c27c6842e9bc8c9b63f7d0"

URI_aarch64_msgpack-devel = "${EPEL_MIRROR}/aarch64/Packages/m/msgpack-devel-3.1.0-17.el10_0.aarch64.rpm;name=aarch64_msgpack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_msgpack-devel}"
SRC_URI[aarch64_msgpack-devel.sha256sum] = "cb4f9a321889b5f0ca2bbee9c4d52229217f79ff35f46ad021d88e0050c7c6c3"

RDEPENDS:msgpack = " \
 glibc \
 "
RDEPENDS:msgpack-devel = " \
 cmake-filesystem \
 msgpack \
 pkgconf-pkg-config \
 "
