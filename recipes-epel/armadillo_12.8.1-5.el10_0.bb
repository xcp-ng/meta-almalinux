# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "armadillo"
PV = "12.8.1"
PR = "5.el10_0"
PACKAGES = " \
 armadillo \
 armadillo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/armadillo-12.8.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72e3700cd4d9dc346f46f6e11eae2854384a39a1029227f37bf5e5b617e4f009"

URI_x86_64_v2_armadillo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/armadillo-12.8.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_armadillo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_armadillo}"
SRC_URI[x86_64_v2_armadillo.sha256sum] = "f8a24ddfe61608104f01bd31e956c737cf0b89310f2ad7453739968b01559e22"

URI_x86_64_v2_armadillo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/armadillo-devel-12.8.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_armadillo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_armadillo-devel}"
SRC_URI[x86_64_v2_armadillo-devel.sha256sum] = "1bbbbeadf6853802d1ae53b6041ebac491cb857642cc815fd239c7fb756e51a9"

URI_aarch64_armadillo = "${EPEL_MIRROR}/aarch64/Packages/a/armadillo-12.8.1-5.el10_0.aarch64.rpm;name=aarch64_armadillo;unpack=0"
SRC_URI:append = " ${URI_aarch64_armadillo}"
SRC_URI[aarch64_armadillo.sha256sum] = "6b0a990583255c277b347d3fa93af3a46d44355f2e9a113141a381f95c22de4c"

URI_aarch64_armadillo-devel = "${EPEL_MIRROR}/aarch64/Packages/a/armadillo-devel-12.8.1-5.el10_0.aarch64.rpm;name=aarch64_armadillo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_armadillo-devel}"
SRC_URI[aarch64_armadillo-devel.sha256sum] = "5272bf3ed68b07fcf57e739e45104877925fedb59023583665c3752c39938fe4"

RDEPENDS:armadillo = " \
 arpack \
 flexiblas-netlib \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:armadillo-devel = " \
 SuperLU-devel \
 armadillo \
 arpack-devel \
 flexiblas-devel \
 hdf5-devel \
 libstdc++-devel \
 pkgconf-pkg-config \
 "
