# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "runc"
PE = "2"
PV = "1.5.1"
PR = "1.el10_3"
PACKAGES = " \
 runc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/runc-1.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "07076a61a081b320a39eace71107518387cc8407a961fd55cd4b6539563dd466"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/runc-1.5.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_runc;unpack=0"
SRC_URI[x86_64_v2_runc.sha256sum] = "5bd007ea959d3cc180cf728eaec94f95c354d510aa05efec764a98e1dc5c8ff9"
RPROVIDES:runc:append:x86_64_v2 = " virtual/oci-runtime"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/runc-1.5.1-1.el10_3.aarch64.rpm;name=aarch64_runc;unpack=0"
SRC_URI[aarch64_runc.sha256sum] = "1f51c13d210a17ead33b18b8cf246660d9ab772ca3aa9314c3cdb1cc2d11b1f2"
RPROVIDES:runc:append:aarch64 = " virtual/oci-runtime"

RDEPENDS:runc = " \
 glibc \
 libseccomp \
 "
