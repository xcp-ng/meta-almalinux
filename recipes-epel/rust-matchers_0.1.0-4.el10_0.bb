# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-matchers"
PV = "0.1.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-matchers+default-devel \
 rust-matchers-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-matchers-0.1.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "453d47bb420e2e52009fc88c6fee05598e2ccc9f1f53d158421c256501f88a38"

URI_x86_64_v2_rust-matchers+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchers+default-devel-0.1.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchers+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchers+default-devel}"
SRC_URI[x86_64_v2_rust-matchers+default-devel.sha256sum] = "4ce3fd2d62f3410d7f2cd1a5077ae5c99992e147b2ca71f422d42337c617ba9c"

URI_x86_64_v2_rust-matchers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchers-devel-0.1.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchers-devel}"
SRC_URI[x86_64_v2_rust-matchers-devel.sha256sum] = "4358ec65bb4ca3b33418bebfa38e31dee5c28aebb64ea9c211efb275c600d120"

URI_aarch64_rust-matchers+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchers+default-devel-0.1.0-4.el10_0.noarch.rpm;name=aarch64_rust-matchers+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchers+default-devel}"
SRC_URI[aarch64_rust-matchers+default-devel.sha256sum] = "86261dd7c9eea5d3f1a90f195c438990e72f0974e4c21e0c9afb3855f684cbd5"

URI_aarch64_rust-matchers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchers-devel-0.1.0-4.el10_0.noarch.rpm;name=aarch64_rust-matchers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchers-devel}"
SRC_URI[aarch64_rust-matchers-devel.sha256sum] = "c7305c781575bd07c5d5a6a38e4a572367834ebbb9bda595b29e61f588bd93e3"

RDEPENDS:rust-matchers+default-devel = " \
 cargo \
 rust-matchers-devel \
 "
RDEPENDS:rust-matchers-devel = " \
 cargo \
 rust-regex-automata0.1+default-devel \
 "
