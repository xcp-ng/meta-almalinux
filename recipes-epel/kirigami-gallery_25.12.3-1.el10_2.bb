# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kirigami-gallery"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kirigami-gallery \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kirigami-gallery-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e2bcf2e2549277200282cd91b327d48452135133fd6f5f1be0bfd6777ca2373"

URI_x86_64_v2_kirigami-gallery = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kirigami-gallery-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kirigami-gallery;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kirigami-gallery}"
SRC_URI[x86_64_v2_kirigami-gallery.sha256sum] = "e337aa75f6d87df063eb0478fc211e23fdcbfe403ee8ae19b75caf65b7732c77"

URI_aarch64_kirigami-gallery = "${EPEL_MIRROR}/aarch64/Packages/k/kirigami-gallery-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kirigami-gallery;unpack=0"
SRC_URI:append = " ${URI_aarch64_kirigami-gallery}"
SRC_URI[aarch64_kirigami-gallery.sha256sum] = "23847496da1e2141fec333eb52af34bec1eeb6d37b83dea50a20d5c4c077f9c0"

RDEPENDS:kirigami-gallery = " \
 breeze-icon-theme \
 glibc \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
