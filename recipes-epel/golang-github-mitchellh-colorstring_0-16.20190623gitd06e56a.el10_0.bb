# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mitchellh-colorstring"
PV = "0"
PR = "16.20190623gitd06e56a.el10_0"
PACKAGES = " \
 golang-github-mitchellh-colorstring-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-mitchellh-colorstring-0-16.20190623gitd06e56a.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d547e72c8eef15bb8323d2dfadee8bca12b0c0aa499634f55d887245931e6e0d"

URI_aarch64_golang-github-mitchellh-colorstring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mitchellh-colorstring-devel-0-16.20190623gitd06e56a.el10_0.noarch.rpm;name=aarch64_golang-github-mitchellh-colorstring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mitchellh-colorstring-devel}"
SRC_URI[aarch64_golang-github-mitchellh-colorstring-devel.sha256sum] = "53268d2074e0947e1968a247a5a3c8e084b9766ba5d243a3be0a7d1381227a01"

RDEPENDS:golang-github-mitchellh-colorstring-devel = " \
 go-filesystem \
 "
