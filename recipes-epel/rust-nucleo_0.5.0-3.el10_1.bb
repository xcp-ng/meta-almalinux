# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nucleo"
PV = "0.5.0"
PR = "3.el10_1"
PACKAGES = " \
 rust-nucleo+default-devel \
 rust-nucleo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nucleo-0.5.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddc6ea5891da35eeaea898e1a16a071810a1a2679c37112d0458999116ccead5"

URI_x86_64_v2_rust-nucleo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nucleo+default-devel-0.5.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nucleo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nucleo+default-devel}"
SRC_URI[x86_64_v2_rust-nucleo+default-devel.sha256sum] = "bd5bb60c9ccec1b7d65b54a46cc6291bbfb2f80fa1513a403d09b881655467eb"

URI_x86_64_v2_rust-nucleo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nucleo-devel-0.5.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nucleo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nucleo-devel}"
SRC_URI[x86_64_v2_rust-nucleo-devel.sha256sum] = "12996e731d1490e90406baa103ede7c196214856b6a9514ae74f2005f0e3b166"

URI_aarch64_rust-nucleo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nucleo+default-devel-0.5.0-3.el10_1.noarch.rpm;name=aarch64_rust-nucleo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nucleo+default-devel}"
SRC_URI[aarch64_rust-nucleo+default-devel.sha256sum] = "b47dce87c1d988c79f9035ae139cf9978ba9aa488d388573877994f5ad333c47"

URI_aarch64_rust-nucleo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nucleo-devel-0.5.0-3.el10_1.noarch.rpm;name=aarch64_rust-nucleo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nucleo-devel}"
SRC_URI[aarch64_rust-nucleo-devel.sha256sum] = "ec447f79f43ffda8f0a141b5cc82a8d3e07b0c8f28d58060b151ba21291bb89a"

RDEPENDS:rust-nucleo+default-devel = " \
 cargo \
 rust-nucleo-devel \
 "
RDEPENDS:rust-nucleo-devel = " \
 cargo \
 rust-nucleo-matcher+default-devel \
 rust-parking_lot+arc_lock-devel \
 rust-parking_lot+default-devel \
 rust-parking_lot+send_guard-devel \
 rust-rayon+default-devel \
 "
