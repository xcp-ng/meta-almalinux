# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bat"
PV = "0.24.0"
PR = "13.el10_2"
PACKAGES = " \
 bat \
 rust-bat+application-devel \
 rust-bat+bugreport-devel \
 rust-bat+build-assets-devel \
 rust-bat+clap-devel \
 rust-bat+default-devel \
 rust-bat+etcetera-devel \
 rust-bat+git-devel \
 rust-bat+git2-devel \
 rust-bat+grep-cli-devel \
 rust-bat+minimal-application-devel \
 rust-bat+paging-devel \
 rust-bat+regex-devel \
 rust-bat+regex-fancy-devel \
 rust-bat+regex-onig-devel \
 rust-bat+shell-words-devel \
 rust-bat+walkdir-devel \
 rust-bat+wild-devel \
 rust-bat-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bat-0.24.0-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "757f63a6a7dcfa7a3e3ac412392f61d4eba4d122e7e5dc83480cff78b240aac6"

URI_x86_64_v2_bat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bat-0.24.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bat}"
SRC_URI[x86_64_v2_bat.sha256sum] = "e17e34ac02c0e0d5c458475ec26e1ec92effa83512f8d4ab3e9332f7a1691ab8"

URI_x86_64_v2_rust-bat+application-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+application-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+application-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+application-devel}"
SRC_URI[x86_64_v2_rust-bat+application-devel.sha256sum] = "4acdea288dda05294f2dc40c266f464fb10eebabcddd1233f12af2a58f690ac3"

URI_x86_64_v2_rust-bat+bugreport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+bugreport-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+bugreport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+bugreport-devel}"
SRC_URI[x86_64_v2_rust-bat+bugreport-devel.sha256sum] = "e907d9e1bf1deeee0d1e1903c1559e778ee856c9f0dc9eb97137a227f08fd1e2"

URI_x86_64_v2_rust-bat+build-assets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+build-assets-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+build-assets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+build-assets-devel}"
SRC_URI[x86_64_v2_rust-bat+build-assets-devel.sha256sum] = "4717f0223665359ebf20fb20d57b9cd0e1edea8e44b78c53cc3edff58cf8df16"

URI_x86_64_v2_rust-bat+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+clap-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+clap-devel}"
SRC_URI[x86_64_v2_rust-bat+clap-devel.sha256sum] = "12f4fc071f35272980dd63322a4415858032f0b9de42692c79e7437ff4a84d5d"

URI_x86_64_v2_rust-bat+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+default-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+default-devel}"
SRC_URI[x86_64_v2_rust-bat+default-devel.sha256sum] = "f6fd63d7291e473e5ebd9947e24169a78c3515b698ab0f037d47e61da418563f"

URI_x86_64_v2_rust-bat+etcetera-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+etcetera-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+etcetera-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+etcetera-devel}"
SRC_URI[x86_64_v2_rust-bat+etcetera-devel.sha256sum] = "926c14be6dd2310b112e8986c6fca0796a24cf5240a36edc39344fd8ef12c2d9"

URI_x86_64_v2_rust-bat+git-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+git-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+git-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+git-devel}"
SRC_URI[x86_64_v2_rust-bat+git-devel.sha256sum] = "f3ad6b8e84e1f5a7376a6a65538eb8b0aa106cfb84cb3dfb5740ee08ca7fb541"

URI_x86_64_v2_rust-bat+git2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+git2-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+git2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+git2-devel}"
SRC_URI[x86_64_v2_rust-bat+git2-devel.sha256sum] = "2651e34022221e386ba8989b2603a8f3c7511b48ba690f024518fea6c2ca8303"

URI_x86_64_v2_rust-bat+grep-cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+grep-cli-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+grep-cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+grep-cli-devel}"
SRC_URI[x86_64_v2_rust-bat+grep-cli-devel.sha256sum] = "b11cab09404156b84f37f51e27c76bf590f8ed068f480eb3c1f71b5a8572e06f"

URI_x86_64_v2_rust-bat+minimal-application-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+minimal-application-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+minimal-application-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+minimal-application-devel}"
SRC_URI[x86_64_v2_rust-bat+minimal-application-devel.sha256sum] = "e8d08f388a6e6c8a2e76d32e07bc81ca7884236a675a05c049eea83a5e83ff92"

URI_x86_64_v2_rust-bat+paging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+paging-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+paging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+paging-devel}"
SRC_URI[x86_64_v2_rust-bat+paging-devel.sha256sum] = "e058145325dfa5409b7c2cb3a3c287485bfc746963e94f1067ae38515243f9fc"

URI_x86_64_v2_rust-bat+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+regex-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+regex-devel}"
SRC_URI[x86_64_v2_rust-bat+regex-devel.sha256sum] = "a672f03c9c1d8266f42afe1fb01647c663b26d7d5ea64a062299c6d3f9d348b4"

URI_x86_64_v2_rust-bat+regex-fancy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+regex-fancy-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+regex-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+regex-fancy-devel}"
SRC_URI[x86_64_v2_rust-bat+regex-fancy-devel.sha256sum] = "3f56d7b5a2acc7b8aa2bc3d0933fa26e08455bcb3d8b993f43d622a0a946edfb"

URI_x86_64_v2_rust-bat+regex-onig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+regex-onig-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+regex-onig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+regex-onig-devel}"
SRC_URI[x86_64_v2_rust-bat+regex-onig-devel.sha256sum] = "7e97d3e80aa806ad613ab9cb1a2fab47f6723895993463b4b38e7da4c3874631"

URI_x86_64_v2_rust-bat+shell-words-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+shell-words-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+shell-words-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+shell-words-devel}"
SRC_URI[x86_64_v2_rust-bat+shell-words-devel.sha256sum] = "b44d2c7bc8cac0317ed8794bc25836557231ebecd9ee7c3323d898541720ab38"

URI_x86_64_v2_rust-bat+walkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+walkdir-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+walkdir-devel}"
SRC_URI[x86_64_v2_rust-bat+walkdir-devel.sha256sum] = "64f2ce964b283f2daa03f73a8f87a3bab0fc6a21bc0f38fc72276b441ff85de3"

URI_x86_64_v2_rust-bat+wild-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+wild-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+wild-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+wild-devel}"
SRC_URI[x86_64_v2_rust-bat+wild-devel.sha256sum] = "4c7991490e0e506114fa818653e196676a16947703cef270858d095f16ae6a09"

URI_x86_64_v2_rust-bat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat-devel-0.24.0-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat-devel}"
SRC_URI[x86_64_v2_rust-bat-devel.sha256sum] = "5b7f0977c74e80d0fa456c6fa86ad2d2c5ae2fa329d942d9aa4f67250af7f5f9"

URI_aarch64_bat = "${EPEL_MIRROR}/aarch64/Packages/b/bat-0.24.0-13.el10_2.aarch64.rpm;name=aarch64_bat;unpack=0"
SRC_URI:append = " ${URI_aarch64_bat}"
SRC_URI[aarch64_bat.sha256sum] = "6dfcea7100f3fc18754a3d98476a8a7fe9a437ca0729367c65b1cb3e615c5b1d"

URI_aarch64_rust-bat+application-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+application-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+application-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+application-devel}"
SRC_URI[aarch64_rust-bat+application-devel.sha256sum] = "c196b1977aef8ce0e9992dd9c5954fb8848ea751627ca41defd1101343b90310"

URI_aarch64_rust-bat+bugreport-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+bugreport-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+bugreport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+bugreport-devel}"
SRC_URI[aarch64_rust-bat+bugreport-devel.sha256sum] = "86df8a62303fd26191059585363d1ddb05a199a606c13ad3c3274cce4f1ad37d"

URI_aarch64_rust-bat+build-assets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+build-assets-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+build-assets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+build-assets-devel}"
SRC_URI[aarch64_rust-bat+build-assets-devel.sha256sum] = "5e70ff1675670644be797c822b7346774b55caca60bc4ab5bb2a90e4f3f0c48a"

URI_aarch64_rust-bat+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+clap-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+clap-devel}"
SRC_URI[aarch64_rust-bat+clap-devel.sha256sum] = "dab68048ee2a5d5ec74b9d4a036aaa0f8d0e36ece4e478ad7254ec7f8814f3c4"

URI_aarch64_rust-bat+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+default-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+default-devel}"
SRC_URI[aarch64_rust-bat+default-devel.sha256sum] = "ea5ecbb3885713a564b9df0cae0c3c365b867185572ba19623d1de5ebe087a81"

URI_aarch64_rust-bat+etcetera-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+etcetera-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+etcetera-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+etcetera-devel}"
SRC_URI[aarch64_rust-bat+etcetera-devel.sha256sum] = "19a9764043f7938ac65c7969e028a8906fcd935b1c9ad92d5f1ee9ee4fe5613a"

URI_aarch64_rust-bat+git-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+git-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+git-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+git-devel}"
SRC_URI[aarch64_rust-bat+git-devel.sha256sum] = "b75a88abe1387598320b1495416d72993f432d8178f9d0a732902ab3b6e084c3"

URI_aarch64_rust-bat+git2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+git2-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+git2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+git2-devel}"
SRC_URI[aarch64_rust-bat+git2-devel.sha256sum] = "c329bb66414dd4a8d34ce8133f512b27444dab8a4cabd366f922864b226906e8"

URI_aarch64_rust-bat+grep-cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+grep-cli-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+grep-cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+grep-cli-devel}"
SRC_URI[aarch64_rust-bat+grep-cli-devel.sha256sum] = "9d5136b69cf1dba097c2d32014cf163c141904b599960454534e139b40ed3df5"

URI_aarch64_rust-bat+minimal-application-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+minimal-application-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+minimal-application-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+minimal-application-devel}"
SRC_URI[aarch64_rust-bat+minimal-application-devel.sha256sum] = "642eb58055b8b8ec8c55b1317a6de58d85f706a64bc169b82b5650211ce9f74e"

URI_aarch64_rust-bat+paging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+paging-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+paging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+paging-devel}"
SRC_URI[aarch64_rust-bat+paging-devel.sha256sum] = "2530624ff8b315ed41fdd05fcbcef3ce8e98d7aa58e52da9e5255d7c10baeef7"

URI_aarch64_rust-bat+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+regex-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+regex-devel}"
SRC_URI[aarch64_rust-bat+regex-devel.sha256sum] = "c03f6e5bcc0842ecf758a486da7927e3b42032933b9e7f8312e95ebcb8698577"

URI_aarch64_rust-bat+regex-fancy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+regex-fancy-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+regex-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+regex-fancy-devel}"
SRC_URI[aarch64_rust-bat+regex-fancy-devel.sha256sum] = "c4e03640b24d34cfbcda71c98342de783b2c3c986558f9da9bb93162e1773386"

URI_aarch64_rust-bat+regex-onig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+regex-onig-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+regex-onig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+regex-onig-devel}"
SRC_URI[aarch64_rust-bat+regex-onig-devel.sha256sum] = "aa9d8e5ef07a601226efa715f667f6b3e4596571a0f09010987eac5e7f351b39"

URI_aarch64_rust-bat+shell-words-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+shell-words-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+shell-words-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+shell-words-devel}"
SRC_URI[aarch64_rust-bat+shell-words-devel.sha256sum] = "e90cc7d107d1bea7d29bd751725f97ce66e1f19bce18cd4411e347358e4fe2d1"

URI_aarch64_rust-bat+walkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+walkdir-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+walkdir-devel}"
SRC_URI[aarch64_rust-bat+walkdir-devel.sha256sum] = "8ac9d17e48c76e564751bb012acc0db6a2903f6d3a755168aefa44a61022f349"

URI_aarch64_rust-bat+wild-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+wild-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat+wild-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+wild-devel}"
SRC_URI[aarch64_rust-bat+wild-devel.sha256sum] = "026494496270d91b13d5e1e6260c1d4f47f763067cc0c0d61d95d4ec7120079b"

URI_aarch64_rust-bat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat-devel-0.24.0-13.el10_2.noarch.rpm;name=aarch64_rust-bat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat-devel}"
SRC_URI[aarch64_rust-bat-devel.sha256sum] = "88ef9d322064c3baa0e53a03cc39a02dac0578c8f23afc5b8db097dfc07f955d"

RDEPENDS:bat = " \
 glibc \
 libgcc \
 oniguruma \
 zlib-ng-compat \
 "
RDEPENDS:rust-bat+application-devel = " \
 cargo \
 rust-bat+bugreport-devel \
 rust-bat+build-assets-devel \
 rust-bat+git-devel \
 rust-bat+minimal-application-devel \
 rust-bat-devel \
 "
RDEPENDS:rust-bat+bugreport-devel = " \
 cargo \
 rust-bat-devel \
 rust-bugreport+default-devel \
 "
RDEPENDS:rust-bat+build-assets-devel = " \
 cargo \
 rust-bat+regex-devel \
 rust-bat+walkdir-devel \
 rust-bat-devel \
 rust-syntect+plist-load-devel \
 rust-syntect+yaml-load-devel \
 "
RDEPENDS:rust-bat+clap-devel = " \
 cargo \
 rust-bat-devel \
 rust-clap+cargo-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 "
RDEPENDS:rust-bat+default-devel = " \
 cargo \
 rust-bat+application-devel \
 rust-bat-devel \
 "
RDEPENDS:rust-bat+etcetera-devel = " \
 cargo \
 rust-bat-devel \
 rust-etcetera0.8+default-devel \
 "
RDEPENDS:rust-bat+git-devel = " \
 cargo \
 rust-bat+git2-devel \
 rust-bat-devel \
 "
RDEPENDS:rust-bat+git2-devel = " \
 cargo \
 rust-bat-devel \
 rust-git2_0.19-devel \
 "
RDEPENDS:rust-bat+grep-cli-devel = " \
 cargo \
 rust-bat-devel \
 rust-grep-cli+default-devel \
 "
RDEPENDS:rust-bat+minimal-application-devel = " \
 cargo \
 rust-bat+clap-devel \
 rust-bat+etcetera-devel \
 rust-bat+paging-devel \
 rust-bat+regex-onig-devel \
 rust-bat+wild-devel \
 rust-bat-devel \
 "
RDEPENDS:rust-bat+paging-devel = " \
 cargo \
 rust-bat+grep-cli-devel \
 rust-bat+shell-words-devel \
 rust-bat-devel \
 "
RDEPENDS:rust-bat+regex-devel = " \
 cargo \
 rust-bat-devel \
 rust-regex+default-devel \
 "
RDEPENDS:rust-bat+regex-fancy-devel = " \
 cargo \
 rust-bat-devel \
 rust-syntect+regex-fancy-devel \
 "
RDEPENDS:rust-bat+regex-onig-devel = " \
 cargo \
 rust-bat-devel \
 rust-syntect+regex-onig-devel \
 "
RDEPENDS:rust-bat+shell-words-devel = " \
 cargo \
 rust-bat-devel \
 rust-shell-words+default-devel \
 "
RDEPENDS:rust-bat+walkdir-devel = " \
 cargo \
 rust-bat-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-bat+wild-devel = " \
 cargo \
 rust-bat-devel \
 rust-wild+default-devel \
 "
RDEPENDS:rust-bat-devel = " \
 bash \
 cargo \
 python3 \
 rust \
 rust-ansi_colours+default-devel \
 rust-bincode1+default-devel \
 rust-bytesize1+default-devel \
 rust-clircle+default-devel \
 rust-console+default-devel \
 rust-content_inspector+default-devel \
 rust-encoding_rs+default-devel \
 rust-flate2+default-devel \
 rust-globset+default-devel \
 rust-nu-ansi-term+default-devel \
 rust-once_cell+default-devel \
 rust-path-absolutize+default-devel \
 rust-semver+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_yaml+default-devel \
 rust-syntect+parsing-devel \
 rust-syntect-devel \
 rust-thiserror1+default-devel \
 rust-unicode-width0.1+default-devel \
 "
