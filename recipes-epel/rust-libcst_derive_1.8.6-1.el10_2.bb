# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libcst_derive"
PV = "1.8.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-libcst_derive+default-devel \
 rust-libcst_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libcst_derive-1.8.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c4b07ca1fa2b67e1b033c441670930636130e321008e39661b528c992bb915b"

URI_x86_64_v2_rust-libcst_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcst_derive+default-devel-1.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcst_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcst_derive+default-devel}"
SRC_URI[x86_64_v2_rust-libcst_derive+default-devel.sha256sum] = "632d1e8b76352f9db0ba88924aaabcd798a534ea83ec8cb58227e12d49f65516"

URI_x86_64_v2_rust-libcst_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcst_derive-devel-1.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcst_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcst_derive-devel}"
SRC_URI[x86_64_v2_rust-libcst_derive-devel.sha256sum] = "fd4c640400c1ac139b2a4d841176c24fe2721bceedfcd5ab4a807a5605e7de88"

URI_aarch64_rust-libcst_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcst_derive+default-devel-1.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-libcst_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcst_derive+default-devel}"
SRC_URI[aarch64_rust-libcst_derive+default-devel.sha256sum] = "93e6c210e5d553af117f1f42652517160973ded514c63d1130715b015552c6e7"

URI_aarch64_rust-libcst_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcst_derive-devel-1.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-libcst_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcst_derive-devel}"
SRC_URI[aarch64_rust-libcst_derive-devel.sha256sum] = "b554bca00cb413073782cdbef5bfdcf2886fd9ced03ce475885be954a0610b0c"

RDEPENDS:rust-libcst_derive+default-devel = " \
 cargo \
 rust-libcst_derive-devel \
 "
RDEPENDS:rust-libcst_derive-devel = " \
 cargo \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
