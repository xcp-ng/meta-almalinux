# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serial_test"
PV = "3.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-serial_test+async-devel \
 rust-serial_test+default-devel \
 rust-serial_test+docsrs-devel \
 rust-serial_test+file_locks-devel \
 rust-serial_test+logging-devel \
 rust-serial_test+test_logging-devel \
 rust-serial_test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serial_test-3.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89565a22819102d2f4c648e791072826ea74d95adea1fc77ff9def5e1ee9ef6c"

URI_x86_64_v2_rust-serial_test+async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+async-devel-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+async-devel}"
SRC_URI[x86_64_v2_rust-serial_test+async-devel.sha256sum] = "dfecbb6761017696f21f1eb0bb019037507b6f40b1492aa3dc4deda98132e4ea"

URI_x86_64_v2_rust-serial_test+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+default-devel-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+default-devel}"
SRC_URI[x86_64_v2_rust-serial_test+default-devel.sha256sum] = "5309775d0d0fac7d244a528348d6d19d9732f56b95448eab331e0f1fe84f4b56"

URI_x86_64_v2_rust-serial_test+docsrs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+docsrs-devel-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+docsrs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+docsrs-devel}"
SRC_URI[x86_64_v2_rust-serial_test+docsrs-devel.sha256sum] = "f699e031098a18f6b6561661be433dd1ebba24fe1adf55cf7002cccf67ac1028"

URI_x86_64_v2_rust-serial_test+file_locks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+file_locks-devel-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+file_locks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+file_locks-devel}"
SRC_URI[x86_64_v2_rust-serial_test+file_locks-devel.sha256sum] = "20cc48cd1249e4d12fd2b136cd040aaab85b3a7797762ee9d278663583164c69"

URI_x86_64_v2_rust-serial_test+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+logging-devel-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+logging-devel}"
SRC_URI[x86_64_v2_rust-serial_test+logging-devel.sha256sum] = "3c8dd505aa06d9c30265c00fd605a76f00aed89a2af30c8b632717b71877962d"

URI_x86_64_v2_rust-serial_test+test_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test+test_logging-devel-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test+test_logging-devel}"
SRC_URI[x86_64_v2_rust-serial_test+test_logging-devel.sha256sum] = "03931c5bcb0e042e51ae8572606d4253296a0ad70f48893e9b5f378d0dc6dbfb"

URI_x86_64_v2_rust-serial_test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test-devel-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test-devel}"
SRC_URI[x86_64_v2_rust-serial_test-devel.sha256sum] = "e17f2306c2c00f9b8861a3a06ec338d420a6a579a665e79b76d69f9b571ba587"

URI_aarch64_rust-serial_test+async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+async-devel-3.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-serial_test+async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+async-devel}"
SRC_URI[aarch64_rust-serial_test+async-devel.sha256sum] = "2f9a45e7a118ffde41b3158a1f17f59e9fba8b137d46a4a44f0084465b2ce031"

URI_aarch64_rust-serial_test+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+default-devel-3.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-serial_test+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+default-devel}"
SRC_URI[aarch64_rust-serial_test+default-devel.sha256sum] = "8694efa542554dcecc3bfcea5b5ba8ffbf95935e1f7d9e5d8c08de12812859b3"

URI_aarch64_rust-serial_test+docsrs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+docsrs-devel-3.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-serial_test+docsrs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+docsrs-devel}"
SRC_URI[aarch64_rust-serial_test+docsrs-devel.sha256sum] = "7b21bd2877e65a621df5fa91d2e585adfe25dc465ff4d3208bb7a20b9056e2f2"

URI_aarch64_rust-serial_test+file_locks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+file_locks-devel-3.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-serial_test+file_locks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+file_locks-devel}"
SRC_URI[aarch64_rust-serial_test+file_locks-devel.sha256sum] = "7291adeb6fae74da8b0f338128331985b63c5b7d810bfbda4d0de53608ec220f"

URI_aarch64_rust-serial_test+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+logging-devel-3.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-serial_test+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+logging-devel}"
SRC_URI[aarch64_rust-serial_test+logging-devel.sha256sum] = "29914a8f09c4d9f79f370c8bd45f08412766dde8bdf9baff917aed30f0885ece"

URI_aarch64_rust-serial_test+test_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test+test_logging-devel-3.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-serial_test+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test+test_logging-devel}"
SRC_URI[aarch64_rust-serial_test+test_logging-devel.sha256sum] = "3ebffb5e3f1ecabcf525e50085a3ded1088d75f383d69c0aba3ff3cce884688b"

URI_aarch64_rust-serial_test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test-devel-3.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-serial_test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test-devel}"
SRC_URI[aarch64_rust-serial_test-devel.sha256sum] = "de21525513432b76182830e524a4ea38e22a1a016f74c29492b2d1fc64837e33"

RDEPENDS:rust-serial_test+async-devel = " \
 cargo \
 rust-futures-executor+std-devel \
 rust-futures-executor-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-serial_test-devel \
 rust-serial_test_derive+async-devel \
 "
RDEPENDS:rust-serial_test+default-devel = " \
 cargo \
 rust-serial_test+async-devel \
 rust-serial_test+logging-devel \
 rust-serial_test-devel \
 "
RDEPENDS:rust-serial_test+docsrs-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-serial_test-devel \
 "
RDEPENDS:rust-serial_test+file_locks-devel = " \
 cargo \
 rust-fslock+std-devel \
 rust-fslock-devel \
 rust-serial_test-devel \
 "
RDEPENDS:rust-serial_test+logging-devel = " \
 cargo \
 rust-log+default-devel \
 rust-serial_test-devel \
 "
RDEPENDS:rust-serial_test+test_logging-devel = " \
 cargo \
 rust-serial_test+logging-devel \
 rust-serial_test-devel \
 rust-serial_test_derive+test_logging-devel \
 virtual/crate_env_logger__ge_0.6.1 \
 "
RDEPENDS:rust-serial_test-devel = " \
 cargo \
 rust \
 rust-once_cell+std-devel \
 rust-once_cell-devel \
 rust-parking_lot-devel \
 rust-scc-devel \
 rust-serial_test_derive+default-devel \
 "
