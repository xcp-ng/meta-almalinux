# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-packaging"
PV = "1"
PR = "21.el10_2"
PACKAGES = " \
 ansible-packaging \
 ansible-packaging-tests \
 ansible-srpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-packaging-1-21.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bab31df465da184c81d7a75497c31c8d91351da2241e7b06c2d54c28139e3c8d"

URI_x86_64_v2_ansible-packaging = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-packaging-1-21.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-packaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-packaging}"
SRC_URI[x86_64_v2_ansible-packaging.sha256sum] = "39700bb1a45d8f5dc33aa4b2ccaa4c05f3114e0b07539ef21117993e6a91a194"

URI_x86_64_v2_ansible-packaging-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-packaging-tests-1-21.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-packaging-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-packaging-tests}"
SRC_URI[x86_64_v2_ansible-packaging-tests.sha256sum] = "c6fd3a72e0f137f8146b15a2e123524e9f04fa4e4a9b4053dec47d554dd3c4dd"

URI_x86_64_v2_ansible-srpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-srpm-macros-1-21.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-srpm-macros}"
SRC_URI[x86_64_v2_ansible-srpm-macros.sha256sum] = "a4966728d863d9fc769ffc48a4c3482fb1dd1604fe9ddafe74aadc94e27f1336"

URI_aarch64_ansible-packaging = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-packaging-1-21.el10_2.noarch.rpm;name=aarch64_ansible-packaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-packaging}"
SRC_URI[aarch64_ansible-packaging.sha256sum] = "c723c71950ffac040d5a021957542f64fd1a251698949246c5c129678dbfaa9f"

URI_aarch64_ansible-packaging-tests = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-packaging-tests-1-21.el10_2.noarch.rpm;name=aarch64_ansible-packaging-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-packaging-tests}"
SRC_URI[aarch64_ansible-packaging-tests.sha256sum] = "5c5abf30fc54375c04871841c85033c4b07b42d59c10707e881a4cfddc4d1310"

URI_aarch64_ansible-srpm-macros = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-srpm-macros-1-21.el10_2.noarch.rpm;name=aarch64_ansible-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-srpm-macros}"
SRC_URI[aarch64_ansible-srpm-macros.sha256sum] = "f58d734255546add3ff7d88b36df333224a8b38f11c063d1dd2acf578b0e7750"

RDEPENDS:ansible-packaging = " \
 ansible-core \
 ansible-srpm-macros \
 python3 \
 python3-pyyaml \
 "
RDEPENDS:ansible-packaging-tests = " \
 ansible-packaging \
 ansible-test \
 python3-pytest \
 python3-pytest-forked \
 python3-pytest-mock \
 python3-pytest-xdist \
 python3-pyyaml \
 "
RDEPENDS:ansible-srpm-macros = " \
 "
