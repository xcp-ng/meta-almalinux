# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fapolicyd"
PV = "1.4.5"
PR = "1.2.el10_2"
PACKAGES = " \
 fapolicyd \
 fapolicyd-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fapolicyd-1.4.5-1.2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b90b7e1efcdf6f3a2cd155db2c956471598b7f2b1f4a40319e32d49a52848f82"

URI_x86_64_v2_fapolicyd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fapolicyd-1.4.5-1.2.el10_2.x86_64_v2.rpm;name=x86_64_v2_fapolicyd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicyd}"
SRC_URI[x86_64_v2_fapolicyd.sha256sum] = "5e48b5ad18278cca3d3b51bc9fd160951f2cec3b1c874f0aea08dc3437eb0daa"

URI_x86_64_v2_fapolicyd-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fapolicyd-selinux-1.4.5-1.2.el10_2.noarch.rpm;name=x86_64_v2_fapolicyd-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicyd-selinux}"
SRC_URI[x86_64_v2_fapolicyd-selinux.sha256sum] = "e4d26b5a5de59c5d8420b8d2c78d5e2a199824089a172d5e6105b98862387148"

URI_aarch64_fapolicyd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fapolicyd-1.4.5-1.2.el10_2.aarch64.rpm;name=aarch64_fapolicyd;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicyd}"
SRC_URI[aarch64_fapolicyd.sha256sum] = "7fb333c8fec4c39c34d9d95190c5650e28946a9552dc64dc8d40446fef9f2adc"

URI_aarch64_fapolicyd-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fapolicyd-selinux-1.4.5-1.2.el10_2.noarch.rpm;name=aarch64_fapolicyd-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicyd-selinux}"
SRC_URI[aarch64_fapolicyd-selinux.sha256sum] = "e4d26b5a5de59c5d8420b8d2c78d5e2a199824089a172d5e6105b98862387148"

RDEPENDS:fapolicyd = " \
 bash \
 file-libs \
 glibc \
 libcap-ng \
 libseccomp \
 lmdb-libs \
 openssl-libs \
 rpm-libs \
 rpm-plugin-fapolicyd \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:fapolicyd-selinux = " \
 bash \
 fapolicyd \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
