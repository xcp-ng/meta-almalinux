# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "luksmeta"
PV = "9"
PR = "26.el10"
PACKAGES = " \
 libluksmeta \
 libluksmeta-devel \
 luksmeta \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/luksmeta-9-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2f83dc47cbcea8bbaecd3fd96442e8a9993f7db4038429f6c268ec99454129d"

URI_x86_64_v2_libluksmeta = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libluksmeta-9-26.el10.x86_64_v2.rpm;name=x86_64_v2_libluksmeta;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libluksmeta}"
SRC_URI[x86_64_v2_libluksmeta.sha256sum] = "91c47e246a651320f98e6a81c07c5570ed709a8d342e7215eca73bc97e351d29"

URI_x86_64_v2_libluksmeta-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libluksmeta-devel-9-26.el10.x86_64_v2.rpm;name=x86_64_v2_libluksmeta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libluksmeta-devel}"
SRC_URI[x86_64_v2_libluksmeta-devel.sha256sum] = "50a6e4b456760761d694f03e353c17729c272cc947cf085c4f317c238e7d6007"

URI_x86_64_v2_luksmeta = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/luksmeta-9-26.el10.x86_64_v2.rpm;name=x86_64_v2_luksmeta;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_luksmeta}"
SRC_URI[x86_64_v2_luksmeta.sha256sum] = "20441381edc462bbee6b06d6a92085815011ef950002037314e6717f7cf5b67f"

URI_aarch64_libluksmeta = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libluksmeta-9-26.el10.aarch64.rpm;name=aarch64_libluksmeta;unpack=0"
SRC_URI:append = " ${URI_aarch64_libluksmeta}"
SRC_URI[aarch64_libluksmeta.sha256sum] = "06194f1414c89eb6a740e0bff879407f2393663d0008ab2386f6da0ac2e4b703"

URI_aarch64_libluksmeta-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libluksmeta-devel-9-26.el10.aarch64.rpm;name=aarch64_libluksmeta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libluksmeta-devel}"
SRC_URI[aarch64_libluksmeta-devel.sha256sum] = "ba3932159811042b37b74d0654fcbea744efecc581b6d679ef5055d544b39a1d"

URI_aarch64_luksmeta = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/luksmeta-9-26.el10.aarch64.rpm;name=aarch64_luksmeta;unpack=0"
SRC_URI:append = " ${URI_aarch64_luksmeta}"
SRC_URI[aarch64_luksmeta.sha256sum] = "82a42b0780b84870c95033c45aff4306835cf74f7c7c83a402e4e112a26802f9"

RDEPENDS:libluksmeta = " \
 cryptsetup-libs \
 glibc \
 "
RDEPENDS:libluksmeta-devel = " \
 cryptsetup-devel \
 libluksmeta \
 pkgconf-pkg-config \
 "
RDEPENDS:luksmeta = " \
 cryptsetup-libs \
 glibc \
 libluksmeta \
 "
