# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "frugally-deep"
PV = "0.15.30"
PR = "10.el10_1"
PACKAGES = " \
 frugally-deep-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/frugally-deep-0.15.30-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bd3855c4a8f14bb337b92006e0325fcbb60bbe84c56dae921fa5fa94efa0590"

URI_x86_64_v2_frugally-deep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/frugally-deep-devel-0.15.30-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_frugally-deep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_frugally-deep-devel}"
SRC_URI[x86_64_v2_frugally-deep-devel.sha256sum] = "c2032b457bfa16c7e8b7a6d5eaf662e40c7e41d561821ea159eaee0c35517bbd"

URI_aarch64_frugally-deep-devel = "${EPEL_MIRROR}/aarch64/Packages/f/frugally-deep-devel-0.15.30-10.el10_1.aarch64.rpm;name=aarch64_frugally-deep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_frugally-deep-devel}"
SRC_URI[aarch64_frugally-deep-devel.sha256sum] = "8338784ad81424e1800a413b7efb89dcbd429e32ce5f22cd0b24a687cbbdd132"

RDEPENDS:frugally-deep-devel = " \
 cmake-filesystem \
 "
