# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksirk"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 ksirk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksirk-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8eead4708bed261a6a6146d444dfc9f3b30436f0e827692b7a5511c5fe022357"

URI_x86_64_v2_ksirk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksirk-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksirk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksirk}"
SRC_URI[x86_64_v2_ksirk.sha256sum] = "cb6cbc1c164e1db5456c2e087c7b7ddeed10f7567dbe06a1fc130e392aa42bcd"

URI_aarch64_ksirk = "${EPEL_MIRROR}/aarch64/Packages/k/ksirk-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ksirk;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksirk}"
SRC_URI[aarch64_ksirk.sha256sum] = "48fed61ea38d1bc0502d999545959558ff083ff72eb5154f17393b9eb1bccb2a"

RDEPENDS:ksirk = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libkdegames \
 libstdc++ \
 qca-qt6-ossl \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
