# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-pcre2"
PV = "0.1.10"
PR = "1.el10_3"
PACKAGES = " \
 rust-grep-pcre2+default-devel \
 rust-grep-pcre2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-pcre2-0.1.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7190d76b9980b668a144e0c40612d72f42037e6b9a86584ec959482517a9e414"

URI_x86_64_v2_rust-grep-pcre2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-pcre2+default-devel-0.1.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-pcre2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-pcre2+default-devel}"
SRC_URI[x86_64_v2_rust-grep-pcre2+default-devel.sha256sum] = "cd100d4b54556b78e6e3c026e5009dae793275ee3677a88db780ba701943bee3"

URI_x86_64_v2_rust-grep-pcre2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-pcre2-devel-0.1.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-pcre2-devel}"
SRC_URI[x86_64_v2_rust-grep-pcre2-devel.sha256sum] = "b3cbe59dd5a9406814721eecedc0cdd046a4f7a606371180bd284f75a3316d37"

URI_aarch64_rust-grep-pcre2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-pcre2+default-devel-0.1.10-1.el10_3.noarch.rpm;name=aarch64_rust-grep-pcre2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-pcre2+default-devel}"
SRC_URI[aarch64_rust-grep-pcre2+default-devel.sha256sum] = "c8548046f2ef95a1c4cae864155e2769aab0dec33c4d7e2dee73790dea618ad6"

URI_aarch64_rust-grep-pcre2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-pcre2-devel-0.1.10-1.el10_3.noarch.rpm;name=aarch64_rust-grep-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-pcre2-devel}"
SRC_URI[aarch64_rust-grep-pcre2-devel.sha256sum] = "2792559b0087e33914aef2efcc782fc2ed704f555c97bdef32b712011523a628"

RDEPENDS:rust-grep-pcre2+default-devel = " \
 cargo \
 rust-grep-pcre2-devel \
 "
RDEPENDS:rust-grep-pcre2-devel = " \
 cargo \
 rust-grep-matcher+default-devel \
 rust-log+default-devel \
 rust-pcre2+default-devel \
 "
