# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_logger0.9"
PV = "0.9.3"
PR = "5.el10_0"
PACKAGES = " \
 rust-env_logger0.9+atty-devel \
 rust-env_logger0.9+default-devel \
 rust-env_logger0.9+humantime-devel \
 rust-env_logger0.9+regex-devel \
 rust-env_logger0.9+termcolor-devel \
 rust-env_logger0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_logger0.9-0.9.3-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0014f3cdec0f9eb7bb5e2bfefbc684dbd555d7e21d8b255abbefcc25d89af3f"

URI_x86_64_v2_rust-env_logger0.9+atty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+atty-devel-0.9.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+atty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+atty-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+atty-devel.sha256sum] = "dbb280782a7cf43bf018f804bacc3dff667ebfdf66ae7d1c1c13ac972df3146d"

URI_x86_64_v2_rust-env_logger0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+default-devel-0.9.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+default-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+default-devel.sha256sum] = "e5c100e1874e06b6b9af01a144fa0b9888b34810bcc553b7223dbdd69a112c6f"

URI_x86_64_v2_rust-env_logger0.9+humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+humantime-devel-0.9.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+humantime-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+humantime-devel.sha256sum] = "b6e4a7ea0b853f8bb1b386478a73eb8cf0d41aff086072231ed9d902046b2c45"

URI_x86_64_v2_rust-env_logger0.9+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+regex-devel-0.9.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+regex-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+regex-devel.sha256sum] = "9cda9132e22b7f96b32c4c31a7631b1bf0f60de4ac649f8d1d980319747c9a19"

URI_x86_64_v2_rust-env_logger0.9+termcolor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+termcolor-devel-0.9.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+termcolor-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+termcolor-devel.sha256sum] = "4d35a71faf5a4065d7ee69b8f2fed7567dd3e9f297634dc7768635928f6a6e03"

URI_x86_64_v2_rust-env_logger0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9-devel-0.9.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9-devel.sha256sum] = "2fa856fb9ed153dd877977b034e15cda3a7ed3091f6fdd722fee39d951e5e2a4"
RPROVIDES:rust-env_logger0.9-devel:x86_64_v2 = "virtual/crate_env_logger__ge_0.6.1"

URI_aarch64_rust-env_logger0.9+atty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+atty-devel-0.9.3-5.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.9+atty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+atty-devel}"
SRC_URI[aarch64_rust-env_logger0.9+atty-devel.sha256sum] = "f925d54a9c94aecf4c5442500f158fa6233de3469c1202e1f2da8f76e8d2ff42"

URI_aarch64_rust-env_logger0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+default-devel-0.9.3-5.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+default-devel}"
SRC_URI[aarch64_rust-env_logger0.9+default-devel.sha256sum] = "0e2d8030052415143281afaaf22613a82b0adeb82cae2a1a9ef4df08975980da"

URI_aarch64_rust-env_logger0.9+humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+humantime-devel-0.9.3-5.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.9+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+humantime-devel}"
SRC_URI[aarch64_rust-env_logger0.9+humantime-devel.sha256sum] = "3f45b672057f57b2e620cef06e1dda0d409894eb6eb9cb6d82e505906732ff6c"

URI_aarch64_rust-env_logger0.9+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+regex-devel-0.9.3-5.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.9+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+regex-devel}"
SRC_URI[aarch64_rust-env_logger0.9+regex-devel.sha256sum] = "3ec24c177e2d6418612ea449fa060846c04475e7f17f1a39c16ba574f5b3d717"

URI_aarch64_rust-env_logger0.9+termcolor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+termcolor-devel-0.9.3-5.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.9+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+termcolor-devel}"
SRC_URI[aarch64_rust-env_logger0.9+termcolor-devel.sha256sum] = "6c9216695fbece4878c3a5b1184ef224f57e956c128f4169374840513de26be1"

URI_aarch64_rust-env_logger0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9-devel-0.9.3-5.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9-devel}"
SRC_URI[aarch64_rust-env_logger0.9-devel.sha256sum] = "a0643e332c177392e8da9ef28adf8516591663fd56464acaaaf442b56e9b19ec"
RPROVIDES:rust-env_logger0.9-devel:aarch64 = "virtual/crate_env_logger__ge_0.6.1"

RDEPENDS:rust-env_logger0.9+atty-devel = " \
 cargo \
 rust-atty+default-devel \
 rust-env_logger0.9-devel \
 "
RDEPENDS:rust-env_logger0.9+default-devel = " \
 cargo \
 rust-env_logger0.9+atty-devel \
 rust-env_logger0.9+humantime-devel \
 rust-env_logger0.9+regex-devel \
 rust-env_logger0.9+termcolor-devel \
 rust-env_logger0.9-devel \
 "
RDEPENDS:rust-env_logger0.9+humantime-devel = " \
 cargo \
 rust-env_logger0.9-devel \
 rust-humantime+default-devel \
 "
RDEPENDS:rust-env_logger0.9+regex-devel = " \
 cargo \
 rust-env_logger0.9-devel \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-env_logger0.9+termcolor-devel = " \
 cargo \
 rust-env_logger0.9-devel \
 rust-termcolor+default-devel \
 "
RDEPENDS:rust-env_logger0.9-devel = " \
 cargo \
 rust-log+default-devel \
 rust-log+std-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_env_logger__ge_0.6.1"

PROVIDES:append:aarch64 = " rpm/virtual/crate_env_logger__ge_0.6.1"
