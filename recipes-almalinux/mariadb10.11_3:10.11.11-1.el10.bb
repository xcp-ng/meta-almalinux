# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mariadb10.11"
PE = "3"
PV = "10.11.11"
PR = "1.el10"
PACKAGES = " \
 mariadb \
 mariadb-backup \
 mariadb-client-utils \
 mariadb-common \
 mariadb-devel \
 mariadb-embedded \
 mariadb-embedded-devel \
 mariadb-errmsg \
 mariadb-gssapi-server \
 mariadb-oqgraph-engine \
 mariadb-pam \
 mariadb-server \
 mariadb-server-galera \
 mariadb-server-utils \
 mariadb-test \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mariadb10.11-10.11.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16d21eabe74531783a2a9060d785dadf4fda65d54616e57f07272a00d3c8e7f3"

URI_x86_64_v2_mariadb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-10.11.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb}"
SRC_URI[x86_64_v2_mariadb.sha256sum] = "5ba2aaa46b0735929c15ef705ecb1f8735cb0d69e6bfc555ff18af887d7ee9ce"

URI_x86_64_v2_mariadb-backup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-backup-10.11.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-backup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-backup}"
SRC_URI[x86_64_v2_mariadb-backup.sha256sum] = "c64307eec300f65d2a8fe055f288bee4382f5816b2cc4ce264041a0587bc2a14"

URI_x86_64_v2_mariadb-client-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-client-utils-10.11.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-client-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-client-utils}"
SRC_URI[x86_64_v2_mariadb-client-utils.sha256sum] = "87540d0e1a19e1e099d7309685e4a75d943dd2d11de25cd2fb4b84dd3497cfe3"

URI_x86_64_v2_mariadb-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-common-10.11.11-1.el10.noarch.rpm;name=x86_64_v2_mariadb-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-common}"
SRC_URI[x86_64_v2_mariadb-common.sha256sum] = "69e0392d522c2b33b7da5499e7c61b1ab03b92dcea900757f672a747b4673226"

URI_x86_64_v2_mariadb-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-devel-10.11.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-devel}"
SRC_URI[x86_64_v2_mariadb-devel.sha256sum] = "5c1cf20daf8ff750059297f11e41a85edccbe54a41ee968f7b40a5193e50d7a5"

URI_x86_64_v2_mariadb-embedded = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-embedded-10.11.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-embedded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-embedded}"
SRC_URI[x86_64_v2_mariadb-embedded.sha256sum] = "524fd0b786cbd444679404cda55229d97feafc4bb98261bdcdd9aab4f7074bf0"

URI_x86_64_v2_mariadb-embedded-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-embedded-devel-10.11.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-embedded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-embedded-devel}"
SRC_URI[x86_64_v2_mariadb-embedded-devel.sha256sum] = "1c690458966d94348e8983a65a5b199c76239d26511fd30086af041672844cb2"

URI_x86_64_v2_mariadb-errmsg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-errmsg-10.11.11-1.el10.noarch.rpm;name=x86_64_v2_mariadb-errmsg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-errmsg}"
SRC_URI[x86_64_v2_mariadb-errmsg.sha256sum] = "b4b6ab8cd76b6667bb2b68ea114f91c3776f0779347dc2d904d8faf0212e48f0"

URI_x86_64_v2_mariadb-gssapi-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-gssapi-server-10.11.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-gssapi-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-gssapi-server}"
SRC_URI[x86_64_v2_mariadb-gssapi-server.sha256sum] = "a573f4da81f822fc4d25a1521a02d46e3dc0a4e293cb23750d2c08b4597af63e"

URI_x86_64_v2_mariadb-oqgraph-engine = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-oqgraph-engine-10.11.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-oqgraph-engine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-oqgraph-engine}"
SRC_URI[x86_64_v2_mariadb-oqgraph-engine.sha256sum] = "3782167076ed33be59c8b3bf3cc5997bd0e6a2c3fb32b841e494574d8848051e"

URI_x86_64_v2_mariadb-pam = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-pam-10.11.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-pam}"
SRC_URI[x86_64_v2_mariadb-pam.sha256sum] = "28b397615dc36a8efdd93b6d9cc14614984dec3c0a3a876f9db2998cee20a1c4"

URI_x86_64_v2_mariadb-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-server-10.11.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-server}"
SRC_URI[x86_64_v2_mariadb-server.sha256sum] = "7af58d35e43b128196dd9b97e289fe6089435c32bcfd38468ad2259d0274aab7"

URI_x86_64_v2_mariadb-server-galera = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-server-galera-10.11.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-server-galera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-server-galera}"
SRC_URI[x86_64_v2_mariadb-server-galera.sha256sum] = "17f27d9eb72a731ae05527d2a8637c0d1eb84800dedc335e961befafb1582080"

URI_x86_64_v2_mariadb-server-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-server-utils-10.11.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-server-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-server-utils}"
SRC_URI[x86_64_v2_mariadb-server-utils.sha256sum] = "b8331cf76ba08f7d5c5aefa8778e809fabc23a4cecee74f980f7f21ede008671"

URI_x86_64_v2_mariadb-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-test-10.11.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-test}"
SRC_URI[x86_64_v2_mariadb-test.sha256sum] = "04adc774c32c53706f75357222e6397593c7c71c55c47f101d15a03ee646ece2"

URI_aarch64_mariadb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-10.11.11-1.el10.aarch64.rpm;name=aarch64_mariadb;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb}"
SRC_URI[aarch64_mariadb.sha256sum] = "546850dac08d89b7d79f7a709307db85b3bbf818d80d9b8746229fbb6decbd91"

URI_aarch64_mariadb-backup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-backup-10.11.11-1.el10.aarch64.rpm;name=aarch64_mariadb-backup;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-backup}"
SRC_URI[aarch64_mariadb-backup.sha256sum] = "c22be44df6e814e4cf1cbbf23788c67adf1714dcc3fa89a6a2ee74eae2fdff2e"

URI_aarch64_mariadb-client-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-client-utils-10.11.11-1.el10.aarch64.rpm;name=aarch64_mariadb-client-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-client-utils}"
SRC_URI[aarch64_mariadb-client-utils.sha256sum] = "44dd1d0053300c20f991dd1d99bf8e68eb7007673f50b714e4bbdbda274453c2"

URI_aarch64_mariadb-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-common-10.11.11-1.el10.noarch.rpm;name=aarch64_mariadb-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-common}"
SRC_URI[aarch64_mariadb-common.sha256sum] = "69e0392d522c2b33b7da5499e7c61b1ab03b92dcea900757f672a747b4673226"

URI_aarch64_mariadb-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-devel-10.11.11-1.el10.aarch64.rpm;name=aarch64_mariadb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-devel}"
SRC_URI[aarch64_mariadb-devel.sha256sum] = "77cfc7e6bdb5be54eafdf58ac905e69cfd600e21eeb2839a58b79c5b9990c193"

URI_aarch64_mariadb-embedded = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-embedded-10.11.11-1.el10.aarch64.rpm;name=aarch64_mariadb-embedded;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-embedded}"
SRC_URI[aarch64_mariadb-embedded.sha256sum] = "f3cbd5ba07d1a6f7a31b7551c3f11324a8ab4af0098ab6638030ebd87cab29de"

URI_aarch64_mariadb-embedded-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-embedded-devel-10.11.11-1.el10.aarch64.rpm;name=aarch64_mariadb-embedded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-embedded-devel}"
SRC_URI[aarch64_mariadb-embedded-devel.sha256sum] = "81a14d2921b405a17e9fa968f20405673a240e241a4c54e825cd4e734e8bd732"

URI_aarch64_mariadb-errmsg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-errmsg-10.11.11-1.el10.noarch.rpm;name=aarch64_mariadb-errmsg;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-errmsg}"
SRC_URI[aarch64_mariadb-errmsg.sha256sum] = "b4b6ab8cd76b6667bb2b68ea114f91c3776f0779347dc2d904d8faf0212e48f0"

URI_aarch64_mariadb-gssapi-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-gssapi-server-10.11.11-1.el10.aarch64.rpm;name=aarch64_mariadb-gssapi-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-gssapi-server}"
SRC_URI[aarch64_mariadb-gssapi-server.sha256sum] = "5bbca5b03296240b2b201c00260fe62f334d95b0093ab8996980b65def0b44cd"

URI_aarch64_mariadb-oqgraph-engine = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-oqgraph-engine-10.11.11-1.el10.aarch64.rpm;name=aarch64_mariadb-oqgraph-engine;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-oqgraph-engine}"
SRC_URI[aarch64_mariadb-oqgraph-engine.sha256sum] = "42a283c6ec98c01b21916bcb70e870c9ea43e11e3e80fba732dc67517a1646b2"

URI_aarch64_mariadb-pam = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-pam-10.11.11-1.el10.aarch64.rpm;name=aarch64_mariadb-pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-pam}"
SRC_URI[aarch64_mariadb-pam.sha256sum] = "06c6f51818f35ed7c9ced46bade20440e56f6d3d0c7e248fa4e3669d53591833"

URI_aarch64_mariadb-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-server-10.11.11-1.el10.aarch64.rpm;name=aarch64_mariadb-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-server}"
SRC_URI[aarch64_mariadb-server.sha256sum] = "c0a484624ac9b58075f854efa3dbc64eee96652121d38c290edb3da6a49e36e2"

URI_aarch64_mariadb-server-galera = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-server-galera-10.11.11-1.el10.aarch64.rpm;name=aarch64_mariadb-server-galera;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-server-galera}"
SRC_URI[aarch64_mariadb-server-galera.sha256sum] = "661f17f4fa5d51971b1f7efbc8fe08aee62ad2067a7593ab83bb8be51588773a"

URI_aarch64_mariadb-server-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-server-utils-10.11.11-1.el10.aarch64.rpm;name=aarch64_mariadb-server-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-server-utils}"
SRC_URI[aarch64_mariadb-server-utils.sha256sum] = "b69ee660456705449717c1d7febd0e1ca8af7a34d54698b6657b7782e6bf756e"

URI_aarch64_mariadb-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-test-10.11.11-1.el10.aarch64.rpm;name=aarch64_mariadb-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-test}"
SRC_URI[aarch64_mariadb-test.sha256sum] = "57209eb1d24f5667b6c8eccdc6065fe0628f15928d984ed022a09dc1945b1883"

RDEPENDS:mariadb = " \
 bash \
 glibc \
 grep \
 libedit \
 libgcc \
 libstdc++ \
 mariadb-common \
 mariadb-connector-c \
 ncurses-libs \
 openssl-libs \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-backup = " \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb-server \
 openssl-libs \
 pcre2 \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-client-utils = " \
 mariadb \
 perl-DBI \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-Sys-Hostname \
 perl-interpreter \
 "
RDEPENDS:mariadb-common = " \
 mariadb-connector-c-config \
 "
RDEPENDS:mariadb-devel = " \
 mariadb-connector-c-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:mariadb-embedded = " \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb-common \
 mariadb-errmsg \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-embedded-devel = " \
 libaio-devel \
 mariadb-devel \
 mariadb-embedded \
 "
RDEPENDS:mariadb-errmsg = " \
 mariadb-common \
 "
RDEPENDS:mariadb-gssapi-server = " \
 glibc \
 krb5-libs \
 mariadb-server \
 "
RDEPENDS:mariadb-oqgraph-engine = " \
 Judy \
 glibc \
 libgcc \
 libstdc++ \
 mariadb-server \
 "
RDEPENDS:mariadb-pam = " \
 glibc \
 mariadb-server \
 pam-libs \
 "
RDEPENDS:mariadb-server = " \
 bash \
 bzip2-libs \
 glibc \
 iproute \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 lz4-libs \
 lzo \
 mariadb \
 mariadb-common \
 mariadb-connector-c-config \
 mariadb-errmsg \
 mysql-selinux \
 openssl-libs \
 pcre2 \
 shadow-utils \
 snappy \
 systemd \
 systemd-libs \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-server-galera = " \
 bash \
 galera \
 libselinux-utils \
 lsof \
 mariadb-common \
 mariadb-server \
 policycoreutils \
 policycoreutils-python-utils \
 rsync \
 "
RDEPENDS:mariadb-server-utils = " \
 glibc \
 mariadb-server \
 perl-DBD-MariaDB \
 perl-DBI \
 perl-Data-Dumper \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-POSIX \
 perl-Sys-Hostname \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:mariadb-test = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb \
 mariadb-common \
 mariadb-server \
 openssl-libs \
 pam-libs \
 patch \
 pcre2 \
 perl-Carp \
 perl-Data-Dumper \
 perl-English \
 perl-Env \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-Memoize \
 perl-POSIX \
 perl-PathTools \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Test-Simple \
 perl-Text-Tabs+Wrap \
 perl-Time \
 perl-Time-HiRes \
 perl-base \
 perl-constant \
 perl-if \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 perl-threads \
 perl-threads-shared \
 zlib-ng-compat \
 "
