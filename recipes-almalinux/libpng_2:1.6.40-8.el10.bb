# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpng"
PE = "2"
PV = "1.6.40"
PR = "8.el10"
PACKAGES = " \
 libpng \
 libpng-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libpng-1.6.40-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d2fa66106e40785268ffeff5e0bb09bf955980f852a5d9c09ddc6e3e04a7476"

URI_x86_64_v2_libpng = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpng-1.6.40-8.el10.x86_64_v2.rpm;name=x86_64_v2_libpng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpng}"
SRC_URI[x86_64_v2_libpng.sha256sum] = "88bcd03a42c41eea8536b133cc4772e4f658e05e1344534e4b0457be1d2f7d65"

URI_x86_64_v2_libpng-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpng-devel-1.6.40-8.el10.x86_64_v2.rpm;name=x86_64_v2_libpng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpng-devel}"
SRC_URI[x86_64_v2_libpng-devel.sha256sum] = "15557092543e32a4ea30aa97b3d10af642482eb66efe87d02be1055fdde7a215"

URI_aarch64_libpng = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpng-1.6.40-8.el10.aarch64.rpm;name=aarch64_libpng;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpng}"
SRC_URI[aarch64_libpng.sha256sum] = "02a4ce9d8d2146c165430919e5e99a2448ee9751a726ae275c448ac772fbf148"

URI_aarch64_libpng-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpng-devel-1.6.40-8.el10.aarch64.rpm;name=aarch64_libpng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpng-devel}"
SRC_URI[aarch64_libpng-devel.sha256sum] = "19b3b0c74a71207b82e01f8248356d09ac35d2f36c4c877db4a6813113a23033"

RDEPENDS:libpng = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:libpng-devel = " \
 bash \
 glibc \
 libpng \
 pkgconf-pkg-config \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
