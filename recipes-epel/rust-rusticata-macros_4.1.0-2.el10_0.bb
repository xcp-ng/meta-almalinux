# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rusticata-macros"
PV = "4.1.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-rusticata-macros+default-devel \
 rust-rusticata-macros-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rusticata-macros-4.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "90cf9bff6038b286834d5e64205d1475426d5882849c5886e2ba1ea2a26f21c0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusticata-macros+default-devel-4.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusticata-macros+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rusticata-macros+default-devel.sha256sum] = "44184a6c02115cb65d1dc1bef32f2789a32d9f5cc8ad82e84e33091eb3fe12e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusticata-macros-devel-4.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusticata-macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rusticata-macros-devel.sha256sum] = "b2d4786a150773c18cb7a3503b92aa516b6ab4f03145d59a8e9217c3d990b04d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rusticata-macros+default-devel-4.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-rusticata-macros+default-devel;unpack=0"
SRC_URI[aarch64_rust-rusticata-macros+default-devel.sha256sum] = "1dee55bbf0986b15bf4ae1cd550777c554681429f16138b4fca94e690400964f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rusticata-macros-devel-4.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-rusticata-macros-devel;unpack=0"
SRC_URI[aarch64_rust-rusticata-macros-devel.sha256sum] = "d5830161efe1b0b2aa002d3778f40278b18be74a5b77ea518cfdd9b6bd401798"

RDEPENDS:rust-rusticata-macros+default-devel = " \
 cargo \
 rust-rusticata-macros-devel \
 "
RDEPENDS:rust-rusticata-macros-devel = " \
 cargo \
 rust-nom+std-devel \
 rust-nom-devel \
 "
