# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_logger0.10"
PV = "0.10.2"
PR = "3.el10_0"
PACKAGES = " \
 rust-env_logger0.10+auto-color-devel \
 rust-env_logger0.10+color-devel \
 rust-env_logger0.10+default-devel \
 rust-env_logger0.10+humantime-devel \
 rust-env_logger0.10+regex-devel \
 rust-env_logger0.10-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_logger0.10-0.10.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23a66f5074a3fe2aaf54daec48934edae2e6d5b9e074c674f82e591c5b1ab3ea"

URI_x86_64_v2_rust-env_logger0.10+auto-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.10+auto-color-devel-0.10.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.10+auto-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.10+auto-color-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.10+auto-color-devel.sha256sum] = "625b2c9c0468d1d696a15f1e2d28080130114d4c25ff6558a351bb62b7ee1a21"

URI_x86_64_v2_rust-env_logger0.10+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.10+color-devel-0.10.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.10+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.10+color-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.10+color-devel.sha256sum] = "785363d89dc5cf402ee83d6e3f0c4febd515b53ecfb7da68de98750c3e42d8e0"

URI_x86_64_v2_rust-env_logger0.10+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.10+default-devel-0.10.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.10+default-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.10+default-devel.sha256sum] = "15b4b2ec2e397388a6fef81133df7c839b478e12c4f1c39c5d7875fdf0ad43f1"

URI_x86_64_v2_rust-env_logger0.10+humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.10+humantime-devel-0.10.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.10+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.10+humantime-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.10+humantime-devel.sha256sum] = "f22f9e33c24ffa7b1d185a112682d260cf9a2cd3f13bd6ffe389a943ead35d9e"

URI_x86_64_v2_rust-env_logger0.10+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.10+regex-devel-0.10.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.10+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.10+regex-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.10+regex-devel.sha256sum] = "20de2458be3f01ac57284078b7120fb88633ca3be24621a28cb40392bc84348d"

URI_x86_64_v2_rust-env_logger0.10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.10-devel-0.10.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.10-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.10-devel.sha256sum] = "c4fe360649414803c2d3a04be5e7c758aa397bb8d2e80fe17a093ee75d697f66"
RPROVIDES:rust-env_logger0.10-devel:x86_64_v2 = "virtual/crate_env_logger__ge_0.6.1"

URI_aarch64_rust-env_logger0.10+auto-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.10+auto-color-devel-0.10.2-3.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.10+auto-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.10+auto-color-devel}"
SRC_URI[aarch64_rust-env_logger0.10+auto-color-devel.sha256sum] = "982d95e84d2add93d7911d23e8eda34049365198e3eecef4f37789bf9d9382ed"

URI_aarch64_rust-env_logger0.10+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.10+color-devel-0.10.2-3.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.10+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.10+color-devel}"
SRC_URI[aarch64_rust-env_logger0.10+color-devel.sha256sum] = "7c67d1ef3a6ed8a95329efccec90df2866117b42839f4efcd1793740ee640174"

URI_aarch64_rust-env_logger0.10+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.10+default-devel-0.10.2-3.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.10+default-devel}"
SRC_URI[aarch64_rust-env_logger0.10+default-devel.sha256sum] = "1ad82765ed635d8c13dcd1e110b101c81ea1fdaf8a0de7ec32d66a05e3866c9f"

URI_aarch64_rust-env_logger0.10+humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.10+humantime-devel-0.10.2-3.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.10+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.10+humantime-devel}"
SRC_URI[aarch64_rust-env_logger0.10+humantime-devel.sha256sum] = "1de5afdf0af9ccc6beb2cb9a58206acf47b2e39c3dc8294918f6e1594fa79dde"

URI_aarch64_rust-env_logger0.10+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.10+regex-devel-0.10.2-3.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.10+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.10+regex-devel}"
SRC_URI[aarch64_rust-env_logger0.10+regex-devel.sha256sum] = "bd971e68a54eed8dfcd3eecaec00dcf39095c50fd8d798619359e4f38a091164"

URI_aarch64_rust-env_logger0.10-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.10-devel-0.10.2-3.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.10-devel}"
SRC_URI[aarch64_rust-env_logger0.10-devel.sha256sum] = "df410f5d81ac39c367affc978bef9befbeebd5e9f46f2f056dbc1fac6b57197d"
RPROVIDES:rust-env_logger0.10-devel:aarch64 = "virtual/crate_env_logger__ge_0.6.1"

RDEPENDS:rust-env_logger0.10+auto-color-devel = " \
 cargo \
 rust-env_logger0.10+color-devel \
 rust-env_logger0.10-devel \
 rust-is-terminal+default-devel \
 "
RDEPENDS:rust-env_logger0.10+color-devel = " \
 cargo \
 rust-env_logger0.10-devel \
 rust-termcolor+default-devel \
 "
RDEPENDS:rust-env_logger0.10+default-devel = " \
 cargo \
 rust-env_logger0.10+auto-color-devel \
 rust-env_logger0.10+humantime-devel \
 rust-env_logger0.10+regex-devel \
 rust-env_logger0.10-devel \
 "
RDEPENDS:rust-env_logger0.10+humantime-devel = " \
 cargo \
 rust-env_logger0.10-devel \
 rust-humantime+default-devel \
 "
RDEPENDS:rust-env_logger0.10+regex-devel = " \
 cargo \
 rust-env_logger0.10-devel \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-env_logger0.10-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-log+std-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_env_logger__ge_0.6.1"

PROVIDES:append:aarch64 = " rpm/virtual/crate_env_logger__ge_0.6.1"
