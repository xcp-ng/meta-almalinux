# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-native-tls"
PV = "0.3.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-tokio-native-tls+default-devel \
 rust-tokio-native-tls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-native-tls-0.3.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e82a506de45098022d67eabdaf456e16f0f662b176c6d1027edb343a6fe50c0f"

URI_x86_64_v2_rust-tokio-native-tls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-native-tls+default-devel-0.3.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-native-tls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-native-tls+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-native-tls+default-devel.sha256sum] = "b2867ac12bfd0b11d0b7ab70ac4b61bd090d112b041577485cf23c8441d052d3"

URI_x86_64_v2_rust-tokio-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-native-tls-devel-0.3.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-native-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-native-tls-devel.sha256sum] = "61c277c7ca13fb683926202db67bd4f900779c0ad64bc08fb7214797b8c50db7"

URI_aarch64_rust-tokio-native-tls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-native-tls+default-devel-0.3.1-4.el10_0.noarch.rpm;name=aarch64_rust-tokio-native-tls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-native-tls+default-devel}"
SRC_URI[aarch64_rust-tokio-native-tls+default-devel.sha256sum] = "14fec0c68442ef75fca5d28c8609d3899c8172403107f15be039c6e322e75f34"

URI_aarch64_rust-tokio-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-native-tls-devel-0.3.1-4.el10_0.noarch.rpm;name=aarch64_rust-tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-native-tls-devel}"
SRC_URI[aarch64_rust-tokio-native-tls-devel.sha256sum] = "e1ea7342a24a55212cf7e47a0e6f66b5e7a16bcf57ae392aae4162fb876a1f72"

RDEPENDS:rust-tokio-native-tls+default-devel = " \
 cargo \
 rust-tokio-native-tls-devel \
 "
RDEPENDS:rust-tokio-native-tls-devel = " \
 bash \
 cargo \
 rust-native-tls+default-devel \
 rust-tokio+default-devel \
 "
