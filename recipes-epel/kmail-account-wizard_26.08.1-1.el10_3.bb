# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmail-account-wizard"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kmail-account-wizard \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kmail-account-wizard-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f3b668a27e8a8f8400c9183763934782bbd7334fce48a8f002accd5e5544fc38"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmail-account-wizard-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmail-account-wizard;unpack=0"
SRC_URI[x86_64_v2_kmail-account-wizard.sha256sum] = "785e55d9c30f1a9212bea9cc9d3cb5c40cc261373e461576a02e05196635f70f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmail-account-wizard-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kmail-account-wizard;unpack=0"
SRC_URI[aarch64_kmail-account-wizard.sha256sum] = "f6834ff4308d5e9cc7cb84e3e8dd9342af61d88e4fd387dabc980f2efc40ae85"

RDEPENDS:kmail-account-wizard = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kmime \
 kidentitymanagement \
 kmailtransport \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
