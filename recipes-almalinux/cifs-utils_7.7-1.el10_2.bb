# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cifs-utils"
PV = "7.7"
PR = "1.el10_2"
PACKAGES = " \
 cifs-utils \
 cifs-utils-devel \
 pam_cifscreds \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cifs-utils-7.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "86c4cc4e55071f0109c76f8a74c93c9f150348c0d21db95279029e081bfe9245"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cifs-utils-7.7-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_cifs-utils;unpack=0"
SRC_URI[x86_64_v2_cifs-utils.sha256sum] = "ae05d9e9389437383e9954b8a3d47172a3ad21dd1c14988ded74615a3c8b4897"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cifs-utils-devel-7.7-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_cifs-utils-devel;unpack=0"
SRC_URI[x86_64_v2_cifs-utils-devel.sha256sum] = "aa1bb752660b59a6378126e7caefc49711f0647d3a665183ac14691cae59b809"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pam_cifscreds-7.7-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_pam_cifscreds;unpack=0"
SRC_URI[x86_64_v2_pam_cifscreds.sha256sum] = "95ca428152709faf2e0ae38ebe035193d4cae08355106861c5dbd6baff3aa59c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cifs-utils-7.7-1.el10_2.aarch64.rpm;name=aarch64_cifs-utils;unpack=0"
SRC_URI[aarch64_cifs-utils.sha256sum] = "6139e97379134a902657897f7d3453ea9c466269b51219e976d46933d8245cab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cifs-utils-devel-7.7-1.el10_2.aarch64.rpm;name=aarch64_cifs-utils-devel;unpack=0"
SRC_URI[aarch64_cifs-utils-devel.sha256sum] = "5601a922cf9673c04d66d543ea095642176bf05fcd72027cbab9b89bf2d743a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pam_cifscreds-7.7-1.el10_2.aarch64.rpm;name=aarch64_pam_cifscreds;unpack=0"
SRC_URI[aarch64_pam_cifscreds.sha256sum] = "02020094a6f2e756e80aba8f942fc3684c58c2e82a8fc4375bc1a0eba46d9370"

RDEPENDS:cifs-utils = " \
 alternatives \
 bash \
 glibc \
 keyutils \
 keyutils-libs \
 krb5-libs \
 libcap-ng \
 libtalloc \
 libwbclient \
 "
RDEPENDS:cifs-utils-devel = " \
 "
RDEPENDS:pam_cifscreds = " \
 glibc \
 keyutils-libs \
 libtalloc \
 pam-libs \
 "
