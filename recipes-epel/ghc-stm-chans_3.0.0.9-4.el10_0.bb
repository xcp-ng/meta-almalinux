# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-stm-chans"
PV = "3.0.0.9"
PR = "4.el10_0"
PACKAGES = " \
 ghc-stm-chans \
 ghc-stm-chans-devel \
 ghc-stm-chans-doc \
 ghc-stm-chans-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-stm-chans-3.0.0.9-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "766e2fec47c409c2dea0c29338e899e2547d59a3714c696c0541f8a33b02230a"

URI_x86_64_v2_ghc-stm-chans = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-stm-chans-3.0.0.9-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-stm-chans;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-stm-chans}"
SRC_URI[x86_64_v2_ghc-stm-chans.sha256sum] = "dc4c6c6d7c679119e26155df0bd38d442cc4d9f18ef3b273302597d467c3b23b"

URI_x86_64_v2_ghc-stm-chans-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-stm-chans-devel-3.0.0.9-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-stm-chans-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-stm-chans-devel}"
SRC_URI[x86_64_v2_ghc-stm-chans-devel.sha256sum] = "4b333c15b7fa8c65499a194aa2e4a007c33068b3a2cbd3585c971b02ed5c4dc8"

URI_x86_64_v2_ghc-stm-chans-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-stm-chans-doc-3.0.0.9-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-stm-chans-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-stm-chans-doc}"
SRC_URI[x86_64_v2_ghc-stm-chans-doc.sha256sum] = "70a0d9268ba3c0d7fb002cfb72f3fe8cf68fe0cc4df5208e9aba0587c7bc278b"

URI_x86_64_v2_ghc-stm-chans-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-stm-chans-prof-3.0.0.9-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-stm-chans-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-stm-chans-prof}"
SRC_URI[x86_64_v2_ghc-stm-chans-prof.sha256sum] = "7209ea901738fd70a554dfb2c11bbea609e8dc80536ab8a20d717cb5d6c1fb8f"

URI_aarch64_ghc-stm-chans = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-stm-chans-3.0.0.9-4.el10_0.aarch64.rpm;name=aarch64_ghc-stm-chans;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-stm-chans}"
SRC_URI[aarch64_ghc-stm-chans.sha256sum] = "4307cea0aa5967b7209c2f4109df4a99bac0d37a601225d78f75946340df5344"

URI_aarch64_ghc-stm-chans-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-stm-chans-devel-3.0.0.9-4.el10_0.aarch64.rpm;name=aarch64_ghc-stm-chans-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-stm-chans-devel}"
SRC_URI[aarch64_ghc-stm-chans-devel.sha256sum] = "78b9111b184af11542e1fffae9d3f9de6c3a5e4a700f4cc799eac8d6bc01942f"

URI_aarch64_ghc-stm-chans-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-stm-chans-doc-3.0.0.9-4.el10_0.noarch.rpm;name=aarch64_ghc-stm-chans-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-stm-chans-doc}"
SRC_URI[aarch64_ghc-stm-chans-doc.sha256sum] = "d12086615e7edf7513a812f57df719a82151474e727500d57dc659cfc40ddeb5"

URI_aarch64_ghc-stm-chans-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-stm-chans-prof-3.0.0.9-4.el10_0.aarch64.rpm;name=aarch64_ghc-stm-chans-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-stm-chans-prof}"
SRC_URI[aarch64_ghc-stm-chans-prof.sha256sum] = "5b52651f978c1bf4e1fd80ee92a7acd068eded4b822c01b2e8f829336cccf5a6"

RDEPENDS:ghc-stm-chans = " \
 ghc-array \
 ghc-base \
 ghc-ghc-bignum \
 ghc-stm \
 glibc \
 gmp \
 "
RDEPENDS:ghc-stm-chans-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-stm-chans \
 ghc-stm-devel \
 "
RDEPENDS:ghc-stm-chans-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-stm-chans-prof = " \
 ghc-base-prof \
 ghc-stm-chans-devel \
 ghc-stm-prof \
 "
