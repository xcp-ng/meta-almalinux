# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "desktop-backgrounds"
PV = "42.0.0"
PR = "2.el10_0"
PACKAGES = " \
 desktop-backgrounds-basic \
 desktop-backgrounds-budgie \
 desktop-backgrounds-compat \
 desktop-backgrounds-gnome \
 desktop-backgrounds-waves \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/desktop-backgrounds-42.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1d42b853da7a484ce19badbdaf5f9b1e22d8e7eb0a60e2afbf748bd63f3403b"

URI_x86_64_v2_desktop-backgrounds-basic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-basic-42.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-basic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-basic}"
SRC_URI[x86_64_v2_desktop-backgrounds-basic.sha256sum] = "8ba046aad5045fcbe6da0a6f3190e13a919d0160e699d6ad2f9096e532210a66"

URI_x86_64_v2_desktop-backgrounds-budgie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-budgie-42.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-budgie}"
SRC_URI[x86_64_v2_desktop-backgrounds-budgie.sha256sum] = "4c7a66082e05e2379b3023a6c0f46a295907998aa4d8ce5d20d2b5ea23642e7b"

URI_x86_64_v2_desktop-backgrounds-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-compat-42.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-compat}"
SRC_URI[x86_64_v2_desktop-backgrounds-compat.sha256sum] = "bac2c93b8ac8ed55d703fbc616689833dc3a3b6f8e835a8e5a7595542d7e0d10"

URI_x86_64_v2_desktop-backgrounds-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-gnome-42.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-gnome}"
SRC_URI[x86_64_v2_desktop-backgrounds-gnome.sha256sum] = "0acba2cf7e82397cfc82896eccb6a347a8982ac2a4f66dc4e57f54e529d1d2c2"

URI_x86_64_v2_desktop-backgrounds-waves = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-waves-42.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-waves;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-waves}"
SRC_URI[x86_64_v2_desktop-backgrounds-waves.sha256sum] = "ed44230754838b68cfebb04309a2c585ee21dfdeccc0b8d7998406118e80cebc"

URI_aarch64_desktop-backgrounds-basic = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-basic-42.0.0-2.el10_0.noarch.rpm;name=aarch64_desktop-backgrounds-basic;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-basic}"
SRC_URI[aarch64_desktop-backgrounds-basic.sha256sum] = "bd4f836e8e18aa9132c53bbc01105aba1f12b2825a3a28ff2556f652e4be4051"

URI_aarch64_desktop-backgrounds-budgie = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-budgie-42.0.0-2.el10_0.noarch.rpm;name=aarch64_desktop-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-budgie}"
SRC_URI[aarch64_desktop-backgrounds-budgie.sha256sum] = "f2d5a235ec44068b6bce7b22dd2fb24fb67b7591806a976b40596c24816dd112"

URI_aarch64_desktop-backgrounds-compat = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-compat-42.0.0-2.el10_0.noarch.rpm;name=aarch64_desktop-backgrounds-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-compat}"
SRC_URI[aarch64_desktop-backgrounds-compat.sha256sum] = "3438a2bb08228e60b18165e5066549ffcc0421a769ae9b2e7ede9f407682e79b"

URI_aarch64_desktop-backgrounds-gnome = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-gnome-42.0.0-2.el10_0.noarch.rpm;name=aarch64_desktop-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-gnome}"
SRC_URI[aarch64_desktop-backgrounds-gnome.sha256sum] = "62a822256e2ab417ee54a28f12d1159c9bb45cbb92fe12c2a4ca507a08ec011c"

URI_aarch64_desktop-backgrounds-waves = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-waves-42.0.0-2.el10_0.noarch.rpm;name=aarch64_desktop-backgrounds-waves;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-waves}"
SRC_URI[aarch64_desktop-backgrounds-waves.sha256sum] = "f970525739b007475c46c73b57b0973d23c5cdd346865170ae4115df55540751"

RDEPENDS:desktop-backgrounds-basic = " \
 "
RDEPENDS:desktop-backgrounds-budgie = " \
 f42-backgrounds-budgie \
 gsettings-desktop-schemas \
 "
RDEPENDS:desktop-backgrounds-compat = " \
 f42-backgrounds-base \
 "
RDEPENDS:desktop-backgrounds-gnome = " \
 f42-backgrounds-gnome \
 gsettings-desktop-schemas \
 "
RDEPENDS:desktop-backgrounds-waves = " \
 "
