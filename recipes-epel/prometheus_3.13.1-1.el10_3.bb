# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "prometheus"
PV = "3.13.1"
PR = "1.el10_3"
PACKAGES = " \
 prometheus \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/prometheus-3.13.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f55a34860af7c3a3c785c7c6d662b5d4a827492a6107075c13ccc67a0b3ee960"

URI_x86_64_v2_prometheus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/prometheus-3.13.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_prometheus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_prometheus}"
SRC_URI[x86_64_v2_prometheus.sha256sum] = "633bc3a9e9aa088ef10ee69b2cf17b03ef40cc869fd7eaa8c27410f9d0b03601"

URI_aarch64_prometheus = "${EPEL_MIRROR}/aarch64/Packages/p/prometheus-3.13.1-1.el10_3.aarch64.rpm;name=aarch64_prometheus;unpack=0"
SRC_URI:append = " ${URI_aarch64_prometheus}"
SRC_URI[aarch64_prometheus.sha256sum] = "86ac7f78b09f0318c3847ed6211882f461dd0cf79cc595633e41110f20e7e9d2"

RDEPENDS:prometheus = " \
 bash \
 glibc \
 shadow-utils \
 "
