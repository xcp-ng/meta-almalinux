# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mimalloc"
PV = "0.1.52"
PR = "1.el10_3"
PACKAGES = " \
 rust-mimalloc+debug-devel \
 rust-mimalloc+debug_in_debug-devel \
 rust-mimalloc+default-devel \
 rust-mimalloc+extended-devel \
 rust-mimalloc+local_dynamic_tls-devel \
 rust-mimalloc+no_thp-devel \
 rust-mimalloc+override-devel \
 rust-mimalloc+secure-devel \
 rust-mimalloc+v2-devel \
 rust-mimalloc+win_direct_tls-devel \
 rust-mimalloc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mimalloc-0.1.52-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2a6c9ce14cd562f9282cc5845ed7d574f8e5bc54ef534992e41acb37171706b"

URI_x86_64_v2_rust-mimalloc+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+debug-devel-0.1.52-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+debug-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+debug-devel.sha256sum] = "a3001121f3c3951c72dec2699cf28945027f632e42ce6b7faebf9efd7a07a3fc"

URI_x86_64_v2_rust-mimalloc+debug_in_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+debug_in_debug-devel-0.1.52-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+debug_in_debug-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+debug_in_debug-devel.sha256sum] = "69179e9b0e0f477059f581943b8fdba425e0b478308e8e3b89f8c1608bd931f5"

URI_x86_64_v2_rust-mimalloc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+default-devel-0.1.52-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+default-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+default-devel.sha256sum] = "338a7f72466c124f20081b42b4992e1d6b7667b98e82241871e19dbb71cfafb6"

URI_x86_64_v2_rust-mimalloc+extended-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+extended-devel-0.1.52-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+extended-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+extended-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+extended-devel.sha256sum] = "ff5e49202b88e78b184f4eb0ef879f32309fdd859ef8d014194949d51653aa7b"

URI_x86_64_v2_rust-mimalloc+local_dynamic_tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+local_dynamic_tls-devel-0.1.52-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+local_dynamic_tls-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+local_dynamic_tls-devel.sha256sum] = "fe5f5c7d88c1ce6a5615736b5fcb5ff2f5015172465e9cdb6194c783f1303b31"

URI_x86_64_v2_rust-mimalloc+no_thp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+no_thp-devel-0.1.52-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+no_thp-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+no_thp-devel.sha256sum] = "015f250e64b592b43984354f90d4a854a3ddefdd731d17039c9db9418c529a55"

URI_x86_64_v2_rust-mimalloc+override-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+override-devel-0.1.52-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+override-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+override-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+override-devel.sha256sum] = "1c6a8fefbf37ba5f672370ac82cc4cc548b12259604252ef69a8034027c3af5c"

URI_x86_64_v2_rust-mimalloc+secure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+secure-devel-0.1.52-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+secure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+secure-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+secure-devel.sha256sum] = "fd99b746a769a5a522abe997fa08c4cadd941445b9b283f00198a341b66c2450"

URI_x86_64_v2_rust-mimalloc+v2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+v2-devel-0.1.52-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+v2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+v2-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+v2-devel.sha256sum] = "b1e8f974f9b271729abcd9b54c7c310be204891b59c91aa17f49458075e02d0b"

URI_x86_64_v2_rust-mimalloc+win_direct_tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+win_direct_tls-devel-0.1.52-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+win_direct_tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+win_direct_tls-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+win_direct_tls-devel.sha256sum] = "71192c9301c9dfe39e3a1196085e10d91f71c6604930dd864422c718c5e8cb99"

URI_x86_64_v2_rust-mimalloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc-devel-0.1.52-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc-devel}"
SRC_URI[x86_64_v2_rust-mimalloc-devel.sha256sum] = "a5f2ded8c846695afadea8be52ec9afad80210fa2781ddb98d2ca3dd5180b979"

URI_aarch64_rust-mimalloc+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+debug-devel-0.1.52-1.el10_3.noarch.rpm;name=aarch64_rust-mimalloc+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+debug-devel}"
SRC_URI[aarch64_rust-mimalloc+debug-devel.sha256sum] = "e3d2faf196fef218f2d54f6b1816f62d5a496f708af8aa7a88c69c4c1f08d0e5"

URI_aarch64_rust-mimalloc+debug_in_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+debug_in_debug-devel-0.1.52-1.el10_3.noarch.rpm;name=aarch64_rust-mimalloc+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+debug_in_debug-devel}"
SRC_URI[aarch64_rust-mimalloc+debug_in_debug-devel.sha256sum] = "fe90d32a8fcb53c018e7da87b2937cd18d19f00a393768aeb243e4ac6f90a463"

URI_aarch64_rust-mimalloc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+default-devel-0.1.52-1.el10_3.noarch.rpm;name=aarch64_rust-mimalloc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+default-devel}"
SRC_URI[aarch64_rust-mimalloc+default-devel.sha256sum] = "90c9ad5eb4f75ee9dee212e6060ee795955d48aed40e1403a04b8db898aa6574"

URI_aarch64_rust-mimalloc+extended-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+extended-devel-0.1.52-1.el10_3.noarch.rpm;name=aarch64_rust-mimalloc+extended-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+extended-devel}"
SRC_URI[aarch64_rust-mimalloc+extended-devel.sha256sum] = "ca27ed5dd3db78b275b4bc3fe79d95f3e1ed5ae875789ecc69074946422ace57"

URI_aarch64_rust-mimalloc+local_dynamic_tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+local_dynamic_tls-devel-0.1.52-1.el10_3.noarch.rpm;name=aarch64_rust-mimalloc+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+local_dynamic_tls-devel}"
SRC_URI[aarch64_rust-mimalloc+local_dynamic_tls-devel.sha256sum] = "528efa33291a502a97490b3e0fe3410fb901c4eaf13c093b8bc8e8229f5345fa"

URI_aarch64_rust-mimalloc+no_thp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+no_thp-devel-0.1.52-1.el10_3.noarch.rpm;name=aarch64_rust-mimalloc+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+no_thp-devel}"
SRC_URI[aarch64_rust-mimalloc+no_thp-devel.sha256sum] = "079b9079aaeb1762efe5107482d50bea51ea44baaa31a71cf4343ac8ce3589ea"

URI_aarch64_rust-mimalloc+override-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+override-devel-0.1.52-1.el10_3.noarch.rpm;name=aarch64_rust-mimalloc+override-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+override-devel}"
SRC_URI[aarch64_rust-mimalloc+override-devel.sha256sum] = "d9e3b155ad2accaa5cc33415a89c2728e1ae82da35cae8ad29e29527502ff7dc"

URI_aarch64_rust-mimalloc+secure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+secure-devel-0.1.52-1.el10_3.noarch.rpm;name=aarch64_rust-mimalloc+secure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+secure-devel}"
SRC_URI[aarch64_rust-mimalloc+secure-devel.sha256sum] = "1b6eb1cded88a6a424d45d3402c332124010abdbc74f03fea3564a985bc576e8"

URI_aarch64_rust-mimalloc+v2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+v2-devel-0.1.52-1.el10_3.noarch.rpm;name=aarch64_rust-mimalloc+v2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+v2-devel}"
SRC_URI[aarch64_rust-mimalloc+v2-devel.sha256sum] = "17a5ba3fe2e40a62f8a5fe112cae398c2cb775b2e800547eff531220d3f7b47c"

URI_aarch64_rust-mimalloc+win_direct_tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+win_direct_tls-devel-0.1.52-1.el10_3.noarch.rpm;name=aarch64_rust-mimalloc+win_direct_tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+win_direct_tls-devel}"
SRC_URI[aarch64_rust-mimalloc+win_direct_tls-devel.sha256sum] = "8b22c31814e9f07e9aea605f221c602ddfaad424ad7d8396b32dc62c2535fb7e"

URI_aarch64_rust-mimalloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc-devel-0.1.52-1.el10_3.noarch.rpm;name=aarch64_rust-mimalloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc-devel}"
SRC_URI[aarch64_rust-mimalloc-devel.sha256sum] = "097fa240f501f9d644e904176b758c49483a4a022a79b8c5942abecf7c1e3a89"

RDEPENDS:rust-mimalloc+debug-devel = " \
 cargo \
 rust-libmimalloc-sys+debug-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+debug_in_debug-devel = " \
 cargo \
 rust-libmimalloc-sys+debug_in_debug-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+default-devel = " \
 cargo \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+extended-devel = " \
 cargo \
 rust-libmimalloc-sys+extended-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+local_dynamic_tls-devel = " \
 cargo \
 rust-libmimalloc-sys+local_dynamic_tls-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+no_thp-devel = " \
 cargo \
 rust-libmimalloc-sys+no_thp-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+override-devel = " \
 cargo \
 rust-libmimalloc-sys+override-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+secure-devel = " \
 cargo \
 rust-libmimalloc-sys+secure-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+v2-devel = " \
 cargo \
 rust-libmimalloc-sys+v2-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+win_direct_tls-devel = " \
 cargo \
 rust-libmimalloc-sys+win_direct_tls-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
