# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-lite"
PV = "2.6.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-futures-lite+alloc-devel \
 rust-futures-lite+default-devel \
 rust-futures-lite+fastrand-devel \
 rust-futures-lite+futures-io-devel \
 rust-futures-lite+memchr-devel \
 rust-futures-lite+parking-devel \
 rust-futures-lite+race-devel \
 rust-futures-lite+std-devel \
 rust-futures-lite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-lite-2.6.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "520ed060b01f60542ab00cacae7690a0febf0554baac3cc75a7b7f3ab31d718d"

URI_x86_64_v2_rust-futures-lite+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+alloc-devel-2.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+alloc-devel.sha256sum] = "189f6506bd42c817c7e26a8dff0e0d6cda390d0766aa1a399471e4d28cb7cf05"

URI_x86_64_v2_rust-futures-lite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+default-devel-2.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+default-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+default-devel.sha256sum] = "539ea26502dcdd305194aa4aabd064cad5d03b4c36c52c5d5073a2b2ed6a0c09"

URI_x86_64_v2_rust-futures-lite+fastrand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+fastrand-devel-2.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+fastrand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+fastrand-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+fastrand-devel.sha256sum] = "8dc296a2281e1cab12993e5067c06c7aba61cac4db59ed0329c0cdb83db12f48"

URI_x86_64_v2_rust-futures-lite+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+futures-io-devel-2.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+futures-io-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+futures-io-devel.sha256sum] = "7ad8c0e061b6d7f4c36273ba7860c69c6547de3c1c779af9a48b72690cece77e"

URI_x86_64_v2_rust-futures-lite+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+memchr-devel-2.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+memchr-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+memchr-devel.sha256sum] = "519656c010f115f1a6d155a8f5dc06975364e3aedb29189c8fe1a98647d79ad7"

URI_x86_64_v2_rust-futures-lite+parking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+parking-devel-2.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+parking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+parking-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+parking-devel.sha256sum] = "5b5f5252a19408d38736899a5fa8801c59d4f1aabfb8f8b05eabbf35e3be8824"

URI_x86_64_v2_rust-futures-lite+race-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+race-devel-2.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+race-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+race-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+race-devel.sha256sum] = "66d62708ddc6c92fa1329686287c0490cb586443aeaed303f286b6ca31148f18"

URI_x86_64_v2_rust-futures-lite+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite+std-devel-2.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite+std-devel}"
SRC_URI[x86_64_v2_rust-futures-lite+std-devel.sha256sum] = "bbafee17674a7c6d254c39ae6b870cfb273250ce17e372460ddc9b4bef993650"

URI_x86_64_v2_rust-futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-lite-devel-2.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-lite-devel}"
SRC_URI[x86_64_v2_rust-futures-lite-devel.sha256sum] = "5925f5883453cc6a74b0d2db9aa618e029577edfbd46f4f8de796ed878501ece"

URI_aarch64_rust-futures-lite+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+alloc-devel-2.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-futures-lite+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+alloc-devel}"
SRC_URI[aarch64_rust-futures-lite+alloc-devel.sha256sum] = "4c01e62311aaa90a7735394c865ec845394655ea3d2f7ae405f08584475bebf5"

URI_aarch64_rust-futures-lite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+default-devel-2.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-futures-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+default-devel}"
SRC_URI[aarch64_rust-futures-lite+default-devel.sha256sum] = "4797d2dd0329a50ef83747b4a097bfca35c99b64665e4842fc49200990b72f01"

URI_aarch64_rust-futures-lite+fastrand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+fastrand-devel-2.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-futures-lite+fastrand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+fastrand-devel}"
SRC_URI[aarch64_rust-futures-lite+fastrand-devel.sha256sum] = "37244440a1c49c5654a76c13caffae7604f730bc2392acf2058f483fb0a2fccd"

URI_aarch64_rust-futures-lite+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+futures-io-devel-2.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-futures-lite+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+futures-io-devel}"
SRC_URI[aarch64_rust-futures-lite+futures-io-devel.sha256sum] = "e1d2e159b1cc12fad07936aea3cb2103cc80d67a0aa890a463c844eb876edd06"

URI_aarch64_rust-futures-lite+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+memchr-devel-2.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-futures-lite+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+memchr-devel}"
SRC_URI[aarch64_rust-futures-lite+memchr-devel.sha256sum] = "fd5e6a321088f96c3f51c4a3096518093544e7e6f74b387c3576fd95513ab316"

URI_aarch64_rust-futures-lite+parking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+parking-devel-2.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-futures-lite+parking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+parking-devel}"
SRC_URI[aarch64_rust-futures-lite+parking-devel.sha256sum] = "b759beeb94ae5288a98b1c4359001eff2bf44a8819fba58d1e3339ce62252150"

URI_aarch64_rust-futures-lite+race-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+race-devel-2.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-futures-lite+race-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+race-devel}"
SRC_URI[aarch64_rust-futures-lite+race-devel.sha256sum] = "0b5ab5165b132dfd2d285fdc71f5b4fce0560e8933c12262974a17fe7e86a661"

URI_aarch64_rust-futures-lite+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite+std-devel-2.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-futures-lite+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite+std-devel}"
SRC_URI[aarch64_rust-futures-lite+std-devel.sha256sum] = "e47ecf8417e2e5b04ed93199b22b5e7b67b1a435c4f9adf8a8f0e62f8b734611"

URI_aarch64_rust-futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-lite-devel-2.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-lite-devel}"
SRC_URI[aarch64_rust-futures-lite-devel.sha256sum] = "98693c7cfc8b77985ae352af8d72a40e2fef182f8db0a004cce35ab31d37aea0"

RDEPENDS:rust-futures-lite+alloc-devel = " \
 cargo \
 rust-futures-lite-devel \
 "
RDEPENDS:rust-futures-lite+default-devel = " \
 cargo \
 rust-futures-lite+race-devel \
 rust-futures-lite+std-devel \
 rust-futures-lite-devel \
 "
RDEPENDS:rust-futures-lite+fastrand-devel = " \
 cargo \
 rust-fastrand-devel \
 rust-futures-lite-devel \
 "
RDEPENDS:rust-futures-lite+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-futures-lite-devel \
 "
RDEPENDS:rust-futures-lite+memchr-devel = " \
 cargo \
 rust-futures-lite-devel \
 rust-memchr+default-devel \
 "
RDEPENDS:rust-futures-lite+parking-devel = " \
 cargo \
 rust-futures-lite-devel \
 rust-parking+default-devel \
 "
RDEPENDS:rust-futures-lite+race-devel = " \
 cargo \
 rust-futures-lite+fastrand-devel \
 rust-futures-lite-devel \
 "
RDEPENDS:rust-futures-lite+std-devel = " \
 cargo \
 rust-fastrand+std-devel \
 rust-fastrand-devel \
 rust-futures-lite+alloc-devel \
 rust-futures-lite+futures-io-devel \
 rust-futures-lite+parking-devel \
 rust-futures-lite-devel \
 "
RDEPENDS:rust-futures-lite-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-pin-project-lite+default-devel \
 "
