# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-MQTT-Simple"
PV = "1.28"
PR = "7.el10_0"
PACKAGES = " \
 perl-Net-MQTT-Simple \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-MQTT-Simple-1.28-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b2c53d360f81f065143ea25e8260f125b735815f450261a0c75ff2ed1164667"

URI_x86_64_v2_perl-Net-MQTT-Simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-MQTT-Simple-1.28-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-MQTT-Simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-MQTT-Simple}"
SRC_URI[x86_64_v2_perl-Net-MQTT-Simple.sha256sum] = "945717c69eecd589e9777e1aede20c3dc9311fb6a8f00de2bba1625ba59959cb"

URI_aarch64_perl-Net-MQTT-Simple = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-MQTT-Simple-1.28-7.el10_0.noarch.rpm;name=aarch64_perl-Net-MQTT-Simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-MQTT-Simple}"
SRC_URI[aarch64_perl-Net-MQTT-Simple.sha256sum] = "3418a4449cbe62922242dcceeb62f5d419820cc3616720ef9bd8f60fb6b1eac9"

RDEPENDS:perl-Net-MQTT-Simple = " \
 perl-Getopt-Long \
 perl-IO-Socket-IP \
 perl-IO-Socket-SSL \
 perl-Net-MQTT-Simple \
 perl-base \
 perl-interpreter \
 perl-libs \
 "
