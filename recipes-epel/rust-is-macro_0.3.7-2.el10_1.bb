# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-is-macro"
PV = "0.3.7"
PR = "2.el10_1"
PACKAGES = " \
 rust-is-macro+default-devel \
 rust-is-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-is-macro-0.3.7-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7d249253f947576654378aad98a93243f21504fc87eff4295b08840f8534f1e"

URI_x86_64_v2_rust-is-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-macro+default-devel-0.3.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is-macro+default-devel}"
SRC_URI[x86_64_v2_rust-is-macro+default-devel.sha256sum] = "5253e71bf9e2fe1965c7e7614041acdbde81b0d2f170459e161f4d344cb22bd2"

URI_x86_64_v2_rust-is-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-macro-devel-0.3.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is-macro-devel}"
SRC_URI[x86_64_v2_rust-is-macro-devel.sha256sum] = "c3f83175fd98260e7572d0788c01bfb338abd5df48318c58ce56048215029c5e"

URI_aarch64_rust-is-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is-macro+default-devel-0.3.7-2.el10_1.noarch.rpm;name=aarch64_rust-is-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is-macro+default-devel}"
SRC_URI[aarch64_rust-is-macro+default-devel.sha256sum] = "42d87345ed2a85f08851a40d8a967c941436e92bdc0482957cca4399ca5ef27c"

URI_aarch64_rust-is-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is-macro-devel-0.3.7-2.el10_1.noarch.rpm;name=aarch64_rust-is-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is-macro-devel}"
SRC_URI[aarch64_rust-is-macro-devel.sha256sum] = "2174023082fd8c37a1f94e49acfe0e2fd1ddf4f5c9347c0ad4697a19808e0ee4"

RDEPENDS:rust-is-macro+default-devel = " \
 cargo \
 rust-is-macro-devel \
 "
RDEPENDS:rust-is-macro-devel = " \
 cargo \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+derive-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+fold-devel \
 rust-syn2+full-devel \
 "
