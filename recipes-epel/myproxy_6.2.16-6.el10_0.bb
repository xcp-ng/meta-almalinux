# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "myproxy"
PV = "6.2.16"
PR = "6.el10_0"
PACKAGES = " \
 myproxy \
 myproxy-admin \
 myproxy-devel \
 myproxy-doc \
 myproxy-libs \
 myproxy-server \
 myproxy-voms \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/myproxy-6.2.16-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2cc4eda3b674802c81387c0a755600dbb21f2666885de6f3ca73a319d4157f9"

URI_x86_64_v2_myproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-6.2.16-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy}"
SRC_URI[x86_64_v2_myproxy.sha256sum] = "79b862985feaeb161cf20eb6d7924eaa9fdb614a3c9515c1771395d87b7b74dc"

URI_x86_64_v2_myproxy-admin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-admin-6.2.16-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy-admin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-admin}"
SRC_URI[x86_64_v2_myproxy-admin.sha256sum] = "27e9c8fb3c1b347e926f771c557cebec1262162107df8261083acb1b22e2a89d"

URI_x86_64_v2_myproxy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-devel-6.2.16-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-devel}"
SRC_URI[x86_64_v2_myproxy-devel.sha256sum] = "dd0ac4628286cf3d2a988f4f8e8993dbbf2a3541d62b68565ba9950d72e662ae"

URI_x86_64_v2_myproxy-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-doc-6.2.16-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_myproxy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-doc}"
SRC_URI[x86_64_v2_myproxy-doc.sha256sum] = "8e30cae1a5afa8438561d7e5f86bda658508f13cd9274861e1957905d271e4d5"

URI_x86_64_v2_myproxy-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-libs-6.2.16-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-libs}"
SRC_URI[x86_64_v2_myproxy-libs.sha256sum] = "f78aa78d52f9f90a5a9601ee3bfd1a8224908539e642eed5e1dd0ff88e29bd87"

URI_x86_64_v2_myproxy-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-server-6.2.16-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-server}"
SRC_URI[x86_64_v2_myproxy-server.sha256sum] = "6b11ebeedc118cf38ec5c1c279ef5fe6b84fd8b23962b2bde03b2ecffa561849"

URI_x86_64_v2_myproxy-voms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-voms-6.2.16-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy-voms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-voms}"
SRC_URI[x86_64_v2_myproxy-voms.sha256sum] = "b32c370e4f815f51ce7607cfe205edf12474a38afa2bb20b16b55d7ae0854a99"

URI_aarch64_myproxy = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-6.2.16-6.el10_0.aarch64.rpm;name=aarch64_myproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy}"
SRC_URI[aarch64_myproxy.sha256sum] = "ec9b3eb8ce56c9b5ca07c7af9987224323aa8bf5096f33b2a6b3ed796a0d6408"

URI_aarch64_myproxy-admin = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-admin-6.2.16-6.el10_0.aarch64.rpm;name=aarch64_myproxy-admin;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-admin}"
SRC_URI[aarch64_myproxy-admin.sha256sum] = "bbc12029f7fc2b11d83a1e286af1adb50fbce53464bf8be8c025940136c4e8d1"

URI_aarch64_myproxy-devel = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-devel-6.2.16-6.el10_0.aarch64.rpm;name=aarch64_myproxy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-devel}"
SRC_URI[aarch64_myproxy-devel.sha256sum] = "e11caf6c0f1e40f98c7dfca2e1b327404cda88849ce19a2ff098351ed665c415"

URI_aarch64_myproxy-doc = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-doc-6.2.16-6.el10_0.noarch.rpm;name=aarch64_myproxy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-doc}"
SRC_URI[aarch64_myproxy-doc.sha256sum] = "f9620b4454ebabf3a0f16186d6d6f05ac85fbf4413274a387d71e063f08b74d8"

URI_aarch64_myproxy-libs = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-libs-6.2.16-6.el10_0.aarch64.rpm;name=aarch64_myproxy-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-libs}"
SRC_URI[aarch64_myproxy-libs.sha256sum] = "8188938ac23a301bfcef8341c897eabb5dcee1849da9d8ce98bb2c350fe6b11b"

URI_aarch64_myproxy-server = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-server-6.2.16-6.el10_0.aarch64.rpm;name=aarch64_myproxy-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-server}"
SRC_URI[aarch64_myproxy-server.sha256sum] = "eb8cd37b998b323c3772c48bfc84366502f444e989d49f33c0256a356f60889f"

URI_aarch64_myproxy-voms = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-voms-6.2.16-6.el10_0.aarch64.rpm;name=aarch64_myproxy-voms;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-voms}"
SRC_URI[aarch64_myproxy-voms.sha256sum] = "ebc98016fad0dcd619469841febff014a88f62c3536a213597db3caafc8dc019"

RDEPENDS:myproxy = " \
 glibc \
 globus-common \
 globus-gsi-cert-utils \
 globus-gsi-sysconfig \
 myproxy-libs \
 openssl-libs \
 "
RDEPENDS:myproxy-admin = " \
 glibc \
 globus-gsi-cert-utils-progs \
 myproxy \
 myproxy-libs \
 myproxy-server \
 perl-Data-Dumper \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Temp \
 perl-File-stat \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-Pod-Usage \
 perl-Socket \
 perl-Time-Local \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:myproxy-devel = " \
 globus-common-devel \
 globus-gsi-callback-devel \
 globus-gsi-cert-utils-devel \
 globus-gsi-credential-devel \
 globus-gsi-proxy-core-devel \
 globus-gsi-sysconfig-devel \
 globus-gss-assist-devel \
 globus-gssapi-gsi-devel \
 myproxy-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:myproxy-doc = " \
 "
RDEPENDS:myproxy-libs = " \
 cyrus-sasl-lib \
 glibc \
 globus-common \
 globus-gsi-callback \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gsi-proxy-core \
 globus-gsi-sysconfig \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-proxy-utils \
 openldap \
 openssl-libs \
 pam-libs \
 "
RDEPENDS:myproxy-server = " \
 bash \
 glibc \
 myproxy-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:myproxy-voms = " \
 glibc \
 globus-gssapi-gsi \
 myproxy-libs \
 openssl-libs \
 virtual/voms-clients \
 voms \
 "
