# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "procServ"
PV = "2.8.0"
PR = "1.el10_3"
PACKAGES = " \
 procServ \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/procServ-2.8.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a47d930eafa25e5107aece001e4a73703ad07bb67cc2d059fea005eaee2759ee"

URI_x86_64_v2_procServ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/procServ-2.8.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_procServ;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_procServ}"
SRC_URI[x86_64_v2_procServ.sha256sum] = "ce892e04547eaaa63eb27bae6192a0d010606323b762a9e37b3516d94999eb4f"

URI_aarch64_procServ = "${EPEL_MIRROR}/aarch64/Packages/p/procServ-2.8.0-1.el10_3.aarch64.rpm;name=aarch64_procServ;unpack=0"
SRC_URI:append = " ${URI_aarch64_procServ}"
SRC_URI[aarch64_procServ.sha256sum] = "f1c51e09bdcb6839ebbc32380364756dfb9269e5a73d91e63c9c67ded9795951"

RDEPENDS:procServ = " \
 glibc \
 libgcc \
 libstdc++ \
 libtelnet \
 "
