# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-az"
PV = "1.2.1"
PR = "7.el10_1"
PACKAGES = " \
 rust-az+default-devel \
 rust-az+fail-on-warnings-devel \
 rust-az-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-az-1.2.1-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4743e7d0a09498d7c2b94cb12688fda28b00d067760742dab3087a96e2d60603"

URI_x86_64_v2_rust-az+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-az+default-devel-1.2.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-az+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-az+default-devel}"
SRC_URI[x86_64_v2_rust-az+default-devel.sha256sum] = "44931baffa16457af3baebaae3dde444585a8c362c233b73d09b2fbf4ed93df8"

URI_x86_64_v2_rust-az+fail-on-warnings-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-az+fail-on-warnings-devel-1.2.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-az+fail-on-warnings-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-az+fail-on-warnings-devel}"
SRC_URI[x86_64_v2_rust-az+fail-on-warnings-devel.sha256sum] = "83c35107edbffbd3e2ce805726e583c68b1a9225966cde177ee35f38483ae7bc"

URI_x86_64_v2_rust-az-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-az-devel-1.2.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-az-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-az-devel}"
SRC_URI[x86_64_v2_rust-az-devel.sha256sum] = "12c86cef5a8b30b4220d9d58b79cf20fd7dce60aee14e314412e8cea3df617a8"

URI_aarch64_rust-az+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-az+default-devel-1.2.1-7.el10_1.noarch.rpm;name=aarch64_rust-az+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-az+default-devel}"
SRC_URI[aarch64_rust-az+default-devel.sha256sum] = "c4784664cd5fa52869f68e193f713f62f630389972469b146f665e0c12faf957"

URI_aarch64_rust-az+fail-on-warnings-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-az+fail-on-warnings-devel-1.2.1-7.el10_1.noarch.rpm;name=aarch64_rust-az+fail-on-warnings-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-az+fail-on-warnings-devel}"
SRC_URI[aarch64_rust-az+fail-on-warnings-devel.sha256sum] = "defca22586d2c3b68d98409bcf282452998269d692c77b638436cad68c6c3b40"

URI_aarch64_rust-az-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-az-devel-1.2.1-7.el10_1.noarch.rpm;name=aarch64_rust-az-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-az-devel}"
SRC_URI[aarch64_rust-az-devel.sha256sum] = "1e6bf611aef9ce2da4444f4533e79543b5083edd4888ebe5a41cad85c30881ce"

RDEPENDS:rust-az+default-devel = " \
 cargo \
 rust-az-devel \
 "
RDEPENDS:rust-az+fail-on-warnings-devel = " \
 cargo \
 rust-az-devel \
 "
RDEPENDS:rust-az-devel = " \
 cargo \
 "
