# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-brukerapi"
PV = "0.1.10"
PR = "1.el10_1"
PACKAGES = " \
 python-brukerapi-doc \
 python3-brukerapi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-brukerapi-0.1.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89c20837e9b84e6d61465c5af906e48e1be6d0b7630cbf615d95968d5c018b71"

URI_x86_64_v2_python-brukerapi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-brukerapi-doc-0.1.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-brukerapi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-brukerapi-doc}"
SRC_URI[x86_64_v2_python-brukerapi-doc.sha256sum] = "1c8b3fc15330ef7ae6439ce1ffc8f280b3b1944a7f3642320fc79ef04389998a"

URI_x86_64_v2_python3-brukerapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-brukerapi-0.1.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-brukerapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-brukerapi}"
SRC_URI[x86_64_v2_python3-brukerapi.sha256sum] = "fe9a3a62557bffef872ca0965a4d46f555faa2932098fa912a886e8e961c6820"

URI_aarch64_python-brukerapi-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-brukerapi-doc-0.1.10-1.el10_1.noarch.rpm;name=aarch64_python-brukerapi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-brukerapi-doc}"
SRC_URI[aarch64_python-brukerapi-doc.sha256sum] = "ce03d267c9b9ec7a97b35e3b3acc542de7fbef9f6ec3995922835b465fa0e85c"

URI_aarch64_python3-brukerapi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-brukerapi-0.1.10-1.el10_1.noarch.rpm;name=aarch64_python3-brukerapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-brukerapi}"
SRC_URI[aarch64_python3-brukerapi.sha256sum] = "e0c2070373307b0d818adf87e1597ff04365d7160a4b602857c3881877ae319f"

RDEPENDS:python-brukerapi-doc = " \
 "
RDEPENDS:python3-brukerapi = " \
 python3 \
 python3-numpy \
 python3-pyyaml \
 "
