# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ujson"
PV = "5.12.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-ujson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ujson-5.12.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b92646a5b420b119bd335958f1a7e6c7c0d8e6b774efb453fdf43d9d548f955"

URI_x86_64_v2_python3-ujson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ujson-5.12.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-ujson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ujson}"
SRC_URI[x86_64_v2_python3-ujson.sha256sum] = "01d9cff20f2e49022f7aa6e4a79a9a0f476478ebf49cc127b223a7b4e1f50e03"

URI_aarch64_python3-ujson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ujson-5.12.1-1.el10_2.aarch64.rpm;name=aarch64_python3-ujson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ujson}"
SRC_URI[aarch64_python3-ujson.sha256sum] = "0e6b89c46c273fa7267932688b4e89393e6ca07cc8779677a8babf3ccf183c94"

RDEPENDS:python3-ujson = " \
 double-conversion \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
