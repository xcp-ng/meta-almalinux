# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chrpath"
PV = "0.16"
PR = "25.el10"
PACKAGES = " \
 chrpath \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/chrpath-0.16-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9d060f5c1f9ec2aa3e82925d3a08f1ffb9d02d66a10dc61a478ceaee101ec60"

URI_x86_64_v2_chrpath = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/chrpath-0.16-25.el10.x86_64_v2.rpm;name=x86_64_v2_chrpath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chrpath}"
SRC_URI[x86_64_v2_chrpath.sha256sum] = "30c0d827226ae2f4f94c2439bf671cb5273dd269263ea1596c0b702b0103dc1f"

URI_aarch64_chrpath = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/chrpath-0.16-25.el10.aarch64.rpm;name=aarch64_chrpath;unpack=0"
SRC_URI:append = " ${URI_aarch64_chrpath}"
SRC_URI[aarch64_chrpath.sha256sum] = "0d7999cc4824cf89fabb6012037a72db349c4d67649538f7e7bdec537b6901af"

RDEPENDS:chrpath = " \
 glibc \
 "
