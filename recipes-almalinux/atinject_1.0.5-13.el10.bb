# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "atinject"
PV = "1.0.5"
PR = "13.el10"
PACKAGES = " \
 atinject \
 atinject-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/atinject-1.0.5-13.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ca5df060fad608586212bfef7d8ffc30c08509a88bea1b01ca9946380244dc6a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/atinject-1.0.5-13.el10.noarch.rpm;name=x86_64_v2_atinject;unpack=0"
SRC_URI[x86_64_v2_atinject.sha256sum] = "abb0c2700f08ce1ff6e0844e977f62fc473fbbe307daa293220bf4ea6711d3e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/atinject-javadoc-1.0.5-13.el10.noarch.rpm;name=x86_64_v2_atinject-javadoc;unpack=0"
SRC_URI[x86_64_v2_atinject-javadoc.sha256sum] = "62d56ebf7d9a14f2c5b56249b82fa8823c98dadcc6b5461211aa2c68912f44cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/atinject-1.0.5-13.el10.noarch.rpm;name=aarch64_atinject;unpack=0"
SRC_URI[aarch64_atinject.sha256sum] = "abb0c2700f08ce1ff6e0844e977f62fc473fbbe307daa293220bf4ea6711d3e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/atinject-javadoc-1.0.5-13.el10.noarch.rpm;name=aarch64_atinject-javadoc;unpack=0"
SRC_URI[aarch64_atinject-javadoc.sha256sum] = "62d56ebf7d9a14f2c5b56249b82fa8823c98dadcc6b5461211aa2c68912f44cd"

RDEPENDS:atinject = " \
 javapackages-filesystem \
 "
RDEPENDS:atinject-javadoc = " \
 javapackages-filesystem \
 "
