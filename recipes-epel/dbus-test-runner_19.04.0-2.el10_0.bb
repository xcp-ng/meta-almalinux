# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dbus-test-runner"
PV = "19.04.0"
PR = "2.el10_0"
PACKAGES = " \
 dbus-test-runner \
 dbus-test-runner-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dbus-test-runner-19.04.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d069cc1ffb37db88622d6700a986e42748bae15f210c64dccd0802f6c43411d0"

URI_x86_64_v2_dbus-test-runner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dbus-test-runner-19.04.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dbus-test-runner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-test-runner}"
SRC_URI[x86_64_v2_dbus-test-runner.sha256sum] = "973042688dfb6f4a938219de1bf55944f5867335facc6d1a53a65e189045b3c2"

URI_x86_64_v2_dbus-test-runner-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dbus-test-runner-devel-19.04.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dbus-test-runner-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-test-runner-devel}"
SRC_URI[x86_64_v2_dbus-test-runner-devel.sha256sum] = "8d63f9dfe2a64072b910c230cfecacd0d08f1ccb39ee1d2323606cd3a536c274"

URI_aarch64_dbus-test-runner = "${EPEL_MIRROR}/aarch64/Packages/d/dbus-test-runner-19.04.0-2.el10_0.aarch64.rpm;name=aarch64_dbus-test-runner;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-test-runner}"
SRC_URI[aarch64_dbus-test-runner.sha256sum] = "7624ac6f909740fcfd1373019a7ea7d10cbe7630cd50d4aa26ba7afe338e68da"

URI_aarch64_dbus-test-runner-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dbus-test-runner-devel-19.04.0-2.el10_0.aarch64.rpm;name=aarch64_dbus-test-runner-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-test-runner-devel}"
SRC_URI[aarch64_dbus-test-runner-devel.sha256sum] = "b5dadf6db860c148275f00bce527b0d2563d83c8c12fe86467f9a18a7276f1fa"

RDEPENDS:dbus-test-runner = " \
 bash \
 dbus-daemon \
 dbus-glib \
 dbus-libs \
 glib2 \
 glibc \
 "
RDEPENDS:dbus-test-runner-devel = " \
 dbus-test-runner \
 glib2-devel \
 pkgconf-pkg-config \
 "
