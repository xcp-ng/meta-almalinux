# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tracer"
PV = "1.3"
PR = "2.el10_0"
PACKAGES = " \
 python3-tracer \
 tracer-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tracer-1.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06b5203d89a32813c3b686637284946f268447f1e3ab9ae2807d0f287aa5f212"

URI_x86_64_v2_python3-tracer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tracer-1.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tracer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tracer}"
SRC_URI[x86_64_v2_python3-tracer.sha256sum] = "d516e38554aa3ec3a7739152d5e5a2353525be50338f1631796b6323cdf9b7dd"

URI_x86_64_v2_tracer-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tracer-common-1.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_tracer-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tracer-common}"
SRC_URI[x86_64_v2_tracer-common.sha256sum] = "31f82f34379d26718f27a19252d9f3dd7e9129242ec69a1581b127f4bbb5b82c"

URI_aarch64_python3-tracer = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tracer-1.3-2.el10_0.noarch.rpm;name=aarch64_python3-tracer;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tracer}"
SRC_URI[aarch64_python3-tracer.sha256sum] = "b3ca5ab1e7049520182d4219379b0766eb0a3b4fc4bc93118ffeee58de9bb679"

URI_aarch64_tracer-common = "${EPEL_MIRROR}/aarch64/Packages/t/tracer-common-1.3-2.el10_0.noarch.rpm;name=aarch64_tracer-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_tracer-common}"
SRC_URI[aarch64_tracer-common.sha256sum] = "b29af8871959ee9607b56cc46c3e971db6bf2203f99838b2fe13f5319fb3bb62"

RDEPENDS:python3-tracer = " \
 python3 \
 python3-dbus \
 python3-distro \
 python3-psutil \
 python3-rpm \
 python3-six \
 tracer-common \
 "
RDEPENDS:tracer-common = " \
 "
