# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-prost"
PV = "0.13.5"
PR = "2.el10_2"
PACKAGES = " \
 rust-prost+default-devel \
 rust-prost+derive-devel \
 rust-prost+no-recursion-limit-devel \
 rust-prost+prost-derive-devel \
 rust-prost+std-devel \
 rust-prost-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-prost-0.13.5-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37f0e29eb9c80d6ecebf52fd6358b4fbfac79519486454b6bf02909442f3f777"

URI_x86_64_v2_rust-prost+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost+default-devel-0.13.5-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost+default-devel}"
SRC_URI[x86_64_v2_rust-prost+default-devel.sha256sum] = "50582173bb3aa60af6f8837d41c90ea9f84cfeb8335bd5c4ac0e37fdcfcca6e2"

URI_x86_64_v2_rust-prost+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost+derive-devel-0.13.5-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost+derive-devel}"
SRC_URI[x86_64_v2_rust-prost+derive-devel.sha256sum] = "b3ccb469758e51fda553a6fc301c46916480de4e98c46c9eff4dfa7d8ac64f00"

URI_x86_64_v2_rust-prost+no-recursion-limit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost+no-recursion-limit-devel-0.13.5-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost+no-recursion-limit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost+no-recursion-limit-devel}"
SRC_URI[x86_64_v2_rust-prost+no-recursion-limit-devel.sha256sum] = "987e69513571382f0217ca1562d007295ac95fca192e4ae42565bcb18b0eff15"

URI_x86_64_v2_rust-prost+prost-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost+prost-derive-devel-0.13.5-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost+prost-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost+prost-derive-devel}"
SRC_URI[x86_64_v2_rust-prost+prost-derive-devel.sha256sum] = "67c0000bda0f1d17acb5b0bce6c5d04d8daa8224dca2a060c1c69364cac2f155"

URI_x86_64_v2_rust-prost+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost+std-devel-0.13.5-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost+std-devel}"
SRC_URI[x86_64_v2_rust-prost+std-devel.sha256sum] = "201f2150c5a0e8500e9bcefd94764474e78e9b50e91d76ff0295367f6e58d1f5"

URI_x86_64_v2_rust-prost-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-devel-0.13.5-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-devel}"
SRC_URI[x86_64_v2_rust-prost-devel.sha256sum] = "5d2f99ffa62cb76df6c65e1cc74a1c5b7123f1390f3618fcb8a3f97d7298866a"

URI_aarch64_rust-prost+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost+default-devel-0.13.5-2.el10_2.noarch.rpm;name=aarch64_rust-prost+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost+default-devel}"
SRC_URI[aarch64_rust-prost+default-devel.sha256sum] = "1feafb59160178228ddc4006d780d8233ac23a9a75b26688544167100ab5c3c1"

URI_aarch64_rust-prost+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost+derive-devel-0.13.5-2.el10_2.noarch.rpm;name=aarch64_rust-prost+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost+derive-devel}"
SRC_URI[aarch64_rust-prost+derive-devel.sha256sum] = "3284076ce5d84c24c1e0561b7fe4c55252992cc5a537de063e7249729d6db4b8"

URI_aarch64_rust-prost+no-recursion-limit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost+no-recursion-limit-devel-0.13.5-2.el10_2.noarch.rpm;name=aarch64_rust-prost+no-recursion-limit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost+no-recursion-limit-devel}"
SRC_URI[aarch64_rust-prost+no-recursion-limit-devel.sha256sum] = "a9b165222ceb671d0b60f181f325e777738d8a586faff0d57e247be6e47ae28d"

URI_aarch64_rust-prost+prost-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost+prost-derive-devel-0.13.5-2.el10_2.noarch.rpm;name=aarch64_rust-prost+prost-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost+prost-derive-devel}"
SRC_URI[aarch64_rust-prost+prost-derive-devel.sha256sum] = "8958edd36ae1b70d715223556817cc25041cad415dc941d9eb82f5fbfed9e9c3"

URI_aarch64_rust-prost+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost+std-devel-0.13.5-2.el10_2.noarch.rpm;name=aarch64_rust-prost+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost+std-devel}"
SRC_URI[aarch64_rust-prost+std-devel.sha256sum] = "61a97c6711221b954002b043828efb9b37f6e84fa113610754221422c8dd253e"

URI_aarch64_rust-prost-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-devel-0.13.5-2.el10_2.noarch.rpm;name=aarch64_rust-prost-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-devel}"
SRC_URI[aarch64_rust-prost-devel.sha256sum] = "0e9759f09c43a6a2a1696818ab39625c3a5d86b88b03b4177f6e89ae19a1540f"

RDEPENDS:rust-prost+default-devel = " \
 cargo \
 rust-prost+derive-devel \
 rust-prost+std-devel \
 rust-prost-devel \
 "
RDEPENDS:rust-prost+derive-devel = " \
 cargo \
 rust-prost-derive+default-devel \
 rust-prost-devel \
 "
RDEPENDS:rust-prost+no-recursion-limit-devel = " \
 cargo \
 rust-prost-devel \
 "
RDEPENDS:rust-prost+prost-derive-devel = " \
 cargo \
 rust-prost+derive-devel \
 rust-prost-devel \
 "
RDEPENDS:rust-prost+std-devel = " \
 cargo \
 rust-prost-devel \
 "
RDEPENDS:rust-prost-devel = " \
 cargo \
 rust \
 rust-bytes-devel \
 "
