# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-pyyaml"
PV = "6.0.3"
PR = "1.el10"
PACKAGES = " \
 python3.14-pyyaml \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-pyyaml-6.0.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d9bcdb5eefcab5e38adfa95938ffe5d551f0df8c44b2a4ce0a7924f7694559e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-pyyaml-6.0.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-pyyaml;unpack=0"
SRC_URI[x86_64_v2_python3.14-pyyaml.sha256sum] = "4f36bd04a880fd67d71cb0416780534db8ae6284529454450d5e2a2beae81ed7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-pyyaml-6.0.3-1.el10.aarch64.rpm;name=aarch64_python3.14-pyyaml;unpack=0"
SRC_URI[aarch64_python3.14-pyyaml.sha256sum] = "ce038f507848e8652e89cbc84b778bda8b5c1ff30d4f6a6fbe6126e89247060c"

RDEPENDS:python3.14-pyyaml = " \
 glibc \
 libyaml \
 python3.14 \
 "
