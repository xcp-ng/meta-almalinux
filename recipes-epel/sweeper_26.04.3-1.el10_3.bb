# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sweeper"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 sweeper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sweeper-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4589bf61d6529a51cb730c8f3a8ae59817877a0c6536a912eef539399a4e9ef6"

URI_x86_64_v2_sweeper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sweeper-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sweeper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sweeper}"
SRC_URI[x86_64_v2_sweeper.sha256sum] = "153b017e215c4211a8bed3fe03575934fe62c460d8ad181c2be2127031019d8b"

URI_aarch64_sweeper = "${EPEL_MIRROR}/aarch64/Packages/s/sweeper-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_sweeper;unpack=0"
SRC_URI:append = " ${URI_aarch64_sweeper}"
SRC_URI[aarch64_sweeper.sha256sum] = "5ea6c2be24f25c1966847793562c7ac13984efa72a173a09bf18552ad9b52490"

RDEPENDS:sweeper = " \
 glibc \
 hicolor-icon-theme \
 kf6-kbookmarks \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 plasma-activities-stats \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
