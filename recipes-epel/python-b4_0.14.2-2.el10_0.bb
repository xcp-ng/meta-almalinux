# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-b4"
PV = "0.14.2"
PR = "2.el10_0"
PACKAGES = " \
 b4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-b4-0.14.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f98065bd6552b79649abc4c8510beffe6fe9acb3d6a8d4399e5053c73d9a3a5"

URI_x86_64_v2_b4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/b4-0.14.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_b4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_b4}"
SRC_URI[x86_64_v2_b4.sha256sum] = "6133c82f2fd4a8edc004ac2ec917cf8c423590318e0464e1c17988c987b10fba"

URI_aarch64_b4 = "${EPEL_MIRROR}/aarch64/Packages/b/b4-0.14.2-2.el10_0.noarch.rpm;name=aarch64_b4;unpack=0"
SRC_URI:append = " ${URI_aarch64_b4}"
SRC_URI[aarch64_b4.sha256sum] = "281dbfd060f15a00a0190920f71db0b9c7e28b27d5dc4afca0aabe7b47818fca"

RDEPENDS:b4 = " \
 git-filter-repo \
 patatt \
 python3 \
 python3-dkimpy \
 python3-requests \
 "
