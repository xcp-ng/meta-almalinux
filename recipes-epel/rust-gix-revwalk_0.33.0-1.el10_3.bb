# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-revwalk"
PV = "0.33.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-revwalk+default-devel \
 rust-gix-revwalk+sha1-devel \
 rust-gix-revwalk+sha256-devel \
 rust-gix-revwalk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-revwalk-0.33.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8eeba537c0c352a6d8b4759f824cfd71737600fcd56e0779b1639bbd2f97afc"

URI_x86_64_v2_rust-gix-revwalk+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revwalk+default-devel-0.33.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revwalk+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revwalk+default-devel}"
SRC_URI[x86_64_v2_rust-gix-revwalk+default-devel.sha256sum] = "faa74c7c6483f06c2e183659f160551349b357e4414b357c9c7cd5afa017135a"

URI_x86_64_v2_rust-gix-revwalk+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revwalk+sha1-devel-0.33.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revwalk+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revwalk+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-revwalk+sha1-devel.sha256sum] = "813f4b9cf8969a15ce2f91f73f75ff5e54d1b8f7a174572cf80a308d5ff3e566"

URI_x86_64_v2_rust-gix-revwalk+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revwalk+sha256-devel-0.33.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revwalk+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revwalk+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-revwalk+sha256-devel.sha256sum] = "6da66df899ce5c0e4591e816cbb64f4fa678b776df5bf278d66cea0bbff01e1f"

URI_x86_64_v2_rust-gix-revwalk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revwalk-devel-0.33.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revwalk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revwalk-devel}"
SRC_URI[x86_64_v2_rust-gix-revwalk-devel.sha256sum] = "7b471fe1a7bb91fff0e8dadae071dd091f3bddaaed02b63f5bebc467ee789173"

URI_aarch64_rust-gix-revwalk+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revwalk+default-devel-0.33.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-revwalk+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revwalk+default-devel}"
SRC_URI[aarch64_rust-gix-revwalk+default-devel.sha256sum] = "d52fa7ac6e182097a855ab87276ac4bcae8435120b9376f8c4712f054f592b61"

URI_aarch64_rust-gix-revwalk+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revwalk+sha1-devel-0.33.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-revwalk+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revwalk+sha1-devel}"
SRC_URI[aarch64_rust-gix-revwalk+sha1-devel.sha256sum] = "cec69fd9cc38da8f46537c000f219d4759f11af6c90b8720e081ba9d679d3c90"

URI_aarch64_rust-gix-revwalk+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revwalk+sha256-devel-0.33.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-revwalk+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revwalk+sha256-devel}"
SRC_URI[aarch64_rust-gix-revwalk+sha256-devel.sha256sum] = "b310bc208c4b64bfc39dd5de1941c786f8201eb27d38d5c73369b030ea68f2e6"

URI_aarch64_rust-gix-revwalk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revwalk-devel-0.33.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-revwalk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revwalk-devel}"
SRC_URI[aarch64_rust-gix-revwalk-devel.sha256sum] = "17317a21df62f422c304da4677f177e390e3347115bb56aa23d4699efb03cb57"

RDEPENDS:rust-gix-revwalk+default-devel = " \
 cargo \
 rust-gix-revwalk-devel \
 "
RDEPENDS:rust-gix-revwalk+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-revwalk-devel \
 "
RDEPENDS:rust-gix-revwalk+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-revwalk-devel \
 "
RDEPENDS:rust-gix-revwalk-devel = " \
 cargo \
 rust \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-error+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-object+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
