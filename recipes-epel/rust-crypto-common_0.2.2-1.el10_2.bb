# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crypto-common"
PV = "0.2.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-crypto-common+default-devel \
 rust-crypto-common+getrandom-devel \
 rust-crypto-common+rand_core-devel \
 rust-crypto-common+zeroize-devel \
 rust-crypto-common-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crypto-common-0.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a53c9046f61ffbc6dfcab4450da797442d41933125b42c919e13fb95c7a00026"

URI_x86_64_v2_rust-crypto-common+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+default-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+default-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+default-devel.sha256sum] = "da26f836c294b6fd50036638024c114550867a9e96f775734352442e864b63a8"

URI_x86_64_v2_rust-crypto-common+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+getrandom-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+getrandom-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+getrandom-devel.sha256sum] = "65abc483d56403c8ab81c80490bbe5fe2ac84301a0d5cb90f8d2d3b38c9e27b1"

URI_x86_64_v2_rust-crypto-common+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+rand_core-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+rand_core-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+rand_core-devel.sha256sum] = "ce74d7539549fddc88a068e0446528460a0aac8d1b4354364e4598978fc8db20"

URI_x86_64_v2_rust-crypto-common+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+zeroize-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+zeroize-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+zeroize-devel.sha256sum] = "b681603f3c43439d55b70dde6e2a2e471d493e8f41f30e490fb2d4266180f818"

URI_x86_64_v2_rust-crypto-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common-devel}"
SRC_URI[x86_64_v2_rust-crypto-common-devel.sha256sum] = "b97dcc126f04d508e80dad9447a6c28f25fb6b1cf4f4cd2093921f89d60ce126"

URI_aarch64_rust-crypto-common+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+default-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-crypto-common+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+default-devel}"
SRC_URI[aarch64_rust-crypto-common+default-devel.sha256sum] = "f80c422948aae48c7a22d5d5ee4248b4b9a75560f72e039644dc5b832e2b1c63"

URI_aarch64_rust-crypto-common+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+getrandom-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-crypto-common+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+getrandom-devel}"
SRC_URI[aarch64_rust-crypto-common+getrandom-devel.sha256sum] = "20cbe613bed2fda08771bef5a67492edbb2c1f56a02d543fc2ecb8ecb42b7b1d"

URI_aarch64_rust-crypto-common+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+rand_core-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-crypto-common+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+rand_core-devel}"
SRC_URI[aarch64_rust-crypto-common+rand_core-devel.sha256sum] = "afccb210b63069183f5bb7f2aa31c65d27e33b9b681d7048c7a8a43cfd639705"

URI_aarch64_rust-crypto-common+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+zeroize-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-crypto-common+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+zeroize-devel}"
SRC_URI[aarch64_rust-crypto-common+zeroize-devel.sha256sum] = "2c342c245960ac7bb97b8792548f8602f84d50eb1619bbd15b49ac4b3f4ba311"

URI_aarch64_rust-crypto-common-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-crypto-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common-devel}"
SRC_URI[aarch64_rust-crypto-common-devel.sha256sum] = "d7e91ef45e08667edc424f50ec51e427d26589464e8aeb8905368339c779aca7"

RDEPENDS:rust-crypto-common+default-devel = " \
 cargo \
 rust-crypto-common-devel \
 "
RDEPENDS:rust-crypto-common+getrandom-devel = " \
 cargo \
 rust-crypto-common+rand_core-devel \
 rust-crypto-common-devel \
 rust-getrandom+default-devel \
 rust-getrandom+sys_rng-devel \
 "
RDEPENDS:rust-crypto-common+rand_core-devel = " \
 cargo \
 rust-crypto-common-devel \
 rust-rand_core+default-devel \
 "
RDEPENDS:rust-crypto-common+zeroize-devel = " \
 cargo \
 rust-crypto-common-devel \
 rust-hybrid-array+zeroize-devel \
 "
RDEPENDS:rust-crypto-common-devel = " \
 cargo \
 rust \
 rust-hybrid-array+default-devel \
 "
