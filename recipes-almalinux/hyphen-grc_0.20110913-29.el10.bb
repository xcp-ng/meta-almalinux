# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-grc"
PV = "0.20110913"
PR = "29.el10"
PACKAGES = " \
 hyphen-grc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-grc-0.20110913-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61d21432dbf072440e2e51b068307d18b61cc92033347785aaa66b4f1a5b486d"

URI_x86_64_v2_hyphen-grc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-grc-0.20110913-29.el10.noarch.rpm;name=x86_64_v2_hyphen-grc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-grc}"
SRC_URI[x86_64_v2_hyphen-grc.sha256sum] = "25c12c518973c5da211e4591359818fea7b2eee56e1982e97a752173506fa55a"

URI_aarch64_hyphen-grc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-grc-0.20110913-29.el10.noarch.rpm;name=aarch64_hyphen-grc;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-grc}"
SRC_URI[aarch64_hyphen-grc.sha256sum] = "25c12c518973c5da211e4591359818fea7b2eee56e1982e97a752173506fa55a"

RDEPENDS:hyphen-grc = " \
 hyphen \
 "
