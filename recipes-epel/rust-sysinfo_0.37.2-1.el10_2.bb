# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sysinfo"
PV = "0.37.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-sysinfo+c-interface-devel \
 rust-sysinfo+component-devel \
 rust-sysinfo+debug-devel \
 rust-sysinfo+default-devel \
 rust-sysinfo+disk-devel \
 rust-sysinfo+linux-netdevs-devel \
 rust-sysinfo+linux-tmpfs-devel \
 rust-sysinfo+multithread-devel \
 rust-sysinfo+network-devel \
 rust-sysinfo+serde-devel \
 rust-sysinfo+system-devel \
 rust-sysinfo+user-devel \
 rust-sysinfo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sysinfo-0.37.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fb5df0bef5d1d0db297cac010237256963624e4600059e5baecdef37a82c13a"

URI_x86_64_v2_rust-sysinfo+c-interface-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+c-interface-devel-0.37.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+c-interface-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+c-interface-devel.sha256sum] = "111688909b7d7a352f54d0695e899fb4926208ecc3f0ee55024f7f19cd9f4534"

URI_x86_64_v2_rust-sysinfo+component-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+component-devel-0.37.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+component-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+component-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+component-devel.sha256sum] = "59d327cb0c813748c63fe93b9ecf202cb3336191b5504f34f0f853a5d773ea10"

URI_x86_64_v2_rust-sysinfo+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+debug-devel-0.37.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+debug-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+debug-devel.sha256sum] = "a92722744450cca727e475eca9db8d90fc362df4399f7587e270c6a767d5b128"

URI_x86_64_v2_rust-sysinfo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+default-devel-0.37.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+default-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+default-devel.sha256sum] = "ae71d250d267058e8c445bd5ede87d867efe2d8acc39e80c1f60ccb5526079a9"

URI_x86_64_v2_rust-sysinfo+disk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+disk-devel-0.37.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+disk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+disk-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+disk-devel.sha256sum] = "26cc3eea7aeefd2c2e2050946308ed8658faf4b0e016cbb981749cf8c3846461"

URI_x86_64_v2_rust-sysinfo+linux-netdevs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+linux-netdevs-devel-0.37.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+linux-netdevs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+linux-netdevs-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+linux-netdevs-devel.sha256sum] = "0007382f48fd8662aad29208aed5576ebe7144a395e18670db5ff5a844af7df3"

URI_x86_64_v2_rust-sysinfo+linux-tmpfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+linux-tmpfs-devel-0.37.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+linux-tmpfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+linux-tmpfs-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+linux-tmpfs-devel.sha256sum] = "d507ce2643944f1737af5716de80e0cd7bd6dcc19bc9b239a719915b460507cc"

URI_x86_64_v2_rust-sysinfo+multithread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+multithread-devel-0.37.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+multithread-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+multithread-devel.sha256sum] = "b376b25a44c151b79db46913b1fdc58d320d1770a661a5659ed8e42a015c2caa"

URI_x86_64_v2_rust-sysinfo+network-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+network-devel-0.37.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+network-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+network-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+network-devel.sha256sum] = "eb2a5a6ff579211f6cae7c2615e088c2be9814e0c6d024e674f521ababe0b262"

URI_x86_64_v2_rust-sysinfo+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+serde-devel-0.37.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+serde-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+serde-devel.sha256sum] = "d5237786198b2aeb73f82aa9f87ef886926583aea1434e357fdd9efa979ef071"

URI_x86_64_v2_rust-sysinfo+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+system-devel-0.37.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+system-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+system-devel.sha256sum] = "2d4125b5b3f84aa8a61a3029e1b55653bf620f126a03003145c208eb4e8d848f"

URI_x86_64_v2_rust-sysinfo+user-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+user-devel-0.37.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+user-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+user-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+user-devel.sha256sum] = "437e0dee223026510cb377a5b14ea4cce1dfc553226d781b11d9d2c9bf5f4509"

URI_x86_64_v2_rust-sysinfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo-devel-0.37.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo-devel}"
SRC_URI[x86_64_v2_rust-sysinfo-devel.sha256sum] = "c830faedf545833017a6fcb2fb17c91ace07802a5136bfa59d22010f38cabbbb"

URI_aarch64_rust-sysinfo+c-interface-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+c-interface-devel-0.37.2-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+c-interface-devel}"
SRC_URI[aarch64_rust-sysinfo+c-interface-devel.sha256sum] = "2856fe09d33022c4e39dc6198a185f4f6b07ba78198df6e49ded546b3eaded4f"

URI_aarch64_rust-sysinfo+component-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+component-devel-0.37.2-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo+component-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+component-devel}"
SRC_URI[aarch64_rust-sysinfo+component-devel.sha256sum] = "21477ac2b7899fec8591f549b807083a584b4b72e2cbdd59c2140e4f58a51b7f"

URI_aarch64_rust-sysinfo+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+debug-devel-0.37.2-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+debug-devel}"
SRC_URI[aarch64_rust-sysinfo+debug-devel.sha256sum] = "6fb6345d8e5e0071d009b2895616a767627b7ae5f1f2471807e7b346ab714bc4"

URI_aarch64_rust-sysinfo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+default-devel-0.37.2-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+default-devel}"
SRC_URI[aarch64_rust-sysinfo+default-devel.sha256sum] = "eb736672a1efcfadc509b61d276b6f1d1e73d29d772658dd155f647d1e3c3495"

URI_aarch64_rust-sysinfo+disk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+disk-devel-0.37.2-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo+disk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+disk-devel}"
SRC_URI[aarch64_rust-sysinfo+disk-devel.sha256sum] = "458cbe01b7cd3b7e3e053df2e1d258d4e5e44a9e52f312035821612432a58e51"

URI_aarch64_rust-sysinfo+linux-netdevs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+linux-netdevs-devel-0.37.2-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo+linux-netdevs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+linux-netdevs-devel}"
SRC_URI[aarch64_rust-sysinfo+linux-netdevs-devel.sha256sum] = "f8bc4a7842e602d600200ae535bb9413b31fdc40ce8b2d49d4e01a7d3c14e542"

URI_aarch64_rust-sysinfo+linux-tmpfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+linux-tmpfs-devel-0.37.2-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo+linux-tmpfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+linux-tmpfs-devel}"
SRC_URI[aarch64_rust-sysinfo+linux-tmpfs-devel.sha256sum] = "f2fe6c45d98473b8cd11271c094dd1be9a068109a8366f9af1db55b32dd97d13"

URI_aarch64_rust-sysinfo+multithread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+multithread-devel-0.37.2-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+multithread-devel}"
SRC_URI[aarch64_rust-sysinfo+multithread-devel.sha256sum] = "428a9431d452463736ede256a22e7b9c74379dcb984e2915c9eead15b485a547"

URI_aarch64_rust-sysinfo+network-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+network-devel-0.37.2-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo+network-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+network-devel}"
SRC_URI[aarch64_rust-sysinfo+network-devel.sha256sum] = "d7aa708b18a14f2da169e11ba1516e7ed265a0a2a9dab247f78d27ceb43378c8"

URI_aarch64_rust-sysinfo+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+serde-devel-0.37.2-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+serde-devel}"
SRC_URI[aarch64_rust-sysinfo+serde-devel.sha256sum] = "d0ab3ac6b6ce70b113a794de2baf11d124e525599de7427cc0ed33376c747636"

URI_aarch64_rust-sysinfo+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+system-devel-0.37.2-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+system-devel}"
SRC_URI[aarch64_rust-sysinfo+system-devel.sha256sum] = "b8680e1e419e3e88d62da93f672a4c698d56a183c2075d12e0f487acfbd7c4a9"

URI_aarch64_rust-sysinfo+user-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+user-devel-0.37.2-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo+user-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+user-devel}"
SRC_URI[aarch64_rust-sysinfo+user-devel.sha256sum] = "c20ac1ec7e173d38206a089f0ab40c36e0fc976534ab4dac020bbd1390370bac"

URI_aarch64_rust-sysinfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo-devel-0.37.2-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo-devel}"
SRC_URI[aarch64_rust-sysinfo-devel.sha256sum] = "8ec7564139339abbbab945d0e78ee4c65656193c8b6b7d406a0d313f44fe7cc2"

RDEPENDS:rust-sysinfo+c-interface-devel = " \
 cargo \
 rust-sysinfo+default-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+component-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+debug-devel = " \
 cargo \
 rust-libc+extra_traits-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+default-devel = " \
 cargo \
 rust-sysinfo+component-devel \
 rust-sysinfo+disk-devel \
 rust-sysinfo+network-devel \
 rust-sysinfo+system-devel \
 rust-sysinfo+user-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+disk-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+linux-netdevs-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+linux-tmpfs-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+multithread-devel = " \
 cargo \
 rust-rayon+default-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+network-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+system-devel = " \
 cargo \
 rust-memchr+default-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+user-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
