# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nss"
PV = "3.112.0"
PR = "8.el10_0"
PACKAGES = " \
 nspr \
 nspr-devel \
 nss \
 nss-devel \
 nss-softokn \
 nss-softokn-devel \
 nss-softokn-freebl \
 nss-softokn-freebl-devel \
 nss-sysinit \
 nss-tools \
 nss-util \
 nss-util-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nss-3.112.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "191785564c3501a758f6937d4ca5687faf2d89f1c4487ff058cf68dfc3bbf180"

URI_x86_64_v2_nspr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nspr-4.36.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_nspr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nspr}"
SRC_URI[x86_64_v2_nspr.sha256sum] = "5edc234f7c4cc99d1ede03091d2c7fad28b689a345ccc8fa26a3a4d7860a64a1"

URI_x86_64_v2_nspr-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nspr-devel-4.36.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_nspr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nspr-devel}"
SRC_URI[x86_64_v2_nspr-devel.sha256sum] = "f0bd16ccb294991feb61abacc18ca3b1bb125bb41a67d6924fffa8a141bbdd5c"

URI_x86_64_v2_nss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-3.112.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss}"
SRC_URI[x86_64_v2_nss.sha256sum] = "a087b13709e6c9fdab9617df98a3b241b5133a38544be53b7ec7fa7685c08b8b"

URI_x86_64_v2_nss-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-devel-3.112.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-devel}"
SRC_URI[x86_64_v2_nss-devel.sha256sum] = "132eeb3c67602b4eb7c70224314f2bab570d08fca4bb4af3901bda4343fcafab"

URI_x86_64_v2_nss-softokn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-softokn-3.112.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-softokn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-softokn}"
SRC_URI[x86_64_v2_nss-softokn.sha256sum] = "eb8e3e691be37af4dffe7b895331a96e998eb1b2c3859589b129e65091c6ee7c"

URI_x86_64_v2_nss-softokn-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-softokn-devel-3.112.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-softokn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-softokn-devel}"
SRC_URI[x86_64_v2_nss-softokn-devel.sha256sum] = "ecf330a29d8ae656231200dd3513e68011214c095edb7cc4b5bf5adf702cf288"

URI_x86_64_v2_nss-softokn-freebl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-softokn-freebl-3.112.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-softokn-freebl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-softokn-freebl}"
SRC_URI[x86_64_v2_nss-softokn-freebl.sha256sum] = "1b839edb4da02da99ee22b83fdef1d0411f2175dce6aa5e9d8f8b5da14b2f2bc"

URI_x86_64_v2_nss-softokn-freebl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-softokn-freebl-devel-3.112.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-softokn-freebl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-softokn-freebl-devel}"
SRC_URI[x86_64_v2_nss-softokn-freebl-devel.sha256sum] = "2bc1aad79cf8986f1991d66bf89f80a1021686d92556f353cb6aee38327a9aef"

URI_x86_64_v2_nss-sysinit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-sysinit-3.112.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-sysinit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-sysinit}"
SRC_URI[x86_64_v2_nss-sysinit.sha256sum] = "ff02cc4c61395ffe6606fdb58afe1f243499b4a2986412d09fa9fb6c09c41cc3"

URI_x86_64_v2_nss-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-tools-3.112.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-tools}"
SRC_URI[x86_64_v2_nss-tools.sha256sum] = "7cb4136715dfb63239c5ce5d417f3db902ed75dc05758c0f1ea9e8fa6eb60489"

URI_x86_64_v2_nss-util = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-util-3.112.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-util}"
SRC_URI[x86_64_v2_nss-util.sha256sum] = "6637be6ba9f36eb92c974afbf9d92dfafcbf01c15830c63db2cf982604d5d48e"

URI_x86_64_v2_nss-util-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-util-devel-3.112.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-util-devel}"
SRC_URI[x86_64_v2_nss-util-devel.sha256sum] = "3798f045cf518c1b4d1c77a0f90f341d9a855b0ee5a166142c67a8310160d5d6"

URI_aarch64_nspr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nspr-4.36.0-8.el10_0.aarch64.rpm;name=aarch64_nspr;unpack=0"
SRC_URI:append = " ${URI_aarch64_nspr}"
SRC_URI[aarch64_nspr.sha256sum] = "59dcbe0ad2d8b7897dfbfb2f230e72ac2af20b766caf6ccc9050770c89398b0e"

URI_aarch64_nspr-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nspr-devel-4.36.0-8.el10_0.aarch64.rpm;name=aarch64_nspr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nspr-devel}"
SRC_URI[aarch64_nspr-devel.sha256sum] = "a4e5dc6e611affdf667b176ed48548e57b82a07d699f7bc0f7fe942a2fda6d87"

URI_aarch64_nss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-3.112.0-8.el10_0.aarch64.rpm;name=aarch64_nss;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss}"
SRC_URI[aarch64_nss.sha256sum] = "772e2cc163be663c192b3df02e6330306488e13bc8dc8c51369c9fe329c92d23"

URI_aarch64_nss-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-devel-3.112.0-8.el10_0.aarch64.rpm;name=aarch64_nss-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-devel}"
SRC_URI[aarch64_nss-devel.sha256sum] = "63714e579ae134a1868c923fa274bd5f8b24f9fce34a28bad3a5a6588ad62bde"

URI_aarch64_nss-softokn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-softokn-3.112.0-8.el10_0.aarch64.rpm;name=aarch64_nss-softokn;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-softokn}"
SRC_URI[aarch64_nss-softokn.sha256sum] = "ddea4ffaa480607f37767762c253ac332386c37fa3a5276eb163e5148946f1fe"

URI_aarch64_nss-softokn-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-softokn-devel-3.112.0-8.el10_0.aarch64.rpm;name=aarch64_nss-softokn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-softokn-devel}"
SRC_URI[aarch64_nss-softokn-devel.sha256sum] = "a9a214ec9d89b7c3f106854c563f398a63e0ba2d0c63fd7c7cdcd6948e6b0bc0"

URI_aarch64_nss-softokn-freebl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-softokn-freebl-3.112.0-8.el10_0.aarch64.rpm;name=aarch64_nss-softokn-freebl;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-softokn-freebl}"
SRC_URI[aarch64_nss-softokn-freebl.sha256sum] = "e214278ac55fead0a78750077c093332a0d6fb217bf4589660c5cc992f806647"

URI_aarch64_nss-softokn-freebl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-softokn-freebl-devel-3.112.0-8.el10_0.aarch64.rpm;name=aarch64_nss-softokn-freebl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-softokn-freebl-devel}"
SRC_URI[aarch64_nss-softokn-freebl-devel.sha256sum] = "7296e6c455d2fd3cd3a223f8008a4a0e52d94adb77f13635bff843f6c2df033a"

URI_aarch64_nss-sysinit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-sysinit-3.112.0-8.el10_0.aarch64.rpm;name=aarch64_nss-sysinit;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-sysinit}"
SRC_URI[aarch64_nss-sysinit.sha256sum] = "3aacc98baeac9f8fbe4f61940de5cda6c84051a0e85dd4d55a9c05fafa0494eb"

URI_aarch64_nss-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-tools-3.112.0-8.el10_0.aarch64.rpm;name=aarch64_nss-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-tools}"
SRC_URI[aarch64_nss-tools.sha256sum] = "b2f1b89e009060164517fc6173d8dc884ba43a6ded76d4964488cf73ab84fa62"

URI_aarch64_nss-util = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-util-3.112.0-8.el10_0.aarch64.rpm;name=aarch64_nss-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-util}"
SRC_URI[aarch64_nss-util.sha256sum] = "979aa2fb2e689b6b7f0b0443039238375ec3973e89f25eeb62dc839b47f959fa"

URI_aarch64_nss-util-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-util-devel-3.112.0-8.el10_0.aarch64.rpm;name=aarch64_nss-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-util-devel}"
SRC_URI[aarch64_nss-util-devel.sha256sum] = "64bb451c4f761a72ff00ae3cb178d7e5e46c8935dfd09c3c914a482b7dc0c66d"

RDEPENDS:nspr = " \
 glibc \
 "
RDEPENDS:nspr-devel = " \
 bash \
 nspr \
 pkgconf-pkg-config \
 "
RDEPENDS:nss = " \
 bash \
 crypto-policies \
 glibc \
 nspr \
 nss-softokn \
 nss-sysinit \
 nss-util \
 p11-kit-trust \
 "
RDEPENDS:nss-devel = " \
 bash \
 nspr-devel \
 nss \
 nss-softokn-devel \
 nss-util-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:nss-softokn = " \
 glibc \
 nspr \
 nss-softokn-freebl \
 nss-util \
 sqlite-libs \
 "
RDEPENDS:nss-softokn-devel = " \
 bash \
 nspr-devel \
 nss-softokn \
 nss-softokn-freebl-devel \
 nss-util-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:nss-softokn-freebl = " \
 bash \
 glibc \
 nspr \
 nss-util \
 "
RDEPENDS:nss-softokn-freebl-devel = " \
 nss-softokn-freebl \
 "
RDEPENDS:nss-sysinit = " \
 bash \
 glibc \
 nspr \
 nss \
 nss-util \
 sed \
 virtual/coreutils \
 "
RDEPENDS:nss-tools = " \
 glibc \
 nspr \
 nss \
 nss-util \
 zlib-ng-compat \
 "
RDEPENDS:nss-util = " \
 glibc \
 nspr \
 "
RDEPENDS:nss-util-devel = " \
 bash \
 nspr-devel \
 nss-util \
 pkgconf-pkg-config \
 "
