# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-gofrs-uuid"
PV = "4.0.0"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-gofrs-uuid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-gofrs-uuid-4.0.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53318f45af1cdb2bc6a01144233710a3244125a387d844deb97fd5a6229b32e8"

URI_x86_64_v2_golang-github-gofrs-uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-gofrs-uuid-devel-4.0.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-gofrs-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-gofrs-uuid-devel}"
SRC_URI[x86_64_v2_golang-github-gofrs-uuid-devel.sha256sum] = "e51e375fd0acace82430855b7921e650dc656ff8b7c381eaca763ff9b20e9683"

URI_aarch64_golang-github-gofrs-uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-gofrs-uuid-devel-4.0.0-12.el10_0.noarch.rpm;name=aarch64_golang-github-gofrs-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-gofrs-uuid-devel}"
SRC_URI[aarch64_golang-github-gofrs-uuid-devel.sha256sum] = "e52c78dd0cadaa1804c9def31fc94d76736bc0ee29142a289fdc6eb10a3886fe"

RDEPENDS:golang-github-gofrs-uuid-devel = " \
 go-filesystem \
 "
