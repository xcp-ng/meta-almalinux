# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexical-parse-float"
PV = "1.0.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-lexical-parse-float+compact-devel \
 rust-lexical-parse-float+default-devel \
 rust-lexical-parse-float+f128-devel \
 rust-lexical-parse-float+f16-devel \
 rust-lexical-parse-float+format-devel \
 rust-lexical-parse-float+lint-devel \
 rust-lexical-parse-float+power-of-two-devel \
 rust-lexical-parse-float+radix-devel \
 rust-lexical-parse-float+std-devel \
 rust-lexical-parse-float-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexical-parse-float-1.0.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7875caba5bb136cebe893d92bdf8cc3ba073cab17d48a18b8af87d6fddc2b25"

URI_x86_64_v2_rust-lexical-parse-float+compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+compact-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+compact-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+compact-devel.sha256sum] = "01a0fdfaa9294fd887027dd59bc8b2b790e379b32cea65a0dda84cdec723ba79"

URI_x86_64_v2_rust-lexical-parse-float+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+default-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+default-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+default-devel.sha256sum] = "11e1d0eddcb9f7531c2d1127e3e6d79ea077dd74bc32d3e2fad981ca25f73db7"

URI_x86_64_v2_rust-lexical-parse-float+f128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+f128-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+f128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+f128-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+f128-devel.sha256sum] = "d9dceed890896537e2c5316b68e9f5b7de74d873a01204048fe0645718b4bf0c"

URI_x86_64_v2_rust-lexical-parse-float+f16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+f16-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+f16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+f16-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+f16-devel.sha256sum] = "45f414125e2b95a0d34d43f9dea4ce17567484ff7004722f819991d7083d2457"

URI_x86_64_v2_rust-lexical-parse-float+format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+format-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+format-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+format-devel.sha256sum] = "8e8e7733888ccce7346586944ba130a68d21337e338ac965636bba797c9f3903"

URI_x86_64_v2_rust-lexical-parse-float+lint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+lint-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+lint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+lint-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+lint-devel.sha256sum] = "19ec3bc26a52e82a6ff65276fe0f0fb187d88db609fca1a76894187a8735db30"

URI_x86_64_v2_rust-lexical-parse-float+power-of-two-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+power-of-two-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+power-of-two-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+power-of-two-devel.sha256sum] = "aa0194f3a1ebad4529149c5e0f39deb999f315ae0ec0ae5f4c7a3e8dc8f92d09"

URI_x86_64_v2_rust-lexical-parse-float+radix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+radix-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+radix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+radix-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+radix-devel.sha256sum] = "1410243da1c65f4b9092d2feb6b26bb35cb027f05781767ad7d244ef5a76b883"

URI_x86_64_v2_rust-lexical-parse-float+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+std-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+std-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+std-devel.sha256sum] = "9a8c171d90f91c91bdddbc8f21d161dfe98a0d2155a360eba0ad8565ccfb442c"

URI_x86_64_v2_rust-lexical-parse-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float-devel.sha256sum] = "725fab101031f0e23e0a5877ab16853b490eda8054aa912eaa8eabf980d5ea3d"

URI_aarch64_rust-lexical-parse-float+compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+compact-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-float+compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+compact-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+compact-devel.sha256sum] = "0a35eff1104b964707154f7fc66f975f5f0e7e50e0721d1cb78b9556252ca623"

URI_aarch64_rust-lexical-parse-float+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+default-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-float+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+default-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+default-devel.sha256sum] = "ae90ef7c1e2b4e6e0d4dde37a2ba05dd5039776d05f183e1a91ca51b50b3c9af"

URI_aarch64_rust-lexical-parse-float+f128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+f128-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-float+f128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+f128-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+f128-devel.sha256sum] = "7898572baaaeac82b9ca96a92cd26f97d466e8420c1ae8bd37a2954e4d75f076"

URI_aarch64_rust-lexical-parse-float+f16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+f16-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-float+f16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+f16-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+f16-devel.sha256sum] = "8ac2423a5450a3bf593060e2d808180713cb6018405cb806f9060be7c574cdd4"

URI_aarch64_rust-lexical-parse-float+format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+format-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-float+format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+format-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+format-devel.sha256sum] = "c9cfb2550994f08f99beb0fee6981656d6b31ada23dafb2b655b0f4b53bed598"

URI_aarch64_rust-lexical-parse-float+lint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+lint-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-float+lint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+lint-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+lint-devel.sha256sum] = "db1198378f0649b3a28ed16f5b1b9c65dd04ef225d98234a0841ecd49a338267"

URI_aarch64_rust-lexical-parse-float+power-of-two-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+power-of-two-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-float+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+power-of-two-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+power-of-two-devel.sha256sum] = "307fe028c0dbae9edb62384596e82a58d91f8c80d9f8a0302f1bf62e97307978"

URI_aarch64_rust-lexical-parse-float+radix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+radix-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-float+radix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+radix-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+radix-devel.sha256sum] = "883d7ace5074b791a5d28d5ca9575e90b28ea6ae83870f29e35b6e1039e32a7e"

URI_aarch64_rust-lexical-parse-float+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+std-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-float+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+std-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+std-devel.sha256sum] = "b4c2b66dde43addd7263d9744f0255830c9c355229b586250110adbe019d0e19"

URI_aarch64_rust-lexical-parse-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float-devel}"
SRC_URI[aarch64_rust-lexical-parse-float-devel.sha256sum] = "34e8de27a771912b218d1dabc39c13ac4447cb1be4e193398996092872db51b7"

RDEPENDS:rust-lexical-parse-float+compact-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+compact-devel \
 rust-lexical-util+compact-devel \
 "
RDEPENDS:rust-lexical-parse-float+default-devel = " \
 cargo \
 rust-lexical-parse-float+std-devel \
 rust-lexical-parse-float-devel \
 "
RDEPENDS:rust-lexical-parse-float+f128-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-util+f128-devel \
 "
RDEPENDS:rust-lexical-parse-float+f16-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-util+f16-devel \
 "
RDEPENDS:rust-lexical-parse-float+format-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+format-devel \
 rust-lexical-util+format-devel \
 "
RDEPENDS:rust-lexical-parse-float+lint-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+lint-devel \
 rust-lexical-util+lint-devel \
 "
RDEPENDS:rust-lexical-parse-float+power-of-two-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+power-of-two-devel \
 rust-lexical-util+power-of-two-devel \
 "
RDEPENDS:rust-lexical-parse-float+radix-devel = " \
 cargo \
 rust-lexical-parse-float+power-of-two-devel \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+radix-devel \
 rust-lexical-util+radix-devel \
 "
RDEPENDS:rust-lexical-parse-float+std-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+std-devel \
 rust-lexical-util+std-devel \
 "
RDEPENDS:rust-lexical-parse-float-devel = " \
 cargo \
 rust \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+parse-floats-devel \
 rust-lexical-util-devel \
 rust-static_assertions+default-devel \
 "
