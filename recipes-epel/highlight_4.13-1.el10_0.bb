# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "highlight"
PV = "4.13"
PR = "1.el10_0"
PACKAGES = " \
 highlight \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/highlight-4.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d20891f7bf8319fd02cfcba8f772bf8495286eefa0f137a6c0a8f3bc304d855e"

URI_x86_64_v2_highlight = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/highlight-4.13-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_highlight;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_highlight}"
SRC_URI[x86_64_v2_highlight.sha256sum] = "c780939550da8f2deecd4dc02971b0e3a6ea1836fb4133286f182d9daef69a6e"

URI_aarch64_highlight = "${EPEL_MIRROR}/aarch64/Packages/h/highlight-4.13-1.el10_0.aarch64.rpm;name=aarch64_highlight;unpack=0"
SRC_URI:append = " ${URI_aarch64_highlight}"
SRC_URI[aarch64_highlight.sha256sum] = "309ec6f146a8d730768fede612b373391e366ef5e9758c031104a0fecdfe4af1"

RDEPENDS:highlight = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 lua-libs \
 "
