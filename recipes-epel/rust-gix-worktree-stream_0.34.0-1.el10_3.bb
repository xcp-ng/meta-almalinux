# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-worktree-stream"
PV = "0.34.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-worktree-stream+default-devel \
 rust-gix-worktree-stream+sha1-devel \
 rust-gix-worktree-stream+sha256-devel \
 rust-gix-worktree-stream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-worktree-stream-0.34.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c590f71d2bc5535acecee6e6491a44d458275657ce10c26413e406b9081b5e7"

URI_x86_64_v2_rust-gix-worktree-stream+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-stream+default-devel-0.34.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-stream+default-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-stream+default-devel.sha256sum] = "405109b51e70f85f049988b49d24d104c3e51cee772e1e883d234aff1004bbdf"

URI_x86_64_v2_rust-gix-worktree-stream+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-stream+sha1-devel-0.34.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-stream+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-stream+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-stream+sha1-devel.sha256sum] = "4fe4f7213812f7807ac4b344cb8ff8326a872c1eab2b88bf1d0d798aa1cc5daa"

URI_x86_64_v2_rust-gix-worktree-stream+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-stream+sha256-devel-0.34.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-stream+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-stream+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-stream+sha256-devel.sha256sum] = "74f982800ada8c935c9e4f595dca0f4f2588f79ecda8cf16cfb9f77e999cabf9"

URI_x86_64_v2_rust-gix-worktree-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-stream-devel-0.34.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-stream-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-stream-devel.sha256sum] = "af28007ce78a20aa27a03795c8bdd0f30c388044563c8eb5adf024fe58d8157c"

URI_aarch64_rust-gix-worktree-stream+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-stream+default-devel-0.34.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-stream+default-devel}"
SRC_URI[aarch64_rust-gix-worktree-stream+default-devel.sha256sum] = "bbf4e4dcd651237dfb2d8cfae6cf1e2ae120afd2cd3f75c9b7884fcc50635c67"

URI_aarch64_rust-gix-worktree-stream+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-stream+sha1-devel-0.34.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree-stream+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-stream+sha1-devel}"
SRC_URI[aarch64_rust-gix-worktree-stream+sha1-devel.sha256sum] = "bb0ea4df0fd2396242b868d746c69dc93f1bcd19777258f29bc6e13269302eb2"

URI_aarch64_rust-gix-worktree-stream+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-stream+sha256-devel-0.34.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree-stream+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-stream+sha256-devel}"
SRC_URI[aarch64_rust-gix-worktree-stream+sha256-devel.sha256sum] = "43d2f5e887a8313c8497b0e8574bdb6402c4d70e5146d22826a7f306bd1fd590"

URI_aarch64_rust-gix-worktree-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-stream-devel-0.34.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-stream-devel}"
SRC_URI[aarch64_rust-gix-worktree-stream-devel.sha256sum] = "e70c284faf66c9f6f2642877752aa7d561ef14626e9302c92ed099b5161e609c"

RDEPENDS:rust-gix-worktree-stream+default-devel = " \
 cargo \
 rust-gix-worktree-stream-devel \
 "
RDEPENDS:rust-gix-worktree-stream+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-worktree-stream-devel \
 "
RDEPENDS:rust-gix-worktree-stream+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-worktree-stream-devel \
 "
RDEPENDS:rust-gix-worktree-stream-devel = " \
 cargo \
 rust \
 rust-gix-attributes+default-devel \
 rust-gix-error+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+io-pipe-devel \
 rust-gix-features+progress-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-traverse+default-devel \
 rust-parking_lot+default-devel \
 "
