# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-amqp"
PV = "2.2.0"
PR = "2.el10_3"
PACKAGES = " \
 php-pecl-amqp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-amqp-2.2.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a91bdffb1c6e10785228f3d8db90f62d7ac7121abfcdc34ae25afa1da0eb3980"

URI_x86_64_v2_php-pecl-amqp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-amqp-2.2.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-amqp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-amqp}"
SRC_URI[x86_64_v2_php-pecl-amqp.sha256sum] = "3e452e2219357285e7126f68e217c3136555a3df7f53a5b525deadc08417bb71"

URI_aarch64_php-pecl-amqp = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-amqp-2.2.0-2.el10_3.aarch64.rpm;name=aarch64_php-pecl-amqp;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-amqp}"
SRC_URI[aarch64_php-pecl-amqp.sha256sum] = "d6c1b8a37b8a101dbaf08054d86f0a49dcc21b7a0102caa61323247b008102ff"

RDEPENDS:php-pecl-amqp = " \
 glibc \
 librabbitmq \
 php-common \
 "
