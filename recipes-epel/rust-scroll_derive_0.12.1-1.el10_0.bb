# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scroll_derive"
PV = "0.12.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-scroll_derive+default-devel \
 rust-scroll_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scroll_derive-0.12.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce297425a672eb55f3a09e282448aa1b8746e1c728b65c70527d68bce086f252"

URI_x86_64_v2_rust-scroll_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll_derive+default-devel-0.12.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll_derive+default-devel}"
SRC_URI[x86_64_v2_rust-scroll_derive+default-devel.sha256sum] = "ede4a14a69e61fcf8372d19e20986708f7b01464cae5d087510255a62017ab35"

URI_x86_64_v2_rust-scroll_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll_derive-devel-0.12.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll_derive-devel}"
SRC_URI[x86_64_v2_rust-scroll_derive-devel.sha256sum] = "2ec9ba303f51e885f6ccd4019dd9a4fa39ef26aa0013611261aa5f3b5a51211f"

URI_aarch64_rust-scroll_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll_derive+default-devel-0.12.1-1.el10_0.noarch.rpm;name=aarch64_rust-scroll_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll_derive+default-devel}"
SRC_URI[aarch64_rust-scroll_derive+default-devel.sha256sum] = "d54348d22a803840b8f6c475aad439cf5e94ec3e5e543f1db01e4b0a61c7137e"

URI_aarch64_rust-scroll_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll_derive-devel-0.12.1-1.el10_0.noarch.rpm;name=aarch64_rust-scroll_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll_derive-devel}"
SRC_URI[aarch64_rust-scroll_derive-devel.sha256sum] = "e5271367f10b361ac7b583cb7ff33bbff29206379c576d83ae167f0541e08c22"

RDEPENDS:rust-scroll_derive+default-devel = " \
 cargo \
 rust-scroll_derive-devel \
 "
RDEPENDS:rust-scroll_derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
