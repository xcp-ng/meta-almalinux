# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mimalloc"
PV = "0.1.46"
PR = "1.el10_1"
PACKAGES = " \
 rust-mimalloc+debug-devel \
 rust-mimalloc+debug_in_debug-devel \
 rust-mimalloc+default-devel \
 rust-mimalloc+extended-devel \
 rust-mimalloc+local_dynamic_tls-devel \
 rust-mimalloc+no_thp-devel \
 rust-mimalloc+override-devel \
 rust-mimalloc+secure-devel \
 rust-mimalloc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mimalloc-0.1.46-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d195aeaa56771a8d9e4634e044bac73d9837b863698df62d3eac2dd269cd0287"

URI_x86_64_v2_rust-mimalloc+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+debug-devel-0.1.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+debug-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+debug-devel.sha256sum] = "5ab96f99f3e815446a1205c9554c90d80fffd294e0cc1eeee0dc93476bccd0bb"

URI_x86_64_v2_rust-mimalloc+debug_in_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+debug_in_debug-devel-0.1.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+debug_in_debug-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+debug_in_debug-devel.sha256sum] = "d3bcbd7684406d5444b2986889e308ff3d119ffdfc7fc1a1117a6a2cee423dca"

URI_x86_64_v2_rust-mimalloc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+default-devel-0.1.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+default-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+default-devel.sha256sum] = "ead35841c3f476070a7631a4318accfd882f71762ce47a53d4f9988ea74dfdc3"

URI_x86_64_v2_rust-mimalloc+extended-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+extended-devel-0.1.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+extended-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+extended-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+extended-devel.sha256sum] = "e74604bdb74739c92a215d5d1386b59b8472cdbac2185c55549633727812a3ba"

URI_x86_64_v2_rust-mimalloc+local_dynamic_tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+local_dynamic_tls-devel-0.1.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+local_dynamic_tls-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+local_dynamic_tls-devel.sha256sum] = "20d0cf66bca618144c8dd87ade2844901caed3f564c1b4a99a2862af8310c407"

URI_x86_64_v2_rust-mimalloc+no_thp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+no_thp-devel-0.1.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+no_thp-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+no_thp-devel.sha256sum] = "c99741f449587abdf06a4fc25c979be1647f79f0ec6c2dff14ffbd090a6d970c"

URI_x86_64_v2_rust-mimalloc+override-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+override-devel-0.1.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+override-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+override-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+override-devel.sha256sum] = "8c938d08066620d55cfdae74723fae82cb2130169799656c95acef1140bc1bd9"

URI_x86_64_v2_rust-mimalloc+secure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+secure-devel-0.1.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+secure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+secure-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+secure-devel.sha256sum] = "6682708b64c4821b957955a2461ba6db4afca7db75d6c7e6d91437f8426431da"

URI_x86_64_v2_rust-mimalloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc-devel-0.1.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc-devel}"
SRC_URI[x86_64_v2_rust-mimalloc-devel.sha256sum] = "2f5c5e06c135b066a51ce37096f00b4243e695f2248551f4907020b331385a25"

URI_aarch64_rust-mimalloc+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+debug-devel-0.1.46-1.el10_1.noarch.rpm;name=aarch64_rust-mimalloc+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+debug-devel}"
SRC_URI[aarch64_rust-mimalloc+debug-devel.sha256sum] = "728c212d06dfdee823bf5f92213adcbcdf1fda9ff13d659df4f5089f093f1ae0"

URI_aarch64_rust-mimalloc+debug_in_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+debug_in_debug-devel-0.1.46-1.el10_1.noarch.rpm;name=aarch64_rust-mimalloc+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+debug_in_debug-devel}"
SRC_URI[aarch64_rust-mimalloc+debug_in_debug-devel.sha256sum] = "92a188b0ab3367377c6684054aa76bf81d5c1f775d679561bfe4323eed47e984"

URI_aarch64_rust-mimalloc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+default-devel-0.1.46-1.el10_1.noarch.rpm;name=aarch64_rust-mimalloc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+default-devel}"
SRC_URI[aarch64_rust-mimalloc+default-devel.sha256sum] = "c1586a154d562e129d64b25adc578c345fe00a1acf6c98373ec5322ec891f737"

URI_aarch64_rust-mimalloc+extended-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+extended-devel-0.1.46-1.el10_1.noarch.rpm;name=aarch64_rust-mimalloc+extended-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+extended-devel}"
SRC_URI[aarch64_rust-mimalloc+extended-devel.sha256sum] = "da4ac0ef5490a8dc263ef4ccde8c511159a24cd0660239af5853adc5f84fbd3f"

URI_aarch64_rust-mimalloc+local_dynamic_tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+local_dynamic_tls-devel-0.1.46-1.el10_1.noarch.rpm;name=aarch64_rust-mimalloc+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+local_dynamic_tls-devel}"
SRC_URI[aarch64_rust-mimalloc+local_dynamic_tls-devel.sha256sum] = "877db021ed9b79b16ecd0a98eba454499b7d64ff0d298b84da8872fe29ad385d"

URI_aarch64_rust-mimalloc+no_thp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+no_thp-devel-0.1.46-1.el10_1.noarch.rpm;name=aarch64_rust-mimalloc+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+no_thp-devel}"
SRC_URI[aarch64_rust-mimalloc+no_thp-devel.sha256sum] = "56e996329dd7ab0912e5c463068d0540a6c31a32b35c86485298e0ac1787e9be"

URI_aarch64_rust-mimalloc+override-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+override-devel-0.1.46-1.el10_1.noarch.rpm;name=aarch64_rust-mimalloc+override-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+override-devel}"
SRC_URI[aarch64_rust-mimalloc+override-devel.sha256sum] = "c6076c66d0bc2f4b96edcf0cabd741fb564bb2648a342d2e29f9ff385bf7ee81"

URI_aarch64_rust-mimalloc+secure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+secure-devel-0.1.46-1.el10_1.noarch.rpm;name=aarch64_rust-mimalloc+secure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+secure-devel}"
SRC_URI[aarch64_rust-mimalloc+secure-devel.sha256sum] = "010c0983b3d182804b06226d2da386d6120c39ddbd15ab4000b9ad3efbababd1"

URI_aarch64_rust-mimalloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc-devel-0.1.46-1.el10_1.noarch.rpm;name=aarch64_rust-mimalloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc-devel}"
SRC_URI[aarch64_rust-mimalloc-devel.sha256sum] = "55a334e67cf7179def6c18c82b75b42a50d861af09244d342c35c6f3c7ddde76"

RDEPENDS:rust-mimalloc+debug-devel = " \
 cargo \
 rust-libmimalloc-sys+debug-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+debug_in_debug-devel = " \
 cargo \
 rust-libmimalloc-sys+debug_in_debug-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+default-devel = " \
 cargo \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+extended-devel = " \
 cargo \
 rust-libmimalloc-sys+extended-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+local_dynamic_tls-devel = " \
 cargo \
 rust-libmimalloc-sys+local_dynamic_tls-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+no_thp-devel = " \
 cargo \
 rust-libmimalloc-sys+no_thp-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+override-devel = " \
 cargo \
 rust-libmimalloc-sys+override-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+secure-devel = " \
 cargo \
 rust-libmimalloc-sys+secure-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
