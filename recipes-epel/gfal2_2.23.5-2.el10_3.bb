# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gfal2"
PV = "2.23.5"
PR = "2.el10_3"
PACKAGES = " \
 gfal2 \
 gfal2-all \
 gfal2-devel \
 gfal2-doc \
 gfal2-plugin-file \
 gfal2-plugin-http \
 gfal2-plugin-mock \
 gfal2-plugin-srm \
 gfal2-plugin-xrootd \
 gfal2-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gfal2-2.23.5-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08d4005b372b685339cd8241c8bf024b8fb7b8232508b3a2f011fc73cd403c78"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - gfal2-plugin-xrootd: libXrdCl.so.3()(64bit)
# - gfal2-plugin-xrootd: libXrdPosix.so.3()(64bit)

URI_x86_64_v2_gfal2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-2.23.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2}"
SRC_URI[x86_64_v2_gfal2.sha256sum] = "5d3ddd3598e2e04d1af625c2b25b5d11e7139c9eefef0ee44329af08e398aabd"

URI_x86_64_v2_gfal2-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-all-2.23.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-all}"
SRC_URI[x86_64_v2_gfal2-all.sha256sum] = "52265ab43d857cf08a6ae9cf7d89c2dc8e73bc6a1d9e9bb7b1bf492ed14911a3"

URI_x86_64_v2_gfal2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-devel-2.23.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-devel}"
SRC_URI[x86_64_v2_gfal2-devel.sha256sum] = "4f6b5e1683f0e50cf0dc32d701f7f36632c7570cf7436c92dea2c97ce22bc326"

URI_x86_64_v2_gfal2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-doc-2.23.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_gfal2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-doc}"
SRC_URI[x86_64_v2_gfal2-doc.sha256sum] = "d6c637abbc093ccc1db76bcc4a6929b694f77dd90ae236383edc30a7c647ffe8"

URI_x86_64_v2_gfal2-plugin-file = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-file-2.23.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-file}"
SRC_URI[x86_64_v2_gfal2-plugin-file.sha256sum] = "595ab5910f714c88e707d295b717736f5a7fe5e5d1edd6927aed28d5632e3207"

URI_x86_64_v2_gfal2-plugin-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-http-2.23.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-http}"
SRC_URI[x86_64_v2_gfal2-plugin-http.sha256sum] = "9c29a053970b7da0376d048a7463bf23fb6b75e3f1f9225abe726782b64e253d"

URI_x86_64_v2_gfal2-plugin-mock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-mock-2.23.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-mock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-mock}"
SRC_URI[x86_64_v2_gfal2-plugin-mock.sha256sum] = "aacdd981f3352418d0074cf485fd1955847bbf0e6b19fc20eaa4ead716cd5ff8"

URI_x86_64_v2_gfal2-plugin-srm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-srm-2.23.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-srm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-srm}"
SRC_URI[x86_64_v2_gfal2-plugin-srm.sha256sum] = "683c3761c47fbc2511fdb2fc359f88c9034598456bedf4f2f2b906d1efd71729"

URI_x86_64_v2_gfal2-plugin-xrootd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-xrootd-2.23.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-xrootd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-xrootd}"
SRC_URI[x86_64_v2_gfal2-plugin-xrootd.sha256sum] = "14c2fa8985a30210a25063b6023912a9a917bf6ad6a8e276bc669ba71b7959f0"

URI_x86_64_v2_gfal2-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-tests-2.23.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-tests}"
SRC_URI[x86_64_v2_gfal2-tests.sha256sum] = "f23d4de22f5074b793059aaef6d63984d9aa929aca07d99831e94094dac7f6dd"

URI_aarch64_gfal2 = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-2.23.5-2.el10_3.aarch64.rpm;name=aarch64_gfal2;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2}"
SRC_URI[aarch64_gfal2.sha256sum] = "5b9131a0c073dde378bb4b1e7315bdf83ce2e11e5049ea7ca945ae2d500023ef"

URI_aarch64_gfal2-all = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-all-2.23.5-2.el10_3.aarch64.rpm;name=aarch64_gfal2-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-all}"
SRC_URI[aarch64_gfal2-all.sha256sum] = "01c2f180de08b70dd5cb3f1d0aa15e5bb08fcd3840169baab0f1c59cf662c875"

URI_aarch64_gfal2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-devel-2.23.5-2.el10_3.aarch64.rpm;name=aarch64_gfal2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-devel}"
SRC_URI[aarch64_gfal2-devel.sha256sum] = "7e949d3ed865cabb9a1e31853dfb0b4d6c430b00fbfe2c7fa8d1992121261351"

URI_aarch64_gfal2-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-doc-2.23.5-2.el10_3.noarch.rpm;name=aarch64_gfal2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-doc}"
SRC_URI[aarch64_gfal2-doc.sha256sum] = "7a8f1828bd1c7d7eaa4e73736c793d16906fe26cbfabe58f2bd6f6023f3076d4"

URI_aarch64_gfal2-plugin-file = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-file-2.23.5-2.el10_3.aarch64.rpm;name=aarch64_gfal2-plugin-file;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-file}"
SRC_URI[aarch64_gfal2-plugin-file.sha256sum] = "34ff32bc49cb8bc070acf86204b1f4f9f15a12f2b77482ae49df35d5a2f9c10a"

URI_aarch64_gfal2-plugin-http = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-http-2.23.5-2.el10_3.aarch64.rpm;name=aarch64_gfal2-plugin-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-http}"
SRC_URI[aarch64_gfal2-plugin-http.sha256sum] = "093ef69f01c9cdd90c11283c980c611779a9ac3cc2b1c22a5c56e67fc5046bec"

URI_aarch64_gfal2-plugin-mock = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-mock-2.23.5-2.el10_3.aarch64.rpm;name=aarch64_gfal2-plugin-mock;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-mock}"
SRC_URI[aarch64_gfal2-plugin-mock.sha256sum] = "81337dd5e9df8cf979ba472a99a9512c540a9d249323f952073be837ab4efd4e"

URI_aarch64_gfal2-plugin-srm = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-srm-2.23.5-2.el10_3.aarch64.rpm;name=aarch64_gfal2-plugin-srm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-srm}"
SRC_URI[aarch64_gfal2-plugin-srm.sha256sum] = "06c13f10cc0add9d6e00c6907759cfeac0014ca637cefe4a1396b7083d8ae45c"

URI_aarch64_gfal2-plugin-xrootd = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-xrootd-2.23.5-2.el10_3.aarch64.rpm;name=aarch64_gfal2-plugin-xrootd;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-xrootd}"
SRC_URI[aarch64_gfal2-plugin-xrootd.sha256sum] = "2ca2e3143102695321acf5323965b990c25aef024291560d367bf9bb388d9880"

URI_aarch64_gfal2-tests = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-tests-2.23.5-2.el10_3.aarch64.rpm;name=aarch64_gfal2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-tests}"
SRC_URI[aarch64_gfal2-tests.sha256sum] = "8f5c6fa0ec1473dc95892fb95ce15208a4a0a6cd6f8ea69dcff6f5b7b0e858d9"

RDEPENDS:gfal2 = " \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 openldap \
 pugixml \
 "
RDEPENDS:gfal2-all = " \
 gfal2 \
 gfal2-plugin-file \
 gfal2-plugin-http \
 gfal2-plugin-srm \
 gfal2-plugin-xrootd \
 "
RDEPENDS:gfal2-devel = " \
 gfal2 \
 gfal2-devel \
 glib2-devel \
 libattr-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gfal2-doc = " \
 "
RDEPENDS:gfal2-plugin-file = " \
 gfal2 \
 glib2 \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:gfal2-plugin-http = " \
 cryptopp \
 davix-libs \
 gfal2 \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gfal2-plugin-mock = " \
 gfal2 \
 glib2 \
 glibc \
 libuuid \
 "
RDEPENDS:gfal2-plugin-srm = " \
 gfal2 \
 glib2 \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 srm-ifce \
 "
RDEPENDS:gfal2-plugin-xrootd:x86_64_v2 = " \
 gfal2 \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
"
RDEPENDS:gfal2-plugin-xrootd:aarch64 = " \
 gfal2 \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 xrootd-client-libs \
"
RDEPENDS:gfal2-tests = " \
 cryptopp \
 davix-libs \
 gfal2 \
 gfal2-all \
 gfal2-plugin-mock \
 glib2 \
 glibc \
 gtest \
 json-c \
 libgcc \
 libstdc++ \
 "
