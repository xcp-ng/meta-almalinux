# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "almalinux-release"
PV = "10.2"
PR = "21.el10"
PACKAGES = " \
 almalinux-gpg-keys \
 almalinux-release \
 almalinux-repos \
 almalinux-sb-certs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/almalinux-release-10.2-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7efeb88f54dd3a80767c49e7c77a8c2523274842370d82e5a6f601a63f08aa66"

URI_x86_64_v2_almalinux-gpg-keys = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/almalinux-gpg-keys-10.2-21.el10.x86_64_v2.rpm;name=x86_64_v2_almalinux-gpg-keys;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-gpg-keys}"
SRC_URI[x86_64_v2_almalinux-gpg-keys.sha256sum] = "9ef6d30ed9fbe52cc989ca4e5f90ca13ab95a56b49a8e032a11107af87b6bc1a"

URI_x86_64_v2_almalinux-release = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/almalinux-release-10.2-21.el10.x86_64_v2.rpm;name=x86_64_v2_almalinux-release;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-release}"
SRC_URI[x86_64_v2_almalinux-release.sha256sum] = "9a0ed34eb92cb5cfed087f3c103bb17fb92da5f5a625db49cd55ab62f0c223ae"

URI_x86_64_v2_almalinux-repos = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/almalinux-repos-10.2-21.el10.x86_64_v2.rpm;name=x86_64_v2_almalinux-repos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-repos}"
SRC_URI[x86_64_v2_almalinux-repos.sha256sum] = "1fbe99315e92287d13375e216fc2ede144592f66f11642a2a6338f9c12744359"

URI_x86_64_v2_almalinux-sb-certs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/almalinux-sb-certs-10.2-21.el10.x86_64_v2.rpm;name=x86_64_v2_almalinux-sb-certs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-sb-certs}"
SRC_URI[x86_64_v2_almalinux-sb-certs.sha256sum] = "85f268e54748b30609f42f25822926366a4afc827b29d7bb33eccb15d686118b"

URI_aarch64_almalinux-gpg-keys = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/almalinux-gpg-keys-10.2-21.el10.aarch64.rpm;name=aarch64_almalinux-gpg-keys;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-gpg-keys}"
SRC_URI[aarch64_almalinux-gpg-keys.sha256sum] = "a8ade1160e029a14bc131965f0843dbdd11e9c301d600134b2829310302c9496"

URI_aarch64_almalinux-release = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/almalinux-release-10.2-21.el10.aarch64.rpm;name=aarch64_almalinux-release;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-release}"
SRC_URI[aarch64_almalinux-release.sha256sum] = "f18c2a68f4fa6a22cb0ef2431cb15b8d759443f407ee12c76a4a2c1fc2876ffd"

URI_aarch64_almalinux-repos = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/almalinux-repos-10.2-21.el10.aarch64.rpm;name=aarch64_almalinux-repos;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-repos}"
SRC_URI[aarch64_almalinux-repos.sha256sum] = "60cf6b40454262bb4f6754a0db33031c15d6820757a9987710a03fd7d9fa3f20"

URI_aarch64_almalinux-sb-certs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/almalinux-sb-certs-10.2-21.el10.aarch64.rpm;name=aarch64_almalinux-sb-certs;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-sb-certs}"
SRC_URI[aarch64_almalinux-sb-certs.sha256sum] = "310fe80041a0428a72e7bde9593a69c38ba115ce3f4bcd37b5b8418959ed2ebf"

RDEPENDS:almalinux-gpg-keys = " \
 "
RDEPENDS:almalinux-release = " \
 almalinux-repos \
 "
RDEPENDS:almalinux-repos = " \
 almalinux-gpg-keys \
 almalinux-release \
 "
RDEPENDS:almalinux-sb-certs = " \
 "
