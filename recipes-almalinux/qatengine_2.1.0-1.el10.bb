# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qatengine"
PV = "2.1.0"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 qatengine \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qatengine-2.1.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "153cefb2169022224fc370b12fbb8f57004311b14b9558eb0783fb9c66c0046e"

URI_x86_64_v2_qatengine = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatengine-2.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatengine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatengine}"
SRC_URI[x86_64_v2_qatengine.sha256sum] = "b6fa685d2f8c00538b3c7ab20766b5dadf350a2e5b9603c56d9ba2e56db72337"

RDEPENDS:qatengine = " \
 glibc \
 qatlib \
 "
