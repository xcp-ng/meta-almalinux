# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-Touch"
PV = "0.12"
PR = "10.el10_1"
PACKAGES = " \
 perl-File-Touch \
 perl-File-Touch-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-Touch-0.12-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5fd7eef7f21abfcc747cc1babb2d1c3c08ffd67f8ba09de25dfddc8d8d7e68f"

URI_x86_64_v2_perl-File-Touch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Touch-0.12-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Touch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Touch}"
SRC_URI[x86_64_v2_perl-File-Touch.sha256sum] = "3496769a5fe2d3ef3229eea0a5429e3dfbbb23010e85f74277f038d2f59497f5"

URI_x86_64_v2_perl-File-Touch-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Touch-tests-0.12-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Touch-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Touch-tests}"
SRC_URI[x86_64_v2_perl-File-Touch-tests.sha256sum] = "3f86df3615954248bf9b5bb5f70ccc0a92565c6d71ea7c8d9f7099ea5f8d7d87"

URI_aarch64_perl-File-Touch = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Touch-0.12-10.el10_1.noarch.rpm;name=aarch64_perl-File-Touch;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Touch}"
SRC_URI[aarch64_perl-File-Touch.sha256sum] = "67e16efc7c1c2a8ddb6f8d84fbdf2eacf427bf8d61c60f17e52fba6b192e481e"

URI_aarch64_perl-File-Touch-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Touch-tests-0.12-10.el10_1.noarch.rpm;name=aarch64_perl-File-Touch-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Touch-tests}"
SRC_URI[aarch64_perl-File-Touch-tests.sha256sum] = "4aa347e77872a52d3843b761f49844fdb843a41c2197fc45b3c42252afe60c5d"

RDEPENDS:perl-File-Touch = " \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-File-stat \
 perl-IO \
 perl-Time-HiRes \
 perl-libs \
 "
RDEPENDS:perl-File-Touch-tests = " \
 bash \
 perl-File-Touch \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-libs \
 virtual/coreutils \
 "
