# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extensions"
PV = "49.0"
PR = "6.el10"
PACKAGES = " \
 gnome-classic-session \
 gnome-shell-extension-apps-menu \
 gnome-shell-extension-auto-move-windows \
 gnome-shell-extension-classification-banner \
 gnome-shell-extension-common \
 gnome-shell-extension-custom-menu \
 gnome-shell-extension-desktop-icons \
 gnome-shell-extension-drive-menu \
 gnome-shell-extension-gesture-inhibitor \
 gnome-shell-extension-heads-up-display \
 gnome-shell-extension-launch-new-instance \
 gnome-shell-extension-light-style \
 gnome-shell-extension-native-window-placement \
 gnome-shell-extension-places-menu \
 gnome-shell-extension-screenshot-window-sizer \
 gnome-shell-extension-status-icons \
 gnome-shell-extension-system-monitor \
 gnome-shell-extension-user-theme \
 gnome-shell-extension-window-list \
 gnome-shell-extension-windowsNavigator \
 gnome-shell-extension-workspace-indicator \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-shell-extensions-49.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3843fef52eb22b139571efe99ac7d5cd7964bae3df81a878c3a6878e6c4611cc"

URI_x86_64_v2_gnome-classic-session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-classic-session-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-classic-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-classic-session}"
SRC_URI[x86_64_v2_gnome-classic-session.sha256sum] = "758d65f8c7e7373cc5733392adcbde327491ed13c93ccff24756e7138cda80f7"

URI_x86_64_v2_gnome-shell-extension-apps-menu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-apps-menu-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-apps-menu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-apps-menu}"
SRC_URI[x86_64_v2_gnome-shell-extension-apps-menu.sha256sum] = "3b4c79b02fcec3530023a244329d56ce3b1a35ca75cea55ab4ffbb8b591135c9"

URI_x86_64_v2_gnome-shell-extension-auto-move-windows = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-auto-move-windows-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-auto-move-windows;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-auto-move-windows}"
SRC_URI[x86_64_v2_gnome-shell-extension-auto-move-windows.sha256sum] = "641ef42c51b6ef7d16bd1ea5d70cb0845757ebc5bf0da7f56a5f1f525f7bb73f"

URI_x86_64_v2_gnome-shell-extension-classification-banner = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-classification-banner-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-classification-banner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-classification-banner}"
SRC_URI[x86_64_v2_gnome-shell-extension-classification-banner.sha256sum] = "d2fef5d98283eaca6d1ea7ba7748dc3da13f2c044238c02a6a38c79a06f1cff3"

URI_x86_64_v2_gnome-shell-extension-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-common-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-common}"
SRC_URI[x86_64_v2_gnome-shell-extension-common.sha256sum] = "5687b25cb0a281bd31860f10950b32bb500568433b6fd99b548722210a4eddad"

URI_x86_64_v2_gnome-shell-extension-custom-menu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-custom-menu-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-custom-menu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-custom-menu}"
SRC_URI[x86_64_v2_gnome-shell-extension-custom-menu.sha256sum] = "c2ce98da6c0c050cfe5896b37f2c93c7696aaf0f339d91a6c30f6c5011d12ecf"

URI_x86_64_v2_gnome-shell-extension-desktop-icons = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-desktop-icons-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-desktop-icons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-desktop-icons}"
SRC_URI[x86_64_v2_gnome-shell-extension-desktop-icons.sha256sum] = "c898c79febe34e1b9dbdefde9176e7ae2c2dbaabc4ffa78c31da777ba830012a"

URI_x86_64_v2_gnome-shell-extension-drive-menu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-drive-menu-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-drive-menu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-drive-menu}"
SRC_URI[x86_64_v2_gnome-shell-extension-drive-menu.sha256sum] = "3c565947908df6c1efc98236e63969173786a8a7a1a0f167606f466127e9da4f"

URI_x86_64_v2_gnome-shell-extension-gesture-inhibitor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-gesture-inhibitor-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-gesture-inhibitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-gesture-inhibitor}"
SRC_URI[x86_64_v2_gnome-shell-extension-gesture-inhibitor.sha256sum] = "4a2d150a7a21936da2e20a2e5e3ebb19301ba8522d137a559d45b09522d01d78"

URI_x86_64_v2_gnome-shell-extension-heads-up-display = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-heads-up-display-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-heads-up-display;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-heads-up-display}"
SRC_URI[x86_64_v2_gnome-shell-extension-heads-up-display.sha256sum] = "d6f907a514a3c6e34236c2894bff1b425f2c5e76b1b19bb0def554cd7dcf26d1"

URI_x86_64_v2_gnome-shell-extension-launch-new-instance = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-launch-new-instance-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-launch-new-instance;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-launch-new-instance}"
SRC_URI[x86_64_v2_gnome-shell-extension-launch-new-instance.sha256sum] = "f52db7ea4ad61b86d658bb1c23940710cbd5f66a15a6eb7710a23fbbc65fde7a"

URI_x86_64_v2_gnome-shell-extension-light-style = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-light-style-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-light-style;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-light-style}"
SRC_URI[x86_64_v2_gnome-shell-extension-light-style.sha256sum] = "1f88d6c2d83a2e422507e6c417dc1588ca32213b890669fd8998da5846a026bd"

URI_x86_64_v2_gnome-shell-extension-native-window-placement = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-native-window-placement-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-native-window-placement;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-native-window-placement}"
SRC_URI[x86_64_v2_gnome-shell-extension-native-window-placement.sha256sum] = "22b0133e650cf322f6728898e9862aa33c5dacbef68b49990e61cc5f15ec2ce8"

URI_x86_64_v2_gnome-shell-extension-places-menu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-places-menu-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-places-menu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-places-menu}"
SRC_URI[x86_64_v2_gnome-shell-extension-places-menu.sha256sum] = "8126816c7903a5a57fa303b23db4764b9c83a16117ad42b391e53e4338924a19"

URI_x86_64_v2_gnome-shell-extension-screenshot-window-sizer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-screenshot-window-sizer-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-screenshot-window-sizer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-screenshot-window-sizer}"
SRC_URI[x86_64_v2_gnome-shell-extension-screenshot-window-sizer.sha256sum] = "c916ad815e51f2aa9bf25c3a41e0f34b9c095a494c5c6721f78e427060bcd4e4"

URI_x86_64_v2_gnome-shell-extension-status-icons = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-status-icons-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-status-icons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-status-icons}"
SRC_URI[x86_64_v2_gnome-shell-extension-status-icons.sha256sum] = "b9aa974c47adce3fcf5ee35d533c4dcab4ffbe3216bf17872d3a247846887355"

URI_x86_64_v2_gnome-shell-extension-system-monitor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-system-monitor-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-system-monitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-system-monitor}"
SRC_URI[x86_64_v2_gnome-shell-extension-system-monitor.sha256sum] = "bf6f0632b8f5a8e552bec2048f60b943949d3d85d9daaf8f5bfdb25ef0e5f504"

URI_x86_64_v2_gnome-shell-extension-user-theme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-user-theme-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-user-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-user-theme}"
SRC_URI[x86_64_v2_gnome-shell-extension-user-theme.sha256sum] = "a3fb0a29f05b5467429c795abe2e5828ca10a8ed4c176cf074652e877e16e697"

URI_x86_64_v2_gnome-shell-extension-window-list = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-window-list-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-window-list;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-window-list}"
SRC_URI[x86_64_v2_gnome-shell-extension-window-list.sha256sum] = "427303f7f775ef130639f7a8c5c88950160c110423104e06fbda42ddf5854f06"

URI_x86_64_v2_gnome-shell-extension-windowsNavigator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-windowsNavigator-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-windowsNavigator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-windowsNavigator}"
SRC_URI[x86_64_v2_gnome-shell-extension-windowsNavigator.sha256sum] = "ab05b8c259f0a07b85466a33a97bf2432a56c2b343aab1138b68e122db8c1bb7"

URI_x86_64_v2_gnome-shell-extension-workspace-indicator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-workspace-indicator-49.0-6.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-workspace-indicator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-workspace-indicator}"
SRC_URI[x86_64_v2_gnome-shell-extension-workspace-indicator.sha256sum] = "e9a1ebae9d564e7c81e516e10db7f6a3fcdb6ed72810e877b0b85dbb497b7e77"

URI_aarch64_gnome-classic-session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-classic-session-49.0-6.el10.noarch.rpm;name=aarch64_gnome-classic-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-classic-session}"
SRC_URI[aarch64_gnome-classic-session.sha256sum] = "758d65f8c7e7373cc5733392adcbde327491ed13c93ccff24756e7138cda80f7"

URI_aarch64_gnome-shell-extension-apps-menu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-apps-menu-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-apps-menu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-apps-menu}"
SRC_URI[aarch64_gnome-shell-extension-apps-menu.sha256sum] = "3b4c79b02fcec3530023a244329d56ce3b1a35ca75cea55ab4ffbb8b591135c9"

URI_aarch64_gnome-shell-extension-auto-move-windows = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-auto-move-windows-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-auto-move-windows;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-auto-move-windows}"
SRC_URI[aarch64_gnome-shell-extension-auto-move-windows.sha256sum] = "641ef42c51b6ef7d16bd1ea5d70cb0845757ebc5bf0da7f56a5f1f525f7bb73f"

URI_aarch64_gnome-shell-extension-classification-banner = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-classification-banner-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-classification-banner;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-classification-banner}"
SRC_URI[aarch64_gnome-shell-extension-classification-banner.sha256sum] = "d2fef5d98283eaca6d1ea7ba7748dc3da13f2c044238c02a6a38c79a06f1cff3"

URI_aarch64_gnome-shell-extension-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-common-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-common}"
SRC_URI[aarch64_gnome-shell-extension-common.sha256sum] = "5687b25cb0a281bd31860f10950b32bb500568433b6fd99b548722210a4eddad"

URI_aarch64_gnome-shell-extension-custom-menu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-custom-menu-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-custom-menu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-custom-menu}"
SRC_URI[aarch64_gnome-shell-extension-custom-menu.sha256sum] = "c2ce98da6c0c050cfe5896b37f2c93c7696aaf0f339d91a6c30f6c5011d12ecf"

URI_aarch64_gnome-shell-extension-desktop-icons = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-desktop-icons-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-desktop-icons;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-desktop-icons}"
SRC_URI[aarch64_gnome-shell-extension-desktop-icons.sha256sum] = "c898c79febe34e1b9dbdefde9176e7ae2c2dbaabc4ffa78c31da777ba830012a"

URI_aarch64_gnome-shell-extension-drive-menu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-drive-menu-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-drive-menu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-drive-menu}"
SRC_URI[aarch64_gnome-shell-extension-drive-menu.sha256sum] = "3c565947908df6c1efc98236e63969173786a8a7a1a0f167606f466127e9da4f"

URI_aarch64_gnome-shell-extension-gesture-inhibitor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-gesture-inhibitor-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-gesture-inhibitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-gesture-inhibitor}"
SRC_URI[aarch64_gnome-shell-extension-gesture-inhibitor.sha256sum] = "4a2d150a7a21936da2e20a2e5e3ebb19301ba8522d137a559d45b09522d01d78"

URI_aarch64_gnome-shell-extension-heads-up-display = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-heads-up-display-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-heads-up-display;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-heads-up-display}"
SRC_URI[aarch64_gnome-shell-extension-heads-up-display.sha256sum] = "d6f907a514a3c6e34236c2894bff1b425f2c5e76b1b19bb0def554cd7dcf26d1"

URI_aarch64_gnome-shell-extension-launch-new-instance = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-launch-new-instance-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-launch-new-instance;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-launch-new-instance}"
SRC_URI[aarch64_gnome-shell-extension-launch-new-instance.sha256sum] = "f52db7ea4ad61b86d658bb1c23940710cbd5f66a15a6eb7710a23fbbc65fde7a"

URI_aarch64_gnome-shell-extension-light-style = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-light-style-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-light-style;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-light-style}"
SRC_URI[aarch64_gnome-shell-extension-light-style.sha256sum] = "1f88d6c2d83a2e422507e6c417dc1588ca32213b890669fd8998da5846a026bd"

URI_aarch64_gnome-shell-extension-native-window-placement = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-native-window-placement-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-native-window-placement;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-native-window-placement}"
SRC_URI[aarch64_gnome-shell-extension-native-window-placement.sha256sum] = "22b0133e650cf322f6728898e9862aa33c5dacbef68b49990e61cc5f15ec2ce8"

URI_aarch64_gnome-shell-extension-places-menu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-places-menu-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-places-menu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-places-menu}"
SRC_URI[aarch64_gnome-shell-extension-places-menu.sha256sum] = "8126816c7903a5a57fa303b23db4764b9c83a16117ad42b391e53e4338924a19"

URI_aarch64_gnome-shell-extension-screenshot-window-sizer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-screenshot-window-sizer-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-screenshot-window-sizer;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-screenshot-window-sizer}"
SRC_URI[aarch64_gnome-shell-extension-screenshot-window-sizer.sha256sum] = "c916ad815e51f2aa9bf25c3a41e0f34b9c095a494c5c6721f78e427060bcd4e4"

URI_aarch64_gnome-shell-extension-status-icons = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-status-icons-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-status-icons;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-status-icons}"
SRC_URI[aarch64_gnome-shell-extension-status-icons.sha256sum] = "b9aa974c47adce3fcf5ee35d533c4dcab4ffbe3216bf17872d3a247846887355"

URI_aarch64_gnome-shell-extension-system-monitor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-system-monitor-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-system-monitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-system-monitor}"
SRC_URI[aarch64_gnome-shell-extension-system-monitor.sha256sum] = "bf6f0632b8f5a8e552bec2048f60b943949d3d85d9daaf8f5bfdb25ef0e5f504"

URI_aarch64_gnome-shell-extension-user-theme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-user-theme-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-user-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-user-theme}"
SRC_URI[aarch64_gnome-shell-extension-user-theme.sha256sum] = "a3fb0a29f05b5467429c795abe2e5828ca10a8ed4c176cf074652e877e16e697"

URI_aarch64_gnome-shell-extension-window-list = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-window-list-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-window-list;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-window-list}"
SRC_URI[aarch64_gnome-shell-extension-window-list.sha256sum] = "427303f7f775ef130639f7a8c5c88950160c110423104e06fbda42ddf5854f06"

URI_aarch64_gnome-shell-extension-windowsNavigator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-windowsNavigator-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-windowsNavigator;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-windowsNavigator}"
SRC_URI[aarch64_gnome-shell-extension-windowsNavigator.sha256sum] = "ab05b8c259f0a07b85466a33a97bf2432a56c2b343aab1138b68e122db8c1bb7"

URI_aarch64_gnome-shell-extension-workspace-indicator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-workspace-indicator-49.0-6.el10.noarch.rpm;name=aarch64_gnome-shell-extension-workspace-indicator;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-workspace-indicator}"
SRC_URI[aarch64_gnome-shell-extension-workspace-indicator.sha256sum] = "e9a1ebae9d564e7c81e516e10db7f6a3fcdb6ed72810e877b0b85dbb497b7e77"

RDEPENDS:gnome-classic-session = " \
 gnome-shell-extension-apps-menu \
 gnome-shell-extension-launch-new-instance \
 gnome-shell-extension-places-menu \
 gnome-shell-extension-window-list \
 nautilus \
 "
RDEPENDS:gnome-shell-extension-apps-menu = " \
 gnome-menus \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-auto-move-windows = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-classification-banner = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-common = " \
 gnome-shell \
 "
RDEPENDS:gnome-shell-extension-custom-menu = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-desktop-icons = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-drive-menu = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-gesture-inhibitor = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-heads-up-display = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-launch-new-instance = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-light-style = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-native-window-placement = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-places-menu = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-screenshot-window-sizer = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-status-icons = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-system-monitor = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-user-theme = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-window-list = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-windowsNavigator = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-workspace-indicator = " \
 gnome-shell-extension-common \
 "
