# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alligator"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 alligator \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/alligator-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "08ed6145543709ea2086653fd8ff8caf756779bd9744fa564dcefd04073756b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alligator-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_alligator;unpack=0"
SRC_URI[x86_64_v2_alligator.sha256sum] = "16cb364b71143f7690c3de2fdd83525fadf6e8238285650238c235a57314dff5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/alligator-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_alligator;unpack=0"
SRC_URI[aarch64_alligator.sha256sum] = "2b852e015bdc44d3073c148bd905cd3ea1af0e7f04a354ae2e90069e3c425bce"

RDEPENDS:alligator = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-syndication \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
