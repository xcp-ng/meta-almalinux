# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-valyala-fasttemplate"
PV = "1.2.1"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-valyala-fasttemplate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-valyala-fasttemplate-1.2.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8114bbb5a953486df396d6b515b1e53a33bb6daff4076225234dea33d1acd66"

URI_x86_64_v2_golang-github-valyala-fasttemplate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-valyala-fasttemplate-devel-1.2.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-valyala-fasttemplate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-valyala-fasttemplate-devel}"
SRC_URI[x86_64_v2_golang-github-valyala-fasttemplate-devel.sha256sum] = "7f825e2f8cc913b5fc351c34dfded9029d1cd3436a562d892f8712e263adab49"

URI_aarch64_golang-github-valyala-fasttemplate-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-valyala-fasttemplate-devel-1.2.1-12.el10_0.noarch.rpm;name=aarch64_golang-github-valyala-fasttemplate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-valyala-fasttemplate-devel}"
SRC_URI[aarch64_golang-github-valyala-fasttemplate-devel.sha256sum] = "3a8f816c412f748251f1b9464ac48e44d1e8116ef296a0c8b2a8deb2e2afbcf7"

RDEPENDS:golang-github-valyala-fasttemplate-devel = " \
 go-filesystem \
 golang-github-valyala-bytebufferpool-devel \
 "
