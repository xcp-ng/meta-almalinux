# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdb"
PV = "16.3"
PR = "2.el10"
PACKAGES = " \
 gdb \
 gdb-doc \
 gdb-gdbserver \
 gdb-headless \
 gdb-minimal \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdb-16.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fabe86e3c2a4976714d4e6c1068dfc06aba7b967cd88f07ea8f7d768f432dcd5"

URI_x86_64_v2_gdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-16.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_gdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdb}"
SRC_URI[x86_64_v2_gdb.sha256sum] = "1b395dfc64e0263c2cb0935af3182b02bf93c40c1095e7dd9409a07cd8a17377"

URI_x86_64_v2_gdb-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-doc-16.3-2.el10.noarch.rpm;name=x86_64_v2_gdb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdb-doc}"
SRC_URI[x86_64_v2_gdb-doc.sha256sum] = "3793107527d4bb85de913a3719f2453f722f1ed39e0e8c492d24ee8f8d91c763"

URI_x86_64_v2_gdb-gdbserver = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-gdbserver-16.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_gdb-gdbserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdb-gdbserver}"
SRC_URI[x86_64_v2_gdb-gdbserver.sha256sum] = "32fbd5a7b6c51cd8a4affce9abb6f7c979252cc97549c31a1938c3599c40188b"

URI_x86_64_v2_gdb-headless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-headless-16.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_gdb-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdb-headless}"
SRC_URI[x86_64_v2_gdb-headless.sha256sum] = "661033f615695d45e49a8de7e17058e1b6a139b2125ee525e8a0e0eaf48de441"
RPROVIDES:gdb-headless:x86_64_v2 = "virtual//usr/bin/gdb-add-index"

URI_x86_64_v2_gdb-minimal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-minimal-16.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_gdb-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdb-minimal}"
SRC_URI[x86_64_v2_gdb-minimal.sha256sum] = "e50e92616556855af7dfb1e268b4063bb4407f4478dd70669bc1f22dd8d928b5"
RPROVIDES:gdb-minimal:x86_64_v2 = "virtual//usr/bin/gdb-add-index"

URI_aarch64_gdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-16.3-2.el10.aarch64.rpm;name=aarch64_gdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdb}"
SRC_URI[aarch64_gdb.sha256sum] = "6e2bc718fad5ade8541e65c47695dfa2a668bb81895a86b60914ebad61746983"

URI_aarch64_gdb-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-doc-16.3-2.el10.noarch.rpm;name=aarch64_gdb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdb-doc}"
SRC_URI[aarch64_gdb-doc.sha256sum] = "3793107527d4bb85de913a3719f2453f722f1ed39e0e8c492d24ee8f8d91c763"

URI_aarch64_gdb-gdbserver = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-gdbserver-16.3-2.el10.aarch64.rpm;name=aarch64_gdb-gdbserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdb-gdbserver}"
SRC_URI[aarch64_gdb-gdbserver.sha256sum] = "fbf99216309f0df391bbbe08e3712985c6291c38ead9c22194f67acc9844d670"

URI_aarch64_gdb-headless = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-headless-16.3-2.el10.aarch64.rpm;name=aarch64_gdb-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdb-headless}"
SRC_URI[aarch64_gdb-headless.sha256sum] = "3ac2a586cd632fc00856edfb241c2eb5c7dd5678bc3b7cff05df5263912fb68b"
RPROVIDES:gdb-headless:aarch64 = "virtual//usr/bin/gdb-add-index"

URI_aarch64_gdb-minimal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-minimal-16.3-2.el10.aarch64.rpm;name=aarch64_gdb-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdb-minimal}"
SRC_URI[aarch64_gdb-minimal.sha256sum] = "cbeb4e16fd8e410f2cb5f447bd4491b83571b7973e125fe89e09352e85476ff7"
RPROVIDES:gdb-minimal:aarch64 = "virtual//usr/bin/gdb-add-index"

RDEPENDS:gdb = " \
 bash \
 gdb-headless \
 "
RDEPENDS:gdb-doc = " \
 "
RDEPENDS:gdb-gdbserver = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gdb-headless:x86_64_v2 = " \
 bash \
 binutils \
 elfutils-debuginfod-client \
 expat \
 glibc \
 gmp \
 libbabeltrace \
 libgcc \
 libipt \
 libstdc++ \
 mpfr \
 ncurses-libs \
 python3-libs \
 readline \
 source-highlight \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:gdb-headless:aarch64 = " \
 bash \
 binutils \
 elfutils-debuginfod-client \
 expat \
 glibc \
 gmp \
 libbabeltrace \
 libgcc \
 libstdc++ \
 mpfr \
 ncurses-libs \
 python3-libs \
 readline \
 source-highlight \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:gdb-minimal = " \
 bash \
 elfutils-debuginfod-client \
 glibc \
 gmp \
 libgcc \
 libstdc++ \
 mpfr \
 ncurses-libs \
 readline \
 xz-libs \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/gdb-add-index"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/gdb-add-index"
