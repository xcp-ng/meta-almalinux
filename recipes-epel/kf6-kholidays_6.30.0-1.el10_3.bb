# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kholidays"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kholidays \
 kf6-kholidays-devel \
 kf6-kholidays-doc \
 kf6-kholidays-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kholidays-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "abcac5474ca29102e0cea9b84ef5274c227023f0ee09c1924a071a5173324056"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kholidays;unpack=0"
SRC_URI[x86_64_v2_kf6-kholidays.sha256sum] = "0b75c1b662eec9d772e69b98d4a8ee3f6ad6608d636c683d716eb2454f32e96a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kholidays-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kholidays-devel.sha256sum] = "3d5442e00c28a77fc6d5973a5ed0dbeec315b02cfdb1145c68b91cc4337ecb79"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kholidays-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kholidays-doc.sha256sum] = "cbf2850714782373e862ad46a8e61c01d8b315e8634e3ceff3dd1a4dc01a6cee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kholidays-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kholidays-html.sha256sum] = "20f358afe17ae7431b92c3da351d2c1f87d8bcad0c930c5c0cd3a43c6cd040f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kholidays;unpack=0"
SRC_URI[aarch64_kf6-kholidays.sha256sum] = "2aca575337101a3b1180dd1d332e79f504d791523754af70bb13cd37097fd307"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kholidays-devel;unpack=0"
SRC_URI[aarch64_kf6-kholidays-devel.sha256sum] = "5331a66091471132f5e1c35d7715f39ebea2bd0c3b4d96865d5bdc03b408cda3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kholidays-doc;unpack=0"
SRC_URI[aarch64_kf6-kholidays-doc.sha256sum] = "fab39432dd2432bdd877f1516f79afef6f9d3c061559acbddd07e73218aa8aed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kholidays-html;unpack=0"
SRC_URI[aarch64_kf6-kholidays-html.sha256sum] = "f43aadbbc1d9df3b436d1e75acb005532af704ea8318c77874b2365397f047ab"

RDEPENDS:kf6-kholidays = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kholidays-devel = " \
 cmake-filesystem \
 kf6-kholidays \
 "
RDEPENDS:kf6-kholidays-doc = " \
 "
RDEPENDS:kf6-kholidays-html = " \
 "
