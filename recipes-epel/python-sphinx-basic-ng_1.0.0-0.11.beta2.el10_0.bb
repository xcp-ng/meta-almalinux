# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-basic-ng"
PV = "1.0.0"
PR = "0.11.beta2.el10_0"
PACKAGES = " \
 python-sphinx-basic-ng-doc \
 python3-sphinx-basic-ng \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-basic-ng-1.0.0-0.11.beta2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3a243ec04fcf947a89fb881bf94ef7b4c0917cd7b712f70e4be4f8503454835"

URI_x86_64_v2_python-sphinx-basic-ng-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-sphinx-basic-ng-doc-1.0.0-0.11.beta2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-sphinx-basic-ng-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-sphinx-basic-ng-doc}"
SRC_URI[x86_64_v2_python-sphinx-basic-ng-doc.sha256sum] = "cd9921b031bd9a868e04c73486a6d21ce339f6fe03785a5ebf788a6703a0e545"

URI_x86_64_v2_python3-sphinx-basic-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-basic-ng-1.0.0-0.11.beta2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-basic-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-basic-ng}"
SRC_URI[x86_64_v2_python3-sphinx-basic-ng.sha256sum] = "e986a8a540e54c542046511f7806b2511b0065051e6b3830f314d8b666275bc3"

URI_aarch64_python-sphinx-basic-ng-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-sphinx-basic-ng-doc-1.0.0-0.11.beta2.el10_0.noarch.rpm;name=aarch64_python-sphinx-basic-ng-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-sphinx-basic-ng-doc}"
SRC_URI[aarch64_python-sphinx-basic-ng-doc.sha256sum] = "04c7c7ef4d0a26ddb1b8b788e7f16a885a9d4f0c50a3302576af4e5d2e9a37ce"

URI_aarch64_python3-sphinx-basic-ng = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-basic-ng-1.0.0-0.11.beta2.el10_0.noarch.rpm;name=aarch64_python3-sphinx-basic-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-basic-ng}"
SRC_URI[aarch64_python3-sphinx-basic-ng.sha256sum] = "4e8541cc2526670401c696784bd21a3095e6b6a2ad6c27d173a46fc4429c2ecd"

RDEPENDS:python-sphinx-basic-ng-doc = " \
 "
RDEPENDS:python3-sphinx-basic-ng = " \
 python3 \
 python3-sphinx \
 "
