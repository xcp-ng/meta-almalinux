# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-termion"
PV = "4.0.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-termion+default-devel \
 rust-termion+serde-devel \
 rust-termion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-termion-4.0.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c25418b473c74613674a9411c2de4535a50d8805087920849864a224c7bf5af"

URI_x86_64_v2_rust-termion+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termion+default-devel-4.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termion+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termion+default-devel}"
SRC_URI[x86_64_v2_rust-termion+default-devel.sha256sum] = "b78a119fcdf0e4d482643e0623ac7c43697872e944633b9b6ad7fc36b194b948"

URI_x86_64_v2_rust-termion+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termion+serde-devel-4.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termion+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termion+serde-devel}"
SRC_URI[x86_64_v2_rust-termion+serde-devel.sha256sum] = "0dca9173f8be07c7aa4d9d3c8a2d2f710e218751a415909d84ad54895a73d29a"

URI_x86_64_v2_rust-termion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termion-devel-4.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termion-devel}"
SRC_URI[x86_64_v2_rust-termion-devel.sha256sum] = "d5a34a092ee81c0488e80077991421bcb8d2fd874d843c8d2bc0e3bca4861368"

URI_aarch64_rust-termion+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termion+default-devel-4.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-termion+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termion+default-devel}"
SRC_URI[aarch64_rust-termion+default-devel.sha256sum] = "0ef0201302d9f3fa33d488c18fe12626a2d0ec7641fa2ce076926a9911a11781"

URI_aarch64_rust-termion+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termion+serde-devel-4.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-termion+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termion+serde-devel}"
SRC_URI[aarch64_rust-termion+serde-devel.sha256sum] = "f771f9a09b5072a9acbd62f7643a2e83d7c2e604f860ddd26561afa1682383ea"

URI_aarch64_rust-termion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termion-devel-4.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-termion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termion-devel}"
SRC_URI[aarch64_rust-termion-devel.sha256sum] = "264f5789bcc9c91f98966a793623a0d0c2d3f354b62f70a3300c8a85f492c02d"

RDEPENDS:rust-termion+default-devel = " \
 cargo \
 rust-termion-devel \
 "
RDEPENDS:rust-termion+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-termion-devel \
 "
RDEPENDS:rust-termion-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-numtoa+default-devel \
 "
