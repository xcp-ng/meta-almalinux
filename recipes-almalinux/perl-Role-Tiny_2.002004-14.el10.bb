# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Role-Tiny"
PV = "2.002004"
PR = "14.el10"
PACKAGES = " \
 perl-Role-Tiny \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Role-Tiny-2.002004-14.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a57ef9a627679473d671897ebadd4a3cbd8f2fe0a36482c08ff4bae1c04ef01f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Role-Tiny-2.002004-14.el10.noarch.rpm;name=x86_64_v2_perl-Role-Tiny;unpack=0"
SRC_URI[x86_64_v2_perl-Role-Tiny.sha256sum] = "afcfcba8a92363855d47d0746a69623015f33283f572855381d4c79a6b3d74a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Role-Tiny-2.002004-14.el10.noarch.rpm;name=aarch64_perl-Role-Tiny;unpack=0"
SRC_URI[aarch64_perl-Role-Tiny.sha256sum] = "afcfcba8a92363855d47d0746a69623015f33283f572855381d4c79a6b3d74a1"

RDEPENDS:perl-Role-Tiny = " \
 perl-Carp \
 perl-Class-Method-Modifiers \
 perl-Exporter \
 perl-Role-Tiny \
 perl-libs \
 perl-mro \
 "
