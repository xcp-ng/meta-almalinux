# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtserialbus"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtserialbus \
 qt5-qtserialbus-devel \
 qt5-qtserialbus-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtserialbus-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b2f666af27f91dc147fa0f0cc490192dcf4f88fd3df7c18498406b3bf37f810"

URI_x86_64_v2_qt5-qtserialbus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialbus-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialbus}"
SRC_URI[x86_64_v2_qt5-qtserialbus.sha256sum] = "f573a5b00d4bb4948f1bd1582fea6cbf8d53e739722c49f2f9165a049c80b400"

URI_x86_64_v2_qt5-qtserialbus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialbus-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialbus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialbus-devel}"
SRC_URI[x86_64_v2_qt5-qtserialbus-devel.sha256sum] = "db3522ecbaada44d1c05d62ff1e3b844d682ddb8565b2e95fd966f25ae5ca17b"

URI_x86_64_v2_qt5-qtserialbus-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialbus-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialbus-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialbus-examples}"
SRC_URI[x86_64_v2_qt5-qtserialbus-examples.sha256sum] = "6c3f76347a30a6e1d692db3b2327fe755a5a42df0f93cbca4439ed6d37f42932"

URI_aarch64_qt5-qtserialbus = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialbus-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtserialbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialbus}"
SRC_URI[aarch64_qt5-qtserialbus.sha256sum] = "37577331ab49d65360c212528cc5eb861988d7f3af8029bc66d4f9440accbc08"

URI_aarch64_qt5-qtserialbus-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialbus-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtserialbus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialbus-devel}"
SRC_URI[aarch64_qt5-qtserialbus-devel.sha256sum] = "9bb05b138f5f53c63747192948bea9ce11660fc510012497d410cf40230e40f1"

URI_aarch64_qt5-qtserialbus-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialbus-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtserialbus-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialbus-examples}"
SRC_URI[aarch64_qt5-qtserialbus-examples.sha256sum] = "fb1ad72bd7986200479e4aea83ee0e057e90bd5074957faf7d8f4b64b665ce6e"

RDEPENDS:qt5-qtserialbus = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtserialport \
 "
RDEPENDS:qt5-qtserialbus-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtserialbus \
 "
RDEPENDS:qt5-qtserialbus-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtserialbus \
 qt5-qtserialport \
 "
