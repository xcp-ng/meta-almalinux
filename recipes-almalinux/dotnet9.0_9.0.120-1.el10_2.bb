# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet9.0"
PV = "9.0.120"
PR = "1.el10_2"
PACKAGES = " \
 aspnetcore-runtime-9.0 \
 aspnetcore-runtime-dbg-9.0 \
 aspnetcore-targeting-pack-9.0 \
 dotnet-apphost-pack-9.0 \
 dotnet-hostfxr-9.0 \
 dotnet-runtime-9.0 \
 dotnet-runtime-dbg-9.0 \
 dotnet-sdk-9.0 \
 dotnet-sdk-9.0-source-built-artifacts \
 dotnet-sdk-aot-9.0 \
 dotnet-sdk-dbg-9.0 \
 dotnet-targeting-pack-9.0 \
 dotnet-templates-9.0 \
 netstandard-targeting-pack-2.1 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet9.0-9.0.120-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1318145a11be0146b2537d7a5dcd2f287bc6cccc777c32c9f521f2470cc1664"

URI_x86_64_v2_aspnetcore-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-9.0-9.0.19-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-9.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-9.0.sha256sum] = "4c222f8dd142ee7502f9be9cf153ad5489c8d1d87fde7aa927389016281cf2da"

URI_x86_64_v2_aspnetcore-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-9.0-9.0.19-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-dbg-9.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-9.0.sha256sum] = "cef07f76b4e688d12bae5e16d157c42006e6ece8f08e7843225589df7a8a21f7"

URI_x86_64_v2_aspnetcore-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-9.0-9.0.19-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-targeting-pack-9.0}"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-9.0.sha256sum] = "60af7b9d8bbc689987b1439a4c2111036a25201447efd11c646ccca7dd1c89d8"

URI_x86_64_v2_dotnet-apphost-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-9.0-9.0.19-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-apphost-pack-9.0}"
SRC_URI[x86_64_v2_dotnet-apphost-pack-9.0.sha256sum] = "200979506e5d861b1e10e064085576e73a7bdae7e119c8dce2d706e7638e1ffd"

URI_x86_64_v2_dotnet-hostfxr-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-9.0-9.0.19-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-hostfxr-9.0}"
SRC_URI[x86_64_v2_dotnet-hostfxr-9.0.sha256sum] = "6fa167235def586b335033c6263e0dbec99200a8129860a3cce397280e250e04"

URI_x86_64_v2_dotnet-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-9.0-9.0.19-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-9.0}"
SRC_URI[x86_64_v2_dotnet-runtime-9.0.sha256sum] = "8a4ded8d22449715374a75f02f5947d9ecdd842eba9c189308765fc0db602190"

URI_x86_64_v2_dotnet-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-9.0-9.0.19-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-dbg-9.0}"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-9.0.sha256sum] = "7feb712424edda5529f861cebfb8cd6ac9844ffdb3048a2575f4b267b70814f1"

URI_x86_64_v2_dotnet-sdk-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-9.0-9.0.120-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-9.0}"
SRC_URI[x86_64_v2_dotnet-sdk-9.0.sha256sum] = "a534e36f13eea76baf244db154170d07ef9980c00fc5fb21c27963c23cebd3d1"

URI_x86_64_v2_dotnet-sdk-9.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-9.0-source-built-artifacts-9.0.120-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-9.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-9.0-source-built-artifacts}"
SRC_URI[x86_64_v2_dotnet-sdk-9.0-source-built-artifacts.sha256sum] = "5fbe16b996ae4b2287d482540aa2e46d67b14ff0566ec6a8839b171811e04ff8"

URI_x86_64_v2_dotnet-sdk-aot-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-aot-9.0-9.0.120-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-aot-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-aot-9.0}"
SRC_URI[x86_64_v2_dotnet-sdk-aot-9.0.sha256sum] = "d3c478c3d375580b36ded0ba1efe91639daceeaad2d86be04b845205446af1aa"

URI_x86_64_v2_dotnet-sdk-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-9.0-9.0.120-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-dbg-9.0}"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-9.0.sha256sum] = "462309574177d65426996ee518964948cbcc28afdaaab9f489e801f5a005091c"

URI_x86_64_v2_dotnet-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-9.0-9.0.19-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-targeting-pack-9.0}"
SRC_URI[x86_64_v2_dotnet-targeting-pack-9.0.sha256sum] = "b3c0207b79674ed4a2d9aba2683c4d61d589ae003e641a3db4b9604e46c7999e"

URI_x86_64_v2_dotnet-templates-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-9.0-9.0.120-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-templates-9.0}"
SRC_URI[x86_64_v2_dotnet-templates-9.0.sha256sum] = "da99db32e8ea57334fb4f9bda52b8735cf315de464366c5d937dca894e69024c"

URI_x86_64_v2_netstandard-targeting-pack-2.1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/netstandard-targeting-pack-2.1-9.0.120-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_netstandard-targeting-pack-2.1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netstandard-targeting-pack-2.1}"
SRC_URI[x86_64_v2_netstandard-targeting-pack-2.1.sha256sum] = "2852cfafb1cc6b0de5598a3afd6c21c5082a1ce3c76226c5946b9c2b7a80b95d"

URI_aarch64_aspnetcore-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-9.0-9.0.19-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-9.0}"
SRC_URI[aarch64_aspnetcore-runtime-9.0.sha256sum] = "a28e308339b081e787117e4fcb9264dafc4dec581d500dd2d71efafce1c6d1ed"

URI_aarch64_aspnetcore-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-9.0-9.0.19-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-dbg-9.0}"
SRC_URI[aarch64_aspnetcore-runtime-dbg-9.0.sha256sum] = "a10cb48a6ea693acc1b80741ed4c1f991e27255817c00c2091c0d48d4e3cb0ea"

URI_aarch64_aspnetcore-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-9.0-9.0.19-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-targeting-pack-9.0}"
SRC_URI[aarch64_aspnetcore-targeting-pack-9.0.sha256sum] = "53875b8cbf1ae6045b9cded945f88c8f7f4be7a48828c7c26911bb96dd3669f4"

URI_aarch64_dotnet-apphost-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-9.0-9.0.19-1.el10_2.aarch64.rpm;name=aarch64_dotnet-apphost-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-apphost-pack-9.0}"
SRC_URI[aarch64_dotnet-apphost-pack-9.0.sha256sum] = "e46e8f6d9f104e8d8c94ec251539750835f415550cbdb4610f661a2fd2a8891f"

URI_aarch64_dotnet-hostfxr-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-9.0-9.0.19-1.el10_2.aarch64.rpm;name=aarch64_dotnet-hostfxr-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-hostfxr-9.0}"
SRC_URI[aarch64_dotnet-hostfxr-9.0.sha256sum] = "772f213fbe46beab817544c5f951228f9ef8dec9e0961408e61b91fb327c7ac1"

URI_aarch64_dotnet-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-9.0-9.0.19-1.el10_2.aarch64.rpm;name=aarch64_dotnet-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-9.0}"
SRC_URI[aarch64_dotnet-runtime-9.0.sha256sum] = "643bfba615c8e751dcc82a53daaae4b65fe4524b5e6c34ed1016166d792e159c"

URI_aarch64_dotnet-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-9.0-9.0.19-1.el10_2.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-dbg-9.0}"
SRC_URI[aarch64_dotnet-runtime-dbg-9.0.sha256sum] = "b1b57502c08b5308f0f80c352dcd6a156e1a6a9f63aeb8a021b919657272fe74"

URI_aarch64_dotnet-sdk-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-9.0-9.0.120-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-9.0}"
SRC_URI[aarch64_dotnet-sdk-9.0.sha256sum] = "92d40eec71f92c54c0c9684e4b05fa77a0a6b57da4a9ebe31eb77d2703ca18ef"

URI_aarch64_dotnet-sdk-9.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-9.0-source-built-artifacts-9.0.120-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-9.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-9.0-source-built-artifacts}"
SRC_URI[aarch64_dotnet-sdk-9.0-source-built-artifacts.sha256sum] = "a7dcce4af3edfb3ad1182b4aa527b46e91a44e796aa53318857d9a454970b563"

URI_aarch64_dotnet-sdk-aot-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-aot-9.0-9.0.120-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-aot-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-aot-9.0}"
SRC_URI[aarch64_dotnet-sdk-aot-9.0.sha256sum] = "a41720b63515e120a5c4b51d414d094ece4cedbce62c53121146d3552c4c7df7"

URI_aarch64_dotnet-sdk-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-9.0-9.0.120-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-dbg-9.0}"
SRC_URI[aarch64_dotnet-sdk-dbg-9.0.sha256sum] = "ebe8c35978af10f5b4ccb164ab7c7fb5b08837fa21c1a07f0df07a43b95e391e"

URI_aarch64_dotnet-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-9.0-9.0.19-1.el10_2.aarch64.rpm;name=aarch64_dotnet-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-targeting-pack-9.0}"
SRC_URI[aarch64_dotnet-targeting-pack-9.0.sha256sum] = "f102a808afdcdb7d0b3b57250e809a5fc8487b1690bf633f7c083ddbd8f6e68c"

URI_aarch64_dotnet-templates-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-9.0-9.0.120-1.el10_2.aarch64.rpm;name=aarch64_dotnet-templates-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-templates-9.0}"
SRC_URI[aarch64_dotnet-templates-9.0.sha256sum] = "c2dd9b8946f0bbdadab02d466766215edcf610b688e0fa2e1c06cd31f84dbeac"

URI_aarch64_netstandard-targeting-pack-2.1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/netstandard-targeting-pack-2.1-9.0.120-1.el10_2.aarch64.rpm;name=aarch64_netstandard-targeting-pack-2.1;unpack=0"
SRC_URI:append = " ${URI_aarch64_netstandard-targeting-pack-2.1}"
SRC_URI[aarch64_netstandard-targeting-pack-2.1.sha256sum] = "c7e46aa942c2d225dc75283fdc7712a27124e488854c97d49f32b53001d0b505"

RDEPENDS:aspnetcore-runtime-9.0 = " \
 dotnet-runtime-9.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-9.0 = " \
 aspnetcore-runtime-9.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-9.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-9.0 = " \
 dotnet-host \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-hostfxr-9.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-9.0 = " \
 dotnet-hostfxr-9.0 \
 glibc \
 libbrotli \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-9.0 = " \
 dotnet-runtime-9.0 \
 "
RDEPENDS:dotnet-sdk-9.0 = " \
 aspnetcore-runtime-9.0 \
 aspnetcore-targeting-pack-9.0 \
 dotnet-apphost-pack-9.0 \
 dotnet-runtime-9.0 \
 dotnet-targeting-pack-9.0 \
 dotnet-templates-9.0 \
 glibc \
 libgcc \
 libstdc++ \
 netstandard-targeting-pack-2.1 \
 "
RDEPENDS:dotnet-sdk-9.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-aot-9.0 = " \
 bash \
 brotli-devel \
 clang \
 dotnet-sdk-9.0 \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-devel \
 openssl-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:dotnet-sdk-dbg-9.0 = " \
 dotnet-sdk-9.0 \
 "
RDEPENDS:dotnet-targeting-pack-9.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-9.0 = " \
 dotnet-host \
 "
RDEPENDS:netstandard-targeting-pack-2.1 = " \
 dotnet-host \
 "
