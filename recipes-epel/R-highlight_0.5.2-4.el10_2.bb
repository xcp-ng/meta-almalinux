# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-highlight"
PV = "0.5.2"
PR = "4.el10_2"
PACKAGES = " \
 R-highlight \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-highlight-0.5.2-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80c52ad7e8ce088ff41e570175b57b921076a1d84fee4479751fb3688e11c1c8"

URI_x86_64_v2_R-highlight = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-highlight-0.5.2-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-highlight;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-highlight}"
SRC_URI[x86_64_v2_R-highlight.sha256sum] = "36bd3d0e1f9044f9b208cd9dad3740638055f253dbd338e3c611e8e61ecd0f63"

URI_aarch64_R-highlight = "${EPEL_MIRROR}/aarch64/Packages/r/R-highlight-0.5.2-4.el10_2.aarch64.rpm;name=aarch64_R-highlight;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-highlight}"
SRC_URI[aarch64_R-highlight.sha256sum] = "cc52cb47cddabddae449455a33e5c8840c8df4cb27642ee0fd8c5c070237fbad"

RDEPENDS:R-highlight = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 "
