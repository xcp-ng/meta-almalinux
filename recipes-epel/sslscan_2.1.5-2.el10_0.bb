# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sslscan"
PV = "2.1.5"
PR = "2.el10_0"
PACKAGES = " \
 sslscan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sslscan-2.1.5-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7c0a0ae8164b56b4b2a85b0200bb54bf8e7c0a5318eb73813e511fd90a67421"

URI_x86_64_v2_sslscan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sslscan-2.1.5-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sslscan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sslscan}"
SRC_URI[x86_64_v2_sslscan.sha256sum] = "a51eb65a9d1ac5d73d5738620383d77e4cfdc9d4ceed666201c79624975607d7"

URI_aarch64_sslscan = "${EPEL_MIRROR}/aarch64/Packages/s/sslscan-2.1.5-2.el10_0.aarch64.rpm;name=aarch64_sslscan;unpack=0"
SRC_URI:append = " ${URI_aarch64_sslscan}"
SRC_URI[aarch64_sslscan.sha256sum] = "cc9dcdcb19d1f4af339019d4542c6a80e3a171addad98b9a61ba7d3980d2ee8c"

RDEPENDS:sslscan = " \
 glibc \
 zlib-ng-compat \
 "
