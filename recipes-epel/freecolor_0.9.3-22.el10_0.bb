# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freecolor"
PV = "0.9.3"
PR = "22.el10_0"
PACKAGES = " \
 freecolor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/freecolor-0.9.3-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47faa601fce1e4c44cbf0ee2fcbb52942c254902bb614bb8cc3f90a4da06e924"

URI_x86_64_v2_freecolor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freecolor-0.9.3-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freecolor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freecolor}"
SRC_URI[x86_64_v2_freecolor.sha256sum] = "d8ec6bfa02413a00082562a148378ffa1d4ca50a94ab6a539bf1d302a7a15caf"

URI_aarch64_freecolor = "${EPEL_MIRROR}/aarch64/Packages/f/freecolor-0.9.3-22.el10_0.aarch64.rpm;name=aarch64_freecolor;unpack=0"
SRC_URI:append = " ${URI_aarch64_freecolor}"
SRC_URI[aarch64_freecolor.sha256sum] = "24c2e72b6da32fa370f79df019f7acd3a15c69bc24391b218ddcfbf509d95f75"

RDEPENDS:freecolor = " \
 glibc \
 "
