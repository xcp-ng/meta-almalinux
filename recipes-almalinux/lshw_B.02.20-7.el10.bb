# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lshw"
PV = "B.02.20"
PR = "7.el10"
PACKAGES = " \
 lshw \
 lshw-gui \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lshw-B.02.20-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "980ff33e5127cb33e62b7e803ddd25b567038f0d14b9a9a68048e85228c85942"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lshw-B.02.20-7.el10.x86_64_v2.rpm;name=x86_64_v2_lshw;unpack=0"
SRC_URI[x86_64_v2_lshw.sha256sum] = "20a3ff167a63661415e2d849cb0ca388bd11e36e37a610812c3429cb618e25f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lshw-gui-B.02.20-7.el10.x86_64_v2.rpm;name=x86_64_v2_lshw-gui;unpack=0"
SRC_URI[x86_64_v2_lshw-gui.sha256sum] = "964e94a509120dff1f6ba88c20a4f12881e1d638080676a151f6dfacbc50639d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lshw-B.02.20-7.el10.aarch64.rpm;name=aarch64_lshw;unpack=0"
SRC_URI[aarch64_lshw.sha256sum] = "44c0b0c8b83b0ebb785e301a5c0f079a51814e1e20db4191002d19076ae57f1d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lshw-gui-B.02.20-7.el10.aarch64.rpm;name=aarch64_lshw-gui;unpack=0"
SRC_URI[aarch64_lshw-gui.sha256sum] = "bf9efefe6ab1bfc6486b54c3f2a10b95fcc108da14c4d16c6b256867b865f5d1"

RDEPENDS:lshw = " \
 glibc \
 hwdata \
 libgcc \
 libstdc++ \
 sqlite-libs \
 "
RDEPENDS:lshw-gui = " \
 bash \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libgcc \
 libstdc++ \
 lshw \
 polkit \
 sqlite-libs \
 "
