# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinxygen"
PV = "1.0.10"
PR = "1.el10_0"
PACKAGES = " \
 python3-sphinxygen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinxygen-1.0.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb77f608dcb3d3171d191288e0c04fbfd39708c329eb43f25b035912ee0af7e7"

URI_x86_64_v2_python3-sphinxygen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinxygen-1.0.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinxygen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinxygen}"
SRC_URI[x86_64_v2_python3-sphinxygen.sha256sum] = "5b07199698cdc410520ebf17020a044b6f40098ca2cef6044d54d19a5c6dcca8"

URI_aarch64_python3-sphinxygen = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinxygen-1.0.10-1.el10_0.noarch.rpm;name=aarch64_python3-sphinxygen;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinxygen}"
SRC_URI[aarch64_python3-sphinxygen.sha256sum] = "3c29312f851aafc4ac1aba3f93f40cbd46301c8f5e2c4c28cfc9ee4f14da1f5b"

RDEPENDS:python3-sphinxygen = " \
 python3 \
 "
