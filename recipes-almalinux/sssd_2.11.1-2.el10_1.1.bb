# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sssd"
PV = "2.11.1"
PR = "2.el10_1.1"
PACKAGES = " \
 libipa_hbac \
 libsss_autofs \
 libsss_certmap \
 libsss_idmap \
 libsss_nss_idmap \
 libsss_nss_idmap-devel \
 libsss_sudo \
 python3-libipa_hbac \
 python3-libsss_nss_idmap \
 python3-sss \
 python3-sss-murmur \
 python3-sssdconfig \
 sssd \
 sssd-ad \
 sssd-client \
 sssd-common \
 sssd-common-pac \
 sssd-dbus \
 sssd-idp \
 sssd-ipa \
 sssd-kcm \
 sssd-krb5 \
 sssd-krb5-common \
 sssd-ldap \
 sssd-nfs-idmap \
 sssd-passkey \
 sssd-proxy \
 sssd-tools \
 sssd-winbind-idmap \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sssd-2.11.1-2.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e12a279ff48ba67e1a6b3a4a2cd87831f0d85e84f0ade59d078ecaf981fd1636"

URI_x86_64_v2_libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libipa_hbac-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libipa_hbac}"
SRC_URI[x86_64_v2_libipa_hbac.sha256sum] = "8a5729f4c8006d9a9b702ab002197691fdd93298e232b9606be504b840d82950"

URI_x86_64_v2_libsss_autofs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_autofs-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_libsss_autofs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_autofs}"
SRC_URI[x86_64_v2_libsss_autofs.sha256sum] = "81abde14dbc91232fa9c993707b531f810ec4f33b00b249c228881537360c72d"

URI_x86_64_v2_libsss_certmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_certmap-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_libsss_certmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_certmap}"
SRC_URI[x86_64_v2_libsss_certmap.sha256sum] = "9650ef862ed79ce5c5bc091ed2498699d24e4d5df6c4b9f462a3849a1a545c2a"

URI_x86_64_v2_libsss_idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_idmap-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_libsss_idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_idmap}"
SRC_URI[x86_64_v2_libsss_idmap.sha256sum] = "cfee15d19ef71b503e5090d0e0d627dd81fb6bebb43895cceda1dde8cf5cf7af"

URI_x86_64_v2_libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_nss_idmap-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_nss_idmap}"
SRC_URI[x86_64_v2_libsss_nss_idmap.sha256sum] = "b38a25584a4f13297f5a0bedb3efc527c2e28219f14f5ca996f0a890802fe646"

URI_x86_64_v2_libsss_nss_idmap-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsss_nss_idmap-devel-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_libsss_nss_idmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_nss_idmap-devel}"
SRC_URI[x86_64_v2_libsss_nss_idmap-devel.sha256sum] = "ddd01e4cee37b0d936d5b9a21e9da6b98f674f1032a3fe152480c870fe227cc1"

URI_x86_64_v2_libsss_sudo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_sudo-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_libsss_sudo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_sudo}"
SRC_URI[x86_64_v2_libsss_sudo.sha256sum] = "166a5e15eabc1a53781eb951fed785f8b4ae8820b95fbfc19341f89f0e77cdc8"

URI_x86_64_v2_python3-libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libipa_hbac-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_python3-libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libipa_hbac}"
SRC_URI[x86_64_v2_python3-libipa_hbac.sha256sum] = "f834f63ac8c0ea2713eb55cb6c6172cdc4618a060a33debc6f6cf1e9fa861c4a"

URI_x86_64_v2_python3-libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libsss_nss_idmap-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_python3-libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libsss_nss_idmap}"
SRC_URI[x86_64_v2_python3-libsss_nss_idmap.sha256sum] = "421dfd33da34448162a7cc1a85c9ad0d08603db4f8da4dc4e47078202101e642"

URI_x86_64_v2_python3-sss = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-sss-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_python3-sss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sss}"
SRC_URI[x86_64_v2_python3-sss.sha256sum] = "2f5d0d10df99323250d45c74dd35e23be1b86a881c40153f35b972328d49cbff"

URI_x86_64_v2_python3-sss-murmur = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-sss-murmur-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_python3-sss-murmur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sss-murmur}"
SRC_URI[x86_64_v2_python3-sss-murmur.sha256sum] = "68141d03584a0f111c6a8274a7296fd1fdf1aa0ce5b6593de9748da73808bdbf"

URI_x86_64_v2_python3-sssdconfig = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-sssdconfig-2.11.1-2.el10_1.1.noarch.rpm;name=x86_64_v2_python3-sssdconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sssdconfig}"
SRC_URI[x86_64_v2_python3-sssdconfig.sha256sum] = "884edb41685a767d190dcb3001baac0be003acb46da98d3abc39ac3d2f37aeab"

URI_x86_64_v2_sssd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd}"
SRC_URI[x86_64_v2_sssd.sha256sum] = "8eb48d1a2ceee9e14958d7a9d542661298d4dd9abfa4ecc279895b1973486ab0"

URI_x86_64_v2_sssd-ad = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-ad-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-ad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-ad}"
SRC_URI[x86_64_v2_sssd-ad.sha256sum] = "279216f7545016b8e14ff46a8cf66aaf7a5a9f3245545d3574914288286d431a"

URI_x86_64_v2_sssd-client = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-client-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-client}"
SRC_URI[x86_64_v2_sssd-client.sha256sum] = "78738b2da9b4496c82402e05b4da482fa12ad33161a4c1cae8e39c777d627e0a"

URI_x86_64_v2_sssd-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-common-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-common}"
SRC_URI[x86_64_v2_sssd-common.sha256sum] = "bc7d3df720228a19bf1a40731fd3f4388490c9a998ae22868c051f0985aca532"

URI_x86_64_v2_sssd-common-pac = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-common-pac-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-common-pac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-common-pac}"
SRC_URI[x86_64_v2_sssd-common-pac.sha256sum] = "f0a3716162436c55e86ff94e5e0efadf58df5e8d691c51b77dcae00b1341119f"

URI_x86_64_v2_sssd-dbus = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-dbus-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-dbus}"
SRC_URI[x86_64_v2_sssd-dbus.sha256sum] = "8b13747c4a4ee8abd3350552595193c911d371ae0130fa44c18820cd0398cbf3"

URI_x86_64_v2_sssd-idp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sssd-idp-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-idp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-idp}"
SRC_URI[x86_64_v2_sssd-idp.sha256sum] = "9350afb00e42ae199a35e7940041859644bb6821b811e79f522d430a0ba41c04"

URI_x86_64_v2_sssd-ipa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-ipa-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-ipa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-ipa}"
SRC_URI[x86_64_v2_sssd-ipa.sha256sum] = "b704cfb2697abdbc282d1949c23ce8e709869aa9253d0266ba0a00d1bee444ed"

URI_x86_64_v2_sssd-kcm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-kcm-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-kcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-kcm}"
SRC_URI[x86_64_v2_sssd-kcm.sha256sum] = "922e6fe4a2fe8875d4613d6a50cd7c8ff7d62be2327dee47f1700e1901ee7c1b"

URI_x86_64_v2_sssd-krb5 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-krb5-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-krb5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-krb5}"
SRC_URI[x86_64_v2_sssd-krb5.sha256sum] = "b81824db86d48e1d75313963feb87bb0b93b4da250790bc4550ee3a23ea52ec7"

URI_x86_64_v2_sssd-krb5-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-krb5-common-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-krb5-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-krb5-common}"
SRC_URI[x86_64_v2_sssd-krb5-common.sha256sum] = "dc93232495fd697daa73f7b61837400d71aa5681a8722f02d20339b1efef181b"

URI_x86_64_v2_sssd-ldap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-ldap-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-ldap}"
SRC_URI[x86_64_v2_sssd-ldap.sha256sum] = "e0c5b5512c684d52b7204e7d02aa535a1ac3b247148e7b5736b1d6974ad717df"

URI_x86_64_v2_sssd-nfs-idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-nfs-idmap-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-nfs-idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-nfs-idmap}"
SRC_URI[x86_64_v2_sssd-nfs-idmap.sha256sum] = "cd18d2bbf7f304f4f537f9ca73de9a996dc3958412009e7712cf7f8f1134c999"

URI_x86_64_v2_sssd-passkey = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-passkey-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-passkey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-passkey}"
SRC_URI[x86_64_v2_sssd-passkey.sha256sum] = "a72a62f843e089c722660c58e712773bfda1bd398e46d3d4e94bdac8c823dee4"

URI_x86_64_v2_sssd-proxy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-proxy-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-proxy}"
SRC_URI[x86_64_v2_sssd-proxy.sha256sum] = "a09c42e7c4d2c66133ee097fb4acea36b50980fa02c465db484267d0400a3086"

URI_x86_64_v2_sssd-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-tools-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-tools}"
SRC_URI[x86_64_v2_sssd-tools.sha256sum] = "7d1d667fafc640f25543c4aa6d8afaebf7c2e49e79d135b2278267defd063b1c"

URI_x86_64_v2_sssd-winbind-idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-winbind-idmap-2.11.1-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_sssd-winbind-idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-winbind-idmap}"
SRC_URI[x86_64_v2_sssd-winbind-idmap.sha256sum] = "2603e1acdb26b671dcd96d10b6f6459c7bab18c5f078a10eecf901163338d2ce"

URI_aarch64_libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libipa_hbac-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_aarch64_libipa_hbac}"
SRC_URI[aarch64_libipa_hbac.sha256sum] = "f49adf346b37cfc86375568bec226e8eb68714fb6cc8a3907c9225870eb00ec8"

URI_aarch64_libsss_autofs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_autofs-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_libsss_autofs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_autofs}"
SRC_URI[aarch64_libsss_autofs.sha256sum] = "fa6f21343ea60249fdf8e3d9a462d3d6ed58850ccc78493bc3be1157281095ef"

URI_aarch64_libsss_certmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_certmap-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_libsss_certmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_certmap}"
SRC_URI[aarch64_libsss_certmap.sha256sum] = "812967dbb377d674cca81d0e2031c815a561e60bfd9faa7c7b91ef62fae59fc5"

URI_aarch64_libsss_idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_idmap-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_libsss_idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_idmap}"
SRC_URI[aarch64_libsss_idmap.sha256sum] = "a6ee656edcc693187f06d32ce844ab608b7fc95565ab797e951f42bc9151079c"

URI_aarch64_libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_nss_idmap-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_nss_idmap}"
SRC_URI[aarch64_libsss_nss_idmap.sha256sum] = "ad00bf86f45c8ed70d36d0e892c7fa837a421c2147133facf6f2a0c0b9205058"

URI_aarch64_libsss_nss_idmap-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsss_nss_idmap-devel-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_libsss_nss_idmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_nss_idmap-devel}"
SRC_URI[aarch64_libsss_nss_idmap-devel.sha256sum] = "3c37962ade31f96d56753974b8ba21afd92d8349c8013d96a7bf996c0c3655fa"

URI_aarch64_libsss_sudo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_sudo-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_libsss_sudo;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_sudo}"
SRC_URI[aarch64_libsss_sudo.sha256sum] = "2d9c658a5177438714b6efcbaecea0634192475a1ef018ed2011713e0badf963"

URI_aarch64_python3-libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libipa_hbac-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_python3-libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libipa_hbac}"
SRC_URI[aarch64_python3-libipa_hbac.sha256sum] = "441c81f14e5c51aa9df09a99596aa74f5d1d86ff1143fbbaa4d84d439a7e6f0d"

URI_aarch64_python3-libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libsss_nss_idmap-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_python3-libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libsss_nss_idmap}"
SRC_URI[aarch64_python3-libsss_nss_idmap.sha256sum] = "a0a3c98ca31d7730c9606039943dc952ea8cc9354344c69df19e524fad840b70"

URI_aarch64_python3-sss = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-sss-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_python3-sss;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sss}"
SRC_URI[aarch64_python3-sss.sha256sum] = "548755e329fc606bed9d4e729a238a84eb9e98a2363af715e3bad64b94f72314"

URI_aarch64_python3-sss-murmur = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-sss-murmur-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_python3-sss-murmur;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sss-murmur}"
SRC_URI[aarch64_python3-sss-murmur.sha256sum] = "77381a07f7e3f6532000fb4a724be8723c95464eddae4d45a7eb7639a83fe555"

URI_aarch64_python3-sssdconfig = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-sssdconfig-2.11.1-2.el10_1.1.noarch.rpm;name=aarch64_python3-sssdconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sssdconfig}"
SRC_URI[aarch64_python3-sssdconfig.sha256sum] = "884edb41685a767d190dcb3001baac0be003acb46da98d3abc39ac3d2f37aeab"

URI_aarch64_sssd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd}"
SRC_URI[aarch64_sssd.sha256sum] = "f512142820283c78e4a954aca2e7f4c2cb7dc7d387801ced0f7c219c9b5da0ef"

URI_aarch64_sssd-ad = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-ad-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-ad;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-ad}"
SRC_URI[aarch64_sssd-ad.sha256sum] = "43d04c4118b8e3e8104bd31025e5c00d8bd9084a615ac4938617f5ac11cdc9f5"

URI_aarch64_sssd-client = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-client-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-client}"
SRC_URI[aarch64_sssd-client.sha256sum] = "cf9f138024ea9a48f5c676be717a97473bb2eead6af2fb3c6d6a44e1d105d8c7"

URI_aarch64_sssd-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-common-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-common}"
SRC_URI[aarch64_sssd-common.sha256sum] = "7ced30814d214ac8da8ee67e9d16825e82fa8ad1853e3b90e55e6848da0cf352"

URI_aarch64_sssd-common-pac = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-common-pac-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-common-pac;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-common-pac}"
SRC_URI[aarch64_sssd-common-pac.sha256sum] = "c5a2b85d4c48f6e2a4b03fea9c8c55314f0da359a4a7455b5e4783c74af40db8"

URI_aarch64_sssd-dbus = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-dbus-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-dbus}"
SRC_URI[aarch64_sssd-dbus.sha256sum] = "615eb588226daf6e1247655151ffdbf9038ca63e94f7dfeaca6ff62799169d77"

URI_aarch64_sssd-idp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sssd-idp-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-idp;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-idp}"
SRC_URI[aarch64_sssd-idp.sha256sum] = "389b5945250576d5d697ffa19c3a7af1e92edf7ae71ec026c9b0518a7f28d12f"

URI_aarch64_sssd-ipa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-ipa-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-ipa;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-ipa}"
SRC_URI[aarch64_sssd-ipa.sha256sum] = "9946ade7b9db8501c112131c8f3f3e3add4c7f2e356b775769a0131014abf32d"

URI_aarch64_sssd-kcm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-kcm-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-kcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-kcm}"
SRC_URI[aarch64_sssd-kcm.sha256sum] = "f9a80fb9a37e25ec0068a3bbd661bce93050f2e9ecb2a6ab1f75fdc58e2f4907"

URI_aarch64_sssd-krb5 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-krb5-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-krb5;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-krb5}"
SRC_URI[aarch64_sssd-krb5.sha256sum] = "e508e9b71df1b38e9294c8646399853a7dedf173cab315286b2fe13150e2dc00"

URI_aarch64_sssd-krb5-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-krb5-common-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-krb5-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-krb5-common}"
SRC_URI[aarch64_sssd-krb5-common.sha256sum] = "3b754a3831012934547564943d7c4ceb644e904f5dfa990a92efc77cb4108964"

URI_aarch64_sssd-ldap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-ldap-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-ldap}"
SRC_URI[aarch64_sssd-ldap.sha256sum] = "75c80784de45e7f6b2d57ed0faf89cd5f926b08b7c168257723fb3dc48fa9b4b"

URI_aarch64_sssd-nfs-idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-nfs-idmap-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-nfs-idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-nfs-idmap}"
SRC_URI[aarch64_sssd-nfs-idmap.sha256sum] = "d5a19c4a1dc7487e82f5ff2c43215343a1f558cc48a9020229478d47cd347ddd"

URI_aarch64_sssd-passkey = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-passkey-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-passkey;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-passkey}"
SRC_URI[aarch64_sssd-passkey.sha256sum] = "b2f00d0bb0d476d7998746565efe67b2e1b6cad823920223771abe9b52bbfaee"

URI_aarch64_sssd-proxy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-proxy-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-proxy}"
SRC_URI[aarch64_sssd-proxy.sha256sum] = "d8b4577e76efc4c4dda0dbbf4b6b40b35485142b1b6c3a57957d07abce4344ec"

URI_aarch64_sssd-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-tools-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-tools}"
SRC_URI[aarch64_sssd-tools.sha256sum] = "301fcfc976604209a3e6ae4cd5e16d1e842b0704139b04d4bc24277a5ca82bfa"

URI_aarch64_sssd-winbind-idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-winbind-idmap-2.11.1-2.el10_1.1.aarch64.rpm;name=aarch64_sssd-winbind-idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-winbind-idmap}"
SRC_URI[aarch64_sssd-winbind-idmap.sha256sum] = "1c70abb47ed88706b0ed94b961b771b087fe96892a1caf688882c78527c3a65a"

RDEPENDS:libipa_hbac = " \
 glibc \
 libunistring \
 "
RDEPENDS:libsss_autofs = " \
 glibc \
 "
RDEPENDS:libsss_certmap = " \
 glibc \
 libtalloc \
 openssl-libs \
 "
RDEPENDS:libsss_idmap = " \
 glibc \
 libunistring \
 "
RDEPENDS:libsss_nss_idmap = " \
 glibc \
 "
RDEPENDS:libsss_nss_idmap-devel = " \
 libsss_nss_idmap \
 pkgconf-pkg-config \
 "
RDEPENDS:libsss_sudo = " \
 glibc \
 "
RDEPENDS:python3-libipa_hbac = " \
 glibc \
 libipa_hbac \
 libunistring \
 python3 \
 "
RDEPENDS:python3-libsss_nss_idmap = " \
 glibc \
 libsss_nss_idmap \
 python3 \
 "
RDEPENDS:python3-sss = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcap \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 python3 \
 sssd-common \
 systemd-libs \
 "
RDEPENDS:python3-sss-murmur = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-sssdconfig = " \
 python3 \
 "
RDEPENDS:sssd = " \
 shadow-utils \
 sssd-ad \
 sssd-common \
 sssd-ipa \
 sssd-krb5 \
 sssd-ldap \
 sssd-proxy \
 "
RDEPENDS:sssd-ad = " \
 cyrus-sasl-lib \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsmbclient \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
 "
RDEPENDS:sssd-client = " \
 alternatives \
 bash \
 glibc \
 krb5-libs \
 libcom_err \
 libsss_idmap \
 libsss_nss_idmap \
 libunistring \
 pam-libs \
 "
RDEPENDS:sssd-common = " \
 bash \
 c-ares \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libnl3 \
 libref_array \
 libselinux \
 libsss_autofs \
 libsss_certmap \
 libsss_idmap \
 libsss_sudo \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 p11-kit \
 pam-libs \
 pcre2 \
 popt \
 shadow-utils \
 sssd-client \
 sssd-nfs-idmap \
 systemd \
 systemd-libs \
 virtual/coreutils \
 "
RDEPENDS:sssd-common-pac = " \
 glibc \
 libldb \
 libselinux \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 popt \
 samba-client-libs \
 sssd-common \
 systemd-libs \
 "
RDEPENDS:sssd-dbus = " \
 bash \
 dbus-libs \
 glibc \
 libdhash \
 libldb \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 popt \
 sssd-common \
 systemd \
 systemd-libs \
 "
RDEPENDS:sssd-idp = " \
 glibc \
 jansson \
 krb5-libs \
 libcom_err \
 libjose \
 libtalloc \
 popt \
 sssd-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:sssd-ipa = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libipa_hbac \
 libldb \
 libref_array \
 libselinux \
 libsemanage \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
 "
RDEPENDS:sssd-kcm = " \
 bash \
 glibc \
 krb5-libs \
 libdhash \
 libldb \
 libselinux \
 libtalloc \
 libtevent \
 libuuid \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd \
 systemd-libs \
 "
RDEPENDS:sssd-krb5 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
 "
RDEPENDS:sssd-krb5-common = " \
 cyrus-sasl-gssapi \
 glibc \
 jansson \
 krb5-libs \
 libcap \
 libtalloc \
 popt \
 sssd-common \
 systemd-libs \
 "
RDEPENDS:sssd-ldap = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
 "
RDEPENDS:sssd-nfs-idmap = " \
 glibc \
 libnfsidmap \
 "
RDEPENDS:sssd-passkey = " \
 acl \
 glibc \
 jansson \
 krb5-libs \
 libcom_err \
 libfido2 \
 libtalloc \
 openssl-libs \
 popt \
 sssd-common \
 "
RDEPENDS:sssd-proxy = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcap \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pam-libs \
 pcre2 \
 popt \
 sssd-common \
 systemd-libs \
 "
RDEPENDS:sssd-tools = " \
 bash \
 glibc \
 libdhash \
 libldb \
 libref_array \
 libsss_certmap \
 libtalloc \
 pam-libs \
 popt \
 python3 \
 python3-sss \
 python3-sssdconfig \
 python3-systemd \
 sssd-common \
 sssd-dbus \
 "
RDEPENDS:sssd-winbind-idmap = " \
 glibc \
 libsss_idmap \
 libsss_nss_idmap \
 libtalloc \
 libunistring \
 "
