# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtwebchannel"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtwebchannel \
 qt5-qtwebchannel-devel \
 qt5-qtwebchannel-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtwebchannel-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb53a96af55e9f037bef7b2c6a31a8b1ee5f6b3087ae230aced5e68b4c3f4ea4"

URI_x86_64_v2_qt5-qtwebchannel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebchannel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebchannel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebchannel}"
SRC_URI[x86_64_v2_qt5-qtwebchannel.sha256sum] = "ca4a5c2d57af9204d8c25267d895dfcdc0a73d37a88245f8c989cb3f6171c631"

URI_x86_64_v2_qt5-qtwebchannel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebchannel-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebchannel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebchannel-devel}"
SRC_URI[x86_64_v2_qt5-qtwebchannel-devel.sha256sum] = "98b1f5a427901dc5378826910aaf4fea95a2e837a3f3366434fd464c33931de4"

URI_x86_64_v2_qt5-qtwebchannel-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebchannel-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebchannel-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebchannel-examples}"
SRC_URI[x86_64_v2_qt5-qtwebchannel-examples.sha256sum] = "3ab5720c1974dc9ee6f27f94a5eebb5bd46fe0982f1c4fb6f1ea61877b9aacb6"

URI_aarch64_qt5-qtwebchannel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebchannel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtwebchannel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebchannel}"
SRC_URI[aarch64_qt5-qtwebchannel.sha256sum] = "0363fc4c6aa33fcd27ec1581fd51b40a95822b8d427756e77a851a6ea049b6b2"

URI_aarch64_qt5-qtwebchannel-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebchannel-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtwebchannel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebchannel-devel}"
SRC_URI[aarch64_qt5-qtwebchannel-devel.sha256sum] = "eb292cf0eecd8aa86e220bfd3f9826b2c2d51eca8b16c02d0b836c03f82ed6ed"

URI_aarch64_qt5-qtwebchannel-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebchannel-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtwebchannel-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebchannel-examples}"
SRC_URI[aarch64_qt5-qtwebchannel-examples.sha256sum] = "763efe66937ff5620d3a9609ab44d3fbec6daa7d24642041a66dae4120ec667b"

RDEPENDS:qt5-qtwebchannel = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtwebchannel-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtwebchannel \
 "
RDEPENDS:qt5-qtwebchannel-examples = " \
 glibc \
 libstdc++ \
 nodejs \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtwebchannel \
 qt5-qtwebsockets \
 "
