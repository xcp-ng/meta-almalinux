# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "buildah"
PE = "2"
PV = "1.41.8"
PR = "2.el10_1"
PACKAGES = " \
 buildah \
 buildah-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/buildah-1.41.8-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f04f79e51d6d50b45cd74fe62a34c1d725b8b98b648fd3db6bd0327f9ecd31f"

URI_x86_64_v2_buildah = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/buildah-1.41.8-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_buildah;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_buildah}"
SRC_URI[x86_64_v2_buildah.sha256sum] = "d78241546caa5b7ff3208678579325a0b3b3507e3bcf515b54794a91ecaeba1c"

URI_x86_64_v2_buildah-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/buildah-tests-1.41.8-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_buildah-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_buildah-tests}"
SRC_URI[x86_64_v2_buildah-tests.sha256sum] = "d725b9a153b47e1086242ed22e204f5627a0a6271b3272e57cf2b968f8d03c80"

URI_aarch64_buildah = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/buildah-1.41.8-2.el10_1.aarch64.rpm;name=aarch64_buildah;unpack=0"
SRC_URI:append = " ${URI_aarch64_buildah}"
SRC_URI[aarch64_buildah.sha256sum] = "ea81262925a67ecf9d7f21ee6b3714184216bbade361a385ea70f17051ebb99a"

URI_aarch64_buildah-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/buildah-tests-1.41.8-2.el10_1.aarch64.rpm;name=aarch64_buildah-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_buildah-tests}"
SRC_URI[aarch64_buildah-tests.sha256sum] = "969371b8582169631ebdd67c5fb93e0c38b096935a4115322ac4c1ce8dac0483"

RDEPENDS:buildah = " \
 containers-common-extra \
 glibc \
 gpgme \
 libseccomp \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:buildah-tests = " \
 bash \
 buildah \
 bzip2 \
 git-daemon \
 glibc \
 golang \
 gpgme \
 httpd-tools \
 jq \
 libseccomp \
 nmap-ncat \
 openssl \
 podman \
 shadow-utils-subid \
 sqlite-libs \
 "
