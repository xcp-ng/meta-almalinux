# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libva-nvidia-driver"
PV = "0.0.18"
PR = "1.el10_2"
PACKAGES = " \
 libva-nvidia-driver \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libva-nvidia-driver-0.0.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7812f8a0a247781905ffcd973681e8580b10ffa727dc3ff5c6991b5b1af21dd0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libva-nvidia-driver-0.0.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libva-nvidia-driver;unpack=0"
SRC_URI[x86_64_v2_libva-nvidia-driver.sha256sum] = "bd5bdc3d94c4ba03c59bd62ef98e55463f352f4619d092eb9196c75d0da7f547"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libva-nvidia-driver-0.0.18-1.el10_2.aarch64.rpm;name=aarch64_libva-nvidia-driver;unpack=0"
SRC_URI[aarch64_libva-nvidia-driver.sha256sum] = "861c8b72f24b0f38ddea2c37868c6a242fb29d8a11ae5ae257640fd0ad853a2f"

RDEPENDS:libva-nvidia-driver = " \
 glibc \
 gstreamer1-plugins-bad-free-libs \
 libgcc \
 libglvnd-egl \
 "
