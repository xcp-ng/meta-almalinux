# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6ct"
PV = "0.9"
PR = "11.el10_0"
PACKAGES = " \
 qt6ct \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6ct-0.9-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2a7f7d596f8b5d14d1eb5fa726a57d358fb14f606715a62122b9f083ae859b3"

URI_x86_64_v2_qt6ct = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6ct-0.9-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6ct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6ct}"
SRC_URI[x86_64_v2_qt6ct.sha256sum] = "f6e1345dd1951f01511268fd9deafb4edf8e4d0b1458e14b5c643bc01d82f0a2"

URI_aarch64_qt6ct = "${EPEL_MIRROR}/aarch64/Packages/q/qt6ct-0.9-11.el10_0.aarch64.rpm;name=aarch64_qt6ct;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6ct}"
SRC_URI[aarch64_qt6ct.sha256sum] = "9128e2078703677e521636fb2620ef15f798a33178db532d68c701e00414b0e2"

RDEPENDS:qt6ct = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
