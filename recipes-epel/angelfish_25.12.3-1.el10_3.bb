# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "angelfish"
PV = "25.12.3"
PR = "1.el10_3"
PACKAGES = " \
 angelfish \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/angelfish-25.12.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3a95d737afe0a8c0abca062dd170e85ca0fdc45ee028c19a94047af0cf5f342"

URI_x86_64_v2_angelfish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/angelfish-25.12.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_angelfish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_angelfish}"
SRC_URI[x86_64_v2_angelfish.sha256sum] = "32e7550c6875e868b2907c005d68b79b53c6bd6c583cf1047d7b1d9eee94a339"

URI_aarch64_angelfish = "${EPEL_MIRROR}/aarch64/Packages/a/angelfish-25.12.3-1.el10_3.aarch64.rpm;name=aarch64_angelfish;unpack=0"
SRC_URI:append = " ${URI_aarch64_angelfish}"
SRC_URI[aarch64_angelfish.sha256sum] = "54b5e527c832317262bb295f097c158b67d4df32639abdff08d09a6cc418c70e"

RDEPENDS:angelfish = " \
 futuresql-qt6 \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kwindowsystem \
 kf6-purpose \
 kf6-qqc2-desktop-style \
 libgcc \
 libstdc++ \
 qcoro-qt6 \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 qt6-qtwebengine \
 "
