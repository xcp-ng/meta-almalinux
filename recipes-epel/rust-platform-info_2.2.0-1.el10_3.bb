# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-platform-info"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-platform-info+default-devel \
 rust-platform-info-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-platform-info-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "234dc85afff17c81514b933d999524113c3dbf73cb8954d92722a331d2677ba2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-platform-info+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-platform-info+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-platform-info+default-devel.sha256sum] = "5c0b396a66ad781f678ba90557204c452d4e86bed2145c3848e750f5e8f708bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-platform-info-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-platform-info-devel;unpack=0"
SRC_URI[x86_64_v2_rust-platform-info-devel.sha256sum] = "b3df7ea25e9dd8c275d00044c0671b58895e4ee21f2321e22efe5fc9ae539ce1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-platform-info+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-platform-info+default-devel;unpack=0"
SRC_URI[aarch64_rust-platform-info+default-devel.sha256sum] = "816fa8fd7fef3c4a728b28ac91097b22d236f3592842f7d1ebba297624ba0713"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-platform-info-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-platform-info-devel;unpack=0"
SRC_URI[aarch64_rust-platform-info-devel.sha256sum] = "7b2110f14a9e1f5f03850197fafc35c1f50aadcb5fc623acc5b5542d6ab5cd23"

RDEPENDS:rust-platform-info+default-devel = " \
 cargo \
 rust-platform-info-devel \
 "
RDEPENDS:rust-platform-info-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
