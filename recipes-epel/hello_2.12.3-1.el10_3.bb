# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hello"
PV = "2.12.3"
PR = "1.el10_3"
PACKAGES = " \
 hello \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hello-2.12.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf49285d6432ad6e8d6a0ed75ad20eaac6fba3cb6f7a3820f61a4f2a4c9bf76c"

URI_x86_64_v2_hello = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hello-2.12.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hello;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hello}"
SRC_URI[x86_64_v2_hello.sha256sum] = "27d52618bf8957de6de28eb93e1a3929b6a4bda71e19186e0bc118ff85c0dd71"

URI_aarch64_hello = "${EPEL_MIRROR}/aarch64/Packages/h/hello-2.12.3-1.el10_3.aarch64.rpm;name=aarch64_hello;unpack=0"
SRC_URI:append = " ${URI_aarch64_hello}"
SRC_URI[aarch64_hello.sha256sum] = "1e4976c83cfd39588533ef5d75a6bf46d841b68f924d51a2910eaed7d5d14ca8"

RDEPENDS:hello = " \
 glibc \
 "
