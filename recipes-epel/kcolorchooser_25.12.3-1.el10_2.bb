# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcolorchooser"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kcolorchooser \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcolorchooser-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "240754a87cf15525df6d6d3fd9b2ceaafe5c0d3d6c2d33a7b6c50d0afd50471b"

URI_x86_64_v2_kcolorchooser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcolorchooser-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcolorchooser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcolorchooser}"
SRC_URI[x86_64_v2_kcolorchooser.sha256sum] = "ea25ee5a436bd0d1f2ca0e7c00f6ffa9a62b3a4309bf2e2e5c950c0e67de0212"

URI_aarch64_kcolorchooser = "${EPEL_MIRROR}/aarch64/Packages/k/kcolorchooser-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kcolorchooser;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcolorchooser}"
SRC_URI[aarch64_kcolorchooser.sha256sum] = "d9507df30a5275ee4cdd202b1fc9945c39440e3831be2768002102752106f47f"

RDEPENDS:kcolorchooser = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
