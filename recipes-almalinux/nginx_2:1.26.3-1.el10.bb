# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx"
PE = "2"
PV = "1.26.3"
PR = "1.el10"
PACKAGES = " \
 nginx \
 nginx-all-modules \
 nginx-core \
 nginx-filesystem \
 nginx-mod-devel \
 nginx-mod-http-image-filter \
 nginx-mod-http-perl \
 nginx-mod-http-xslt-filter \
 nginx-mod-mail \
 nginx-mod-stream \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nginx-1.26.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f65c9da51df25408d5c6869ad6428430d8466d756f69db5f63c06f67178e29ae"

URI_x86_64_v2_nginx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-1.26.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx}"
SRC_URI[x86_64_v2_nginx.sha256sum] = "9016c02d498b0f4cc3e2ee8cf977815464f2846d5987216a1b1b6c4c87e4d700"
RPROVIDES:nginx:x86_64_v2 = "virtual/httpd_or_nginx virtual/webserver"

URI_x86_64_v2_nginx-all-modules = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-all-modules-1.26.3-1.el10.noarch.rpm;name=x86_64_v2_nginx-all-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-all-modules}"
SRC_URI[x86_64_v2_nginx-all-modules.sha256sum] = "f4948f1a6d238656fd0b33b46a619344316507808459be0edb0200c18c636f31"

URI_x86_64_v2_nginx-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-core-1.26.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-core}"
SRC_URI[x86_64_v2_nginx-core.sha256sum] = "2007e5e7169f1ae432e3f5e10ca2bba535e7fb49692626a5155d59a6c297a65c"

URI_x86_64_v2_nginx-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-filesystem-1.26.3-1.el10.noarch.rpm;name=x86_64_v2_nginx-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-filesystem}"
SRC_URI[x86_64_v2_nginx-filesystem.sha256sum] = "ab05f6d7b541261a74c072bb572662581ee467da797cca93300d5ffb855e1bc3"

URI_x86_64_v2_nginx-mod-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nginx-mod-devel-1.26.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-devel}"
SRC_URI[x86_64_v2_nginx-mod-devel.sha256sum] = "71c21b0141f9dc55a72bd9c869ce62ce3961ec295d3ad8ad45cbcc4f22acc31e"

URI_x86_64_v2_nginx-mod-http-image-filter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-image-filter-1.26.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-image-filter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-http-image-filter}"
SRC_URI[x86_64_v2_nginx-mod-http-image-filter.sha256sum] = "035f90228b28f80a2412477d648ee13e671b0701136746be5ea377b4a894fdb3"

URI_x86_64_v2_nginx-mod-http-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-perl-1.26.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-http-perl}"
SRC_URI[x86_64_v2_nginx-mod-http-perl.sha256sum] = "5061ba46e8d740e9684317b3385c965f1d780602e410307d65cc4eb6ca3cd02b"

URI_x86_64_v2_nginx-mod-http-xslt-filter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-xslt-filter-1.26.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-xslt-filter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-http-xslt-filter}"
SRC_URI[x86_64_v2_nginx-mod-http-xslt-filter.sha256sum] = "84a6ad3d0eaed127245fa229d7922c90e0c4413c2ee8e51d0610ed04f26e256f"

URI_x86_64_v2_nginx-mod-mail = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-mail-1.26.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-mail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-mail}"
SRC_URI[x86_64_v2_nginx-mod-mail.sha256sum] = "332a092032a5a8273a47f24ecdc79fca29ee9b0327ed873525110c69ec4dc98f"

URI_x86_64_v2_nginx-mod-stream = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-stream-1.26.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-stream;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-stream}"
SRC_URI[x86_64_v2_nginx-mod-stream.sha256sum] = "4e3fc40bf3fc880224c437f22203a6af09c5925b00f31a31aadc7d409aedb064"

URI_aarch64_nginx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-1.26.3-1.el10.aarch64.rpm;name=aarch64_nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx}"
SRC_URI[aarch64_nginx.sha256sum] = "10a4d0aa538aa819c794b650c583fa938109c1bd4f82edd369df85d23e359920"
RPROVIDES:nginx:aarch64 = "virtual/httpd_or_nginx virtual/webserver"

URI_aarch64_nginx-all-modules = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-all-modules-1.26.3-1.el10.noarch.rpm;name=aarch64_nginx-all-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-all-modules}"
SRC_URI[aarch64_nginx-all-modules.sha256sum] = "f4948f1a6d238656fd0b33b46a619344316507808459be0edb0200c18c636f31"

URI_aarch64_nginx-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-core-1.26.3-1.el10.aarch64.rpm;name=aarch64_nginx-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-core}"
SRC_URI[aarch64_nginx-core.sha256sum] = "ec04f4c1ad8e51b30ce6a5b92f461ef24f6e89ee61a63617b931b76c8162c8b9"

URI_aarch64_nginx-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-filesystem-1.26.3-1.el10.noarch.rpm;name=aarch64_nginx-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-filesystem}"
SRC_URI[aarch64_nginx-filesystem.sha256sum] = "ab05f6d7b541261a74c072bb572662581ee467da797cca93300d5ffb855e1bc3"

URI_aarch64_nginx-mod-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nginx-mod-devel-1.26.3-1.el10.aarch64.rpm;name=aarch64_nginx-mod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-devel}"
SRC_URI[aarch64_nginx-mod-devel.sha256sum] = "3e64eb6a649eb323998a118ec7e01ba3532a4b82d2ff7ef90580006218481bee"

URI_aarch64_nginx-mod-http-image-filter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-image-filter-1.26.3-1.el10.aarch64.rpm;name=aarch64_nginx-mod-http-image-filter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-http-image-filter}"
SRC_URI[aarch64_nginx-mod-http-image-filter.sha256sum] = "9a588d5e079cc04cd984dd50ab2aa73b7e8c8138747340f6a33335b05b02821a"

URI_aarch64_nginx-mod-http-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-perl-1.26.3-1.el10.aarch64.rpm;name=aarch64_nginx-mod-http-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-http-perl}"
SRC_URI[aarch64_nginx-mod-http-perl.sha256sum] = "1736a3458654c9cf9f31210c97bb2b1c35d52fd9a5b232dd7559590bcc1f2633"

URI_aarch64_nginx-mod-http-xslt-filter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-xslt-filter-1.26.3-1.el10.aarch64.rpm;name=aarch64_nginx-mod-http-xslt-filter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-http-xslt-filter}"
SRC_URI[aarch64_nginx-mod-http-xslt-filter.sha256sum] = "0f376b5f2219fb07b55734a10286b79820ab15e446605c11650a47df2ada870c"

URI_aarch64_nginx-mod-mail = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-mail-1.26.3-1.el10.aarch64.rpm;name=aarch64_nginx-mod-mail;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-mail}"
SRC_URI[aarch64_nginx-mod-mail.sha256sum] = "e873761534d018765aa6303da4fd80fd6db8b581e94294c7e2cafc8f4f7d6a50"

URI_aarch64_nginx-mod-stream = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-stream-1.26.3-1.el10.aarch64.rpm;name=aarch64_nginx-mod-stream;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-stream}"
SRC_URI[aarch64_nginx-mod-stream.sha256sum] = "169081ded0d0d57ef5f5b279261ba361be8fe1c0b895bbeea08e5cb16062b6c6"

RDEPENDS:nginx = " \
 almalinux-logos-httpd \
 bash \
 nginx-core \
 nginx-filesystem \
 systemd \
 "
RDEPENDS:nginx-all-modules = " \
 nginx-mod-http-image-filter \
 nginx-mod-http-perl \
 nginx-mod-http-xslt-filter \
 nginx-mod-mail \
 nginx-mod-stream \
 "
RDEPENDS:nginx-core = " \
 glibc \
 libxcrypt \
 nginx-filesystem \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:nginx-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:nginx-mod-devel = " \
 bash \
 gcc \
 gd-devel \
 libxslt-devel \
 make \
 nginx \
 openssl-devel \
 pcre2-devel \
 perl-Exporter \
 perl-ExtUtils-Embed \
 perl-constant \
 perl-devel \
 perl-interpreter \
 perl-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:nginx-mod-http-image-filter = " \
 bash \
 gd \
 glibc \
 nginx \
 "
RDEPENDS:nginx-mod-http-perl = " \
 bash \
 glibc \
 nginx \
 perl-Exporter \
 perl-constant \
 perl-libs \
 "
RDEPENDS:nginx-mod-http-xslt-filter = " \
 bash \
 glibc \
 libxml2 \
 libxslt \
 nginx \
 "
RDEPENDS:nginx-mod-mail = " \
 bash \
 glibc \
 nginx \
 "
RDEPENDS:nginx-mod-stream = " \
 bash \
 glibc \
 nginx \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/httpd_or_nginx rpm/virtual/webserver"

PROVIDES:append:aarch64 = " rpm/virtual/httpd_or_nginx rpm/virtual/webserver"
