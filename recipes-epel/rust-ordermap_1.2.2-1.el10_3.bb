# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ordermap"
PV = "1.2.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-ordermap+arbitrary-devel \
 rust-ordermap+default-devel \
 rust-ordermap+quickcheck-devel \
 rust-ordermap+rayon-devel \
 rust-ordermap+serde-devel \
 rust-ordermap+std-devel \
 rust-ordermap-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-ordermap-1.2.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5fb36150e0718c60b559332ce14ee731ecdbdea9523a9b0a9b1d1b80aabf3668"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+arbitrary-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ordermap+arbitrary-devel.sha256sum] = "0a5a5e15c6fb020900877bf62b02e3fbcc0deb97a44487030b738c6feb1b51e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+default-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ordermap+default-devel.sha256sum] = "cbd82bb8a94acb3f287b278ac9658daaccf1f26fa16b30a0c18e81b230970efc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+quickcheck-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+quickcheck-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ordermap+quickcheck-devel.sha256sum] = "a930b18da253381e294413b67c7543cbfb95685030fb8098fcde555676af7713"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+rayon-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+rayon-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ordermap+rayon-devel.sha256sum] = "ffa2be5cd13d672f9b24d8d93982a551a560f4673911105b305b555334fa908f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+serde-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ordermap+serde-devel.sha256sum] = "aa8074d499957c212fe06b9c76cd32b1f9c3a3bd2993443172661ebf95c00b84"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+std-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ordermap+std-devel.sha256sum] = "24767aed3a867e1d8535d0189cd2f8d4f85880b795f4fe18ff248da30413b614"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ordermap-devel.sha256sum] = "dae120c730661440d0ef1713beb159784b2f8f4824d1251f94ccfcbc6edac566"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+arbitrary-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-ordermap+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-ordermap+arbitrary-devel.sha256sum] = "32e73c9cf29a6f267ce35db9028deb282cfad03c21eda14aa2db8507f8e1f4cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+default-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-ordermap+default-devel;unpack=0"
SRC_URI[aarch64_rust-ordermap+default-devel.sha256sum] = "255c28bcaefd15a7ee779967d50074c5c357a0ee7451f5c77d40c5b2d0ca9038"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+quickcheck-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-ordermap+quickcheck-devel;unpack=0"
SRC_URI[aarch64_rust-ordermap+quickcheck-devel.sha256sum] = "259dac5938a0977cfc2aa74f26d0ee3e4981e6db6bc2905329b8fe0b9c6d50d1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+rayon-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-ordermap+rayon-devel;unpack=0"
SRC_URI[aarch64_rust-ordermap+rayon-devel.sha256sum] = "e31dc997520e1349e35777095692672c40b1e3bdd85b92c6ecc34c8cd304a32f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+serde-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-ordermap+serde-devel;unpack=0"
SRC_URI[aarch64_rust-ordermap+serde-devel.sha256sum] = "7848c8e489254d03b53ab772af9407df52da2c76cc4d72823c84b1b90a308e27"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+std-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-ordermap+std-devel;unpack=0"
SRC_URI[aarch64_rust-ordermap+std-devel.sha256sum] = "dc5dfef547a608740c619dfd80f8379910ae642fb09d338a05e91d5dc09c7dbf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-ordermap-devel;unpack=0"
SRC_URI[aarch64_rust-ordermap-devel.sha256sum] = "c10885dd21db1b42ea03f23e29c1c3f4b4c4e7d84a5ceed91dad1bacc6d55055"

RDEPENDS:rust-ordermap+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-indexmap+arbitrary-devel \
 rust-ordermap-devel \
 "
RDEPENDS:rust-ordermap+default-devel = " \
 cargo \
 rust-ordermap+std-devel \
 rust-ordermap-devel \
 "
RDEPENDS:rust-ordermap+quickcheck-devel = " \
 cargo \
 rust-indexmap+quickcheck-devel \
 rust-ordermap-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-ordermap+rayon-devel = " \
 cargo \
 rust-indexmap+rayon-devel \
 rust-ordermap-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-ordermap+serde-devel = " \
 cargo \
 rust-indexmap+serde-devel \
 rust-ordermap-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-ordermap+std-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-ordermap-devel \
 "
RDEPENDS:rust-ordermap-devel = " \
 cargo \
 rust \
 rust-indexmap-devel \
 "
