# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mailimporter"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 mailimporter \
 mailimporter-akonadi \
 mailimporter-devel \
 mailimporter-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mailimporter-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbb481868a4ac6246154e2d98eb41af3a8c121b65ed66da26c847d363033950a"

URI_x86_64_v2_mailimporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailimporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter}"
SRC_URI[x86_64_v2_mailimporter.sha256sum] = "cb1010b636ba9231543b4390961d18b413c46572d21431f6d684c1c288362ab6"

URI_x86_64_v2_mailimporter-akonadi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-akonadi-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailimporter-akonadi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter-akonadi}"
SRC_URI[x86_64_v2_mailimporter-akonadi.sha256sum] = "69d35b16981c1c95ce379066a20b373cd18de63e6e2dd290a19b0b2c5c661097"

URI_x86_64_v2_mailimporter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailimporter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter-devel}"
SRC_URI[x86_64_v2_mailimporter-devel.sha256sum] = "05616dc4d36a370df2116428408bd111bf5d0d83f855235543ed029e67651223"

URI_x86_64_v2_mailimporter-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mailimporter-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter-doc}"
SRC_URI[x86_64_v2_mailimporter-doc.sha256sum] = "d71e332d840755e6176f1e38db3bf435c14ec80c99365ca9e7604461fce744a3"

URI_aarch64_mailimporter = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_mailimporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter}"
SRC_URI[aarch64_mailimporter.sha256sum] = "ca3d5b050f28f467c6e7d46393aec22dfe9c40ca4d4e6569239535fc6330d82b"

URI_aarch64_mailimporter-akonadi = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-akonadi-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_mailimporter-akonadi;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter-akonadi}"
SRC_URI[aarch64_mailimporter-akonadi.sha256sum] = "a9c13e0817a04ef219d9a878d04a95a51b8addfe056f33b69066c30baba781d5"

URI_aarch64_mailimporter-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_mailimporter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter-devel}"
SRC_URI[aarch64_mailimporter-devel.sha256sum] = "327cbb11e4735f146827d938fb11855a8f6c429c2f10438a1851a2951b8017e5"

URI_aarch64_mailimporter-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_mailimporter-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter-doc}"
SRC_URI[aarch64_mailimporter-doc.sha256sum] = "f7b9a41db10354c530e7192dd07129eef8d5c37eed1df18b2d8b30aaa8b3c485"

RDEPENDS:mailimporter = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-ki18n \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:mailimporter-akonadi = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kmime \
 libgcc \
 libstdc++ \
 mailimporter \
 qt6-qtbase \
 "
RDEPENDS:mailimporter-devel = " \
 cmake-filesystem \
 kf6-karchive-devel \
 mailimporter \
 mailimporter-akonadi \
 "
RDEPENDS:mailimporter-doc = " \
 "
