# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "anaconda-liveinst"
PV = "40.22.3.20_1"
PR = "1.el10_0"
PACKAGES = " \
 anaconda-liveinst \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/anaconda-liveinst-40.22.3.20_1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e0aae5fa920bd8fe3ae4f390dad413ae37b29eef38ea852ece7b53262a914d9"

URI_x86_64_v2_anaconda-liveinst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/anaconda-liveinst-40.22.3.20_1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_anaconda-liveinst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-liveinst}"
SRC_URI[x86_64_v2_anaconda-liveinst.sha256sum] = "51f263efa0cc137e418f9095d3f6277b308b696662aaf4666b76b11e908d147d"

URI_aarch64_anaconda-liveinst = "${EPEL_MIRROR}/aarch64/Packages/a/anaconda-liveinst-40.22.3.20_1-1.el10_0.noarch.rpm;name=aarch64_anaconda-liveinst;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-liveinst}"
SRC_URI[aarch64_anaconda-liveinst.sha256sum] = "24b7b29837d9537afaad46dcc40616238296b1675d4bd711299627ac180041b9"

RDEPENDS:anaconda-liveinst = " \
 anaconda-gui \
 bash \
 usermode \
 xisxwayland \
 zenity \
 "
