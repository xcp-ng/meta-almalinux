# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-assert2"
PV = "0.3.16"
PR = "2.el10_2"
PACKAGES = " \
 rust-assert2+default-devel \
 rust-assert2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-assert2-0.3.16-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3f4964e40844f4c9b26f80e3702c0c8fe152d96a06631af14f4a14bb0650d49"

URI_x86_64_v2_rust-assert2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert2+default-devel-0.3.16-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert2+default-devel}"
SRC_URI[x86_64_v2_rust-assert2+default-devel.sha256sum] = "f6dfa0ff3ff3b91d30272e1833a6339878b20c7db938f62bbbf621fa8b9adf1a"

URI_x86_64_v2_rust-assert2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert2-devel-0.3.16-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert2-devel}"
SRC_URI[x86_64_v2_rust-assert2-devel.sha256sum] = "2a60011bdb905e84b909deb049620eaf748543af12d16ded0afbacb82e50e73e"

URI_aarch64_rust-assert2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert2+default-devel-0.3.16-2.el10_2.noarch.rpm;name=aarch64_rust-assert2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert2+default-devel}"
SRC_URI[aarch64_rust-assert2+default-devel.sha256sum] = "d9a1d2adb66c9a38e6df15c55148e06305e1c2d816608ac475b66011b8cca2ea"

URI_aarch64_rust-assert2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert2-devel-0.3.16-2.el10_2.noarch.rpm;name=aarch64_rust-assert2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert2-devel}"
SRC_URI[aarch64_rust-assert2-devel.sha256sum] = "3dc470026ba3c3354cc8536246d59f4bd61f4310e505bf7294ced0f4b5b5756b"

RDEPENDS:rust-assert2+default-devel = " \
 cargo \
 rust-assert2-devel \
 "
RDEPENDS:rust-assert2-devel = " \
 cargo \
 rust \
 rust-assert2-macros+default-devel \
 rust-diff+default-devel \
 rust-yansi+default-devel \
 "
