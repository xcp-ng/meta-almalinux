# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libbpf-sys"
PV = "1.6.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-libbpf-sys+bindgen-devel \
 rust-libbpf-sys+bindgen-source-devel \
 rust-libbpf-sys+default-devel \
 rust-libbpf-sys+novendor-devel \
 rust-libbpf-sys+static-devel \
 rust-libbpf-sys+static-libbpf-devel \
 rust-libbpf-sys+static-libelf-devel \
 rust-libbpf-sys+static-zlib-devel \
 rust-libbpf-sys+vendored-devel \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys+vendored-libelf-devel \
 rust-libbpf-sys+vendored-zlib-devel \
 rust-libbpf-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libbpf-sys-1.6.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91b94d7f138c84c54987923c6556129b324f7b1c9fb394551481433679d3d0ed"

URI_x86_64_v2_rust-libbpf-sys+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+bindgen-devel-1.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+bindgen-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+bindgen-devel.sha256sum] = "76b39f527a35d27125435ebc7c6ec5141d566e8b036d54a55414b5fe53c39f11"

URI_x86_64_v2_rust-libbpf-sys+bindgen-source-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+bindgen-source-devel-1.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+bindgen-source-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+bindgen-source-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+bindgen-source-devel.sha256sum] = "11a756d1e02e5ae5ce7a371b21020d75eac336f033c95189869ff187a3c2e996"

URI_x86_64_v2_rust-libbpf-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+default-devel-1.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+default-devel.sha256sum] = "3d03b8443e58e644fb4617f6cb524f7d939f0b3d1c800893a0e2fc73a46d3b33"

URI_x86_64_v2_rust-libbpf-sys+novendor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+novendor-devel-1.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+novendor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+novendor-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+novendor-devel.sha256sum] = "811d4d0edbdbabf9d64aeabd62364109dd5f59d25454291934bbd06970e67e22"

URI_x86_64_v2_rust-libbpf-sys+static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+static-devel-1.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+static-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+static-devel.sha256sum] = "072a7216a3713e356d311f218fc010799a1b5b58ad14c126f56b36642a859f5a"

URI_x86_64_v2_rust-libbpf-sys+static-libbpf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+static-libbpf-devel-1.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+static-libbpf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+static-libbpf-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+static-libbpf-devel.sha256sum] = "700859c39fb34655a2ffc72b4807c95136fcf6e4833c0b492e65b0b659cdfd06"

URI_x86_64_v2_rust-libbpf-sys+static-libelf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+static-libelf-devel-1.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+static-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+static-libelf-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+static-libelf-devel.sha256sum] = "b8c9218fdb3de902a2959ed6a2a4ce791ff33eec3715f67f2b809c2eab312da4"

URI_x86_64_v2_rust-libbpf-sys+static-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+static-zlib-devel-1.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+static-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+static-zlib-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+static-zlib-devel.sha256sum] = "85535f5030bf4b6b360e0c5e0f30bfb349addc619de5cc69343bbe82867e1c28"

URI_x86_64_v2_rust-libbpf-sys+vendored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+vendored-devel-1.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+vendored-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+vendored-devel.sha256sum] = "a37f9d227987f3e9be89826b5902829454674b01b433daf3b7cf7c54fb8a751e"

URI_x86_64_v2_rust-libbpf-sys+vendored-libbpf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+vendored-libbpf-devel-1.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+vendored-libbpf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+vendored-libbpf-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+vendored-libbpf-devel.sha256sum] = "04ce7aeb62ebe631b7d2948eb2ba6d16bd099f5174ab88c5fa3e35a39f12e342"

URI_x86_64_v2_rust-libbpf-sys+vendored-libelf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+vendored-libelf-devel-1.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+vendored-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+vendored-libelf-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+vendored-libelf-devel.sha256sum] = "7876b78087071be7dd1410ff0f6a21d68a842ae0af0b4506c5bc5edcfcc9bf67"

URI_x86_64_v2_rust-libbpf-sys+vendored-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys+vendored-zlib-devel-1.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys+vendored-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys+vendored-zlib-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys+vendored-zlib-devel.sha256sum] = "978fe352d817185bc34cf65afd5dfe27d1505dd21923c59859af1a5758776501"

URI_x86_64_v2_rust-libbpf-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-sys-devel-1.6.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-sys-devel}"
SRC_URI[x86_64_v2_rust-libbpf-sys-devel.sha256sum] = "a293f9e7d2916c8981d3236484e588e929b499dd3dd19f2b83aaf301af15c4fb"

URI_aarch64_rust-libbpf-sys+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+bindgen-devel-1.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+bindgen-devel}"
SRC_URI[aarch64_rust-libbpf-sys+bindgen-devel.sha256sum] = "f6ae453d4941e04da980fce9841094c510935c5016a02ca057305d31c1415465"

URI_aarch64_rust-libbpf-sys+bindgen-source-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+bindgen-source-devel-1.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-sys+bindgen-source-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+bindgen-source-devel}"
SRC_URI[aarch64_rust-libbpf-sys+bindgen-source-devel.sha256sum] = "745fa82e3e15c44e3bb809d4dba1872e70ddf5eaef1c2f13af5d9cfa69d9cd2f"

URI_aarch64_rust-libbpf-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+default-devel-1.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+default-devel}"
SRC_URI[aarch64_rust-libbpf-sys+default-devel.sha256sum] = "b654dc5af573a54b1919a43be823e4aab5ca91e8c4f34568308382255122d587"

URI_aarch64_rust-libbpf-sys+novendor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+novendor-devel-1.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-sys+novendor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+novendor-devel}"
SRC_URI[aarch64_rust-libbpf-sys+novendor-devel.sha256sum] = "bd728106ff2a0b8c5510c8ea4a2e57f413bd98d64e3aa516a4fa5ac35569c3f5"

URI_aarch64_rust-libbpf-sys+static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+static-devel-1.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-sys+static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+static-devel}"
SRC_URI[aarch64_rust-libbpf-sys+static-devel.sha256sum] = "5cea1ff2fb487e286878587cad93791f121782b7eb25b7a899e4ddf44ccb4e1f"

URI_aarch64_rust-libbpf-sys+static-libbpf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+static-libbpf-devel-1.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-sys+static-libbpf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+static-libbpf-devel}"
SRC_URI[aarch64_rust-libbpf-sys+static-libbpf-devel.sha256sum] = "074fd3597c298f38a742454e2d46eb77eed466572cb37543403c4d3b7d4b0407"

URI_aarch64_rust-libbpf-sys+static-libelf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+static-libelf-devel-1.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-sys+static-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+static-libelf-devel}"
SRC_URI[aarch64_rust-libbpf-sys+static-libelf-devel.sha256sum] = "2bf7e836c7e20f1259fde126c3d141d25fcd3b29c325e90cb860c88bfa6808b9"

URI_aarch64_rust-libbpf-sys+static-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+static-zlib-devel-1.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-sys+static-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+static-zlib-devel}"
SRC_URI[aarch64_rust-libbpf-sys+static-zlib-devel.sha256sum] = "0f039a136ce8d91068dc8fa17b8a7c2f330edaae5df907d83b63ce66d017740d"

URI_aarch64_rust-libbpf-sys+vendored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+vendored-devel-1.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-sys+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+vendored-devel}"
SRC_URI[aarch64_rust-libbpf-sys+vendored-devel.sha256sum] = "6581bcfc892e9f35e16aca09102c0a39a60043a4c94701bff2518ae04d5aaf85"

URI_aarch64_rust-libbpf-sys+vendored-libbpf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+vendored-libbpf-devel-1.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-sys+vendored-libbpf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+vendored-libbpf-devel}"
SRC_URI[aarch64_rust-libbpf-sys+vendored-libbpf-devel.sha256sum] = "45940589104f2db6e5400b9f9ea55ac365559468437d4d3f70470d298394bcb8"

URI_aarch64_rust-libbpf-sys+vendored-libelf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+vendored-libelf-devel-1.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-sys+vendored-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+vendored-libelf-devel}"
SRC_URI[aarch64_rust-libbpf-sys+vendored-libelf-devel.sha256sum] = "9644ccde51a9a381c18e57878163b05e8677c1db6eab85ff29349a91e4410bc9"

URI_aarch64_rust-libbpf-sys+vendored-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys+vendored-zlib-devel-1.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-sys+vendored-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys+vendored-zlib-devel}"
SRC_URI[aarch64_rust-libbpf-sys+vendored-zlib-devel.sha256sum] = "9d6cdc88c785f78ba8f643c10de91e47549966a92b5f6528b7f86cb9b434ce00"

URI_aarch64_rust-libbpf-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-sys-devel-1.6.2-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-sys-devel}"
SRC_URI[aarch64_rust-libbpf-sys-devel.sha256sum] = "4b43a4add0110d4b72d03e3540996f515ae3890eb5f75d712ed7a6b6a3a85c8c"

RDEPENDS:rust-libbpf-sys+bindgen-devel = " \
 cargo \
 rust-bindgen+default-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+bindgen-source-devel = " \
 cargo \
 rust-libbpf-sys+bindgen-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+default-devel = " \
 cargo \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+novendor-devel = " \
 cargo \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+static-devel = " \
 cargo \
 rust-libbpf-sys+static-libbpf-devel \
 rust-libbpf-sys+static-libelf-devel \
 rust-libbpf-sys+static-zlib-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+static-libbpf-devel = " \
 cargo \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+static-libelf-devel = " \
 cargo \
 rust-libbpf-sys+static-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+static-zlib-devel = " \
 cargo \
 rust-libbpf-sys+static-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+vendored-devel = " \
 cargo \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys+vendored-libelf-devel \
 rust-libbpf-sys+vendored-zlib-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+vendored-libbpf-devel = " \
 cargo \
 rust-libbpf-sys+static-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+vendored-libelf-devel = " \
 cargo \
 rust-libbpf-sys+static-libelf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys+vendored-zlib-devel = " \
 cargo \
 rust-libbpf-sys+static-zlib-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-sys-devel = " \
 bash \
 cargo \
 elfutils-libelf-devel \
 kernel-headers \
 rust \
 rust-cc+default-devel \
 rust-nix0.30+fs-devel \
 rust-nix0.30-devel \
 rust-pkg-config+default-devel \
 zlib-ng-compat-devel \
 "
