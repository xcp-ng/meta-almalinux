# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-heck0.3"
PV = "0.3.3"
PR = "8.el10_0"
PACKAGES = " \
 rust-heck0.3+default-devel \
 rust-heck0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-heck0.3-0.3.3-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a78f7e19b30c13aa50205d4c194d54b9ea6ca3a28a082bc45ade2fd5c896157"

URI_x86_64_v2_rust-heck0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heck0.3+default-devel-0.3.3-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heck0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heck0.3+default-devel}"
SRC_URI[x86_64_v2_rust-heck0.3+default-devel.sha256sum] = "436eb8178f52dd27e8f286a6ac553600851523b146b0a411453f8b89a40455e4"

URI_x86_64_v2_rust-heck0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heck0.3-devel-0.3.3-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heck0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heck0.3-devel}"
SRC_URI[x86_64_v2_rust-heck0.3-devel.sha256sum] = "0de34f3cba8230bb448273db14b004a3c63b6cabbfe4f48f0cd29c9fc93ed8a0"

URI_aarch64_rust-heck0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heck0.3+default-devel-0.3.3-8.el10_0.noarch.rpm;name=aarch64_rust-heck0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heck0.3+default-devel}"
SRC_URI[aarch64_rust-heck0.3+default-devel.sha256sum] = "861f8821990fded376ec65ec5ca8a55383b070d1cd825264b81fe3c49dc37882"

URI_aarch64_rust-heck0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heck0.3-devel-0.3.3-8.el10_0.noarch.rpm;name=aarch64_rust-heck0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heck0.3-devel}"
SRC_URI[aarch64_rust-heck0.3-devel.sha256sum] = "231a3a7ba8bf5a95a3ddc98459df7fafbe2bfb9b370b9e59021a0cf673127e6b"

RDEPENDS:rust-heck0.3+default-devel = " \
 cargo \
 rust-heck0.3-devel \
 "
RDEPENDS:rust-heck0.3-devel = " \
 cargo \
 rust-unicode-segmentation+default-devel \
 "
