# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwayland"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kwayland \
 kwayland-devel \
 kwayland-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwayland-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c0ed01cf012539dc83336c7de7b5489eb5ff04d800445bb1a3b4ea263917cce"

URI_x86_64_v2_kwayland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwayland-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwayland}"
SRC_URI[x86_64_v2_kwayland.sha256sum] = "355a4a56cbdb13f89858421fa7db02338155abe47dca9735f9f568dbed055b05"

URI_x86_64_v2_kwayland-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwayland-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwayland-devel}"
SRC_URI[x86_64_v2_kwayland-devel.sha256sum] = "709c30ac78a8cc21c0aa51aa31ede1d7187ac3bbc45ccfae8d1523edabe15149"

URI_x86_64_v2_kwayland-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwayland-doc-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kwayland-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwayland-doc}"
SRC_URI[x86_64_v2_kwayland-doc.sha256sum] = "2ce4ec1f2a6fd8cd6e8bb45186e6bbf922239bc67f85b64662b71c44401d5f07"

URI_aarch64_kwayland = "${EPEL_MIRROR}/aarch64/Packages/k/kwayland-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kwayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwayland}"
SRC_URI[aarch64_kwayland.sha256sum] = "1fe9b61c37d2e4632f157983f1510e4d048a7203a01791df3fa711f61591b01a"

URI_aarch64_kwayland-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kwayland-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kwayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwayland-devel}"
SRC_URI[aarch64_kwayland-devel.sha256sum] = "c0994fc98095f44378858f661ef9c90e04a711c90159c0e2fb5eed9af3a9b96a"

URI_aarch64_kwayland-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kwayland-doc-6.6.4-1.el10_2.noarch.rpm;name=aarch64_kwayland-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwayland-doc}"
SRC_URI[aarch64_kwayland-doc.sha256sum] = "1cbbed4148fa9d1def908d20338a5233b1c03e05a01a4e1386956b86d852b46d"

RDEPENDS:kwayland = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kwayland-devel = " \
 cmake-filesystem \
 kwayland \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kwayland-doc = " \
 "
