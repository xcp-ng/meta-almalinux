# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf_macros0.11"
PV = "0.11.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-phf_macros0.11+default-devel \
 rust-phf_macros0.11+unicase-devel \
 rust-phf_macros0.11+unicase_-devel \
 rust-phf_macros0.11-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf_macros0.11-0.11.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c7761d014ae6acc03ac16d4482ba36343e234aed003388d8a048b60c931506b"

URI_x86_64_v2_rust-phf_macros0.11+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros0.11+default-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros0.11+default-devel}"
SRC_URI[x86_64_v2_rust-phf_macros0.11+default-devel.sha256sum] = "55a125c2b3735262d775147ad634c86e05562ef4bd708094ef2ef1ec6703b64e"

URI_x86_64_v2_rust-phf_macros0.11+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros0.11+unicase-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros0.11+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros0.11+unicase-devel}"
SRC_URI[x86_64_v2_rust-phf_macros0.11+unicase-devel.sha256sum] = "b573b972988bc9b1abb883def50d414465abbcda2f6bf67df5073b327a92c890"

URI_x86_64_v2_rust-phf_macros0.11+unicase_-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros0.11+unicase_-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros0.11+unicase_-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros0.11+unicase_-devel}"
SRC_URI[x86_64_v2_rust-phf_macros0.11+unicase_-devel.sha256sum] = "f9264188c72a56f9e90f31302f1fedbd67fd7f520028e101924ad1b0946aaccb"

URI_x86_64_v2_rust-phf_macros0.11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros0.11-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros0.11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros0.11-devel}"
SRC_URI[x86_64_v2_rust-phf_macros0.11-devel.sha256sum] = "d410230f01c868239327c1cfb0730a8277dc823406ce30969a9fc24dfe1e3f93"

URI_aarch64_rust-phf_macros0.11+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros0.11+default-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf_macros0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros0.11+default-devel}"
SRC_URI[aarch64_rust-phf_macros0.11+default-devel.sha256sum] = "c97a5e3b3066cf105745e395b034a0c7ab179c932f58bd11ec8c729f8559a411"

URI_aarch64_rust-phf_macros0.11+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros0.11+unicase-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf_macros0.11+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros0.11+unicase-devel}"
SRC_URI[aarch64_rust-phf_macros0.11+unicase-devel.sha256sum] = "6b797ab02b23a8422bb8282597c420f8474a34e7f255dd04ae960469b978cd75"

URI_aarch64_rust-phf_macros0.11+unicase_-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros0.11+unicase_-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf_macros0.11+unicase_-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros0.11+unicase_-devel}"
SRC_URI[aarch64_rust-phf_macros0.11+unicase_-devel.sha256sum] = "64d12d3553d824c9f17c5c5ed31af23fb5b79e89f22510f4b08314bf13a90f10"

URI_aarch64_rust-phf_macros0.11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros0.11-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf_macros0.11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros0.11-devel}"
SRC_URI[aarch64_rust-phf_macros0.11-devel.sha256sum] = "f4dc21ff006d802bbe41323630cd4b810c45bb2d19e5a779178addf29e231ca9"

RDEPENDS:rust-phf_macros0.11+default-devel = " \
 cargo \
 rust-phf_macros0.11-devel \
 "
RDEPENDS:rust-phf_macros0.11+unicase-devel = " \
 cargo \
 rust-phf_macros0.11+unicase_-devel \
 rust-phf_macros0.11-devel \
 rust-phf_shared0.11+unicase-devel \
 "
RDEPENDS:rust-phf_macros0.11+unicase_-devel = " \
 cargo \
 rust-phf_macros0.11-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-phf_macros0.11-devel = " \
 cargo \
 rust \
 rust-phf_generator0.11+default-devel \
 rust-phf_shared0.11-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
