# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-stevedore"
PV = "5.7.0"
PR = "5.el10_3"
PACKAGES = " \
 python3-stevedore \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-stevedore-5.7.0-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e0b1dfc732fb6c9c493deb2a1427cb840a6c60b59b3c126266446ec8178dcd0"

URI_x86_64_v2_python3-stevedore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-stevedore-5.7.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-stevedore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-stevedore}"
SRC_URI[x86_64_v2_python3-stevedore.sha256sum] = "9eee79538c54e1e22f1687192354fcb0992989cc2749658026c7f0c402879a0a"

URI_aarch64_python3-stevedore = "${EPEL_MIRROR}/aarch64/Packages/p/python3-stevedore-5.7.0-5.el10_3.noarch.rpm;name=aarch64_python3-stevedore;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-stevedore}"
SRC_URI[aarch64_python3-stevedore.sha256sum] = "036f5aa46c852cc8a15f373fc16867ecbfde1f3b5137a900cb49eb4f8d601b16"

RDEPENDS:python3-stevedore = " \
 python3 \
 "
