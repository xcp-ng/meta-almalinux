# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-Format-MySQL"
PV = "0.08"
PR = "2.el10_0"
PACKAGES = " \
 perl-DateTime-Format-MySQL \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-Format-MySQL-0.08-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2204c6073c1e270e82d75bd7cdfebcc62ee5a12cf7b3c9c908519caa3b1dc3e4"

URI_x86_64_v2_perl-DateTime-Format-MySQL = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-Format-MySQL-0.08-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-Format-MySQL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-Format-MySQL}"
SRC_URI[x86_64_v2_perl-DateTime-Format-MySQL.sha256sum] = "76a89c65de9fd0216068993298dcc4d29db1b25a0fba05e1296523a24463e768"

URI_aarch64_perl-DateTime-Format-MySQL = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-Format-MySQL-0.08-2.el10_0.noarch.rpm;name=aarch64_perl-DateTime-Format-MySQL;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-Format-MySQL}"
SRC_URI[aarch64_perl-DateTime-Format-MySQL.sha256sum] = "9518187c3aa558d12a5adba707b6783544699162ee8d290c01acc4b403a83669"

RDEPENDS:perl-DateTime-Format-MySQL = " \
 perl-DateTime \
 perl-DateTime-Format-Builder \
 perl-libs \
 perl-vars \
 "
