# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-syn"
PV = "2.0.108"
PR = "1.el10_0"
PACKAGES = " \
 rust-syn+clone-impls-devel \
 rust-syn+default-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+test-devel \
 rust-syn+visit-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-syn-2.0.108-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ceaa17b666daf7ecc94eb2be2b6404526851021a797d584ce09a8ca2f9728b1"

URI_x86_64_v2_rust-syn+clone-impls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+clone-impls-devel-2.0.108-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+clone-impls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+clone-impls-devel}"
SRC_URI[x86_64_v2_rust-syn+clone-impls-devel.sha256sum] = "c1a98bb8503d5962f7514ee034edc9da3687378b735e97877db0e1a10a163f29"

URI_x86_64_v2_rust-syn+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+default-devel-2.0.108-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+default-devel}"
SRC_URI[x86_64_v2_rust-syn+default-devel.sha256sum] = "87e880386668c9cfc1fcbe1dde365152465e65f5fb54723bbf5f38667b0b5e9d"

URI_x86_64_v2_rust-syn+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+derive-devel-2.0.108-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+derive-devel}"
SRC_URI[x86_64_v2_rust-syn+derive-devel.sha256sum] = "26488b12c409c28a6498294a80f928b903bf45b448977c9e988d714606bb9dec"

URI_x86_64_v2_rust-syn+extra-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+extra-traits-devel-2.0.108-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+extra-traits-devel}"
SRC_URI[x86_64_v2_rust-syn+extra-traits-devel.sha256sum] = "07e2bfe8ce14b56b308381b42a7b2def4a8870a57675cae0a1e0a83484d4fc15"

URI_x86_64_v2_rust-syn+fold-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+fold-devel-2.0.108-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+fold-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+fold-devel}"
SRC_URI[x86_64_v2_rust-syn+fold-devel.sha256sum] = "a07dd73714e9fdf170a554313678473ecd6be18639c38af9b51d4672f10d3f5b"

URI_x86_64_v2_rust-syn+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+full-devel-2.0.108-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+full-devel}"
SRC_URI[x86_64_v2_rust-syn+full-devel.sha256sum] = "5aecdaa4861ba833bd0ef51709af91c1d7ecdd6b3d5a499f925ddfceed8ca052"

URI_x86_64_v2_rust-syn+parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+parsing-devel-2.0.108-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+parsing-devel}"
SRC_URI[x86_64_v2_rust-syn+parsing-devel.sha256sum] = "d3e0df75d718bbf8ae162adb453f9bf3dbf5c7b576feaf993ca493b1719ba880"

URI_x86_64_v2_rust-syn+printing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+printing-devel-2.0.108-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+printing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+printing-devel}"
SRC_URI[x86_64_v2_rust-syn+printing-devel.sha256sum] = "469e8a6346db6a29a8ddd7783b388fa44d47a13ee1f05226b71e914bd5f7d4ea"

URI_x86_64_v2_rust-syn+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+proc-macro-devel-2.0.108-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-syn+proc-macro-devel.sha256sum] = "79292441e8d55f4d14914ebb894b449b01a1052a1cfae337b7ea3adee745405a"

URI_x86_64_v2_rust-syn+test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+test-devel-2.0.108-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+test-devel}"
SRC_URI[x86_64_v2_rust-syn+test-devel.sha256sum] = "e05ba7b8fecae826005d38f70c0560453ac3671a17cb4af119530019f99be069"

URI_x86_64_v2_rust-syn+visit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+visit-devel-2.0.108-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+visit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+visit-devel}"
SRC_URI[x86_64_v2_rust-syn+visit-devel.sha256sum] = "5c0dfd9e8475d472278eb2b44507b67678c5fa0f06e4baf3a87594659ea7e7cd"

URI_x86_64_v2_rust-syn+visit-mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+visit-mut-devel-2.0.108-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+visit-mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+visit-mut-devel}"
SRC_URI[x86_64_v2_rust-syn+visit-mut-devel.sha256sum] = "f869a3803d160ebe31fc3c0bd429b19de36ac4f7b27cbb2f2e804a5cf9b262f6"

URI_x86_64_v2_rust-syn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn-devel-2.0.108-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn-devel}"
SRC_URI[x86_64_v2_rust-syn-devel.sha256sum] = "a1496b91df04fb50daf303dfd02ffa4db230f0acfd22ae48afa38aacca411926"

URI_aarch64_rust-syn+clone-impls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+clone-impls-devel-2.0.108-1.el10_0.noarch.rpm;name=aarch64_rust-syn+clone-impls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+clone-impls-devel}"
SRC_URI[aarch64_rust-syn+clone-impls-devel.sha256sum] = "999a298eaf302cc1462c511cf3b4f05b2ea07806bf5fec15852eb1ebba23d871"

URI_aarch64_rust-syn+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+default-devel-2.0.108-1.el10_0.noarch.rpm;name=aarch64_rust-syn+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+default-devel}"
SRC_URI[aarch64_rust-syn+default-devel.sha256sum] = "cda41adcaf173586a16a0319bf843391d5b273f4756cd58f5e05c1c66af17003"

URI_aarch64_rust-syn+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+derive-devel-2.0.108-1.el10_0.noarch.rpm;name=aarch64_rust-syn+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+derive-devel}"
SRC_URI[aarch64_rust-syn+derive-devel.sha256sum] = "2037c0a3affa4f3fc98318f2379f7adf7cc76d795bf4d5a4484412c3289cdf33"

URI_aarch64_rust-syn+extra-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+extra-traits-devel-2.0.108-1.el10_0.noarch.rpm;name=aarch64_rust-syn+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+extra-traits-devel}"
SRC_URI[aarch64_rust-syn+extra-traits-devel.sha256sum] = "873df264577eb3bff1eab8ac433b8fe21e9ff0956ae1e627999df35c0e7da006"

URI_aarch64_rust-syn+fold-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+fold-devel-2.0.108-1.el10_0.noarch.rpm;name=aarch64_rust-syn+fold-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+fold-devel}"
SRC_URI[aarch64_rust-syn+fold-devel.sha256sum] = "29a2df4db3f28e12332e3505041021f9543c6cd4a1590fe2457e58ceb9b052a3"

URI_aarch64_rust-syn+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+full-devel-2.0.108-1.el10_0.noarch.rpm;name=aarch64_rust-syn+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+full-devel}"
SRC_URI[aarch64_rust-syn+full-devel.sha256sum] = "d5b02d0be4af82c34e3987d68ad7bd975d42095ded4df38d1e1ae35c85b57f56"

URI_aarch64_rust-syn+parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+parsing-devel-2.0.108-1.el10_0.noarch.rpm;name=aarch64_rust-syn+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+parsing-devel}"
SRC_URI[aarch64_rust-syn+parsing-devel.sha256sum] = "74b7654eab68d139a7d4401996d2afdce608bafda475059c185102f5d434585b"

URI_aarch64_rust-syn+printing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+printing-devel-2.0.108-1.el10_0.noarch.rpm;name=aarch64_rust-syn+printing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+printing-devel}"
SRC_URI[aarch64_rust-syn+printing-devel.sha256sum] = "61cb6bd848a43859fa382a2ef599de379739daae2adebd2f512dbc602d310a3b"

URI_aarch64_rust-syn+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+proc-macro-devel-2.0.108-1.el10_0.noarch.rpm;name=aarch64_rust-syn+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+proc-macro-devel}"
SRC_URI[aarch64_rust-syn+proc-macro-devel.sha256sum] = "31fdff97bf2b7a0df42bb189307db25620bc8ad1d3b4376519beb1fbbd3322cf"

URI_aarch64_rust-syn+test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+test-devel-2.0.108-1.el10_0.noarch.rpm;name=aarch64_rust-syn+test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+test-devel}"
SRC_URI[aarch64_rust-syn+test-devel.sha256sum] = "442a51d5c7c78b2c48ad08ea6de5e9070fe1db5439ff5082b93489ead76dbd3b"

URI_aarch64_rust-syn+visit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+visit-devel-2.0.108-1.el10_0.noarch.rpm;name=aarch64_rust-syn+visit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+visit-devel}"
SRC_URI[aarch64_rust-syn+visit-devel.sha256sum] = "6f539e7f047fcdb4fcfcd0d4494f188d6cab638a4ef9a8c44f01e1540b8a403f"

URI_aarch64_rust-syn+visit-mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+visit-mut-devel-2.0.108-1.el10_0.noarch.rpm;name=aarch64_rust-syn+visit-mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+visit-mut-devel}"
SRC_URI[aarch64_rust-syn+visit-mut-devel.sha256sum] = "3dfff207e0abc284490984674a92a1f9f815f49625891162de2d8cd6258fe34c"

URI_aarch64_rust-syn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn-devel-2.0.108-1.el10_0.noarch.rpm;name=aarch64_rust-syn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn-devel}"
SRC_URI[aarch64_rust-syn-devel.sha256sum] = "6c901f73ab961843c16401b26819e2509dbdf31e1ec4e0586904c181ac5e474f"

RDEPENDS:rust-syn+clone-impls-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+default-devel = " \
 cargo \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+derive-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+extra-traits-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+fold-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+full-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+parsing-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+printing-devel = " \
 cargo \
 rust-quote-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+proc-macro-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+test-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+visit-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+visit-mut-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-unicode-ident+default-devel \
 "
