# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-hatch-requirements-txt"
PV = "0.4.1"
PR = "4.el10_0"
PACKAGES = " \
 python3-hatch-requirements-txt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-hatch-requirements-txt-0.4.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0533be79fb3e4c3c7768a78a7971ef66fbed5aea5ede05f55e1612130c66042"

URI_x86_64_v2_python3-hatch-requirements-txt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hatch-requirements-txt-0.4.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hatch-requirements-txt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hatch-requirements-txt}"
SRC_URI[x86_64_v2_python3-hatch-requirements-txt.sha256sum] = "73cc9b8fd94775116a56ef745544502832deb68d016c701612eae79af414f3a2"

URI_aarch64_python3-hatch-requirements-txt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hatch-requirements-txt-0.4.1-4.el10_0.noarch.rpm;name=aarch64_python3-hatch-requirements-txt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hatch-requirements-txt}"
SRC_URI[aarch64_python3-hatch-requirements-txt.sha256sum] = "fd96f0440ef3c96787f25d52db6e185c48c3a023bbd89606fc89566a551b319f"

RDEPENDS:python3-hatch-requirements-txt = " \
 python3 \
 python3-hatchling \
 python3-packaging \
 "
