# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pretty_assertions"
PV = "1.4.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-pretty_assertions+alloc-devel \
 rust-pretty_assertions+default-devel \
 rust-pretty_assertions+std-devel \
 rust-pretty_assertions+unstable-devel \
 rust-pretty_assertions-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pretty_assertions-1.4.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20d1754c3ae426dfa6ac7dbf188841e93f88fc1e33fe53698de8743bd095d789"

URI_x86_64_v2_rust-pretty_assertions+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pretty_assertions+alloc-devel-1.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pretty_assertions+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pretty_assertions+alloc-devel}"
SRC_URI[x86_64_v2_rust-pretty_assertions+alloc-devel.sha256sum] = "5a0fea5d28163085bbe14882c4be1175a548d4419350de413815b7d1075d9a6d"

URI_x86_64_v2_rust-pretty_assertions+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pretty_assertions+default-devel-1.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pretty_assertions+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pretty_assertions+default-devel}"
SRC_URI[x86_64_v2_rust-pretty_assertions+default-devel.sha256sum] = "211df5b8b6bf723f29a11d9d9428b220c22e65a77152cb064f07fbe926c9c803"

URI_x86_64_v2_rust-pretty_assertions+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pretty_assertions+std-devel-1.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pretty_assertions+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pretty_assertions+std-devel}"
SRC_URI[x86_64_v2_rust-pretty_assertions+std-devel.sha256sum] = "241b3ae27d95e59b6047cd8196a72c7a356d33f0d340530d925b2475d7c2f3f3"

URI_x86_64_v2_rust-pretty_assertions+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pretty_assertions+unstable-devel-1.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pretty_assertions+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pretty_assertions+unstable-devel}"
SRC_URI[x86_64_v2_rust-pretty_assertions+unstable-devel.sha256sum] = "de5c504f1d872a048d13e2a1cf4128096ee350383d3914c65777d29c814538f4"

URI_x86_64_v2_rust-pretty_assertions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pretty_assertions-devel-1.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pretty_assertions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pretty_assertions-devel}"
SRC_URI[x86_64_v2_rust-pretty_assertions-devel.sha256sum] = "2f756b30093b99fefeeaa7fde423feb3d77f85b10757a69a9c611722dd00ce00"

URI_aarch64_rust-pretty_assertions+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pretty_assertions+alloc-devel-1.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-pretty_assertions+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pretty_assertions+alloc-devel}"
SRC_URI[aarch64_rust-pretty_assertions+alloc-devel.sha256sum] = "ea030fd6c967337d18da51af1773ea597162c0bd9520419d4a1e4ec51b245e5f"

URI_aarch64_rust-pretty_assertions+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pretty_assertions+default-devel-1.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-pretty_assertions+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pretty_assertions+default-devel}"
SRC_URI[aarch64_rust-pretty_assertions+default-devel.sha256sum] = "db649167e0ed907e92da3f1deda9f7ffab437fdc50d344a74a3245f2d1aeb6d4"

URI_aarch64_rust-pretty_assertions+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pretty_assertions+std-devel-1.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-pretty_assertions+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pretty_assertions+std-devel}"
SRC_URI[aarch64_rust-pretty_assertions+std-devel.sha256sum] = "74b1ecc3b9ae8af151fc5f783746500083508f5b14b47ff6478b4719d77bb19b"

URI_aarch64_rust-pretty_assertions+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pretty_assertions+unstable-devel-1.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-pretty_assertions+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pretty_assertions+unstable-devel}"
SRC_URI[aarch64_rust-pretty_assertions+unstable-devel.sha256sum] = "9f8fb400181e9e70833144df4a4d65e4a8c2c1d8f40c02c20a33878c4d5b66fc"

URI_aarch64_rust-pretty_assertions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pretty_assertions-devel-1.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-pretty_assertions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pretty_assertions-devel}"
SRC_URI[aarch64_rust-pretty_assertions-devel.sha256sum] = "488d74278708a6c309a14cab72916c8d8080d5f1f6de95c5e473fc7448270fcf"

RDEPENDS:rust-pretty_assertions+alloc-devel = " \
 cargo \
 rust-pretty_assertions-devel \
 "
RDEPENDS:rust-pretty_assertions+default-devel = " \
 cargo \
 rust-pretty_assertions+std-devel \
 rust-pretty_assertions-devel \
 "
RDEPENDS:rust-pretty_assertions+std-devel = " \
 cargo \
 rust-pretty_assertions-devel \
 "
RDEPENDS:rust-pretty_assertions+unstable-devel = " \
 cargo \
 rust-pretty_assertions-devel \
 "
RDEPENDS:rust-pretty_assertions-devel = " \
 cargo \
 rust-diff+default-devel \
 rust-yansi+default-devel \
 "
