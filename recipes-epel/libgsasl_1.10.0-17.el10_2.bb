# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgsasl"
PV = "1.10.0"
PR = "17.el10_2"
PACKAGES = " \
 libgsasl \
 libgsasl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgsasl-1.10.0-17.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78de0d9f3ed4ed9741342e846a50dd7c291fa9881299763fbd65445827164834"

URI_x86_64_v2_libgsasl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgsasl-1.10.0-17.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgsasl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgsasl}"
SRC_URI[x86_64_v2_libgsasl.sha256sum] = "8229f6d55b69a07e7c7e1cab2d5c47d70a18b9066f85123176e94e3fbd5ca1ff"

URI_x86_64_v2_libgsasl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgsasl-devel-1.10.0-17.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgsasl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgsasl-devel}"
SRC_URI[x86_64_v2_libgsasl-devel.sha256sum] = "66f6e6db396d8f4199e743d3c0fbac637e52bc4cfcf56b33b8a0e9ec98c23439"

URI_aarch64_libgsasl = "${EPEL_MIRROR}/aarch64/Packages/l/libgsasl-1.10.0-17.el10_2.aarch64.rpm;name=aarch64_libgsasl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgsasl}"
SRC_URI[aarch64_libgsasl.sha256sum] = "2ca95e5b3f6135c41e44e32cad7853ef419a063c615953a9b6285e43df01868d"

URI_aarch64_libgsasl-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgsasl-devel-1.10.0-17.el10_2.aarch64.rpm;name=aarch64_libgsasl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgsasl-devel}"
SRC_URI[aarch64_libgsasl-devel.sha256sum] = "b3bbdff03acc58965a8a23dbf4c41725833d35ef8975bdf529c9b0d72e13675d"

RDEPENDS:libgsasl = " \
 glibc \
 krb5-libs \
 libcom_err \
 libidn \
 libntlm \
 "
RDEPENDS:libgsasl-devel = " \
 libgsasl \
 pkgconf-pkg-config \
 "
