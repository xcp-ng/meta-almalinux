# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "toolbox"
PV = "0.2"
PR = "2.el10"
PACKAGES = " \
 toolbox \
 toolbox-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/toolbox-0.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4c13dbd682619ed598e44af85958bdea336579745cc5aa917aa0cd3f9b03272"

URI_x86_64_v2_toolbox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/toolbox-0.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_toolbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_toolbox}"
SRC_URI[x86_64_v2_toolbox.sha256sum] = "aa3dfb748f69d83debb06dbb4b8bcbe6593d97d9434e896007997cbae3be38fb"

URI_x86_64_v2_toolbox-tests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/toolbox-tests-0.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_toolbox-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_toolbox-tests}"
SRC_URI[x86_64_v2_toolbox-tests.sha256sum] = "32c40d7b64894b75817faf6b5d7986c7f3e5429973ff03ff17aec5bf19d561d4"

URI_aarch64_toolbox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/toolbox-0.2-2.el10.aarch64.rpm;name=aarch64_toolbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_toolbox}"
SRC_URI[aarch64_toolbox.sha256sum] = "b0837514f16b38fb5c1a524bdf3c8f4872eb794b015f226ce7d9b36528617723"

URI_aarch64_toolbox-tests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/toolbox-tests-0.2-2.el10.aarch64.rpm;name=aarch64_toolbox-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_toolbox-tests}"
SRC_URI[aarch64_toolbox-tests.sha256sum] = "eb518908f5e9acf6181c12463f2db665e54f55a55d3f9407af7493d8c026c8ac"

RDEPENDS:toolbox = " \
 containers-common \
 flatpak-session-helper \
 glibc \
 podman \
 shadow-utils-subid \
 "
RDEPENDS:toolbox-tests = " \
 diffutils \
 glib2 \
 grep \
 httpd-tools \
 openssl \
 python3 \
 skopeo \
 toolbox \
 virtual/coreutils \
 "
