# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-anyio"
PV = "4.8.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-anyio \
 python3-anyio+trio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-anyio-4.8.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0237d11c3725eeed9c718697b286d414277a62ec0dcfab82dac231c623f1e25"

URI_x86_64_v2_python3-anyio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-anyio-4.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-anyio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-anyio}"
SRC_URI[x86_64_v2_python3-anyio.sha256sum] = "0165ad0b8003632c00d74e24b9476ec86a15b18e0c83e71c700b0f52e746b120"

URI_x86_64_v2_python3-anyio+trio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-anyio+trio-4.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-anyio+trio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-anyio+trio}"
SRC_URI[x86_64_v2_python3-anyio+trio.sha256sum] = "c2f3eba4d27faf97ff42dfd83bb8e6f0d3568b9975e3043a66ed42f498f342c9"

URI_aarch64_python3-anyio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-anyio-4.8.0-1.el10_0.noarch.rpm;name=aarch64_python3-anyio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-anyio}"
SRC_URI[aarch64_python3-anyio.sha256sum] = "e62a5d9f15a8a7446959e6e9875a6c8356be2e709b00ad1d05dd0f4961dfd289"

URI_aarch64_python3-anyio+trio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-anyio+trio-4.8.0-1.el10_0.noarch.rpm;name=aarch64_python3-anyio+trio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-anyio+trio}"
SRC_URI[aarch64_python3-anyio+trio.sha256sum] = "9da183f21384b610a82960c2d9aa98f60135529412ca03bcebe20f0f90dbf703"

RDEPENDS:python3-anyio = " \
 python3 \
 python3-idna \
 python3-sniffio \
 python3-typing-extensions \
 "
RDEPENDS:python3-anyio+trio = " \
 python3 \
 python3-anyio \
 python3-trio \
 "
