# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-text-icu"
PV = "0.8.0.5"
PR = "1.el10_0"
PACKAGES = " \
 ghc-text-icu \
 ghc-text-icu-devel \
 ghc-text-icu-doc \
 ghc-text-icu-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-text-icu-0.8.0.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1bca7a397dd356f5881b45f8ac7a8b8fc7040e4af58b3824a4a496450b6c38e"

URI_x86_64_v2_ghc-text-icu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-icu-0.8.0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-icu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-icu}"
SRC_URI[x86_64_v2_ghc-text-icu.sha256sum] = "cbb9eef5e2900b01c2f888a549ff67cb3b1b1fb6600bf82301c04a7edb001f98"

URI_x86_64_v2_ghc-text-icu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-icu-devel-0.8.0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-icu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-icu-devel}"
SRC_URI[x86_64_v2_ghc-text-icu-devel.sha256sum] = "6a59cdeb03e29e6aaf98d3b6a03458e048a1b3105374fc267435e4ef96208a74"

URI_x86_64_v2_ghc-text-icu-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-icu-doc-0.8.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-text-icu-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-icu-doc}"
SRC_URI[x86_64_v2_ghc-text-icu-doc.sha256sum] = "bef4e6bbad2bd3a07340dfadc1a75d05cc75cc6b4dfdff6b256d040f840fd9dd"

URI_x86_64_v2_ghc-text-icu-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-icu-prof-0.8.0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-icu-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-icu-prof}"
SRC_URI[x86_64_v2_ghc-text-icu-prof.sha256sum] = "2fc4163fb20d02d4bc09b9cdc3a9791b7184390f1cfe25f2123e31f006ab8f0a"

URI_aarch64_ghc-text-icu = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-icu-0.8.0.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-text-icu;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-icu}"
SRC_URI[aarch64_ghc-text-icu.sha256sum] = "535bda1068c8ce60f53f4cc586687e8053ec5cc374a229d58943f15f8f78f3e7"

URI_aarch64_ghc-text-icu-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-icu-devel-0.8.0.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-text-icu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-icu-devel}"
SRC_URI[aarch64_ghc-text-icu-devel.sha256sum] = "12e9787fdb2d677c035cacc2c7dcfe6af04a19466f615bfd56fc161a66b54f22"

URI_aarch64_ghc-text-icu-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-icu-doc-0.8.0.5-1.el10_0.noarch.rpm;name=aarch64_ghc-text-icu-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-icu-doc}"
SRC_URI[aarch64_ghc-text-icu-doc.sha256sum] = "aa97002b5c55cc06597df0c2d552f77dc74ee22304c637ed960239d37f48150c"

URI_aarch64_ghc-text-icu-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-icu-prof-0.8.0.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-text-icu-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-icu-prof}"
SRC_URI[aarch64_ghc-text-icu-prof.sha256sum] = "1c7258070c58dba5c98073e153100e17d661622415ebaecd25003e1617751970"

RDEPENDS:ghc-text-icu = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 glibc \
 gmp \
 libicu \
 "
RDEPENDS:ghc-text-icu-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-text-devel \
 ghc-text-icu \
 ghc-time-devel \
 libicu-devel \
 "
RDEPENDS:ghc-text-icu-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-text-icu-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-deepseq-prof \
 ghc-text-icu-devel \
 ghc-text-prof \
 ghc-time-prof \
 "
