# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdeflate"
PV = "1.25"
PR = "2.el10_1"
PACKAGES = " \
 libdeflate \
 libdeflate-devel \
 libdeflate-utils \
 mingw32-libdeflate \
 mingw32-libdeflate-utils \
 mingw64-libdeflate \
 mingw64-libdeflate-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdeflate-1.25-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee34dac5f21d244522e2df09f5cce68c06d55374db75b3d8ac46fada911f45ed"

URI_x86_64_v2_libdeflate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdeflate-1.25-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdeflate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdeflate}"
SRC_URI[x86_64_v2_libdeflate.sha256sum] = "81c52b6d16b45ae34fc14b51d315c262ccba736b79fa6f8ea1fc5d31880310eb"

URI_x86_64_v2_libdeflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdeflate-devel-1.25-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdeflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdeflate-devel}"
SRC_URI[x86_64_v2_libdeflate-devel.sha256sum] = "86c6e8b4a054891e2d015c46108a7e16d90dfd6d3f595dd47a834a9ffb708391"

URI_x86_64_v2_libdeflate-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdeflate-utils-1.25-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdeflate-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdeflate-utils}"
SRC_URI[x86_64_v2_libdeflate-utils.sha256sum] = "a9763a9a176c026baf7303b0bc487c337e511b5e939dc064ce88c157508e2597"

URI_x86_64_v2_mingw32-libdeflate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-libdeflate-1.25-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-libdeflate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-libdeflate}"
SRC_URI[x86_64_v2_mingw32-libdeflate.sha256sum] = "b99c7bfbbddc64484e45eb176d888cfea1f7d2cd77cc074fb0c56d133c426531"

URI_x86_64_v2_mingw32-libdeflate-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-libdeflate-utils-1.25-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-libdeflate-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-libdeflate-utils}"
SRC_URI[x86_64_v2_mingw32-libdeflate-utils.sha256sum] = "d9268fab39b308718ae06a32aa76cbd7f6d4a5115617e9c94cc3deb55457c6c6"

URI_x86_64_v2_mingw64-libdeflate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-libdeflate-1.25-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-libdeflate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-libdeflate}"
SRC_URI[x86_64_v2_mingw64-libdeflate.sha256sum] = "fc1ef3d5b728bfda801eeac6870beac98afef522d31a8d7ad85ba223f26bd9df"

URI_x86_64_v2_mingw64-libdeflate-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-libdeflate-utils-1.25-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-libdeflate-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-libdeflate-utils}"
SRC_URI[x86_64_v2_mingw64-libdeflate-utils.sha256sum] = "6a60ff94b4e4d6b43d99597b58cdeec174dba7f63bc3cc931e861a275527abbb"

URI_aarch64_libdeflate = "${EPEL_MIRROR}/aarch64/Packages/l/libdeflate-1.25-2.el10_1.aarch64.rpm;name=aarch64_libdeflate;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdeflate}"
SRC_URI[aarch64_libdeflate.sha256sum] = "819d0573face9b583d7a139d56b68ab8810f010260aa42b64abe2e2d5e71e4c4"

URI_aarch64_libdeflate-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdeflate-devel-1.25-2.el10_1.aarch64.rpm;name=aarch64_libdeflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdeflate-devel}"
SRC_URI[aarch64_libdeflate-devel.sha256sum] = "a50c41b78c613dbe71a1162d2f3b00a1d9293666462587c6fb186a57990e82c8"

URI_aarch64_libdeflate-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libdeflate-utils-1.25-2.el10_1.aarch64.rpm;name=aarch64_libdeflate-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdeflate-utils}"
SRC_URI[aarch64_libdeflate-utils.sha256sum] = "a88f31c2a35745898f6dd396323e575b59078cb80b08034651c937d39a79fd93"

URI_aarch64_mingw32-libdeflate = "${EPEL_MIRROR}/aarch64/Packages/m/mingw32-libdeflate-1.25-2.el10_1.noarch.rpm;name=aarch64_mingw32-libdeflate;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-libdeflate}"
SRC_URI[aarch64_mingw32-libdeflate.sha256sum] = "c37c9fcb61958c06810522494e3e0fe0bf50f0f743eb983b878b8f351b76c232"

URI_aarch64_mingw32-libdeflate-utils = "${EPEL_MIRROR}/aarch64/Packages/m/mingw32-libdeflate-utils-1.25-2.el10_1.noarch.rpm;name=aarch64_mingw32-libdeflate-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-libdeflate-utils}"
SRC_URI[aarch64_mingw32-libdeflate-utils.sha256sum] = "5cb4b9afc81ba37c07ce0dacfc447288f972f896018798d19b66d4bf895c2220"

URI_aarch64_mingw64-libdeflate = "${EPEL_MIRROR}/aarch64/Packages/m/mingw64-libdeflate-1.25-2.el10_1.noarch.rpm;name=aarch64_mingw64-libdeflate;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-libdeflate}"
SRC_URI[aarch64_mingw64-libdeflate.sha256sum] = "f17a4765bd44b9b1f10b138ed73782c82742cc2748e4cc448fd50a33866faa64"

URI_aarch64_mingw64-libdeflate-utils = "${EPEL_MIRROR}/aarch64/Packages/m/mingw64-libdeflate-utils-1.25-2.el10_1.noarch.rpm;name=aarch64_mingw64-libdeflate-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-libdeflate-utils}"
SRC_URI[aarch64_mingw64-libdeflate-utils.sha256sum] = "27cf78803633e04df9426e4752b0b149f36b7d657f27adf97b1f8022d9c0f27d"

RDEPENDS:libdeflate = " \
 glibc \
 "
RDEPENDS:libdeflate-devel = " \
 cmake-filesystem \
 libdeflate \
 pkgconf-pkg-config \
 "
RDEPENDS:libdeflate-utils = " \
 glibc \
 libdeflate \
 "
RDEPENDS:mingw32-libdeflate = " \
 mingw32-crt \
 mingw32-filesystem \
 "
RDEPENDS:mingw32-libdeflate-utils = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libdeflate \
 "
RDEPENDS:mingw64-libdeflate = " \
 mingw64-crt \
 mingw64-filesystem \
 "
RDEPENDS:mingw64-libdeflate-utils = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-libdeflate \
 "
