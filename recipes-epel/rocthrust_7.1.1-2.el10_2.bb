# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocthrust"
PV = "7.1.1"
PR = "2.el10_2"
PACKAGES:x86_64_v2 = " \
 rocthrust-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocthrust-7.1.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74bce2d7afdd3f246bc4acc35798a075c5f650c53bfc1b7c85f79536dbe8b5d3"

URI_x86_64_v2_rocthrust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocthrust-devel-7.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocthrust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocthrust-devel}"
SRC_URI[x86_64_v2_rocthrust-devel.sha256sum] = "c26914f0dbb04072fe06c4f21d31aed2c7135ed6400cc946856ef894a70da54d"

RDEPENDS:rocthrust-devel = " \
 cmake-filesystem \
 "
