# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-urllib3"
PV = "1.26.19"
PR = "2.el10"
PACKAGES = " \
 python3-urllib3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-urllib3-1.26.19-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6cdd2c85a3333c3c4f4efa1a8b5df385578b348044e3eb7c333c07153543e43a"

URI_x86_64_v2_python3-urllib3 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-urllib3-1.26.19-2.el10.noarch.rpm;name=x86_64_v2_python3-urllib3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-urllib3}"
SRC_URI[x86_64_v2_python3-urllib3.sha256sum] = "759531e2e5a8a2254349ae91b046a3397e5633b31a562e252409a0aee4d7bc0f"

URI_aarch64_python3-urllib3 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-urllib3-1.26.19-2.el10.noarch.rpm;name=aarch64_python3-urllib3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-urllib3}"
SRC_URI[aarch64_python3-urllib3.sha256sum] = "759531e2e5a8a2254349ae91b046a3397e5633b31a562e252409a0aee4d7bc0f"

RDEPENDS:python3-urllib3 = " \
 ca-certificates \
 python3 \
 python3-idna \
 "
