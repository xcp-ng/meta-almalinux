# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "marble"
PE = "1"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 marble \
 marble-astro \
 marble-astro-devel \
 marble-common \
 marble-plasma \
 marble-qt \
 marble-widget-data \
 marble-widget-qt6 \
 marble-widget-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/marble-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58c0063381ee445ebec05b09ab689c0f2c16bc488d9d670029594357c2af2132"

URI_x86_64_v2_marble = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble}"
SRC_URI[x86_64_v2_marble.sha256sum] = "6a000be54b1cab699727720e7685c18b799e614561f9aff0b54420cd8ab7e06f"

URI_x86_64_v2_marble-astro = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-astro-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-astro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-astro}"
SRC_URI[x86_64_v2_marble-astro.sha256sum] = "2f60d0be31261db5663345427798981dc8a76bf6779e49cfed19a8f246cc20ba"

URI_x86_64_v2_marble-astro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-astro-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-astro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-astro-devel}"
SRC_URI[x86_64_v2_marble-astro-devel.sha256sum] = "80caf8019d8b4a4e4b1e3ee92b3b841686a2f194ff8ce4d995d1d97ef094523a"

URI_x86_64_v2_marble-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-common-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_marble-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-common}"
SRC_URI[x86_64_v2_marble-common.sha256sum] = "25450d3a5b1a578ee8d3107e23404edf52b93c277be03af71cb339839b6627a1"

URI_x86_64_v2_marble-plasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-plasma-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-plasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-plasma}"
SRC_URI[x86_64_v2_marble-plasma.sha256sum] = "d130a3a6efbd1aef59c22f389fd9fa76b58b8ac9ac6032e53e1a302ed41e88f5"

URI_x86_64_v2_marble-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-qt-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-qt}"
SRC_URI[x86_64_v2_marble-qt.sha256sum] = "72b33ce083d93e05a676e664f3130d4f5db1940da9b98c79ca7ad1d6581457a2"

URI_x86_64_v2_marble-widget-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-widget-data-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_marble-widget-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-widget-data}"
SRC_URI[x86_64_v2_marble-widget-data.sha256sum] = "ced4c991a857b174946f2a40660c7220ebbaa7850e1e2c4a3ad4cdc65758ce7c"

URI_x86_64_v2_marble-widget-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-widget-qt6-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-widget-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-widget-qt6}"
SRC_URI[x86_64_v2_marble-widget-qt6.sha256sum] = "fb934d86052387d52a2e6332e83c617cac2bd8a3d1e4eef98f4e0cc409faa7d7"

URI_x86_64_v2_marble-widget-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-widget-qt6-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-widget-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-widget-qt6-devel}"
SRC_URI[x86_64_v2_marble-widget-qt6-devel.sha256sum] = "2f64ebaf800cb1fc0d37070afeeb7465544872e00774412d6b775c5508b01412"

URI_aarch64_marble = "${EPEL_MIRROR}/aarch64/Packages/m/marble-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_marble;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble}"
SRC_URI[aarch64_marble.sha256sum] = "5e8c41a878d173fec6a2daf8def79e211930a85140562efbaffbf794ee05d893"

URI_aarch64_marble-astro = "${EPEL_MIRROR}/aarch64/Packages/m/marble-astro-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_marble-astro;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-astro}"
SRC_URI[aarch64_marble-astro.sha256sum] = "65f604e408c39d3c1ddba8892e06612a9427f55670ff819c07b273edbf0a0722"

URI_aarch64_marble-astro-devel = "${EPEL_MIRROR}/aarch64/Packages/m/marble-astro-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_marble-astro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-astro-devel}"
SRC_URI[aarch64_marble-astro-devel.sha256sum] = "f18784a0aade58dd0d89d326be6fe6faa9860720a3ac281d05a9eaabb4e34a42"

URI_aarch64_marble-common = "${EPEL_MIRROR}/aarch64/Packages/m/marble-common-26.04.3-1.el10_3.noarch.rpm;name=aarch64_marble-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-common}"
SRC_URI[aarch64_marble-common.sha256sum] = "0faa9260e763d60d91d4c54a63068569d96995610c141a48ffdf22e14d6ec4cd"

URI_aarch64_marble-plasma = "${EPEL_MIRROR}/aarch64/Packages/m/marble-plasma-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_marble-plasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-plasma}"
SRC_URI[aarch64_marble-plasma.sha256sum] = "4fad18df2796bc0f84462020cf25567be86bb7a01db652c4954d0987560ddba1"

URI_aarch64_marble-qt = "${EPEL_MIRROR}/aarch64/Packages/m/marble-qt-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_marble-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-qt}"
SRC_URI[aarch64_marble-qt.sha256sum] = "728f681c2dcb3b1f537139d930a6dca81b8901112fedfcfbf4e926d61ce0ead6"

URI_aarch64_marble-widget-data = "${EPEL_MIRROR}/aarch64/Packages/m/marble-widget-data-26.04.3-1.el10_3.noarch.rpm;name=aarch64_marble-widget-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-widget-data}"
SRC_URI[aarch64_marble-widget-data.sha256sum] = "7d5710dfc058699f6f7007abb2f5ed8e41fc9c489ce5bb37a986dbdee6a2475a"

URI_aarch64_marble-widget-qt6 = "${EPEL_MIRROR}/aarch64/Packages/m/marble-widget-qt6-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_marble-widget-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-widget-qt6}"
SRC_URI[aarch64_marble-widget-qt6.sha256sum] = "4e3aca0f423a53443055793d4dd7ad6d8eefc8de4b8978c6afeb02a059a56bbc"

URI_aarch64_marble-widget-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/m/marble-widget-qt6-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_marble-widget-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-widget-qt6-devel}"
SRC_URI[aarch64_marble-widget-qt6-devel.sha256sum] = "73b856a6c9d75dbcc212b40d94db4a981811694ef3408cf1e79d5efd4dac90d3"

RDEPENDS:marble = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 marble-widget-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 "
RDEPENDS:marble-astro = " \
 glibc \
 libstdc++ \
 marble-common \
 "
RDEPENDS:marble-astro-devel = " \
 cmake-filesystem \
 marble-astro \
 "
RDEPENDS:marble-common = " \
 "
RDEPENDS:marble-plasma = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-krunner \
 libstdc++ \
 marble-common \
 marble-widget-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:marble-qt = " \
 glibc \
 libstdc++ \
 marble-common \
 marble-widget-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:marble-widget-data = " \
 marble-common \
 "
RDEPENDS:marble-widget-qt6 = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 marble-astro \
 marble-widget-data \
 phonon-qt6 \
 protobuf \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 qt6-qtserialport \
 qt6-qtsvg \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 shapelib \
 zlib-ng-compat \
 "
RDEPENDS:marble-widget-qt6-devel = " \
 cmake-filesystem \
 marble-widget-qt6 \
 qt6-qt5compat-devel \
 qt6-qtbase-devel \
 qt6-qtwebengine-devel \
 "
