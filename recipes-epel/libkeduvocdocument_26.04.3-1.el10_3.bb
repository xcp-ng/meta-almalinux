# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkeduvocdocument"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 libkeduvocdocument \
 libkeduvocdocument-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkeduvocdocument-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78b6dd1ae7f855b35795749d9058b681947df295698263310ced34af09c00eff"

URI_x86_64_v2_libkeduvocdocument = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkeduvocdocument-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkeduvocdocument;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkeduvocdocument}"
SRC_URI[x86_64_v2_libkeduvocdocument.sha256sum] = "ff2fd8b4070e9d25fc76f7f2cc36fd4b5b279804cf4e366ea59ebe49804fd6fc"

URI_x86_64_v2_libkeduvocdocument-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkeduvocdocument-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkeduvocdocument-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkeduvocdocument-devel}"
SRC_URI[x86_64_v2_libkeduvocdocument-devel.sha256sum] = "b9fff745e33d586eaa7ff8f6448d854a45ac9ab5cbb73b21e06ea1c10b60345c"

URI_aarch64_libkeduvocdocument = "${EPEL_MIRROR}/aarch64/Packages/l/libkeduvocdocument-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkeduvocdocument;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkeduvocdocument}"
SRC_URI[aarch64_libkeduvocdocument.sha256sum] = "6d8e0442a9eeb49a94ed6779411cfaa8e4a0ee5c3882bc8cca40f97ac91cc442"

URI_aarch64_libkeduvocdocument-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkeduvocdocument-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkeduvocdocument-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkeduvocdocument-devel}"
SRC_URI[aarch64_libkeduvocdocument-devel.sha256sum] = "fc81fd11aacb7c4badfe522f3e0d94d81443e0376196d308572708b6fa6d8b16"

RDEPENDS:libkeduvocdocument = " \
 glibc \
 kdeedu-data \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:libkeduvocdocument-devel = " \
 cmake-filesystem \
 libkeduvocdocument \
 "
