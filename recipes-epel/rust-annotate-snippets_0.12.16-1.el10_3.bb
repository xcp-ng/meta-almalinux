# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-annotate-snippets"
PV = "0.12.16"
PR = "1.el10_3"
PACKAGES = " \
 rust-annotate-snippets+default-devel \
 rust-annotate-snippets+simd-devel \
 rust-annotate-snippets+std-devel \
 rust-annotate-snippets+testing-colors-devel \
 rust-annotate-snippets-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-annotate-snippets-0.12.16-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ee9a85818c24b1a5e595f708241fa58b4147d62aef5c978f68329b95924e32e"

URI_x86_64_v2_rust-annotate-snippets+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets+default-devel-0.12.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets+default-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets+default-devel.sha256sum] = "1385e6ef6b0db2e550931c22fb2397537848c47a132735e983d711618f1cad21"

URI_x86_64_v2_rust-annotate-snippets+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets+simd-devel-0.12.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets+simd-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets+simd-devel.sha256sum] = "fc73e3af566428c4b40dc97620f8b649f094e8523a7cb25607a80f9d0795eebf"

URI_x86_64_v2_rust-annotate-snippets+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets+std-devel-0.12.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets+std-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets+std-devel.sha256sum] = "f75dda4f27eca8546af93e51b42bc6281c5c9a5f1ac4795f0cd2cdf7e0638c10"

URI_x86_64_v2_rust-annotate-snippets+testing-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets+testing-colors-devel-0.12.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets+testing-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets+testing-colors-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets+testing-colors-devel.sha256sum] = "2b88e378ebe7b8d76188a27572b864aa7303f308d105342c17458974a0036307"

URI_x86_64_v2_rust-annotate-snippets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets-devel-0.12.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets-devel.sha256sum] = "c0d1bc8dbb02a732aefa7ff9930b7bb7fe708d68f48e214c1bbe9d7ee4a76c49"

URI_aarch64_rust-annotate-snippets+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets+default-devel-0.12.16-1.el10_3.noarch.rpm;name=aarch64_rust-annotate-snippets+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets+default-devel}"
SRC_URI[aarch64_rust-annotate-snippets+default-devel.sha256sum] = "e4aaa62c0ceb3cf97b06cb8438b81d017fad33e4c863d87c186482109cbd69d5"

URI_aarch64_rust-annotate-snippets+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets+simd-devel-0.12.16-1.el10_3.noarch.rpm;name=aarch64_rust-annotate-snippets+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets+simd-devel}"
SRC_URI[aarch64_rust-annotate-snippets+simd-devel.sha256sum] = "4cb369cf714e7556818e1ba9ff37acd8a37da47c5bdacb95439564da88f9b1ba"

URI_aarch64_rust-annotate-snippets+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets+std-devel-0.12.16-1.el10_3.noarch.rpm;name=aarch64_rust-annotate-snippets+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets+std-devel}"
SRC_URI[aarch64_rust-annotate-snippets+std-devel.sha256sum] = "ffee43a8c6c3a0a847eab0dcf120a681ba50720468cdb22ca780501af68862a8"

URI_aarch64_rust-annotate-snippets+testing-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets+testing-colors-devel-0.12.16-1.el10_3.noarch.rpm;name=aarch64_rust-annotate-snippets+testing-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets+testing-colors-devel}"
SRC_URI[aarch64_rust-annotate-snippets+testing-colors-devel.sha256sum] = "76686ea13847e46c41de415139ef93070c8b24ec6e542efa502614bd7dd863aa"

URI_aarch64_rust-annotate-snippets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets-devel-0.12.16-1.el10_3.noarch.rpm;name=aarch64_rust-annotate-snippets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets-devel}"
SRC_URI[aarch64_rust-annotate-snippets-devel.sha256sum] = "5c0403d6ae47944623b1862de3ca62b4073a095f32a779149eef10edbcf6220e"

RDEPENDS:rust-annotate-snippets+default-devel = " \
 cargo \
 rust-annotate-snippets+std-devel \
 rust-annotate-snippets-devel \
 "
RDEPENDS:rust-annotate-snippets+simd-devel = " \
 cargo \
 rust-annotate-snippets-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-annotate-snippets+std-devel = " \
 cargo \
 rust-annotate-snippets-devel \
 rust-anstyle+std-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-annotate-snippets+testing-colors-devel = " \
 cargo \
 rust-annotate-snippets-devel \
 "
RDEPENDS:rust-annotate-snippets-devel = " \
 cargo \
 rust \
 rust-anstyle-devel \
 rust-unicode-width+default-devel \
 "
