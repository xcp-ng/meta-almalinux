# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Constraint"
PV = "1.204"
PR = "2.el10_0"
PACKAGES = " \
 perl-Data-Constraint \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Constraint-1.204-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92f26b75ef041294157d1a8c7cffd60c57053a4906a172f1a10d8e5d2e5315ce"

URI_x86_64_v2_perl-Data-Constraint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Constraint-1.204-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Constraint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Constraint}"
SRC_URI[x86_64_v2_perl-Data-Constraint.sha256sum] = "3d9e294089dc60b5c60c5918f004becf1e75fe53d20a51b9fe37ed3c9c25576b"

URI_aarch64_perl-Data-Constraint = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Constraint-1.204-2.el10_0.noarch.rpm;name=aarch64_perl-Data-Constraint;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Constraint}"
SRC_URI[aarch64_perl-Data-Constraint.sha256sum] = "367ee037a7eb589f24d13746d6a251c69c8832a4098c5a2ebb825c2164fddd73"

RDEPENDS:perl-Data-Constraint = " \
 perl-Class-Prototyped \
 perl-base \
 perl-libs \
 "
