# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustyline-derive"
PV = "0.11.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustyline-derive+default-devel \
 rust-rustyline-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustyline-derive-0.11.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fb218461587cee2c2a3979157648879c4189c3353c7016a5bc3b53716f1aa83"

URI_x86_64_v2_rust-rustyline-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline-derive+default-devel-0.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline-derive+default-devel}"
SRC_URI[x86_64_v2_rust-rustyline-derive+default-devel.sha256sum] = "e00b1e4dcffd0d2344d614b9f98086b80abdcced57291348d98880f9f4a16082"

URI_x86_64_v2_rust-rustyline-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline-derive-devel-0.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline-derive-devel}"
SRC_URI[x86_64_v2_rust-rustyline-derive-devel.sha256sum] = "94ac3b8f6c82958a849f4836e7e3e4698d58a9d166a7947cbb1d9b4e6afce8c0"

URI_aarch64_rust-rustyline-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline-derive+default-devel-0.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline-derive+default-devel}"
SRC_URI[aarch64_rust-rustyline-derive+default-devel.sha256sum] = "55f1323baa4e34f75d95e08061d780feb341fafd71ab52b678f5c13637277613"

URI_aarch64_rust-rustyline-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline-derive-devel-0.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline-derive-devel}"
SRC_URI[aarch64_rust-rustyline-derive-devel.sha256sum] = "e0472a973e568dad684332144f0b92c63ceefa149d9dea52ed85d272f7d584cc"

RDEPENDS:rust-rustyline-derive+default-devel = " \
 cargo \
 rust-rustyline-derive-devel \
 "
RDEPENDS:rust-rustyline-derive-devel = " \
 cargo \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn2+derive-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2+proc-macro-devel \
 rust-syn2-devel \
 "
