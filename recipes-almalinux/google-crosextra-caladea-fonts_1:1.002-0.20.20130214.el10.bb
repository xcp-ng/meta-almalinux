# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-crosextra-caladea-fonts"
PE = "1"
PV = "1.002"
PR = "0.20.20130214.el10"
PACKAGES = " \
 google-crosextra-caladea-fonts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/google-crosextra-caladea-fonts-1.002-0.20.20130214.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a1ef20435ff175411461233c51aa89aa718233cc4ac66fbe4eb1a7580ecba3a"

URI_x86_64_v2_google-crosextra-caladea-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/google-crosextra-caladea-fonts-1.002-0.20.20130214.el10.noarch.rpm;name=x86_64_v2_google-crosextra-caladea-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-crosextra-caladea-fonts}"
SRC_URI[x86_64_v2_google-crosextra-caladea-fonts.sha256sum] = "9581d07eb1a6059023afd3e229d58e336f9ddb9e72455a31bd74c513a818a50f"

URI_aarch64_google-crosextra-caladea-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/google-crosextra-caladea-fonts-1.002-0.20.20130214.el10.noarch.rpm;name=aarch64_google-crosextra-caladea-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-crosextra-caladea-fonts}"
SRC_URI[aarch64_google-crosextra-caladea-fonts.sha256sum] = "9581d07eb1a6059023afd3e229d58e336f9ddb9e72455a31bd74c513a818a50f"

RDEPENDS:google-crosextra-caladea-fonts = " \
 fonts-filesystem \
 "
