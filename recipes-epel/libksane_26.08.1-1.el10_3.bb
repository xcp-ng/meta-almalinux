# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libksane"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 libksane \
 libksane-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libksane-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ac1ff1ead6f14590da431ac8c3fd580134b2732c6c2003c8352be712b72334d9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksane-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksane;unpack=0"
SRC_URI[x86_64_v2_libksane.sha256sum] = "b7d1d14cabcdb0f36f6562068d94b7c410a4a94243a4ca34f4304fdfc0638c37"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksane-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksane-devel;unpack=0"
SRC_URI[x86_64_v2_libksane-devel.sha256sum] = "5354d7ff5f5d08b2bcd6328b908521779d9f0f327560d48f96d16983651350c1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libksane-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libksane;unpack=0"
SRC_URI[aarch64_libksane.sha256sum] = "b3279b7aa7579c3129c18e41d935874b002b9908a8605f41bd11ede3a0bd64f8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libksane-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libksane-devel;unpack=0"
SRC_URI[aarch64_libksane-devel.sha256sum] = "b78e149b97692110456ce182c7fdc31f6ee95debaf91817e68e35e80a61c74c1"

RDEPENDS:libksane = " \
 glibc \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 ksanecore \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libksane-devel = " \
 cmake-filesystem \
 libksane \
 qt6-qtbase-devel \
 "
