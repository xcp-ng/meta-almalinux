# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cepces"
PV = "0.3.9"
PR = "2.el10"
PACKAGES = " \
 cepces \
 cepces-certmonger \
 cepces-selinux \
 python3-cepces \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cepces-0.3.9-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "27dcd2cb00fc5a67abd599b1654fd923bfa139366f6ed0525dcaa37a1cb31563"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cepces-0.3.9-2.el10.noarch.rpm;name=x86_64_v2_cepces;unpack=0"
SRC_URI[x86_64_v2_cepces.sha256sum] = "424c9ea3c6d06a317a49d0e9e5b3dd285c279c18fe204f8e9e9a209a334d61a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cepces-certmonger-0.3.9-2.el10.noarch.rpm;name=x86_64_v2_cepces-certmonger;unpack=0"
SRC_URI[x86_64_v2_cepces-certmonger.sha256sum] = "9ef49f635224af8ed17eae40d35e9fc555f2da7590398eff114642d1b9bb849e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cepces-selinux-0.3.9-2.el10.noarch.rpm;name=x86_64_v2_cepces-selinux;unpack=0"
SRC_URI[x86_64_v2_cepces-selinux.sha256sum] = "c39544e0c58c698221d52cd1530020f068c7deb672fd777b73cdbea20d6ae13c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-cepces-0.3.9-2.el10.noarch.rpm;name=x86_64_v2_python3-cepces;unpack=0"
SRC_URI[x86_64_v2_python3-cepces.sha256sum] = "b932dde9aab756edc815fc05f407f75ac245339f05e0d849d2e2834a10bc271d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cepces-0.3.9-2.el10.noarch.rpm;name=aarch64_cepces;unpack=0"
SRC_URI[aarch64_cepces.sha256sum] = "424c9ea3c6d06a317a49d0e9e5b3dd285c279c18fe204f8e9e9a209a334d61a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cepces-certmonger-0.3.9-2.el10.noarch.rpm;name=aarch64_cepces-certmonger;unpack=0"
SRC_URI[aarch64_cepces-certmonger.sha256sum] = "9ef49f635224af8ed17eae40d35e9fc555f2da7590398eff114642d1b9bb849e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cepces-selinux-0.3.9-2.el10.noarch.rpm;name=aarch64_cepces-selinux;unpack=0"
SRC_URI[aarch64_cepces-selinux.sha256sum] = "c39544e0c58c698221d52cd1530020f068c7deb672fd777b73cdbea20d6ae13c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-cepces-0.3.9-2.el10.noarch.rpm;name=aarch64_python3-cepces;unpack=0"
SRC_URI[aarch64_python3-cepces.sha256sum] = "b932dde9aab756edc815fc05f407f75ac245339f05e0d849d2e2834a10bc271d"

RDEPENDS:cepces = " \
 cepces-selinux \
 python3-cepces \
 "
RDEPENDS:cepces-certmonger = " \
 bash \
 cepces \
 certmonger \
 python3 \
 "
RDEPENDS:cepces-selinux = " \
 bash \
 cepces \
 selinux-policy-targeted \
 "
RDEPENDS:python3-cepces = " \
 python3 \
 python3-cryptography \
 python3-gssapi \
 python3-requests \
 python3-requests-gssapi \
 python3-setuptools \
 "
