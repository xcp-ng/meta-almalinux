# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mitchellh-mapstructure"
PV = "1.5.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-mitchellh-mapstructure-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-mitchellh-mapstructure-1.5.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85221104a950a4c5eab1267faaaccc027ba98d34ae8b850ac1c4bcb68a1c2125"

URI_x86_64_v2_golang-github-mitchellh-mapstructure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-mitchellh-mapstructure-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-mitchellh-mapstructure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-mitchellh-mapstructure-devel}"
SRC_URI[x86_64_v2_golang-github-mitchellh-mapstructure-devel.sha256sum] = "cb3a3327a804a70df9d472da478172d4e38b1450e1c40e1d3272e79f68ab1a8b"

URI_aarch64_golang-github-mitchellh-mapstructure-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mitchellh-mapstructure-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-mitchellh-mapstructure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mitchellh-mapstructure-devel}"
SRC_URI[aarch64_golang-github-mitchellh-mapstructure-devel.sha256sum] = "1a5021df5d7120656d416967dc2d9ffcfba7c3dd5405d86586af3d91b303bcbe"

RDEPENDS:golang-github-mitchellh-mapstructure-devel = " \
 go-filesystem \
 "
