# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-packaging"
PV = "1"
PR = "21.el10_1"
PACKAGES = " \
 ansible-packaging \
 ansible-packaging-tests \
 ansible-srpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-packaging-1-21.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a07d43da032111dbeda1d64213428866fc81622586427becb332316d09cc408"

URI_x86_64_v2_ansible-packaging = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-packaging-1-21.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-packaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-packaging}"
SRC_URI[x86_64_v2_ansible-packaging.sha256sum] = "d6d07a90d77c76bd1093fad8260df13e3ff724247e1511262484f4b05f58b703"

URI_x86_64_v2_ansible-packaging-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-packaging-tests-1-21.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-packaging-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-packaging-tests}"
SRC_URI[x86_64_v2_ansible-packaging-tests.sha256sum] = "99197b09118306b8de6822508f359543d6f4f1669322a3cd825087e8d6dbc230"

URI_x86_64_v2_ansible-srpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-srpm-macros-1-21.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-srpm-macros}"
SRC_URI[x86_64_v2_ansible-srpm-macros.sha256sum] = "56301aee704b0a87586b064a7b167bf883159daefc24b9bd170da61cd8e05639"

URI_aarch64_ansible-packaging = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-packaging-1-21.el10_1.noarch.rpm;name=aarch64_ansible-packaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-packaging}"
SRC_URI[aarch64_ansible-packaging.sha256sum] = "28ac68bba3d38e5d9729d11aa865d63500b9db583bc6483c2bcdb7997a8dee76"

URI_aarch64_ansible-packaging-tests = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-packaging-tests-1-21.el10_1.noarch.rpm;name=aarch64_ansible-packaging-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-packaging-tests}"
SRC_URI[aarch64_ansible-packaging-tests.sha256sum] = "60ed69d2073d4f878041a8b67fd3a3790285ad01c078da0571f3d6ca098869aa"

URI_aarch64_ansible-srpm-macros = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-srpm-macros-1-21.el10_1.noarch.rpm;name=aarch64_ansible-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-srpm-macros}"
SRC_URI[aarch64_ansible-srpm-macros.sha256sum] = "3957737e7e79a0882e2c0267dc7abeacca79c967b67145fba603f69ffebf44ed"

RDEPENDS:ansible-packaging = " \
 ansible-core \
 ansible-srpm-macros \
 python3 \
 python3-pyyaml \
 "
RDEPENDS:ansible-packaging-tests = " \
 ansible-packaging \
 ansible-test \
 python3-pytest \
 python3-pytest-forked \
 python3-pytest-mock \
 python3-pytest-xdist \
 python3-pyyaml \
 "
RDEPENDS:ansible-srpm-macros = " \
 "
