# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtwayland"
PV = "6.9.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtwayland \
 qt6-qtwayland-devel \
 qt6-qtwayland-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtwayland-6.9.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4274a562c56d28bda72c991666de2eea9f0f9efb262f97432f11ea75e964b0b7"

URI_x86_64_v2_qt6-qtwayland = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwayland-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwayland}"
SRC_URI[x86_64_v2_qt6-qtwayland.sha256sum] = "40dc5966f084297d2f5ca99306724cc70611398657b5055e59169ed728a3f682"

URI_x86_64_v2_qt6-qtwayland-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwayland-devel-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwayland-devel}"
SRC_URI[x86_64_v2_qt6-qtwayland-devel.sha256sum] = "dad463697126fbbb444db50b4b7b08ee4faa09b12188cb0a9fc641b48d9c9b32"

URI_x86_64_v2_qt6-qtwayland-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtwayland-examples-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwayland-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwayland-examples}"
SRC_URI[x86_64_v2_qt6-qtwayland-examples.sha256sum] = "bb648926017a240e47579fe379bed455aee273e9e2c5e9e01f1376bd0fdaefd5"

URI_aarch64_qt6-qtwayland = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwayland-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtwayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwayland}"
SRC_URI[aarch64_qt6-qtwayland.sha256sum] = "5b496effe950d8172d8be6f2e99ba20081c6894f11c3b21ac5fc7ddf46c17244"

URI_aarch64_qt6-qtwayland-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwayland-devel-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtwayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwayland-devel}"
SRC_URI[aarch64_qt6-qtwayland-devel.sha256sum] = "9d08f495197f8862e70a477494397f76d9927a413a6d41c5f693f5d6dba7ecbd"

URI_aarch64_qt6-qtwayland-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtwayland-examples-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtwayland-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwayland-examples}"
SRC_URI[aarch64_qt6-qtwayland-examples.sha256sum] = "5dda4d02b580161f10045509acaff57696865541e36452103caa4d6f3ea6eb0e"

RDEPENDS:qt6-qtwayland = " \
 glibc \
 libglvnd-egl \
 libglvnd-opengl \
 libstdc++ \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libwayland-server \
 libxkbcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:qt6-qtwayland-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtwayland \
 wayland-devel \
 "
RDEPENDS:qt6-qtwayland-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 "
