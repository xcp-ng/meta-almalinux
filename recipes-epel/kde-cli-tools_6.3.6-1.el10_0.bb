# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-cli-tools"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 kde-cli-tools \
 kdesu \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-cli-tools-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "deeaf86b2dce496c55dab0504290471d3752c2c9e2886843ce6c2b1927fbc38b"

URI_x86_64_v2_kde-cli-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-cli-tools-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-cli-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-cli-tools}"
SRC_URI[x86_64_v2_kde-cli-tools.sha256sum] = "dbd5bb10372f13b3fb1fefeaf88bb14eedae4f941bc26e2e3f50ca5788f0b455"

URI_x86_64_v2_kdesu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdesu-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdesu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdesu}"
SRC_URI[x86_64_v2_kdesu.sha256sum] = "67813b4fe0818bef93b0fee1c91e57993c3b13acd13e1fa9f3ca9782486b6e4c"

URI_aarch64_kde-cli-tools = "${EPEL_MIRROR}/aarch64/Packages/k/kde-cli-tools-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kde-cli-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-cli-tools}"
SRC_URI[aarch64_kde-cli-tools.sha256sum] = "a7095173b59683953d1e4b309e61b643df4685a52c34e573ae9026a86952be61"

URI_aarch64_kdesu = "${EPEL_MIRROR}/aarch64/Packages/k/kdesu-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kdesu;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdesu}"
SRC_URI[aarch64_kdesu.sha256sum] = "db7790be16f802faabbee05c46658f7ffc0c85aa3b3861c8dab15ee3fcf0e3a7"

RDEPENDS:kde-cli-tools = " \
 bash \
 glibc \
 kdesu \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kservice \
 kf6-kwindowsystem \
 libkworkspace6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:kdesu = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdesu \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
