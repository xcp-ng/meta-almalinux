# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iio-sensor-proxy"
PV = "3.5"
PR = "5.el10"
PACKAGES = " \
 iio-sensor-proxy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/iio-sensor-proxy-3.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a0343d76179b6017175f80d4bc3f8fd7319eb825e46b0b2bcb8fc2fce73b403"

URI_x86_64_v2_iio-sensor-proxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iio-sensor-proxy-3.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_iio-sensor-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iio-sensor-proxy}"
SRC_URI[x86_64_v2_iio-sensor-proxy.sha256sum] = "7a36d82964dff2f5b1903f77b33251650b829816ddddacca61d4cadcf389e494"

URI_aarch64_iio-sensor-proxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iio-sensor-proxy-3.5-5.el10.aarch64.rpm;name=aarch64_iio-sensor-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_iio-sensor-proxy}"
SRC_URI[aarch64_iio-sensor-proxy.sha256sum] = "fbf09c7f66b4775ffc74b6681aaed695e60a2c98bc66aebf182574146b532914"

RDEPENDS:iio-sensor-proxy = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libgudev \
 polkit-libs \
 systemd \
 "
