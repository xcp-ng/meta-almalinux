# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-xio-gridftp-driver"
PV = "3.6"
PR = "4.el10_0"
PACKAGES = " \
 globus-xio-gridftp-driver \
 globus-xio-gridftp-driver-devel \
 globus-xio-gridftp-driver-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-xio-gridftp-driver-3.6-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7911141a1699049bd7d977cb0b218c2abd92ddc6f996332df8841c88bd5771d"

URI_x86_64_v2_globus-xio-gridftp-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-gridftp-driver-3.6-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-gridftp-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-gridftp-driver}"
SRC_URI[x86_64_v2_globus-xio-gridftp-driver.sha256sum] = "58f4bb86f69b2e8036c4b1f6e4936de7982a16d5037a7137123a3d6cf3669d5a"

URI_x86_64_v2_globus-xio-gridftp-driver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-gridftp-driver-devel-3.6-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-gridftp-driver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-gridftp-driver-devel}"
SRC_URI[x86_64_v2_globus-xio-gridftp-driver-devel.sha256sum] = "06061431b6bbf7b464d9a78a3aa01c5ec4b3f7db46fe42a0a122d9d2594b1e11"

URI_x86_64_v2_globus-xio-gridftp-driver-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-gridftp-driver-doc-3.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-xio-gridftp-driver-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-gridftp-driver-doc}"
SRC_URI[x86_64_v2_globus-xio-gridftp-driver-doc.sha256sum] = "f668c2677d299d255742b713195cdbcf3d4a5ac60a9f8612a755e4348114700f"

URI_aarch64_globus-xio-gridftp-driver = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-gridftp-driver-3.6-4.el10_0.aarch64.rpm;name=aarch64_globus-xio-gridftp-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-gridftp-driver}"
SRC_URI[aarch64_globus-xio-gridftp-driver.sha256sum] = "7b341396213cea9ad077cfad6922e733a2192958db6332acf08a89440a2e0ccb"

URI_aarch64_globus-xio-gridftp-driver-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-gridftp-driver-devel-3.6-4.el10_0.aarch64.rpm;name=aarch64_globus-xio-gridftp-driver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-gridftp-driver-devel}"
SRC_URI[aarch64_globus-xio-gridftp-driver-devel.sha256sum] = "b18c567eafeaa0611d0476470f5b4bceda20ed33f345aad5f090ec7c95eed3fb"

URI_aarch64_globus-xio-gridftp-driver-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-gridftp-driver-doc-3.6-4.el10_0.noarch.rpm;name=aarch64_globus-xio-gridftp-driver-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-gridftp-driver-doc}"
SRC_URI[aarch64_globus-xio-gridftp-driver-doc.sha256sum] = "7a6cae5afd01f569b0ec4616928cfa80ad28cbccadeb23bb9a0b7716037724be"

RDEPENDS:globus-xio-gridftp-driver = " \
 glibc \
 globus-common \
 globus-ftp-client \
 globus-xio \
 globus-xio-gsi-driver \
 "
RDEPENDS:globus-xio-gridftp-driver-devel = " \
 globus-common-devel \
 globus-ftp-client-devel \
 globus-xio-devel \
 globus-xio-gridftp-driver \
 globus-xio-gsi-driver-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-xio-gridftp-driver-doc = " \
 "
