# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcupsfilters"
PE = "1"
PV = "2.0.0"
PR = "13.el10"
PACKAGES = " \
 libcupsfilters \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libcupsfilters-2.0.0-13.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "86874dc7676d5d36f388f4c2de55890d8476b6bb88de91990afd838079c16d4e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcupsfilters-2.0.0-13.el10.x86_64_v2.rpm;name=x86_64_v2_libcupsfilters;unpack=0"
SRC_URI[x86_64_v2_libcupsfilters.sha256sum] = "25b803f8b8a0d2dceb47191861df034e2aa4b29d7a15b728457a6d90fd617aff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcupsfilters-2.0.0-13.el10.aarch64.rpm;name=aarch64_libcupsfilters;unpack=0"
SRC_URI[aarch64_libcupsfilters.sha256sum] = "885e11c7346fbdd62ce5d0d6748fb33730d3ca7f141585e8993452e4471467a1"

RDEPENDS:libcupsfilters = " \
 colord \
 cups-filesystem \
 cups-libs \
 dbus-libs \
 fontconfig \
 ghostscript \
 glibc \
 lcms2 \
 libexif \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 poppler-cpp \
 qpdf-libs \
 "
