# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-task"
PV = "0.3.33"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-task+alloc-devel \
 rust-futures-task+cfg-target-has-atomic-devel \
 rust-futures-task+default-devel \
 rust-futures-task+std-devel \
 rust-futures-task+unstable-devel \
 rust-futures-task-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-task-0.3.33-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e05cddb5ad4634907ed0aff0a14e69e45b593b0f3aed632d54b3abb351f69011"

URI_x86_64_v2_rust-futures-task+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+alloc-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-task+alloc-devel.sha256sum] = "24a35fb63b16cb1c7da839feb6561b894f81d04c1f9da45673b6cd18800e3730"

URI_x86_64_v2_rust-futures-task+cfg-target-has-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+cfg-target-has-atomic-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task+cfg-target-has-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-task+cfg-target-has-atomic-devel.sha256sum] = "b25514c579d1d5b7263d19a4c94a2c7056489c1b4a57a7ee49f703c13d57d0b8"

URI_x86_64_v2_rust-futures-task+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+default-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task+default-devel}"
SRC_URI[x86_64_v2_rust-futures-task+default-devel.sha256sum] = "6e47e63ace55068d728c74cd089aa79dec68f367c8e9211627086917f06fb3ff"

URI_x86_64_v2_rust-futures-task+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+std-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task+std-devel}"
SRC_URI[x86_64_v2_rust-futures-task+std-devel.sha256sum] = "4501a899ed07a67bc1ed1b7521110e755cf53f4f7d602899fe5a55a51ce670a6"

URI_x86_64_v2_rust-futures-task+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+unstable-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures-task+unstable-devel.sha256sum] = "116f468285990ed040711ef9951b9bb84095cab617b5712451bf1bb59964fd17"

URI_x86_64_v2_rust-futures-task-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task-devel}"
SRC_URI[x86_64_v2_rust-futures-task-devel.sha256sum] = "a57abed0bc8d57b6e27064d127d3885bc85ca1e7d1be654981c78e6535024d6c"

URI_aarch64_rust-futures-task+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+alloc-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-task+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task+alloc-devel}"
SRC_URI[aarch64_rust-futures-task+alloc-devel.sha256sum] = "d04e3d80db5f13cdbc98bc618b2f80764e2f37baa75d5e202ca4ee1646c1e931"

URI_aarch64_rust-futures-task+cfg-target-has-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+cfg-target-has-atomic-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-task+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task+cfg-target-has-atomic-devel}"
SRC_URI[aarch64_rust-futures-task+cfg-target-has-atomic-devel.sha256sum] = "0e227046835d251a31ee3d853aca98c0cc489818305f77c14abba2e61912145e"

URI_aarch64_rust-futures-task+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+default-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-task+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task+default-devel}"
SRC_URI[aarch64_rust-futures-task+default-devel.sha256sum] = "8d7e7c03bdf271b222e097b44d48d0b6d56bbf4b7b3533fa7faeaeacae8ea2ab"

URI_aarch64_rust-futures-task+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+std-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-task+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task+std-devel}"
SRC_URI[aarch64_rust-futures-task+std-devel.sha256sum] = "f40aa87537f40203e0c118f61f9fd100edeb0024c8b2f64ad1a3205fbd01d563"

URI_aarch64_rust-futures-task+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+unstable-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-task+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task+unstable-devel}"
SRC_URI[aarch64_rust-futures-task+unstable-devel.sha256sum] = "3e7a03d069d141a98afafa8669a1d7c44a131f68c99921c582fb19523ef606c6"

URI_aarch64_rust-futures-task-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-task-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task-devel}"
SRC_URI[aarch64_rust-futures-task-devel.sha256sum] = "0b9b5fb9c96dd81fc974aa44321144c90102a795fed4f66694517dda84cdeb7c"

RDEPENDS:rust-futures-task+alloc-devel = " \
 cargo \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+default-devel = " \
 cargo \
 rust-futures-task+std-devel \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+std-devel = " \
 cargo \
 rust-futures-task+alloc-devel \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+unstable-devel = " \
 cargo \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task-devel = " \
 cargo \
 rust \
 "
