# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-asyncpg"
PV = "0.30.0"
PR = "5.el10_0"
PACKAGES = " \
 python3-asyncpg \
 python3-asyncpg+gssauth \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-asyncpg-0.30.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed4ac692db02453978b8f3b2076ea4e661149598139a509ad472c828b460ace1"

URI_x86_64_v2_python3-asyncpg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-asyncpg-0.30.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-asyncpg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-asyncpg}"
SRC_URI[x86_64_v2_python3-asyncpg.sha256sum] = "de4e1dd96a9f096b4359f9e1a5f692be489965f7da7dde1cb8b854c6f6636fbc"

URI_x86_64_v2_python3-asyncpg+gssauth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-asyncpg+gssauth-0.30.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-asyncpg+gssauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-asyncpg+gssauth}"
SRC_URI[x86_64_v2_python3-asyncpg+gssauth.sha256sum] = "5674051f524c3882983d3a797df2e334ab54fbbd793ab0b932970b782cc796cf"

URI_aarch64_python3-asyncpg = "${EPEL_MIRROR}/aarch64/Packages/p/python3-asyncpg-0.30.0-5.el10_0.aarch64.rpm;name=aarch64_python3-asyncpg;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-asyncpg}"
SRC_URI[aarch64_python3-asyncpg.sha256sum] = "8e9bb9df15245b068e956eb26faab99526dcb42196e382a276244a94eeca1cd6"

URI_aarch64_python3-asyncpg+gssauth = "${EPEL_MIRROR}/aarch64/Packages/p/python3-asyncpg+gssauth-0.30.0-5.el10_0.aarch64.rpm;name=aarch64_python3-asyncpg+gssauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-asyncpg+gssauth}"
SRC_URI[aarch64_python3-asyncpg+gssauth.sha256sum] = "3bb40a98af8a249e14e9ba632bd76a9859aae20a780567f8eeb70222cdb4f6ac"

RDEPENDS:python3-asyncpg = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-asyncpg+gssauth = " \
 python3 \
 python3-asyncpg \
 python3-gssapi \
 "
