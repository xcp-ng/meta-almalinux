# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytecheck_derive"
PV = "0.8.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-bytecheck_derive+default-devel \
 rust-bytecheck_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytecheck_derive-0.8.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "698789d0524f025801cd36e74760e409d46cc91bc7503fe48f3b970c913b9520"

URI_x86_64_v2_rust-bytecheck_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck_derive+default-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck_derive+default-devel}"
SRC_URI[x86_64_v2_rust-bytecheck_derive+default-devel.sha256sum] = "3a6bb72977ceb931afba1a5f4fd7b1b72349ab3ac6d4fe9b4581c7c9a510b047"

URI_x86_64_v2_rust-bytecheck_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck_derive-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck_derive-devel}"
SRC_URI[x86_64_v2_rust-bytecheck_derive-devel.sha256sum] = "da41b4f7ade4a244f32eca987a5387b7e03436f41d9e9fbea929363deffa57e2"

URI_aarch64_rust-bytecheck_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck_derive+default-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-bytecheck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck_derive+default-devel}"
SRC_URI[aarch64_rust-bytecheck_derive+default-devel.sha256sum] = "a657fd5a71d6df1bd9490afc3620a4d11a61b21678808491a90bd456643f14be"

URI_aarch64_rust-bytecheck_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck_derive-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-bytecheck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck_derive-devel}"
SRC_URI[aarch64_rust-bytecheck_derive-devel.sha256sum] = "cfc4d91d8f263a836044bb867238a8de2baa7b3f758183c773c3e95cec2a0ed3"

RDEPENDS:rust-bytecheck_derive+default-devel = " \
 cargo \
 rust-bytecheck_derive-devel \
 "
RDEPENDS:rust-bytecheck_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
