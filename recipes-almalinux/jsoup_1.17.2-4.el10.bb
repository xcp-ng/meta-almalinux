# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jsoup"
PV = "1.17.2"
PR = "4.el10"
PACKAGES = " \
 jsoup \
 jsoup-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jsoup-1.17.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c2a9aae54bbd183d2b224e39d87ecb9989c733f655d101364f66963f4c78cf2"

URI_x86_64_v2_jsoup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jsoup-1.17.2-4.el10.noarch.rpm;name=x86_64_v2_jsoup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsoup}"
SRC_URI[x86_64_v2_jsoup.sha256sum] = "9c587e444e4d5ebe7b543a8b7d4536d011b6a45c75d1e48bfe97fd290ff1b0d6"

URI_x86_64_v2_jsoup-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jsoup-javadoc-1.17.2-4.el10.noarch.rpm;name=x86_64_v2_jsoup-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsoup-javadoc}"
SRC_URI[x86_64_v2_jsoup-javadoc.sha256sum] = "da7f8a1cd51fe6a1ac5c12b22eee2bda75215bba6bd9e9827993f317a518354a"

URI_aarch64_jsoup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jsoup-1.17.2-4.el10.noarch.rpm;name=aarch64_jsoup;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsoup}"
SRC_URI[aarch64_jsoup.sha256sum] = "9c587e444e4d5ebe7b543a8b7d4536d011b6a45c75d1e48bfe97fd290ff1b0d6"

URI_aarch64_jsoup-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jsoup-javadoc-1.17.2-4.el10.noarch.rpm;name=aarch64_jsoup-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsoup-javadoc}"
SRC_URI[aarch64_jsoup-javadoc.sha256sum] = "da7f8a1cd51fe6a1ac5c12b22eee2bda75215bba6bd9e9827993f317a518354a"

RDEPENDS:jsoup = " \
 javapackages-filesystem \
 "
RDEPENDS:jsoup-javadoc = " \
 javapackages-filesystem \
 "
