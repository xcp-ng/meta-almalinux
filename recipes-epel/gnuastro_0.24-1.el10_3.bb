# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnuastro"
PV = "0.24"
PR = "1.el10_3"
PACKAGES = " \
 gnuastro \
 gnuastro-devel \
 gnuastro-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gnuastro-0.24-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1ba32528d76a6dd671b9acfdcd6cdc6edcec00706a5841fef56c5ab5571d9c02"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuastro-0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuastro;unpack=0"
SRC_URI[x86_64_v2_gnuastro.sha256sum] = "89d5c9e50511c9f89ad64a6b77beee507052ec071b5d39fe1d291fa2882a1606"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuastro-devel-0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuastro-devel;unpack=0"
SRC_URI[x86_64_v2_gnuastro-devel.sha256sum] = "cd39c722e35a116f78186a483a75cd499fbccf6e019eb2b5f891da179ab61677"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuastro-doc-0.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_gnuastro-doc;unpack=0"
SRC_URI[x86_64_v2_gnuastro-doc.sha256sum] = "7f9ca2b0ad09ea0a84e8d672cb05035b24be7057cb2fa30129ab35281349365a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gnuastro-0.24-1.el10_3.aarch64.rpm;name=aarch64_gnuastro;unpack=0"
SRC_URI[aarch64_gnuastro.sha256sum] = "dfdbfe50ec52df31f42377b8f08256b7f5b69874013c89f1256ba6fa0ad887e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gnuastro-devel-0.24-1.el10_3.aarch64.rpm;name=aarch64_gnuastro-devel;unpack=0"
SRC_URI[aarch64_gnuastro-devel.sha256sum] = "ee610e7173b97b28e54ee0ce5ae3cd333ac2ca40da6d7a4b57b601fd9d5a21ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gnuastro-doc-0.24-1.el10_3.noarch.rpm;name=aarch64_gnuastro-doc;unpack=0"
SRC_URI[aarch64_gnuastro-doc.sha256sum] = "78cf4931000a341d60242f76a2a1b4cb8c3305a2b50dbaa4352b01fca3e9a329"

RDEPENDS:gnuastro = " \
 bash \
 cfitsio \
 glibc \
 gsl \
 libgit2_1.9 \
 libjpeg-turbo \
 libtiff \
 wcslib \
 zlib-ng-compat \
 "
RDEPENDS:gnuastro-devel = " \
 cfitsio-devel \
 gnuastro \
 gsl-devel \
 libjpeg-turbo-devel \
 libtiff-devel \
 pkgconf-pkg-config \
 virtual/pkgconfig_libgit2_ \
 wcslib-devel \
 "
RDEPENDS:gnuastro-doc = " \
 "
