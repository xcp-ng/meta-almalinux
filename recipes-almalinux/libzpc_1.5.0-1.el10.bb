# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libzpc"
PV = "1.5.0"
PR = "1.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libzpc-1.5.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e787e0762cedd5da6d51289023d5cb48de3334ba964bcb60e79ba1cb85d8cc9e"

