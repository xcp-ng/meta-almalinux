# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opentrep"
PV = "0.07.18"
PR = "1.el10_2"
PACKAGES = " \
 opentrep \
 opentrep-devel \
 opentrep-doc \
 python3-opentrep \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opentrep-0.07.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a580d51e4ce7359260600515cca32c7cf8537338b82f99ab58b525abd6216d93"

URI_x86_64_v2_opentrep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opentrep-0.07.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opentrep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opentrep}"
SRC_URI[x86_64_v2_opentrep.sha256sum] = "05e7a92e76a33513e12c509626bfe63ed6e345a81b8617904ba57095d29ef63e"

URI_x86_64_v2_opentrep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opentrep-devel-0.07.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opentrep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opentrep-devel}"
SRC_URI[x86_64_v2_opentrep-devel.sha256sum] = "dde1c77d3599356bd8d863b64e962233996b388e7a77c3adfc3db42d4561a19b"

URI_x86_64_v2_opentrep-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opentrep-doc-0.07.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_opentrep-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opentrep-doc}"
SRC_URI[x86_64_v2_opentrep-doc.sha256sum] = "67897f501de83cfe5ae8c4bec80c904a9ac95e17c3ce0a2d614558d2b82f9c07"

URI_x86_64_v2_python3-opentrep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opentrep-0.07.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-opentrep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opentrep}"
SRC_URI[x86_64_v2_python3-opentrep.sha256sum] = "d9134fb193f5adbb721a1ec68fd65d7efc8d5fea2343b8c59eccfeb188595967"

URI_aarch64_opentrep = "${EPEL_MIRROR}/aarch64/Packages/o/opentrep-0.07.18-1.el10_2.aarch64.rpm;name=aarch64_opentrep;unpack=0"
SRC_URI:append = " ${URI_aarch64_opentrep}"
SRC_URI[aarch64_opentrep.sha256sum] = "2558ecf27e6643a740e85f880204eb5da955f1e9b725fd44956cca479378be34"

URI_aarch64_opentrep-devel = "${EPEL_MIRROR}/aarch64/Packages/o/opentrep-devel-0.07.18-1.el10_2.aarch64.rpm;name=aarch64_opentrep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_opentrep-devel}"
SRC_URI[aarch64_opentrep-devel.sha256sum] = "bb0dce7f0004221c2b8589e2dc0c7d38e00ec11ff8240ef0cd2d6cf84b736313"

URI_aarch64_opentrep-doc = "${EPEL_MIRROR}/aarch64/Packages/o/opentrep-doc-0.07.18-1.el10_2.noarch.rpm;name=aarch64_opentrep-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opentrep-doc}"
SRC_URI[aarch64_opentrep-doc.sha256sum] = "08fef619c5baf741c6868460d51fbfc48579aca88337a1de6cee0894166a381e"

URI_aarch64_python3-opentrep = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opentrep-0.07.18-1.el10_2.aarch64.rpm;name=aarch64_python3-opentrep;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opentrep}"
SRC_URI[aarch64_python3-opentrep.sha256sum] = "b76a4d70c54bc5960458a60bf01320f145b53ed816da968ceac50090c3832b62"

RDEPENDS:opentrep = " \
 boost-filesystem \
 boost-iostreams \
 boost-program-options \
 boost-random \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 protobuf \
 readline \
 soci \
 soci-mysql \
 soci-sqlite3 \
 xapian-core-libs \
 "
RDEPENDS:opentrep-devel = " \
 bash \
 cmake-filesystem \
 opentrep \
 pkgconf-pkg-config \
 "
RDEPENDS:opentrep-doc = " \
 "
RDEPENDS:python3-opentrep = " \
 bash \
 boost-python3 \
 glibc \
 libgcc \
 libstdc++ \
 opentrep \
 python3 \
 python3-libs \
 "
