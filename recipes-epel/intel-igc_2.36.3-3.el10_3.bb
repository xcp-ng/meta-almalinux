# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-igc"
PV = "2.36.3"
PR = "3.el10_3"
PACKAGES:x86_64_v2 = " \
 intel-igc \
 intel-igc-devel \
 intel-igc-libs \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-igc-2.36.3-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "672a18790466ed1c5a53d343c25fb90093a0da0b34c32773d6e66ce8bfa1ecf4"

URI_x86_64_v2_intel-igc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-igc-2.36.3-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-igc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-igc}"
SRC_URI[x86_64_v2_intel-igc.sha256sum] = "8360ebbbb9f390ea05667e4b927672761ef8290a302ec40cc54fe12a58db2ccd"

URI_x86_64_v2_intel-igc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-igc-devel-2.36.3-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-igc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-igc-devel}"
SRC_URI[x86_64_v2_intel-igc-devel.sha256sum] = "fb682c698725c6108cc37fd4018f63ae4ed12063198f4e50e628e94b0444ee85"

URI_x86_64_v2_intel-igc-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-igc-libs-2.36.3-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-igc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-igc-libs}"
SRC_URI[x86_64_v2_intel-igc-libs.sha256sum] = "9d46a4053a0762ce32781745be7794bc629e9ece9586e3924c84877057c37c0d"

RDEPENDS:intel-igc = " \
 glibc \
 intel-igc-libs \
 libgcc \
 libstdc++ \
 "
RDEPENDS:intel-igc-devel = " \
 intel-igc-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:intel-igc-libs = " \
 glibc \
 intel-igc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
