# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libIDL"
PV = "0.8.14"
PR = "81.el10_0"
PACKAGES = " \
 libIDL \
 libIDL-devel \
 libIDL-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libIDL-0.8.14-81.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0eed1564eff2db877d705378a9141af3ea17467cac07b16938bfd998ff9b654"

URI_x86_64_v2_libIDL = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libIDL-0.8.14-81.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libIDL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libIDL}"
SRC_URI[x86_64_v2_libIDL.sha256sum] = "d317158ae611d6aeb396e948d8878ef5d0c99ef4e13bd1b04aeb708d97b87123"

URI_x86_64_v2_libIDL-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libIDL-devel-0.8.14-81.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libIDL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libIDL-devel}"
SRC_URI[x86_64_v2_libIDL-devel.sha256sum] = "2d5b7ed14311350569141790bf35bd5d752ce949a8b477013bf5746991854be2"

URI_x86_64_v2_libIDL-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libIDL-doc-0.8.14-81.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libIDL-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libIDL-doc}"
SRC_URI[x86_64_v2_libIDL-doc.sha256sum] = "1db60923d7c1a5c556eac6066b737f239f9523caac40cfc56cb9f79ba0ce147a"

URI_aarch64_libIDL = "${EPEL_MIRROR}/aarch64/Packages/l/libIDL-0.8.14-81.el10_0.aarch64.rpm;name=aarch64_libIDL;unpack=0"
SRC_URI:append = " ${URI_aarch64_libIDL}"
SRC_URI[aarch64_libIDL.sha256sum] = "035ccd0d75a66e43d82a1f1177b6fc99051d71aa2bc052a7d47931f61b710dc6"

URI_aarch64_libIDL-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libIDL-devel-0.8.14-81.el10_0.aarch64.rpm;name=aarch64_libIDL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libIDL-devel}"
SRC_URI[aarch64_libIDL-devel.sha256sum] = "55941c3ae491fe43cef9497d4b0aa6b89a493e1c6c8c8d7834832eb9be270597"

URI_aarch64_libIDL-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libIDL-doc-0.8.14-81.el10_0.noarch.rpm;name=aarch64_libIDL-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libIDL-doc}"
SRC_URI[aarch64_libIDL-doc.sha256sum] = "8ba018ee5c5372058f1d5aecd22d58e8effd25ebdccf6ca06d7b1736c56959d0"

RDEPENDS:libIDL = " \
 glib2 \
 glibc \
 "
RDEPENDS:libIDL-devel = " \
 bash \
 glib2-devel \
 libIDL \
 pkgconf-pkg-config \
 "
RDEPENDS:libIDL-doc = " \
 "
