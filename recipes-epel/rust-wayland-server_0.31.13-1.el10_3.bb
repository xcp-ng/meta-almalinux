# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-server"
PV = "0.31.13"
PR = "1.el10_3"
PACKAGES = " \
 rust-wayland-server+default-devel \
 rust-wayland-server+dlopen-devel \
 rust-wayland-server+libwayland_1_22-devel \
 rust-wayland-server+libwayland_1_23-devel \
 rust-wayland-server+log-devel \
 rust-wayland-server+system-devel \
 rust-wayland-server-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-server-0.31.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8251f56f4baa4418cab072cda84c0424544abea1e371526caf563ca38b35599"

URI_x86_64_v2_rust-wayland-server+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+default-devel-0.31.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-server+default-devel.sha256sum] = "1147f68fc37030e0b2c6a70bef866c0c739605bcc45d2355df1cd6d8d75950e5"

URI_x86_64_v2_rust-wayland-server+dlopen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+dlopen-devel-0.31.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server+dlopen-devel}"
SRC_URI[x86_64_v2_rust-wayland-server+dlopen-devel.sha256sum] = "894b99d6d8f8cbe285bbe148a94f89002b4cc5548d5e538b0ad7725bd0c49d9d"

URI_x86_64_v2_rust-wayland-server+libwayland_1_22-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+libwayland_1_22-devel-0.31.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+libwayland_1_22-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server+libwayland_1_22-devel}"
SRC_URI[x86_64_v2_rust-wayland-server+libwayland_1_22-devel.sha256sum] = "f5cdd80ff426d2fcfa9616204ab2977ad36f3a74d34c7010f73684bff0060006"

URI_x86_64_v2_rust-wayland-server+libwayland_1_23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+libwayland_1_23-devel-0.31.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+libwayland_1_23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server+libwayland_1_23-devel}"
SRC_URI[x86_64_v2_rust-wayland-server+libwayland_1_23-devel.sha256sum] = "f23e68084f46e0c25d65548657ed1f4d1f658f8f8b60e898ca3aae9e3017602b"

URI_x86_64_v2_rust-wayland-server+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+log-devel-0.31.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server+log-devel}"
SRC_URI[x86_64_v2_rust-wayland-server+log-devel.sha256sum] = "b7bda4169c2fd1e5f8ccb47e2f308c21971e88db7df938833ed823d00eac1859"

URI_x86_64_v2_rust-wayland-server+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+system-devel-0.31.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server+system-devel}"
SRC_URI[x86_64_v2_rust-wayland-server+system-devel.sha256sum] = "c0dd66c4de8d33cf6da1c6d976849ec08390ab693b42d19a0f91273c6fb8e002"

URI_x86_64_v2_rust-wayland-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server-devel-0.31.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server-devel}"
SRC_URI[x86_64_v2_rust-wayland-server-devel.sha256sum] = "d63a0b4d63f844aa3de81e391b00797008248a292400c4866f3417c6d5f0e115"

URI_aarch64_rust-wayland-server+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+default-devel-0.31.13-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-server+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server+default-devel}"
SRC_URI[aarch64_rust-wayland-server+default-devel.sha256sum] = "89a2f897b5122e6a3dbf4b4243685de1f039e52b0222656c14d5151135c0d40d"

URI_aarch64_rust-wayland-server+dlopen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+dlopen-devel-0.31.13-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-server+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server+dlopen-devel}"
SRC_URI[aarch64_rust-wayland-server+dlopen-devel.sha256sum] = "b32fc7075e7b7bb8a224dc9fe36097f0ab4fd22ad012246ef2d809fab7979b7d"

URI_aarch64_rust-wayland-server+libwayland_1_22-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+libwayland_1_22-devel-0.31.13-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-server+libwayland_1_22-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server+libwayland_1_22-devel}"
SRC_URI[aarch64_rust-wayland-server+libwayland_1_22-devel.sha256sum] = "f6077c3595b01d91acc7090acefa01353cceffa109894de0b48e1a1338fd5ae5"

URI_aarch64_rust-wayland-server+libwayland_1_23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+libwayland_1_23-devel-0.31.13-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-server+libwayland_1_23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server+libwayland_1_23-devel}"
SRC_URI[aarch64_rust-wayland-server+libwayland_1_23-devel.sha256sum] = "a8129fff36fa12230c1086b6635faa6f8495ba44f05292e518502f188dd8532e"

URI_aarch64_rust-wayland-server+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+log-devel-0.31.13-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-server+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server+log-devel}"
SRC_URI[aarch64_rust-wayland-server+log-devel.sha256sum] = "227e5fab2fc3eae3bbe0aadfb798bfefb8ceabbe834832bb300f8bccff0dd266"

URI_aarch64_rust-wayland-server+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+system-devel-0.31.13-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-server+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server+system-devel}"
SRC_URI[aarch64_rust-wayland-server+system-devel.sha256sum] = "eb476e1510cbabe7cf9dbcf2a18ecae333a6856f5ec3d9313646b7a7f3ed563e"

URI_aarch64_rust-wayland-server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server-devel-0.31.13-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server-devel}"
SRC_URI[aarch64_rust-wayland-server-devel.sha256sum] = "f4800e198185ce146f6b08f52eec5f92ca81fa663a448bd27b238c475e7b2710"

RDEPENDS:rust-wayland-server+default-devel = " \
 cargo \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server+dlopen-devel = " \
 cargo \
 rust-wayland-backend+dlopen-devel \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server+libwayland_1_22-devel = " \
 cargo \
 rust-wayland-backend+libwayland_server_1_22-devel \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server+libwayland_1_23-devel = " \
 cargo \
 rust-wayland-backend+libwayland_server_1_23-devel \
 rust-wayland-server+libwayland_1_22-devel \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server+system-devel = " \
 cargo \
 rust-wayland-backend+server_system-devel \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-downcast-rs1+default-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-scanner+default-devel \
 "
