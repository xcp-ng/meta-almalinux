# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cage"
PV = "0.2.0"
PR = "3.el10_2"
PACKAGES = " \
 cage \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cage-0.2.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e252b96b21aa45f1c6c3ae282a8138f00e613a28bf90f6af61a11dd1d72fe4b"

URI_x86_64_v2_cage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cage-0.2.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cage}"
SRC_URI[x86_64_v2_cage.sha256sum] = "1752ab5291862664eb77f20e3de906bb04f0e3eb6e3ff7778ed30bb19eb23bf4"
RPROVIDES:cage:x86_64_v2 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_aarch64_cage = "${EPEL_MIRROR}/aarch64/Packages/c/cage-0.2.0-3.el10_2.aarch64.rpm;name=aarch64_cage;unpack=0"
SRC_URI:append = " ${URI_aarch64_cage}"
SRC_URI[aarch64_cage.sha256sum] = "2aab84d20924cb6edd15c4b6cf2b9026c74465d6f9cdaba0f5df51a6c5f188b5"
RPROVIDES:cage:aarch64 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

RDEPENDS:cage = " \
 glibc \
 libwayland-server \
 libxkbcommon \
 wlroots \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

PROVIDES:append:aarch64 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"
