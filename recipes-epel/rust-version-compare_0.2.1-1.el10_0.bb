# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-version-compare"
PV = "0.2.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-version-compare+default-devel \
 rust-version-compare-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-version-compare-0.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "042af4e2ac51a98630db893c321e8334df15f5282a4722a7b72550c79b581652"

URI_x86_64_v2_rust-version-compare+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-compare+default-devel-0.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-compare+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-compare+default-devel}"
SRC_URI[x86_64_v2_rust-version-compare+default-devel.sha256sum] = "ab98b27b86cdf531ad37ee115c2fbd8d0c6bc59753a38dc562c8be80c034d0c0"

URI_x86_64_v2_rust-version-compare-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-compare-devel-0.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-compare-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-compare-devel}"
SRC_URI[x86_64_v2_rust-version-compare-devel.sha256sum] = "aae5e05ef6d2c33f5a8be6b2ae02e086e90795477a3733c5ddde128197417469"

URI_aarch64_rust-version-compare+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-compare+default-devel-0.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-version-compare+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-compare+default-devel}"
SRC_URI[aarch64_rust-version-compare+default-devel.sha256sum] = "39dee5eeb46fe8061285eec8fdc9170c5ff3a7104ba69badbd03244bbe8003aa"

URI_aarch64_rust-version-compare-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-compare-devel-0.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-version-compare-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-compare-devel}"
SRC_URI[aarch64_rust-version-compare-devel.sha256sum] = "39db11272552fc8f995dada16110e93578cad21abed69af83e3f07f0edec6672"

RDEPENDS:rust-version-compare+default-devel = " \
 cargo \
 rust-version-compare-devel \
 "
RDEPENDS:rust-version-compare-devel = " \
 cargo \
 rust \
 "
