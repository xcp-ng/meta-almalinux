# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "joe"
PV = "4.6"
PR = "22.el10_0"
PACKAGES = " \
 joe \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/joe-4.6-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "93bf4c2794f74d7aab890db05979ae8ec8f479194a9da1a2e33d3424d0464d11"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/joe-4.6-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_joe;unpack=0"
SRC_URI[x86_64_v2_joe.sha256sum] = "ebd30410919b0a96b7de1d525d64b9d39b39e9540d72a53db1477e255b5cd917"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/joe-4.6-22.el10_0.aarch64.rpm;name=aarch64_joe;unpack=0"
SRC_URI[aarch64_joe.sha256sum] = "03e05df91969e67eeaa4a6c29be14d7db4f89e257b28a50029752687a45e39bb"

RDEPENDS:joe = " \
 glibc \
 libselinux \
 ncurses-libs \
 "
