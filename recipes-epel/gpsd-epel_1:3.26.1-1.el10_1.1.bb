# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpsd-epel"
PE = "1"
PV = "3.26.1"
PR = "1.el10_1.1"
PACKAGES = " \
 gpsd-devel \
 gpsd-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gpsd-epel-3.26.1-1.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4eb9b5f99f27741e0509c711599efd1497c09a42dd25846e44e81e5f2c0fe191"

URI_x86_64_v2_gpsd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpsd-devel-3.26.1-1.el10_1.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gpsd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpsd-devel}"
SRC_URI[x86_64_v2_gpsd-devel.sha256sum] = "b664270d43e10944f28d50100a7fc06de09e3a2302b0861b42f3180a60d8f2cc"

URI_x86_64_v2_gpsd-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpsd-libs-3.26.1-1.el10_1.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gpsd-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpsd-libs}"
SRC_URI[x86_64_v2_gpsd-libs.sha256sum] = "d6b108d620ec089d2a49a2cb3628b7ab1fda54375118151885ade36376c0f700"

URI_aarch64_gpsd-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gpsd-devel-3.26.1-1.el10_1.1.aarch64.rpm;name=aarch64_gpsd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd-devel}"
SRC_URI[aarch64_gpsd-devel.sha256sum] = "1b51f7c28de3c342a1a86f31263f221910ba610e8ba4749f76c09bee569993b7"

URI_aarch64_gpsd-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gpsd-libs-3.26.1-1.el10_1.1.aarch64.rpm;name=aarch64_gpsd-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd-libs}"
SRC_URI[aarch64_gpsd-libs.sha256sum] = "a561178dea2dfd47fdd468a4e24551c00304180e8e22a9a7872ad646dfe931cc"

RDEPENDS:gpsd-devel = " \
 gpsd-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:gpsd-libs:x86_64_v2 = " \
 dbus-libs \
 glibc \
 libstdc++ \
"
RDEPENDS:gpsd-libs:aarch64 = " \
 dbus-libs \
 glibc \
"
