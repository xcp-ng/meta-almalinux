# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdesdk-kioslaves"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdesdk-kioslaves \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdesdk-kioslaves-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c119773279dbafa0b7411bd0fc67d4d27767fe98f3551d24527de97a593f18f"

URI_x86_64_v2_kdesdk-kioslaves = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdesdk-kioslaves-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdesdk-kioslaves;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdesdk-kioslaves}"
SRC_URI[x86_64_v2_kdesdk-kioslaves.sha256sum] = "cca04069ac02e3ae14604c675651afebd69c49c2252e44f37d7ea1471c9279ab"

URI_aarch64_kdesdk-kioslaves = "${EPEL_MIRROR}/aarch64/Packages/k/kdesdk-kioslaves-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdesdk-kioslaves;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdesdk-kioslaves}"
SRC_URI[aarch64_kdesdk-kioslaves.sha256sum] = "d965fb04675dc09b5d1e856465e4939679d902e67bb53ad02dd55675248dec6f"

RDEPENDS:kdesdk-kioslaves = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 perl-Carp \
 perl-English \
 perl-Pod-Parser \
 perl-base \
 perl-interpreter \
 perl-libs \
 qt6-qtbase \
 "
