# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "egl-wayland2"
PV = "1.0.1"
PR = "1.el10_3"
PACKAGES = " \
 egl-wayland2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/egl-wayland2-1.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92b5b8517b84fe9c5eb1dd319540eae1d58c28eb4346396503d09150f412d43a"

URI_aarch64_egl-wayland2 = "${EPEL_MIRROR}/aarch64/Packages/e/egl-wayland2-1.0.1-1.el10_3.aarch64.rpm;name=aarch64_egl-wayland2;unpack=0"
SRC_URI:append = " ${URI_aarch64_egl-wayland2}"
SRC_URI[aarch64_egl-wayland2.sha256sum] = "c60435308b9be86a201edc2eb4e56b3f28c23ea5817e037d262474aef089cfe2"

RDEPENDS:egl-wayland2 = " \
 glibc \
 libdrm \
 libglvnd-egl \
 libwayland-client \
 mesa-libgbm \
 "
