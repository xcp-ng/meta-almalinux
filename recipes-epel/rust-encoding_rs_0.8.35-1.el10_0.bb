# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-encoding_rs"
PV = "0.8.35"
PR = "1.el10_0"
PACKAGES = " \
 rust-encoding_rs+alloc-devel \
 rust-encoding_rs+default-devel \
 rust-encoding_rs+fast-big5-hanzi-encode-devel \
 rust-encoding_rs+fast-gb-hanzi-encode-devel \
 rust-encoding_rs+fast-hangul-encode-devel \
 rust-encoding_rs+fast-hanja-encode-devel \
 rust-encoding_rs+fast-kanji-encode-devel \
 rust-encoding_rs+fast-legacy-encode-devel \
 rust-encoding_rs+less-slow-big5-hanzi-encode-devel \
 rust-encoding_rs+less-slow-gb-hanzi-encode-devel \
 rust-encoding_rs+less-slow-kanji-encode-devel \
 rust-encoding_rs+serde-devel \
 rust-encoding_rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-encoding_rs-0.8.35-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d59169e33dcbec669bf0a317e0b5c8b4dc70056d958fb1b318e94782dfae3185"

URI_x86_64_v2_rust-encoding_rs+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs+alloc-devel-0.8.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs+alloc-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs+alloc-devel.sha256sum] = "ba511e7900d62c26fff0e254184543aedf0304142e23995c65ca9ecf17c350ab"

URI_x86_64_v2_rust-encoding_rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs+default-devel-0.8.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs+default-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs+default-devel.sha256sum] = "9685ec5e598ef647af09b2ecab1cc5f4f54a3eace20365fac86ec155d03a0703"

URI_x86_64_v2_rust-encoding_rs+fast-big5-hanzi-encode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs+fast-big5-hanzi-encode-devel-0.8.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs+fast-big5-hanzi-encode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs+fast-big5-hanzi-encode-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs+fast-big5-hanzi-encode-devel.sha256sum] = "47d17e6c49cfd5160935246a44e61a7679354cc0c005097b4a3f238e2f780dcd"

URI_x86_64_v2_rust-encoding_rs+fast-gb-hanzi-encode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs+fast-gb-hanzi-encode-devel-0.8.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs+fast-gb-hanzi-encode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs+fast-gb-hanzi-encode-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs+fast-gb-hanzi-encode-devel.sha256sum] = "f2d741e5ecf0dbf42fb00f204440d6f2d26055c303082acc93cdf15030e060ce"

URI_x86_64_v2_rust-encoding_rs+fast-hangul-encode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs+fast-hangul-encode-devel-0.8.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs+fast-hangul-encode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs+fast-hangul-encode-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs+fast-hangul-encode-devel.sha256sum] = "7dd909067be580d1a6e39f7e14cec6f970f32865792445bd0ea0756cbcabf52e"

URI_x86_64_v2_rust-encoding_rs+fast-hanja-encode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs+fast-hanja-encode-devel-0.8.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs+fast-hanja-encode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs+fast-hanja-encode-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs+fast-hanja-encode-devel.sha256sum] = "fb80697c904a53a66895f3c833254ba31afae482a15590177d05f3fe271cb25e"

URI_x86_64_v2_rust-encoding_rs+fast-kanji-encode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs+fast-kanji-encode-devel-0.8.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs+fast-kanji-encode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs+fast-kanji-encode-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs+fast-kanji-encode-devel.sha256sum] = "03477a934c576e64b243724f36a83b207768b4c5046e398d5b7a257ee01dcc6f"

URI_x86_64_v2_rust-encoding_rs+fast-legacy-encode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs+fast-legacy-encode-devel-0.8.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs+fast-legacy-encode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs+fast-legacy-encode-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs+fast-legacy-encode-devel.sha256sum] = "786db13da81b8a5db1fdfef6ce33f27f85b2943654c7d70a74985424da54675e"

URI_x86_64_v2_rust-encoding_rs+less-slow-big5-hanzi-encode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs+less-slow-big5-hanzi-encode-devel-0.8.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs+less-slow-big5-hanzi-encode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs+less-slow-big5-hanzi-encode-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs+less-slow-big5-hanzi-encode-devel.sha256sum] = "a703db6aeca7aeb9d1f35befc2f0d97eb3e9af17d0a69febb35115a094508d4c"

URI_x86_64_v2_rust-encoding_rs+less-slow-gb-hanzi-encode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs+less-slow-gb-hanzi-encode-devel-0.8.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs+less-slow-gb-hanzi-encode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs+less-slow-gb-hanzi-encode-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs+less-slow-gb-hanzi-encode-devel.sha256sum] = "ec4dda0e7e3eb58fa39d25ca2c566a6e1c3450cc2938130709530e3c29790035"

URI_x86_64_v2_rust-encoding_rs+less-slow-kanji-encode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs+less-slow-kanji-encode-devel-0.8.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs+less-slow-kanji-encode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs+less-slow-kanji-encode-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs+less-slow-kanji-encode-devel.sha256sum] = "a5c2900c2ec8913ee06e7cb29c24b461c1643863d6a0931562e9c5df89b4b903"

URI_x86_64_v2_rust-encoding_rs+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs+serde-devel-0.8.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs+serde-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs+serde-devel.sha256sum] = "eea91968b6f9d535bf64798a7bbf75536d43057a56e51729e28b0a8840db0178"

URI_x86_64_v2_rust-encoding_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs-devel-0.8.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs-devel.sha256sum] = "efb20c6e8d7f1044c8509b34f659c19867d84ea7c09a77831b57537ebfc6e403"

URI_aarch64_rust-encoding_rs+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs+alloc-devel-0.8.35-1.el10_0.noarch.rpm;name=aarch64_rust-encoding_rs+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs+alloc-devel}"
SRC_URI[aarch64_rust-encoding_rs+alloc-devel.sha256sum] = "73541e8f855cf77645724d6e17fd0a7ee9fc18a379d0025f51f9372b91faa015"

URI_aarch64_rust-encoding_rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs+default-devel-0.8.35-1.el10_0.noarch.rpm;name=aarch64_rust-encoding_rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs+default-devel}"
SRC_URI[aarch64_rust-encoding_rs+default-devel.sha256sum] = "46efc0df10dc6c8420f73d23adeeb15994a7b5aeedfd5f5ab8662e09e202999d"

URI_aarch64_rust-encoding_rs+fast-big5-hanzi-encode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs+fast-big5-hanzi-encode-devel-0.8.35-1.el10_0.noarch.rpm;name=aarch64_rust-encoding_rs+fast-big5-hanzi-encode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs+fast-big5-hanzi-encode-devel}"
SRC_URI[aarch64_rust-encoding_rs+fast-big5-hanzi-encode-devel.sha256sum] = "633c5fcc412f24678f880e51321da18e90c5b0551364ba210719d234cbf3fea1"

URI_aarch64_rust-encoding_rs+fast-gb-hanzi-encode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs+fast-gb-hanzi-encode-devel-0.8.35-1.el10_0.noarch.rpm;name=aarch64_rust-encoding_rs+fast-gb-hanzi-encode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs+fast-gb-hanzi-encode-devel}"
SRC_URI[aarch64_rust-encoding_rs+fast-gb-hanzi-encode-devel.sha256sum] = "f6e403588b478301adf30889a82076ee056521c3da1dc6e6c0baa088391671e2"

URI_aarch64_rust-encoding_rs+fast-hangul-encode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs+fast-hangul-encode-devel-0.8.35-1.el10_0.noarch.rpm;name=aarch64_rust-encoding_rs+fast-hangul-encode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs+fast-hangul-encode-devel}"
SRC_URI[aarch64_rust-encoding_rs+fast-hangul-encode-devel.sha256sum] = "0c26834a5af1d8c44d350bfee44982efe03aea391f768671f8516488a8ec8ee5"

URI_aarch64_rust-encoding_rs+fast-hanja-encode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs+fast-hanja-encode-devel-0.8.35-1.el10_0.noarch.rpm;name=aarch64_rust-encoding_rs+fast-hanja-encode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs+fast-hanja-encode-devel}"
SRC_URI[aarch64_rust-encoding_rs+fast-hanja-encode-devel.sha256sum] = "70a138d810bf46fc3d7accc3606119542f1347db0fa192b5aba5ff3eead53293"

URI_aarch64_rust-encoding_rs+fast-kanji-encode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs+fast-kanji-encode-devel-0.8.35-1.el10_0.noarch.rpm;name=aarch64_rust-encoding_rs+fast-kanji-encode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs+fast-kanji-encode-devel}"
SRC_URI[aarch64_rust-encoding_rs+fast-kanji-encode-devel.sha256sum] = "3dc5e5eaf89c352c3b06bfe987c00b3e7f00b70a9e44d0c631172c51e5a8a214"

URI_aarch64_rust-encoding_rs+fast-legacy-encode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs+fast-legacy-encode-devel-0.8.35-1.el10_0.noarch.rpm;name=aarch64_rust-encoding_rs+fast-legacy-encode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs+fast-legacy-encode-devel}"
SRC_URI[aarch64_rust-encoding_rs+fast-legacy-encode-devel.sha256sum] = "bbc1c6c4bf669af479d39e82e7c30678a2e5e8db877520fbd5acc7dea407e451"

URI_aarch64_rust-encoding_rs+less-slow-big5-hanzi-encode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs+less-slow-big5-hanzi-encode-devel-0.8.35-1.el10_0.noarch.rpm;name=aarch64_rust-encoding_rs+less-slow-big5-hanzi-encode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs+less-slow-big5-hanzi-encode-devel}"
SRC_URI[aarch64_rust-encoding_rs+less-slow-big5-hanzi-encode-devel.sha256sum] = "e0dee90f17117157d3f43d70665512cb288f87ae7f5a0abb52da1c741324c4dd"

URI_aarch64_rust-encoding_rs+less-slow-gb-hanzi-encode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs+less-slow-gb-hanzi-encode-devel-0.8.35-1.el10_0.noarch.rpm;name=aarch64_rust-encoding_rs+less-slow-gb-hanzi-encode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs+less-slow-gb-hanzi-encode-devel}"
SRC_URI[aarch64_rust-encoding_rs+less-slow-gb-hanzi-encode-devel.sha256sum] = "d5942ed8ae0f6d2e29e108f073a9f407bc7d5cb13151d742c692b70e0fa319a3"

URI_aarch64_rust-encoding_rs+less-slow-kanji-encode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs+less-slow-kanji-encode-devel-0.8.35-1.el10_0.noarch.rpm;name=aarch64_rust-encoding_rs+less-slow-kanji-encode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs+less-slow-kanji-encode-devel}"
SRC_URI[aarch64_rust-encoding_rs+less-slow-kanji-encode-devel.sha256sum] = "fc27ed52af47214b7196c8f4ee938045730046d5362119bf37e40cb230f4613c"

URI_aarch64_rust-encoding_rs+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs+serde-devel-0.8.35-1.el10_0.noarch.rpm;name=aarch64_rust-encoding_rs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs+serde-devel}"
SRC_URI[aarch64_rust-encoding_rs+serde-devel.sha256sum] = "7e1d3358561fc151b7143416a1767396fbaf2982b356426123dac82f14065f8e"

URI_aarch64_rust-encoding_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs-devel-0.8.35-1.el10_0.noarch.rpm;name=aarch64_rust-encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs-devel}"
SRC_URI[aarch64_rust-encoding_rs-devel.sha256sum] = "6dcf3edafee99796aba964f8832763344ea432b69b82d815d567f373110e3bcb"

RDEPENDS:rust-encoding_rs+alloc-devel = " \
 cargo \
 rust-encoding_rs-devel \
 "
RDEPENDS:rust-encoding_rs+default-devel = " \
 cargo \
 rust-encoding_rs+alloc-devel \
 rust-encoding_rs-devel \
 "
RDEPENDS:rust-encoding_rs+fast-big5-hanzi-encode-devel = " \
 cargo \
 rust-encoding_rs-devel \
 "
RDEPENDS:rust-encoding_rs+fast-gb-hanzi-encode-devel = " \
 cargo \
 rust-encoding_rs-devel \
 "
RDEPENDS:rust-encoding_rs+fast-hangul-encode-devel = " \
 cargo \
 rust-encoding_rs-devel \
 "
RDEPENDS:rust-encoding_rs+fast-hanja-encode-devel = " \
 cargo \
 rust-encoding_rs-devel \
 "
RDEPENDS:rust-encoding_rs+fast-kanji-encode-devel = " \
 cargo \
 rust-encoding_rs-devel \
 "
RDEPENDS:rust-encoding_rs+fast-legacy-encode-devel = " \
 cargo \
 rust-encoding_rs+fast-big5-hanzi-encode-devel \
 rust-encoding_rs+fast-gb-hanzi-encode-devel \
 rust-encoding_rs+fast-hangul-encode-devel \
 rust-encoding_rs+fast-hanja-encode-devel \
 rust-encoding_rs+fast-kanji-encode-devel \
 rust-encoding_rs-devel \
 "
RDEPENDS:rust-encoding_rs+less-slow-big5-hanzi-encode-devel = " \
 cargo \
 rust-encoding_rs-devel \
 "
RDEPENDS:rust-encoding_rs+less-slow-gb-hanzi-encode-devel = " \
 cargo \
 rust-encoding_rs-devel \
 "
RDEPENDS:rust-encoding_rs+less-slow-kanji-encode-devel = " \
 cargo \
 rust-encoding_rs-devel \
 "
RDEPENDS:rust-encoding_rs+serde-devel = " \
 cargo \
 rust-encoding_rs-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-encoding_rs-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 "
