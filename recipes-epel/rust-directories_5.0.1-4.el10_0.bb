# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-directories"
PV = "5.0.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-directories+default-devel \
 rust-directories-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-directories-5.0.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a6895dc08eb00966fd7d9bc425fa1ad2fa1090353f4031bfdb3116ca0422499"

URI_x86_64_v2_rust-directories+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-directories+default-devel-5.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-directories+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-directories+default-devel}"
SRC_URI[x86_64_v2_rust-directories+default-devel.sha256sum] = "3a3d6d2ef4d23fd2999d5a6f29291148d73cfef1e9359f415ce69965b2a7027e"

URI_x86_64_v2_rust-directories-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-directories-devel-5.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-directories-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-directories-devel}"
SRC_URI[x86_64_v2_rust-directories-devel.sha256sum] = "022233aa87a7676be6d8981d19fc9ed8157e5f3be63ccf8fb321d34e1d2d1e8a"

URI_aarch64_rust-directories+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-directories+default-devel-5.0.1-4.el10_0.noarch.rpm;name=aarch64_rust-directories+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-directories+default-devel}"
SRC_URI[aarch64_rust-directories+default-devel.sha256sum] = "c8280e13de2b358bfbc060b7354a75c1b5b599dc01798aa41871377f1425e28b"

URI_aarch64_rust-directories-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-directories-devel-5.0.1-4.el10_0.noarch.rpm;name=aarch64_rust-directories-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-directories-devel}"
SRC_URI[aarch64_rust-directories-devel.sha256sum] = "4592c3117799c8ff2ca10272e26e19cbd7e5eff7f5895e19fd7e6086cce0a701"

RDEPENDS:rust-directories+default-devel = " \
 cargo \
 rust-directories-devel \
 "
RDEPENDS:rust-directories-devel = " \
 cargo \
 rust-dirs-sys+default-devel \
 "
