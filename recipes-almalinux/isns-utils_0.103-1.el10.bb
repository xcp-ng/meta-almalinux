# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "isns-utils"
PV = "0.103"
PR = "1.el10"
PACKAGES = " \
 isns-utils \
 isns-utils-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/isns-utils-0.103-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2a105a8f5af71179ce5f4b391eef443f57fa02773415ae3868102da6d3578a5"

URI_x86_64_v2_isns-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/isns-utils-0.103-1.el10.x86_64_v2.rpm;name=x86_64_v2_isns-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isns-utils}"
SRC_URI[x86_64_v2_isns-utils.sha256sum] = "f5d897ecdb6c4c2f6bd7611bd5e3703c608ff653cdf8b97a6f8d412f6f74c647"

URI_x86_64_v2_isns-utils-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/isns-utils-libs-0.103-1.el10.x86_64_v2.rpm;name=x86_64_v2_isns-utils-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isns-utils-libs}"
SRC_URI[x86_64_v2_isns-utils-libs.sha256sum] = "53e6bbb5a556c861978423a955d896a1ded9017f49d639f8381e96a3830d9972"

URI_aarch64_isns-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/isns-utils-0.103-1.el10.aarch64.rpm;name=aarch64_isns-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_isns-utils}"
SRC_URI[aarch64_isns-utils.sha256sum] = "d3aba3c2ee412b46262e381321c911612ac227de9c3eac663478677ceeb66ba3"

URI_aarch64_isns-utils-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/isns-utils-libs-0.103-1.el10.aarch64.rpm;name=aarch64_isns-utils-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_isns-utils-libs}"
SRC_URI[aarch64_isns-utils-libs.sha256sum] = "417cc7389ab412afc6df597703308e4471d818987686dee919d812e089bc7ec3"

RDEPENDS:isns-utils = " \
 bash \
 glibc \
 isns-utils-libs \
 systemd \
 "
RDEPENDS:isns-utils-libs = " \
 glibc \
 "
