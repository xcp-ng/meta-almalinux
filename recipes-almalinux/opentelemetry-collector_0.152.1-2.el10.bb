# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opentelemetry-collector"
PV = "0.152.1"
PR = "2.el10"
PACKAGES = " \
 opentelemetry-collector \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/opentelemetry-collector-0.152.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ea8662cc84be9fb2393cc9e214d5ae21287db7f1efc575f3058d3ee838327c83"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/opentelemetry-collector-0.152.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_opentelemetry-collector;unpack=0"
SRC_URI[x86_64_v2_opentelemetry-collector.sha256sum] = "ca61ec096f34bb988bafaa0105891be4cd53607ba33dee06292a84878bcbaa11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/opentelemetry-collector-0.152.1-2.el10.aarch64.rpm;name=aarch64_opentelemetry-collector;unpack=0"
SRC_URI[aarch64_opentelemetry-collector.sha256sum] = "7de5225d5bcd072e5a30e4f471b3878e4e51e10b301ab335c9a42d24769d048c"

RDEPENDS:opentelemetry-collector = " \
 bash \
 glibc \
 glibc-common \
 shadow-utils \
 systemd \
 util-linux \
 "
