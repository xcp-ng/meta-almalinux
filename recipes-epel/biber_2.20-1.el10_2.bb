# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "biber"
PV = "2.20"
PR = "1.el10_2"
PACKAGES = " \
 biber \
 biber-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/biber-2.20-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "54cf228217faab039087103c45b6ee29b08d27443ed03ef632308de72d86de02"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/biber-2.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_biber;unpack=0"
SRC_URI[x86_64_v2_biber.sha256sum] = "d08be7297eca690333e237ab43b77c210683e8663b5f3096c0177e91104e98a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/biber-tests-2.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_biber-tests;unpack=0"
SRC_URI[x86_64_v2_biber-tests.sha256sum] = "aafbd630a8001d2e0b7f629fc500c2ba6778884d3cc9b97ec63813c9b295a1ea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/biber-2.20-1.el10_2.noarch.rpm;name=aarch64_biber;unpack=0"
SRC_URI[aarch64_biber.sha256sum] = "f179356d94f34e5900fff63b7f73dfdfe8456f36a7ab3b7678da3c8a454ba722"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/biber-tests-2.20-1.el10_2.noarch.rpm;name=aarch64_biber-tests;unpack=0"
SRC_URI[aarch64_biber-tests.sha256sum] = "c8f3a401e304b37a87527c5214b4b937c693e05e9b913a1800a4aba5cc807561"

RDEPENDS:biber = " \
 biber \
 perl-Business-ISBN \
 perl-Business-ISMN \
 perl-Business-ISSN \
 perl-Carp \
 perl-Class-Accessor \
 perl-Data-Compare \
 perl-Data-Dump \
 perl-Data-Uniqid \
 perl-DateTime \
 perl-DateTime-Calendar-Julian \
 perl-DateTime-Format-Builder \
 perl-DateTime-TimeZone \
 perl-Digest-MD5 \
 perl-Encode \
 perl-Exporter \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Slurper \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IO-String \
 perl-IPC-Cmd \
 perl-IPC-Run3 \
 perl-LWP-Protocol-https \
 perl-Lingua-Translit \
 perl-List-AllUtils \
 perl-Log-Log4perl \
 perl-POSIX \
 perl-Parse-RecDescent \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Regexp-Common \
 perl-Scalar-List-Utils \
 perl-Sort-Key \
 perl-Storable \
 perl-Text-Balanced \
 perl-Text-BibTeX \
 perl-Text-CSV \
 perl-Text-Roman \
 perl-Text-Tabs+Wrap \
 perl-URI \
 perl-Unicode-Collate \
 perl-Unicode-LineBreak \
 perl-Unicode-Normalize \
 perl-Unicode-UCD \
 perl-XML-LibXML \
 perl-XML-LibXML-Simple \
 perl-XML-LibXSLT \
 perl-XML-Writer \
 perl-autovivification \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 perl-locale \
 perl-parent \
 perl-sigtrap \
 perl-vars \
 "
RDEPENDS:biber-tests = " \
 bash \
 biber \
 perl-Capture-Tiny \
 perl-Encode \
 perl-File-Compare \
 perl-File-Temp \
 perl-File-Which \
 perl-IPC-Cmd \
 perl-IPC-Run3 \
 perl-List-AllUtils \
 perl-Log-Log4perl \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Test-Differences \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Text-Diff \
 perl-Unicode-Normalize \
 perl-XML-LibXML \
 perl-interpreter \
 perl-libs \
 perl-open \
 virtual/coreutils \
 "
