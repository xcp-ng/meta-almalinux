# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-safe"
PV = "0.3.21"
PR = "1.el10_0"
PACKAGES = " \
 ghc-safe \
 ghc-safe-devel \
 ghc-safe-doc \
 ghc-safe-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-safe-0.3.21-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a40e9b209d30aad34410926fff479004db17d271ae2770710d70ab8a25d5ad93"

URI_x86_64_v2_ghc-safe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-safe-0.3.21-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-safe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-safe}"
SRC_URI[x86_64_v2_ghc-safe.sha256sum] = "5fe9a19b1d7e69cebee0597d9991e8dafafef400fa9a500ab487c1f6b236b59f"

URI_x86_64_v2_ghc-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-safe-devel-0.3.21-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-safe-devel}"
SRC_URI[x86_64_v2_ghc-safe-devel.sha256sum] = "3fd695c4121a116d8db1a7610c6f605ac474a611cdc090c6db296f47e34337fd"

URI_x86_64_v2_ghc-safe-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-safe-doc-0.3.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-safe-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-safe-doc}"
SRC_URI[x86_64_v2_ghc-safe-doc.sha256sum] = "9ab31767bd61874f233d0867369d3f63a00a331e6b21440413d9b54baa061671"

URI_x86_64_v2_ghc-safe-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-safe-prof-0.3.21-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-safe-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-safe-prof}"
SRC_URI[x86_64_v2_ghc-safe-prof.sha256sum] = "eda89f25436fd44063425338f0e96906de425d0a7c95ae7276ba8972f0e388a7"

URI_aarch64_ghc-safe = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-safe-0.3.21-1.el10_0.aarch64.rpm;name=aarch64_ghc-safe;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-safe}"
SRC_URI[aarch64_ghc-safe.sha256sum] = "3e983f1221c13c7ddd004d7b19f902697f2e689c1f12b75c0b1910f037c47543"

URI_aarch64_ghc-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-safe-devel-0.3.21-1.el10_0.aarch64.rpm;name=aarch64_ghc-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-safe-devel}"
SRC_URI[aarch64_ghc-safe-devel.sha256sum] = "24e35fc4e3c977f710f98e1dd258bdc56811ea2f957b94b18a7c7299975dd082"

URI_aarch64_ghc-safe-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-safe-doc-0.3.21-1.el10_0.noarch.rpm;name=aarch64_ghc-safe-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-safe-doc}"
SRC_URI[aarch64_ghc-safe-doc.sha256sum] = "7a24ee51e23991ca4c4af4d8f81aea6aaadacf5469d06ad816ae84b3b7a6517b"

URI_aarch64_ghc-safe-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-safe-prof-0.3.21-1.el10_0.aarch64.rpm;name=aarch64_ghc-safe-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-safe-prof}"
SRC_URI[aarch64_ghc-safe-prof.sha256sum] = "063ba15580d9bbdb41e930b78208900a80789b800a695c142622658d583de97e"

RDEPENDS:ghc-safe = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-safe-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-safe \
 "
RDEPENDS:ghc-safe-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-safe-prof = " \
 ghc-base-prof \
 ghc-safe-devel \
 "
