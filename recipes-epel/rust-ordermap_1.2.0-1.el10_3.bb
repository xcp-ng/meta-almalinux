# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ordermap"
PV = "1.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-ordermap+arbitrary-devel \
 rust-ordermap+default-devel \
 rust-ordermap+quickcheck-devel \
 rust-ordermap+rayon-devel \
 rust-ordermap+serde-devel \
 rust-ordermap+std-devel \
 rust-ordermap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ordermap-1.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1de5f97ac98c65bb8621654ae4307e6afbf80930875f51daa3be96a6186b297e"

URI_x86_64_v2_rust-ordermap+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+arbitrary-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-ordermap+arbitrary-devel.sha256sum] = "7fb8e04b77f6d551f4071c6e891298aa6bf729d55fc3f1600ac52bef2a15126d"

URI_x86_64_v2_rust-ordermap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+default-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+default-devel}"
SRC_URI[x86_64_v2_rust-ordermap+default-devel.sha256sum] = "c05562b3411f16df737e0e5c9441249f9e750d3d1131ef6bd0bbaf454eef3d0b"

URI_x86_64_v2_rust-ordermap+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+quickcheck-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-ordermap+quickcheck-devel.sha256sum] = "da2224732d0fa7d541b22f876956c271e5cb022b8f465ce3ce8c112a0e380452"

URI_x86_64_v2_rust-ordermap+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+rayon-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+rayon-devel}"
SRC_URI[x86_64_v2_rust-ordermap+rayon-devel.sha256sum] = "7556ffaec3b6d77d40fc258752c35b6cfdb23388923cab5ff4ec8ed5112b41fe"

URI_x86_64_v2_rust-ordermap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+serde-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+serde-devel}"
SRC_URI[x86_64_v2_rust-ordermap+serde-devel.sha256sum] = "a41adc0fe6616326f1b4521cdbe0b47dd81e37e23b1fd5101dac419e98091409"

URI_x86_64_v2_rust-ordermap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+std-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+std-devel}"
SRC_URI[x86_64_v2_rust-ordermap+std-devel.sha256sum] = "f44024641c7bbb278ba673ace62479d7d8483ca60d2941c26bf80efab0e2059d"

URI_x86_64_v2_rust-ordermap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap-devel}"
SRC_URI[x86_64_v2_rust-ordermap-devel.sha256sum] = "a2147de087f04f919b9dcc35f0715a4adf0ed8c64b51bdb911e281e4d39a937d"

URI_aarch64_rust-ordermap+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+arbitrary-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-ordermap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+arbitrary-devel}"
SRC_URI[aarch64_rust-ordermap+arbitrary-devel.sha256sum] = "54cffb8404cd91b84dc9a9763848f310bdc6dbc56dbcd0fc21a6d6474a2e1efc"

URI_aarch64_rust-ordermap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+default-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-ordermap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+default-devel}"
SRC_URI[aarch64_rust-ordermap+default-devel.sha256sum] = "6af5037dfb370d0b873931625d58e35cce942105be1c1b6557304f2a7101c65e"

URI_aarch64_rust-ordermap+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+quickcheck-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-ordermap+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+quickcheck-devel}"
SRC_URI[aarch64_rust-ordermap+quickcheck-devel.sha256sum] = "22b63d879fb99cad052de69e738433bf6ab7ea02810f2f3762d5a04e70c34abd"

URI_aarch64_rust-ordermap+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+rayon-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-ordermap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+rayon-devel}"
SRC_URI[aarch64_rust-ordermap+rayon-devel.sha256sum] = "9c367c88f6acc7dd34d0c5cf5ada5d5b7924e154d77c77b22629decaeaa42150"

URI_aarch64_rust-ordermap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+serde-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-ordermap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+serde-devel}"
SRC_URI[aarch64_rust-ordermap+serde-devel.sha256sum] = "07e55ee96e9263085492699b15280933635a25bdbd99ca20ae6b8e2ce17393b6"

URI_aarch64_rust-ordermap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+std-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-ordermap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+std-devel}"
SRC_URI[aarch64_rust-ordermap+std-devel.sha256sum] = "5b5b7d495f80be0a2c02fe35653823ef87f9d4a92b507f49060814d1a4c7c366"

URI_aarch64_rust-ordermap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-ordermap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap-devel}"
SRC_URI[aarch64_rust-ordermap-devel.sha256sum] = "ba8c70ec70b461a969c760455dc95696072a1df1c4d56e91407e44add5d3f541"

RDEPENDS:rust-ordermap+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-indexmap+arbitrary-devel \
 rust-ordermap-devel \
 "
RDEPENDS:rust-ordermap+default-devel = " \
 cargo \
 rust-ordermap+std-devel \
 rust-ordermap-devel \
 "
RDEPENDS:rust-ordermap+quickcheck-devel = " \
 cargo \
 rust-indexmap+quickcheck-devel \
 rust-ordermap-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-ordermap+rayon-devel = " \
 cargo \
 rust-indexmap+rayon-devel \
 rust-ordermap-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-ordermap+serde-devel = " \
 cargo \
 rust-indexmap+serde-devel \
 rust-ordermap-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-ordermap+std-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-ordermap-devel \
 "
RDEPENDS:rust-ordermap-devel = " \
 cargo \
 rust \
 rust-indexmap-devel \
 "
