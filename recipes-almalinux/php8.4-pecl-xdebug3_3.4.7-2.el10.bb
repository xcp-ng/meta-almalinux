# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php8.4-pecl-xdebug3"
PV = "3.4.7"
PR = "2.el10"
PACKAGES = " \
 php8.4-pecl-xdebug3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/php8.4-pecl-xdebug3-3.4.7-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebdd899cd4c4514b3d17757057b5c26d2f6cbecb81a0e6b23bcd0c5272de3888"

URI_x86_64_v2_php8.4-pecl-xdebug3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-pecl-xdebug3-3.4.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-pecl-xdebug3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-pecl-xdebug3}"
SRC_URI[x86_64_v2_php8.4-pecl-xdebug3.sha256sum] = "0d6e9d1437c27a3d976c538eb640d419e93ca0ce7459eae763785e8352dd8596"

URI_aarch64_php8.4-pecl-xdebug3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-pecl-xdebug3-3.4.7-2.el10.aarch64.rpm;name=aarch64_php8.4-pecl-xdebug3;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-pecl-xdebug3}"
SRC_URI[aarch64_php8.4-pecl-xdebug3.sha256sum] = "b719a8354b4565c5087becf0f3b9aa5ab2fc9e714f41f9af28eb9b66eb2607fb"

RDEPENDS:php8.4-pecl-xdebug3 = " \
 glibc \
 php8.4-common \
 zlib-ng-compat \
 "
