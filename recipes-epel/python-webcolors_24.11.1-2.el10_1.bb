# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-webcolors"
PV = "24.11.1"
PR = "2.el10_1"
PACKAGES = " \
 python3-webcolors \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-webcolors-24.11.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "078c19ac6350938c01c86d0792c445b1b22efd246cf03895ac14881fe5cbc924"

URI_x86_64_v2_python3-webcolors = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-webcolors-24.11.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-webcolors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-webcolors}"
SRC_URI[x86_64_v2_python3-webcolors.sha256sum] = "68645e027f87e05c53008f0685985a5924935c9aaa24056d6803ea2bfb8c45b1"

URI_aarch64_python3-webcolors = "${EPEL_MIRROR}/aarch64/Packages/p/python3-webcolors-24.11.1-2.el10_1.noarch.rpm;name=aarch64_python3-webcolors;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-webcolors}"
SRC_URI[aarch64_python3-webcolors.sha256sum] = "0ccedd2023c4b4d5dc6d0a18afb36a6d88a519336672adbbc2c4872cbfce613e"

RDEPENDS:python3-webcolors = " \
 python3 \
 "
