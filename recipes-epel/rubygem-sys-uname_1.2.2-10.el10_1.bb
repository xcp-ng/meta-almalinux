# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-sys-uname"
PV = "1.2.2"
PR = "10.el10_1"
PACKAGES = " \
 rubygem-sys-uname \
 rubygem-sys-uname-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-sys-uname-1.2.2-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6fec692ff08d637b4c46a6f4d0fdfbf35d3982276fe6a2e06d230a62b919435"

URI_x86_64_v2_rubygem-sys-uname = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-sys-uname-1.2.2-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-sys-uname;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-sys-uname}"
SRC_URI[x86_64_v2_rubygem-sys-uname.sha256sum] = "3e72ed28171f8791a248df924dec2e94292b2c7fc4d20fb11c896ce45bb35ec4"

URI_x86_64_v2_rubygem-sys-uname-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-sys-uname-doc-1.2.2-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-sys-uname-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-sys-uname-doc}"
SRC_URI[x86_64_v2_rubygem-sys-uname-doc.sha256sum] = "ca3c587e62914fd01508584403343e42a9f6a690aa84045d975789a200995206"

URI_aarch64_rubygem-sys-uname = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-sys-uname-1.2.2-10.el10_1.noarch.rpm;name=aarch64_rubygem-sys-uname;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-sys-uname}"
SRC_URI[aarch64_rubygem-sys-uname.sha256sum] = "f0c0c83f611e35ccdb67ba311654322500d0ef1856b76b45556f408c79c03566"

URI_aarch64_rubygem-sys-uname-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-sys-uname-doc-1.2.2-10.el10_1.noarch.rpm;name=aarch64_rubygem-sys-uname-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-sys-uname-doc}"
SRC_URI[aarch64_rubygem-sys-uname-doc.sha256sum] = "7cb232b294b777e8200af8b17b89e010d13adc3e45d677ac9c21e805898d5a78"

RDEPENDS:rubygem-sys-uname = " \
 rubygem-ffi \
 rubygems \
 "
RDEPENDS:rubygem-sys-uname-doc = " \
 rubygem-sys-uname \
 "
