# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mdns-repeater"
PV = "1.11"
PR = "12.el10_0"
PACKAGES = " \
 mdns-repeater \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mdns-repeater-1.11-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eee62c44d8ec18179c0eb9dd9f9c1a61e30ed28214b06526da1bfc09d9f742c5"

URI_x86_64_v2_mdns-repeater = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mdns-repeater-1.11-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mdns-repeater;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mdns-repeater}"
SRC_URI[x86_64_v2_mdns-repeater.sha256sum] = "aa59a09c3e776c7f444d0db725a0c6d4f012170b5eb93c760a98b0098bc00873"

URI_aarch64_mdns-repeater = "${EPEL_MIRROR}/aarch64/Packages/m/mdns-repeater-1.11-12.el10_0.aarch64.rpm;name=aarch64_mdns-repeater;unpack=0"
SRC_URI:append = " ${URI_aarch64_mdns-repeater}"
SRC_URI[aarch64_mdns-repeater.sha256sum] = "6829f053e797ad408dfc813a636c85d103de44ce488123e07706a3121bfc3f66"

RDEPENDS:mdns-repeater = " \
 bash \
 glibc \
 systemd \
 "
