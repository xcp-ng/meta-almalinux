# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-attributes"
PV = "0.1.31"
PR = "1.el10_1"
PACKAGES = " \
 rust-tracing-attributes+async-await-devel \
 rust-tracing-attributes+default-devel \
 rust-tracing-attributes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-attributes-0.1.31-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a7d839e0e1a9997d770e9f16c959b3d5a02015635ce305d8271b15cd4dbd7fe"

URI_x86_64_v2_rust-tracing-attributes+async-await-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-attributes+async-await-devel-0.1.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-attributes+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-attributes+async-await-devel}"
SRC_URI[x86_64_v2_rust-tracing-attributes+async-await-devel.sha256sum] = "e1dcd2e948884d5eaa5c879be40106d6513fb3cfaf2927e1ac2024470582f28a"

URI_x86_64_v2_rust-tracing-attributes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-attributes+default-devel-0.1.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-attributes+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-attributes+default-devel.sha256sum] = "84095d9fec4d8746f59a0f7543b2397950c1fd8959334259d8a795c324789866"

URI_x86_64_v2_rust-tracing-attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-attributes-devel-0.1.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-attributes-devel}"
SRC_URI[x86_64_v2_rust-tracing-attributes-devel.sha256sum] = "b09aa7f418e25855d063085e1d468104f6df072ab9c8aad6c94d48c164c3cd93"

URI_aarch64_rust-tracing-attributes+async-await-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-attributes+async-await-devel-0.1.31-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-attributes+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-attributes+async-await-devel}"
SRC_URI[aarch64_rust-tracing-attributes+async-await-devel.sha256sum] = "055f3a5817aea978a99e8546741fb8aec59566c30e070667049c11202a66b72a"

URI_aarch64_rust-tracing-attributes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-attributes+default-devel-0.1.31-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-attributes+default-devel}"
SRC_URI[aarch64_rust-tracing-attributes+default-devel.sha256sum] = "6769a91bb69b497881db202ddaa3f8056e6f4a6cdc4e1330e6adce1f1ee489f1"

URI_aarch64_rust-tracing-attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-attributes-devel-0.1.31-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-attributes-devel}"
SRC_URI[aarch64_rust-tracing-attributes-devel.sha256sum] = "51f6285990479e8360381454a05cbccef9f51f859b07d8cdb26787bd715a9719"

RDEPENDS:rust-tracing-attributes+async-await-devel = " \
 cargo \
 rust-tracing-attributes-devel \
 "
RDEPENDS:rust-tracing-attributes+default-devel = " \
 cargo \
 rust-tracing-attributes-devel \
 "
RDEPENDS:rust-tracing-attributes-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "
