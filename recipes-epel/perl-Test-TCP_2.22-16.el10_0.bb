# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-TCP"
PV = "2.22"
PR = "16.el10_0"
PACKAGES = " \
 perl-Test-TCP \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-TCP-2.22-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d4dec0ea479a4a53921b0dbc10335fc38c7a4db85779ab7e77d1cdf7ceafbda"

URI_x86_64_v2_perl-Test-TCP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-TCP-2.22-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-TCP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-TCP}"
SRC_URI[x86_64_v2_perl-Test-TCP.sha256sum] = "e44b6a7203d74f4d6b05775714b009d181175166c96d97ac4bb5327440143318"

URI_aarch64_perl-Test-TCP = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-TCP-2.22-16.el10_0.noarch.rpm;name=aarch64_perl-Test-TCP;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-TCP}"
SRC_URI[aarch64_perl-Test-TCP.sha256sum] = "08e50056ca3999860d254c6b6f6dc90f74b39958956ea7e18deeed0598f22263"

RDEPENDS:perl-Test-TCP = " \
 perl-Carp \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-IO-Socket-IP \
 perl-POSIX \
 perl-Test-SharedFork \
 perl-Test-Simple \
 perl-Time-HiRes \
 perl-base \
 perl-libs \
 "
