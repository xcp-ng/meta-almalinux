# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aodhclient"
PV = "3.10.1"
PR = "1.el10_3"
PACKAGES = " \
 python3-aodhclient \
 python3-aodhclient-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aodhclient-3.10.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8aea925fde9af65529355f3a4747a2f2d34d063a209c1699379cca974f69ce55"

URI_x86_64_v2_python3-aodhclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aodhclient-3.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aodhclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aodhclient}"
SRC_URI[x86_64_v2_python3-aodhclient.sha256sum] = "88c1e36b619686377fdba472fba95a00b647c42c29e2548aaee05478271b7907"

URI_x86_64_v2_python3-aodhclient-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aodhclient-tests-3.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aodhclient-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aodhclient-tests}"
SRC_URI[x86_64_v2_python3-aodhclient-tests.sha256sum] = "821afeef44a40d35a3300f7bf984d0ec79d597b4aabb157d0a50d277fde014cf"

URI_aarch64_python3-aodhclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aodhclient-3.10.1-1.el10_3.noarch.rpm;name=aarch64_python3-aodhclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aodhclient}"
SRC_URI[aarch64_python3-aodhclient.sha256sum] = "e3f67c9f6912ff655b1f73014b5e56e29696242bf6edd0764a37cceda187ad7b"

URI_aarch64_python3-aodhclient-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aodhclient-tests-3.10.1-1.el10_3.noarch.rpm;name=aarch64_python3-aodhclient-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aodhclient-tests}"
SRC_URI[aarch64_python3-aodhclient-tests.sha256sum] = "a02f5868e626425f82d756637b5969a376991294e14c3d87bb05c7ae73bf62ae"

RDEPENDS:python3-aodhclient = " \
 python3 \
 python3-cliff \
 python3-keystoneauth1 \
 python3-osc-lib \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-pyparsing \
 "
RDEPENDS:python3-aodhclient-tests = " \
 python3 \
 python3-aodhclient \
 "
