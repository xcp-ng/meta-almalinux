# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kauth"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kauth \
 kf6-kauth-devel \
 kf6-kauth-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kauth-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80eaf6252b72e333497a27b72348355dc425f0cf79c1a2d66dcd615e5738e0d9"

URI_x86_64_v2_kf6-kauth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kauth}"
SRC_URI[x86_64_v2_kf6-kauth.sha256sum] = "91dd57d56356dd8155164d15f7386f5bb39b2d1cd8c4ec5e7e270d2e3ca5f40f"

URI_x86_64_v2_kf6-kauth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kauth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kauth-devel}"
SRC_URI[x86_64_v2_kf6-kauth-devel.sha256sum] = "e4b5df2c4e0b2f466af296ffdbf2779e877b608bf6abbcef8c59809302975204"

URI_x86_64_v2_kf6-kauth-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kauth-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kauth-doc}"
SRC_URI[x86_64_v2_kf6-kauth-doc.sha256sum] = "f38cd4600c04be86247ca47032fc26ec3cd6a6c82594f30c5b03b99d9eb86fba"

URI_aarch64_kf6-kauth = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kauth}"
SRC_URI[aarch64_kf6-kauth.sha256sum] = "34311a9252831ad3a4ebdb2d34e4781428e5c1d341c514877b6703548bc394b2"

URI_aarch64_kf6-kauth-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kauth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kauth-devel}"
SRC_URI[aarch64_kf6-kauth-devel.sha256sum] = "3fb316d38b2be1003a19be95729ba4dd7fa039c4ed89c7751031114700d8bb57"

URI_aarch64_kf6-kauth-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kauth-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kauth-doc}"
SRC_URI[aarch64_kf6-kauth-doc.sha256sum] = "cbc1675dde968e146045b970d549df37f9dce1fec7e4e193b10d9fb29e14506d"

RDEPENDS:kf6-kauth = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-kwindowsystem \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kauth-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons-devel \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kauth-doc = " \
 "
