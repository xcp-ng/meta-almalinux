# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kmime"
PV = "6.30.0"
PR = "2.el10_3"
PACKAGES = " \
 kf6-kmime \
 kf6-kmime-devel \
 kf6-kmime-doc \
 kf6-kmime-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kmime-6.30.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "669cd2f6f9de53d2a7f12ba0b627e7c2b113884b07182fb5dca58390b00b985d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kmime-6.30.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kmime;unpack=0"
SRC_URI[x86_64_v2_kf6-kmime.sha256sum] = "696a5eecb6ddd92d547e18e26ef7d0922af2c48d65e1b55513d1adc47ecf6d79"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kmime-devel-6.30.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kmime-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kmime-devel.sha256sum] = "5aca79e46b146d9ec6cb29c719a3a25c54921aa5f958bf551290282287917ea1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kmime-doc-6.30.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kmime-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kmime-doc.sha256sum] = "70bd0be9fb59babf33eda4a4a7142f829b4ec66e018990ce4a8f6df092c7c7d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kmime-html-6.30.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kmime-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kmime-html.sha256sum] = "1383fd8d3d1d7c29a09ab81e29d2604b0fc7684dc6e30346c3d1212e683c2ff7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kmime-6.30.0-2.el10_3.aarch64.rpm;name=aarch64_kf6-kmime;unpack=0"
SRC_URI[aarch64_kf6-kmime.sha256sum] = "9242b20ca4b8b2cc85e9fffb916a8bfbc5daaed60df58006f20a5e4aaf1faf77"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kmime-devel-6.30.0-2.el10_3.aarch64.rpm;name=aarch64_kf6-kmime-devel;unpack=0"
SRC_URI[aarch64_kf6-kmime-devel.sha256sum] = "71ceb7da977890bdead2904d54a3db5bff296d969553c5fe37d650a47510dd96"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kmime-doc-6.30.0-2.el10_3.noarch.rpm;name=aarch64_kf6-kmime-doc;unpack=0"
SRC_URI[aarch64_kf6-kmime-doc.sha256sum] = "16f914a2e82a93d3e2bb3833a2566a59d5ec59b2e36ed3205def377acd91bbbf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kmime-html-6.30.0-2.el10_3.noarch.rpm;name=aarch64_kf6-kmime-html;unpack=0"
SRC_URI[aarch64_kf6-kmime-html.sha256sum] = "f489da4368d5d94d5348444c9fb7d194172e79c919a0c1251dc80b8bafd92398"

RDEPENDS:kf6-kmime = " \
 glibc \
 kf6-kcodecs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kmime-devel = " \
 cmake-filesystem \
 kf6-kcodecs-devel \
 kf6-kmime \
 "
RDEPENDS:kf6-kmime-doc = " \
 "
RDEPENDS:kf6-kmime-html = " \
 "
