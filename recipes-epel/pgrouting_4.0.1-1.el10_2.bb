# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pgrouting"
PV = "4.0.1"
PR = "1.el10_2"
PACKAGES = " \
 pgrouting \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pgrouting-4.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86a600b7344c1fad4bc5e18b18cf59e156ba3664a0fc96f5a1505ae0b393c9b1"

URI_x86_64_v2_pgrouting = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pgrouting-4.0.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pgrouting;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pgrouting}"
SRC_URI[x86_64_v2_pgrouting.sha256sum] = "6923b9e0e2fc0bc3229bb310e4afaa8b4c13d4a9a93d4242ceccb812f15fb24e"

URI_aarch64_pgrouting = "${EPEL_MIRROR}/aarch64/Packages/p/pgrouting-4.0.1-1.el10_2.aarch64.rpm;name=aarch64_pgrouting;unpack=0"
SRC_URI:append = " ${URI_aarch64_pgrouting}"
SRC_URI[aarch64_pgrouting.sha256sum] = "a18a36a1410cee74228de815d60eee0cfe3763eeead11126cf4038b8d1a23d62"

RDEPENDS:pgrouting = " \
 glibc \
 libgcc \
 libstdc++ \
 postgis \
 postgresql-server \
 "
