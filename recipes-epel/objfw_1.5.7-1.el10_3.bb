# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "objfw"
PV = "1.5.7"
PR = "1.el10_3"
PACKAGES = " \
 libobjfw \
 libobjfw-devel \
 libobjfwhid \
 libobjfwhid-devel \
 libobjfwrt \
 libobjfwrt-devel \
 libobjfwtls \
 libobjfwtls-devel \
 objfw \
 objfw-doc \
 ofarc \
 ofdns \
 ofgctester \
 ofhash \
 ofhttp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/objfw-1.5.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfe45328e561796f170fa466642d461ff733913a0f4e96f397b034a402882deb"

URI_x86_64_v2_libobjfw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfw-1.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfw}"
SRC_URI[x86_64_v2_libobjfw.sha256sum] = "cb88409efdd697dc426ae85fc6ea4cf01a06f8790a9b7fc40fd5d0a14741e68a"

URI_x86_64_v2_libobjfw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfw-devel-1.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfw-devel}"
SRC_URI[x86_64_v2_libobjfw-devel.sha256sum] = "a3600ea72a19398e9024563889393e8f8a52b9a389aa663601748c963f807dd6"

URI_x86_64_v2_libobjfwhid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwhid-1.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwhid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwhid}"
SRC_URI[x86_64_v2_libobjfwhid.sha256sum] = "f433bf98bddcd11d0cd8944d48de61609fc3e9cd4fd958fb02a464cdec5b88a4"

URI_x86_64_v2_libobjfwhid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwhid-devel-1.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwhid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwhid-devel}"
SRC_URI[x86_64_v2_libobjfwhid-devel.sha256sum] = "59816623041f57e6aa268fca724c504536132cb3572472c7bb28029256e80265"

URI_x86_64_v2_libobjfwrt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwrt-1.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwrt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwrt}"
SRC_URI[x86_64_v2_libobjfwrt.sha256sum] = "62908c17884c207b592f5ebdf6bc6f9e9e44a372baf2451f26d00f7236427766"

URI_x86_64_v2_libobjfwrt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwrt-devel-1.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwrt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwrt-devel}"
SRC_URI[x86_64_v2_libobjfwrt-devel.sha256sum] = "82150aab25fdf1308380e225fca411ede70ca946b7bc61c1305319f76d4007ad"

URI_x86_64_v2_libobjfwtls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwtls-1.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwtls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwtls}"
SRC_URI[x86_64_v2_libobjfwtls.sha256sum] = "5e32bad111ab7c3273d249e49197ddf112afba63814e586eb1f37ca40971fc25"

URI_x86_64_v2_libobjfwtls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwtls-devel-1.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwtls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwtls-devel}"
SRC_URI[x86_64_v2_libobjfwtls-devel.sha256sum] = "bb025b58ea4e627e71f2c0bc2d8027dfa67d298eb66f80b084c0e0aea32bb7d5"

URI_x86_64_v2_objfw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/objfw-1.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_objfw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_objfw}"
SRC_URI[x86_64_v2_objfw.sha256sum] = "fcd07a2f5e2987cd3503ccc66226cee44956075fe614271a57a47d642313e8db"

URI_x86_64_v2_objfw-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/objfw-doc-1.5.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_objfw-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_objfw-doc}"
SRC_URI[x86_64_v2_objfw-doc.sha256sum] = "8bc5d5a3ba43711560eca6df54fc0ba295bd277e7c23c4f33131685189bd6437"

URI_x86_64_v2_ofarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofarc-1.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofarc}"
SRC_URI[x86_64_v2_ofarc.sha256sum] = "d1c8cd541ca7f62e0b85ab3ef58a8b81378103929b92b4c786afa1824a88be4f"

URI_x86_64_v2_ofdns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofdns-1.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofdns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofdns}"
SRC_URI[x86_64_v2_ofdns.sha256sum] = "5fea7695dcd886b0fb908f1b99c9df5bf31cbdb8e4cacd551751a4b658b49173"

URI_x86_64_v2_ofgctester = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofgctester-1.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofgctester;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofgctester}"
SRC_URI[x86_64_v2_ofgctester.sha256sum] = "67bb6c12edbca68468831cf701ab58e894b591f30b8af8ee754e323c32891b6b"

URI_x86_64_v2_ofhash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofhash-1.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofhash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofhash}"
SRC_URI[x86_64_v2_ofhash.sha256sum] = "c07cf7a6dad37a291bcdc2ce83d3c3f980a76e99349f65f556af1cfbb724f29b"

URI_x86_64_v2_ofhttp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofhttp-1.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofhttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofhttp}"
SRC_URI[x86_64_v2_ofhttp.sha256sum] = "834ec665d7bf91cc080a83720b156f90f440084aa90b58caa2f9208fc7f481e6"

URI_aarch64_libobjfw = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfw-1.5.7-1.el10_3.aarch64.rpm;name=aarch64_libobjfw;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfw}"
SRC_URI[aarch64_libobjfw.sha256sum] = "0c660e0e8f2a7b925293b6b3a06446f146da369b0210434c16cac674c7e422e3"

URI_aarch64_libobjfw-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfw-devel-1.5.7-1.el10_3.aarch64.rpm;name=aarch64_libobjfw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfw-devel}"
SRC_URI[aarch64_libobjfw-devel.sha256sum] = "410e3582b0cfc17c610485229811fa1f8d9bda66fa4800820b5e10c33b34af69"

URI_aarch64_libobjfwhid = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwhid-1.5.7-1.el10_3.aarch64.rpm;name=aarch64_libobjfwhid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwhid}"
SRC_URI[aarch64_libobjfwhid.sha256sum] = "52d44839e6ef7286508302ee0bc8245defafb651d993e569c3a35db95b730d61"

URI_aarch64_libobjfwhid-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwhid-devel-1.5.7-1.el10_3.aarch64.rpm;name=aarch64_libobjfwhid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwhid-devel}"
SRC_URI[aarch64_libobjfwhid-devel.sha256sum] = "752f07b65c58b99a1356f144b2fb1224036ba43c9f2d089cf87f105af5d4179a"

URI_aarch64_libobjfwrt = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwrt-1.5.7-1.el10_3.aarch64.rpm;name=aarch64_libobjfwrt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwrt}"
SRC_URI[aarch64_libobjfwrt.sha256sum] = "fc94e13e8c532c27210b9d0315ed08680ad9535d15fd297ed62bad1ccef343be"

URI_aarch64_libobjfwrt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwrt-devel-1.5.7-1.el10_3.aarch64.rpm;name=aarch64_libobjfwrt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwrt-devel}"
SRC_URI[aarch64_libobjfwrt-devel.sha256sum] = "afe3bdd714234622f5044e579ad55038754804ccfc4b74fecb0421901dae8a57"

URI_aarch64_libobjfwtls = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwtls-1.5.7-1.el10_3.aarch64.rpm;name=aarch64_libobjfwtls;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwtls}"
SRC_URI[aarch64_libobjfwtls.sha256sum] = "cc59254e308e7dd238af5bdf1eba29da95765ffcbc7169c80447aa05f1e3a809"

URI_aarch64_libobjfwtls-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwtls-devel-1.5.7-1.el10_3.aarch64.rpm;name=aarch64_libobjfwtls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwtls-devel}"
SRC_URI[aarch64_libobjfwtls-devel.sha256sum] = "875e94226f1366ae54c35914f100ceb6f66f0f4f9bece45fe395eb29ee377d00"

URI_aarch64_objfw = "${EPEL_MIRROR}/aarch64/Packages/o/objfw-1.5.7-1.el10_3.aarch64.rpm;name=aarch64_objfw;unpack=0"
SRC_URI:append = " ${URI_aarch64_objfw}"
SRC_URI[aarch64_objfw.sha256sum] = "0fc0f55e20ebffdfe2201d2765c2fbc02fb0f28bf88badecf27d80d10c9e40f2"

URI_aarch64_objfw-doc = "${EPEL_MIRROR}/aarch64/Packages/o/objfw-doc-1.5.7-1.el10_3.noarch.rpm;name=aarch64_objfw-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_objfw-doc}"
SRC_URI[aarch64_objfw-doc.sha256sum] = "a74f86e20461ce9fe46fe01a8c6906ecf65ea9a2b607c8d26fae91e986c2cf54"

URI_aarch64_ofarc = "${EPEL_MIRROR}/aarch64/Packages/o/ofarc-1.5.7-1.el10_3.aarch64.rpm;name=aarch64_ofarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofarc}"
SRC_URI[aarch64_ofarc.sha256sum] = "646ee589122be1d6eb784c7c120ef17d2c64f6865424a984d0b42557b4932759"

URI_aarch64_ofdns = "${EPEL_MIRROR}/aarch64/Packages/o/ofdns-1.5.7-1.el10_3.aarch64.rpm;name=aarch64_ofdns;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofdns}"
SRC_URI[aarch64_ofdns.sha256sum] = "191c19a7e2873ee3ec6ea9637d5b2a936d190a37d31218154278a4c7966701f3"

URI_aarch64_ofgctester = "${EPEL_MIRROR}/aarch64/Packages/o/ofgctester-1.5.7-1.el10_3.aarch64.rpm;name=aarch64_ofgctester;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofgctester}"
SRC_URI[aarch64_ofgctester.sha256sum] = "49c60f2694716a4524fa4802a37472d256e0a4c16f8529591756aae54a7b2f4b"

URI_aarch64_ofhash = "${EPEL_MIRROR}/aarch64/Packages/o/ofhash-1.5.7-1.el10_3.aarch64.rpm;name=aarch64_ofhash;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofhash}"
SRC_URI[aarch64_ofhash.sha256sum] = "809a78fb78f7841ee634f81df4fd59db77e7c0decc9b7832e15c17be53ce8335"

URI_aarch64_ofhttp = "${EPEL_MIRROR}/aarch64/Packages/o/ofhttp-1.5.7-1.el10_3.aarch64.rpm;name=aarch64_ofhttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofhttp}"
SRC_URI[aarch64_ofhttp.sha256sum] = "7f2d60c50f33ab4004120db4671acc7f56a230bce8a1be92d8a8c724b97f9172"

RDEPENDS:libobjfw = " \
 glibc \
 libgcc \
 libobjfwrt \
 "
RDEPENDS:libobjfw-devel = " \
 bash \
 clang \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 libobjfwrt-devel \
 lksctp-tools-devel \
 "
RDEPENDS:libobjfwhid = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 "
RDEPENDS:libobjfwhid-devel = " \
 libobjfw-devel \
 libobjfwhid \
 libobjfwrt-devel \
 "
RDEPENDS:libobjfwrt = " \
 glibc \
 libgcc \
 "
RDEPENDS:libobjfwrt-devel = " \
 libobjfwrt \
 "
RDEPENDS:libobjfwtls = " \
 glibc \
 gnutls \
 libgcc \
 libobjfw \
 libobjfwrt \
 "
RDEPENDS:libobjfwtls-devel = " \
 libobjfw-devel \
 libobjfwrt-devel \
 libobjfwtls \
 "
RDEPENDS:objfw = " \
 libobjfw \
 libobjfw-devel \
 libobjfwhid \
 libobjfwhid-devel \
 libobjfwrt \
 libobjfwrt-devel \
 libobjfwtls \
 libobjfwtls-devel \
 ofarc \
 ofdns \
 ofgctester \
 ofhash \
 ofhttp \
 "
RDEPENDS:objfw-doc = " \
 "
RDEPENDS:ofarc = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 libobjfwtls \
 "
RDEPENDS:ofdns = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 "
RDEPENDS:ofgctester = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwhid \
 libobjfwrt \
 "
RDEPENDS:ofhash = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 libobjfwtls \
 "
RDEPENDS:ofhttp = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 libobjfwtls \
 "
