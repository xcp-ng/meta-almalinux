# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sys-locale"
PV = "0.3.2"
PR = "4.el10_3"
PACKAGES = " \
 rust-sys-locale+default-devel \
 rust-sys-locale-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sys-locale-0.3.2-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38d27f918b68b0c135bb1c0299fd50b59c266a10a5bd770dc21edfbcd13712ff"

URI_x86_64_v2_rust-sys-locale+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sys-locale+default-devel-0.3.2-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sys-locale+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sys-locale+default-devel}"
SRC_URI[x86_64_v2_rust-sys-locale+default-devel.sha256sum] = "dc4cc44b324b1140ebc4c2109de2dfa58deca4c92730eef75cdf9ae454a3df50"

URI_x86_64_v2_rust-sys-locale-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sys-locale-devel-0.3.2-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sys-locale-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sys-locale-devel}"
SRC_URI[x86_64_v2_rust-sys-locale-devel.sha256sum] = "2aa22ed3eee11e684ecd2ea7f2e1ec396fbed2adfa0665af2a2392fab7809a65"

URI_aarch64_rust-sys-locale+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sys-locale+default-devel-0.3.2-4.el10_3.noarch.rpm;name=aarch64_rust-sys-locale+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sys-locale+default-devel}"
SRC_URI[aarch64_rust-sys-locale+default-devel.sha256sum] = "52cb21dfe07566e45eb1d872e455fdeb990938bb7aa226f42af1fc7968690fa9"

URI_aarch64_rust-sys-locale-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sys-locale-devel-0.3.2-4.el10_3.noarch.rpm;name=aarch64_rust-sys-locale-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sys-locale-devel}"
SRC_URI[aarch64_rust-sys-locale-devel.sha256sum] = "d4c713250a67fca07aebf4cc124b778b56ef9482bb783e30dc44bd95119b472f"

RDEPENDS:rust-sys-locale+default-devel = " \
 cargo \
 rust-sys-locale-devel \
 "
RDEPENDS:rust-sys-locale-devel = " \
 cargo \
 rust \
 "
