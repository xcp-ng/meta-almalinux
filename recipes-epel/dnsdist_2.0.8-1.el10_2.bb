# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnsdist"
PV = "2.0.8"
PR = "1.el10_2"
PACKAGES = " \
 dnsdist \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dnsdist-2.0.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8cde8bdb8f85ce16186ee4383f823fbba72a9734d58b0481bcbfd882c1ffaf19"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnsdist-2.0.8-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dnsdist;unpack=0"
SRC_URI[x86_64_v2_dnsdist.sha256sum] = "e360d8af1d165a5db7661cc1562aec9c02e2bb84ed047bbad6e0f995c8f119be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dnsdist-2.0.8-1.el10_2.aarch64.rpm;name=aarch64_dnsdist;unpack=0"
SRC_URI[aarch64_dnsdist.sha256sum] = "f9f5ce88e15fd6cd48ed617dc76b288f8328c6a22380993e316e153ee20d2610"

RDEPENDS:dnsdist = " \
 bash \
 fstrm \
 glibc \
 libcap \
 libedit \
 libgcc \
 libnghttp2 \
 libsodium \
 libstdc++ \
 lmdb-libs \
 luajit \
 openssl-libs \
 re2 \
 shadow-utils \
 systemd \
 systemd-libs \
 tinycdb \
 "
