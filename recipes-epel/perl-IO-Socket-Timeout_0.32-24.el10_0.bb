# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Socket-Timeout"
PV = "0.32"
PR = "24.el10_0"
PACKAGES = " \
 perl-IO-Socket-Timeout \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IO-Socket-Timeout-0.32-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a86f214bc627c24f02cb508847edca40e93acc28d22167ed7a98bd4a1b58d51"

URI_x86_64_v2_perl-IO-Socket-Timeout = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IO-Socket-Timeout-0.32-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-IO-Socket-Timeout;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-Socket-Timeout}"
SRC_URI[x86_64_v2_perl-IO-Socket-Timeout.sha256sum] = "db22fcbae4f026d714c27a89dc3d4f7897dc4ed8181b60c8a243fd08cbd7a096"

URI_aarch64_perl-IO-Socket-Timeout = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IO-Socket-Timeout-0.32-24.el10_0.noarch.rpm;name=aarch64_perl-IO-Socket-Timeout;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-Socket-Timeout}"
SRC_URI[aarch64_perl-IO-Socket-Timeout.sha256sum] = "18f80607ebd82c56eada43eebdbd5e77c36f00afe35b5aeecc9c2a7b2c25d111"

RDEPENDS:perl-IO-Socket-Timeout = " \
 perl-Carp \
 perl-PerlIO-via-Timeout \
 perl-Socket \
 perl-libs \
 "
