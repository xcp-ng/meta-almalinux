# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-convert_case"
PV = "0.10.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-convert_case+default-devel \
 rust-convert_case-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-convert_case-0.10.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12bfbf81e62e7173e96cc6f507b525433755045b9a198f236d1d84b96ada2326"

URI_x86_64_v2_rust-convert_case+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case+default-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case+default-devel}"
SRC_URI[x86_64_v2_rust-convert_case+default-devel.sha256sum] = "44facd690a2bfa9dfadfbcbf10911479e1ac58ae787967ad5c34da56416832d9"

URI_x86_64_v2_rust-convert_case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case-devel}"
SRC_URI[x86_64_v2_rust-convert_case-devel.sha256sum] = "4c889477d0a713d808b5d71dbad7779a3b46a7438577c16159b3258b393ce24e"

URI_aarch64_rust-convert_case+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case+default-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-convert_case+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case+default-devel}"
SRC_URI[aarch64_rust-convert_case+default-devel.sha256sum] = "f3fd98b9dd673d77e3b174a9990fbf8bfa63027a84e1c2b42255960aad0a47ab"

URI_aarch64_rust-convert_case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-convert_case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case-devel}"
SRC_URI[aarch64_rust-convert_case-devel.sha256sum] = "2af052027710ead47c9651700d5dad625d62db7f55c968965e2a85da44dfaadb"

RDEPENDS:rust-convert_case+default-devel = " \
 cargo \
 rust-convert_case-devel \
 "
RDEPENDS:rust-convert_case-devel = " \
 cargo \
 rust-unicode-segmentation+default-devel \
 "
