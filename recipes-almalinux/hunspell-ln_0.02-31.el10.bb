# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ln"
PV = "0.02"
PR = "31.el10"
PACKAGES = " \
 hunspell-ln \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ln-0.02-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d5df97519af7185ffe8c1d1558051cef7386be23f5489f4dae6a65e6e17d1dd"

URI_x86_64_v2_hunspell-ln = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ln-0.02-31.el10.noarch.rpm;name=x86_64_v2_hunspell-ln;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-ln}"
SRC_URI[x86_64_v2_hunspell-ln.sha256sum] = "9b2f3d425068793a023185526a3230891a1d04a9c2536a7a3f6b8dd3af6af4a2"

URI_aarch64_hunspell-ln = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ln-0.02-31.el10.noarch.rpm;name=aarch64_hunspell-ln;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-ln}"
SRC_URI[aarch64_hunspell-ln.sha256sum] = "9b2f3d425068793a023185526a3230891a1d04a9c2536a7a3f6b8dd3af6af4a2"

RDEPENDS:hunspell-ln = " \
 hunspell-filesystem \
 "
