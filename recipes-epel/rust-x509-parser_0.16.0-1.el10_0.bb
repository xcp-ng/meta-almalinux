# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-x509-parser"
PV = "0.16.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-x509-parser+default-devel \
 rust-x509-parser+ring-devel \
 rust-x509-parser+validate-devel \
 rust-x509-parser+verify-devel \
 rust-x509-parser-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-x509-parser-0.16.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3be037b4ea15bbed23e302b21d918b7719c8a38bdfb3f9b6b1c0796c8f4dbd7"

URI_x86_64_v2_rust-x509-parser+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x509-parser+default-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x509-parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x509-parser+default-devel}"
SRC_URI[x86_64_v2_rust-x509-parser+default-devel.sha256sum] = "704536609f6014772d4116265ead9f3bdca95079b9bd4a1b8549cd6dfe738d23"

URI_x86_64_v2_rust-x509-parser+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x509-parser+ring-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x509-parser+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x509-parser+ring-devel}"
SRC_URI[x86_64_v2_rust-x509-parser+ring-devel.sha256sum] = "00d74802a33eedbcf0566866af1623b81b37f4615a261252312f421cc3e5081b"

URI_x86_64_v2_rust-x509-parser+validate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x509-parser+validate-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x509-parser+validate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x509-parser+validate-devel}"
SRC_URI[x86_64_v2_rust-x509-parser+validate-devel.sha256sum] = "e259fabf37421124a663dde3b08ddb836dbe0149a8647a67adf727d87d1d943d"

URI_x86_64_v2_rust-x509-parser+verify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x509-parser+verify-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x509-parser+verify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x509-parser+verify-devel}"
SRC_URI[x86_64_v2_rust-x509-parser+verify-devel.sha256sum] = "7fc4df19de11f1e6aa089bfaa0f5934f0c82a8f009c26e22e3df95f5e5b89e04"

URI_x86_64_v2_rust-x509-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x509-parser-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x509-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x509-parser-devel}"
SRC_URI[x86_64_v2_rust-x509-parser-devel.sha256sum] = "f7b1f6b427e7d8d8a2550d7dbf6b1e0d38d88ff384a15cbcb3b4fbe9085a5154"

URI_aarch64_rust-x509-parser+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x509-parser+default-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_rust-x509-parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x509-parser+default-devel}"
SRC_URI[aarch64_rust-x509-parser+default-devel.sha256sum] = "1ec5cfeee472a88436492d1dab75fbffd265a2c0d947418991a44653b5e66ff0"

URI_aarch64_rust-x509-parser+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x509-parser+ring-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_rust-x509-parser+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x509-parser+ring-devel}"
SRC_URI[aarch64_rust-x509-parser+ring-devel.sha256sum] = "e852ac2446d3f03046e62f7fdf72bf57451ed3b850072e6d29f15ae1a892566f"

URI_aarch64_rust-x509-parser+validate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x509-parser+validate-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_rust-x509-parser+validate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x509-parser+validate-devel}"
SRC_URI[aarch64_rust-x509-parser+validate-devel.sha256sum] = "6f7e5e318a099760b512acec510c3d79f680014e09098b354eaf472131ecb177"

URI_aarch64_rust-x509-parser+verify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x509-parser+verify-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_rust-x509-parser+verify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x509-parser+verify-devel}"
SRC_URI[aarch64_rust-x509-parser+verify-devel.sha256sum] = "634b0af209d382331d48790954ac96621a47ba9619c66f2e107f95652fe1a906"

URI_aarch64_rust-x509-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x509-parser-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_rust-x509-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x509-parser-devel}"
SRC_URI[aarch64_rust-x509-parser-devel.sha256sum] = "ce69afa1cb048b27e9a5dce37b43426baac8497175fb8365cc239d9a6f79af34"

RDEPENDS:rust-x509-parser+default-devel = " \
 cargo \
 rust-x509-parser-devel \
 "
RDEPENDS:rust-x509-parser+ring-devel = " \
 cargo \
 rust-ring+default-devel \
 rust-x509-parser-devel \
 "
RDEPENDS:rust-x509-parser+validate-devel = " \
 cargo \
 rust-x509-parser-devel \
 "
RDEPENDS:rust-x509-parser+verify-devel = " \
 cargo \
 rust-x509-parser+ring-devel \
 rust-x509-parser-devel \
 "
RDEPENDS:rust-x509-parser-devel = " \
 cargo \
 rust \
 rust-asn1-rs+datetime-devel \
 rust-asn1-rs+default-devel \
 rust-data-encoding+default-devel \
 rust-der-parser+bigint-devel \
 rust-der-parser+default-devel \
 rust-lazy_static+default-devel \
 rust-nom+default-devel \
 rust-oid-registry+crypto-devel \
 rust-oid-registry+default-devel \
 rust-oid-registry+x509-devel \
 rust-oid-registry+x962-devel \
 rust-rusticata-macros+default-devel \
 rust-thiserror1+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 "
