# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dustin-domestic-manners-fonts"
PV = "20030527"
PR = "32.el10_0"
PACKAGES = " \
 dustin-domestic-manners-fonts \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dustin-domestic-manners-fonts-20030527-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "97e230784824b1848f31597b87d6c86af6b4c1afd321d3f7d8c2f39c591a9157"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dustin-domestic-manners-fonts-20030527-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dustin-domestic-manners-fonts;unpack=0"
SRC_URI[x86_64_v2_dustin-domestic-manners-fonts.sha256sum] = "6206af1fb0f5ce5e9e69cdfd3ccfc13ca3e493c42f1d405f409eb961e43796b2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dustin-domestic-manners-fonts-20030527-32.el10_0.noarch.rpm;name=aarch64_dustin-domestic-manners-fonts;unpack=0"
SRC_URI[aarch64_dustin-domestic-manners-fonts.sha256sum] = "79bbd838ceb97942df6f97476aff33ee14c4dc72423bf447d24df39cb864feab"

RDEPENDS:dustin-domestic-manners-fonts = " \
 fonts-filesystem \
 "
