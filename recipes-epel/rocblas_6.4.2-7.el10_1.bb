# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocblas"
PV = "6.4.2"
PR = "7.el10_1"
PACKAGES:x86_64_v2 = " \
 rocblas \
 rocblas-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocblas-6.4.2-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3239bea225e520906ff4c52bbfeaa183d6b1206c668835f4eec7c651b7433f13"

URI_x86_64_v2_rocblas = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocblas-6.4.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocblas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocblas}"
SRC_URI[x86_64_v2_rocblas.sha256sum] = "a756df939c44cb82276ab76b7f2de4e599b48cfa9e0b1b67b0df4caca156716d"

URI_x86_64_v2_rocblas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocblas-devel-6.4.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocblas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocblas-devel}"
SRC_URI[x86_64_v2_rocblas-devel.sha256sum] = "f92f3add20f2486cd3c1dea0223df250ba7e3203e9be075215299ba4f4e859b1"

RDEPENDS:rocblas = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 "
RDEPENDS:rocblas-devel = " \
 cmake-filesystem \
 rocblas \
 rocm-hip-devel \
 "
