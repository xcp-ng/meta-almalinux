# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures"
PV = "0.3.32"
PR = "1.el10_2"
PACKAGES = " \
 rust-futures+alloc-devel \
 rust-futures+async-await-devel \
 rust-futures+bilock-devel \
 rust-futures+cfg-target-has-atomic-devel \
 rust-futures+default-devel \
 rust-futures+executor-devel \
 rust-futures+futures-executor-devel \
 rust-futures+spin-devel \
 rust-futures+std-devel \
 rust-futures+thread-pool-devel \
 rust-futures+unstable-devel \
 rust-futures+write-all-vectored-devel \
 rust-futures-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-0.3.32-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ee68216c66e614754c070ce9fb60b7dc0b3a34274c21b412b3ac9bbd8909e1f"

URI_x86_64_v2_rust-futures+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+alloc-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures+alloc-devel.sha256sum] = "2e6716a9b7f6cb2d2721d21cca6ddc03c4b1fcb09c12f6a3fc801936a97f82d8"

URI_x86_64_v2_rust-futures+async-await-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+async-await-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+async-await-devel}"
SRC_URI[x86_64_v2_rust-futures+async-await-devel.sha256sum] = "200020226eb33750c8acd742ba19efb1b86fa2abcf870d7fa747fe059e292329"

URI_x86_64_v2_rust-futures+bilock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+bilock-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+bilock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+bilock-devel}"
SRC_URI[x86_64_v2_rust-futures+bilock-devel.sha256sum] = "79f248257a2fd6c88c17da33ba7134d2857d9076260081ec55c831ecf60b571b"

URI_x86_64_v2_rust-futures+cfg-target-has-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+cfg-target-has-atomic-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+cfg-target-has-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures+cfg-target-has-atomic-devel.sha256sum] = "2f13ef702311f6765c20ea93051c14bdfa70adbe6b22ae5434f9a286139e8180"

URI_x86_64_v2_rust-futures+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+default-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+default-devel}"
SRC_URI[x86_64_v2_rust-futures+default-devel.sha256sum] = "ec36a47d3aa4fa4e1eff83b64a1da6fd6324a1043ba88f288505d6e69b54eb75"

URI_x86_64_v2_rust-futures+executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+executor-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+executor-devel}"
SRC_URI[x86_64_v2_rust-futures+executor-devel.sha256sum] = "bcd60811980645e5443a3ae8be5194f4b033f8be54e8e311ee636ab0103ac285"

URI_x86_64_v2_rust-futures+futures-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+futures-executor-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+futures-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+futures-executor-devel}"
SRC_URI[x86_64_v2_rust-futures+futures-executor-devel.sha256sum] = "e93a7278e45e552f5762c11dae1c12d69d138906d421336e361c984f0af073a7"

URI_x86_64_v2_rust-futures+spin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+spin-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+spin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+spin-devel}"
SRC_URI[x86_64_v2_rust-futures+spin-devel.sha256sum] = "f8c133b4afc12efed04db591c9e6c528b67318a78b5475b5fedb95f01645aa7c"

URI_x86_64_v2_rust-futures+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+std-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+std-devel}"
SRC_URI[x86_64_v2_rust-futures+std-devel.sha256sum] = "77078347f5b811adedaa8113d8f26dbd80abc337c04803ae04b05f79fff673c4"

URI_x86_64_v2_rust-futures+thread-pool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+thread-pool-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+thread-pool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+thread-pool-devel}"
SRC_URI[x86_64_v2_rust-futures+thread-pool-devel.sha256sum] = "57df6561864d990820dcc9a171f7efc12512499436887537c817680693459d72"

URI_x86_64_v2_rust-futures+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+unstable-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures+unstable-devel.sha256sum] = "a7784c2d20fa0012545f8a30b69a70a47c7cea40d06703bab439fdd1db50558a"

URI_x86_64_v2_rust-futures+write-all-vectored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+write-all-vectored-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+write-all-vectored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+write-all-vectored-devel}"
SRC_URI[x86_64_v2_rust-futures+write-all-vectored-devel.sha256sum] = "6c15d0cb0cbef0e8bb3c515988e42a9a92264e4db83e00bd71568cc6dfda1c89"

URI_x86_64_v2_rust-futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-devel}"
SRC_URI[x86_64_v2_rust-futures-devel.sha256sum] = "c447fc8c6f3f8fc69aa2779b331303c208987c5cdf2d55ba1a6eb9ade292f606"

URI_aarch64_rust-futures+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+alloc-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+alloc-devel}"
SRC_URI[aarch64_rust-futures+alloc-devel.sha256sum] = "b37bba974fb3266c34662f976d0ea5fbf706295d09008dfe10bd5aed7e4259b1"

URI_aarch64_rust-futures+async-await-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+async-await-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+async-await-devel}"
SRC_URI[aarch64_rust-futures+async-await-devel.sha256sum] = "9733dd9a16b08e47d9385fe90ed02d03b803c5314d144c6a7fa37d936d649c37"

URI_aarch64_rust-futures+bilock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+bilock-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures+bilock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+bilock-devel}"
SRC_URI[aarch64_rust-futures+bilock-devel.sha256sum] = "2e4185b8e6a551af85aa42491cade4636a2543708e93f3ee81236c11d6074611"

URI_aarch64_rust-futures+cfg-target-has-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+cfg-target-has-atomic-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+cfg-target-has-atomic-devel}"
SRC_URI[aarch64_rust-futures+cfg-target-has-atomic-devel.sha256sum] = "0685056bbe3358221ee70fc30df66b5996fd3e82ffd30d704d35117f6db3545e"

URI_aarch64_rust-futures+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+default-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+default-devel}"
SRC_URI[aarch64_rust-futures+default-devel.sha256sum] = "5ec3bb426fde35aa3980fae1afcee71c9ec758d59b37d6f80f76add2d041e5f6"

URI_aarch64_rust-futures+executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+executor-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures+executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+executor-devel}"
SRC_URI[aarch64_rust-futures+executor-devel.sha256sum] = "961e6a3c5780ed3a344623df52aaf0ecab8617dd0ed2b11a073e0603ca722694"

URI_aarch64_rust-futures+futures-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+futures-executor-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures+futures-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+futures-executor-devel}"
SRC_URI[aarch64_rust-futures+futures-executor-devel.sha256sum] = "70a082c537dac6bb98b270340bfca7819752e5c1e0fe1584b54bc4d543ba186e"

URI_aarch64_rust-futures+spin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+spin-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures+spin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+spin-devel}"
SRC_URI[aarch64_rust-futures+spin-devel.sha256sum] = "1890a6b70bce692d8be4a2f0f5b6aab6881f3e89939ee2459ca2d4c4b71712da"

URI_aarch64_rust-futures+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+std-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+std-devel}"
SRC_URI[aarch64_rust-futures+std-devel.sha256sum] = "26fc6af0a9c5655d3bcbb59a16bc4366d9bacc25d134f9d66a2ef72736bae71e"

URI_aarch64_rust-futures+thread-pool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+thread-pool-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures+thread-pool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+thread-pool-devel}"
SRC_URI[aarch64_rust-futures+thread-pool-devel.sha256sum] = "3e69e30c9fa83d814aa7428a6e5580917a9b4644592f01af9bebba2e11980409"

URI_aarch64_rust-futures+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+unstable-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+unstable-devel}"
SRC_URI[aarch64_rust-futures+unstable-devel.sha256sum] = "5af200220355079db3a94a9e533a80dbb191e0a3f2b586e1860627606809f9f6"

URI_aarch64_rust-futures+write-all-vectored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+write-all-vectored-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures+write-all-vectored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+write-all-vectored-devel}"
SRC_URI[aarch64_rust-futures+write-all-vectored-devel.sha256sum] = "0bba2dcbda6d0b39132921877665609ffcdaf817b5a1fec5073098b2169d4bf9"

URI_aarch64_rust-futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-devel}"
SRC_URI[aarch64_rust-futures-devel.sha256sum] = "a29965b66ffe17320cc91b32b1d4831de539566d5b1ec126498f70e94306fe3c"

RDEPENDS:rust-futures+alloc-devel = " \
 cargo \
 rust-futures-channel+alloc-devel \
 rust-futures-core+alloc-devel \
 rust-futures-devel \
 rust-futures-sink+alloc-devel \
 rust-futures-task+alloc-devel \
 rust-futures-util+alloc-devel \
 "
RDEPENDS:rust-futures+async-await-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-util+async-await-devel \
 rust-futures-util+async-await-macro-devel \
 "
RDEPENDS:rust-futures+bilock-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-util+bilock-devel \
 "
RDEPENDS:rust-futures+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-devel \
 "
RDEPENDS:rust-futures+default-devel = " \
 cargo \
 rust-futures+async-await-devel \
 rust-futures+executor-devel \
 rust-futures+std-devel \
 rust-futures-devel \
 "
RDEPENDS:rust-futures+executor-devel = " \
 cargo \
 rust-futures+std-devel \
 rust-futures-devel \
 rust-futures-executor+std-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures+futures-executor-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures+spin-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-util+spin-devel \
 "
RDEPENDS:rust-futures+std-devel = " \
 cargo \
 rust-futures+alloc-devel \
 rust-futures-core+std-devel \
 rust-futures-devel \
 rust-futures-io+std-devel \
 rust-futures-sink+std-devel \
 rust-futures-task+std-devel \
 rust-futures-util+channel-devel \
 rust-futures-util+io-devel \
 rust-futures-util+std-devel \
 "
RDEPENDS:rust-futures+thread-pool-devel = " \
 cargo \
 rust-futures+executor-devel \
 rust-futures-devel \
 rust-futures-executor+thread-pool-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures+unstable-devel = " \
 cargo \
 rust-futures-channel+unstable-devel \
 rust-futures-core+unstable-devel \
 rust-futures-devel \
 rust-futures-io+unstable-devel \
 rust-futures-task+unstable-devel \
 rust-futures-util+unstable-devel \
 "
RDEPENDS:rust-futures+write-all-vectored-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-util+write-all-vectored-devel \
 "
RDEPENDS:rust-futures-devel = " \
 cargo \
 rust \
 rust-futures-channel+sink-devel \
 rust-futures-channel-devel \
 rust-futures-core-devel \
 rust-futures-io-devel \
 rust-futures-sink-devel \
 rust-futures-task-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 "
