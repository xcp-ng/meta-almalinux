# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdesu"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kdesu \
 kf6-kdesu-devel \
 kf6-kdesu-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kdesu-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3e1a71ac5a48e048e83a48e0b5c70a825e98c15a07a23bed8547e7f24fde2b69"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdesu;unpack=0"
SRC_URI[x86_64_v2_kf6-kdesu.sha256sum] = "90d36ccc1fc90922fd47fc5498db7fa851d00279274dda44cd3b7ba4365df7bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdesu-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kdesu-devel.sha256sum] = "2b1ed1973d3d6eee2e7318165f1f2925f2196e3d641aaff8b1fedec0ae765680"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdesu-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kdesu-doc.sha256sum] = "6255ba0ea8aeae4286fe1d15f0521a1d54fd4cd151599eada4530cea594a0125"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kdesu;unpack=0"
SRC_URI[aarch64_kf6-kdesu.sha256sum] = "00f259cafa2619794bc89fda4d46b08816aee559841fb69544c035eb00eca152"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kdesu-devel;unpack=0"
SRC_URI[aarch64_kf6-kdesu-devel.sha256sum] = "a1540162da7bf4aa4adcc60f5f9c6468be09b2eeaed83422ad16ec22e55a60c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kdesu-doc;unpack=0"
SRC_URI[aarch64_kf6-kdesu-doc.sha256sum] = "cccce634104f9b53826aa5e916827087691e337c63f6698cdbc1ffe33ab7c2ac"

RDEPENDS:kf6-kdesu = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpty \
 libX11 \
 libstdc++ \
 qt6-qtbase \
 sudo \
 "
RDEPENDS:kf6-kdesu-devel = " \
 cmake-filesystem \
 kf6-kdesu \
 kf6-kpty-devel \
 "
RDEPENDS:kf6-kdesu-doc = " \
 "
