# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "GitPython"
PV = "3.1.45"
PR = "1.el10_0"
PACKAGES = " \
 python3-GitPython \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/GitPython-3.1.45-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f656ba6ad84d0665b3d03ce9fdee75aa69f66929e87b806f1ae9fe66ed2c5424"

URI_x86_64_v2_python3-GitPython = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-GitPython-3.1.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-GitPython;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-GitPython}"
SRC_URI[x86_64_v2_python3-GitPython.sha256sum] = "3606b0733035b4b298a49d47f2dd368f2ee25014109dbda94b38bcca085aeb06"

URI_aarch64_python3-GitPython = "${EPEL_MIRROR}/aarch64/Packages/p/python3-GitPython-3.1.45-1.el10_0.noarch.rpm;name=aarch64_python3-GitPython;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-GitPython}"
SRC_URI[aarch64_python3-GitPython.sha256sum] = "cfc8fc04cc6da26d9981d473f3b900db69c5ae7a6c47142f2d7f607fb96a1af4"

RDEPENDS:python3-GitPython = " \
 git-core \
 python3 \
 python3-gitdb \
 "
