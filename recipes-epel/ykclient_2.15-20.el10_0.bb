# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ykclient"
PV = "2.15"
PR = "20.el10_0"
PACKAGES = " \
 ykclient \
 ykclient-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/ykclient-2.15-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3033c530a6d44e4d4fdab2e81646705d03c37ff1644aa5506f9e8a6190b40a19"

URI_x86_64_v2_ykclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ykclient-2.15-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ykclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ykclient}"
SRC_URI[x86_64_v2_ykclient.sha256sum] = "e8c7fd5bf98195565b713a5866f2fce7857eb8c8ee37aa98ebf1cc99896e4ad0"

URI_x86_64_v2_ykclient-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ykclient-devel-2.15-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ykclient-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ykclient-devel}"
SRC_URI[x86_64_v2_ykclient-devel.sha256sum] = "4f230ddfefe0bc91bdcbc28b86849edb0c2c4c81b9ff383665eb811346672ae4"

URI_aarch64_ykclient = "${EPEL_MIRROR}/aarch64/Packages/y/ykclient-2.15-20.el10_0.aarch64.rpm;name=aarch64_ykclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_ykclient}"
SRC_URI[aarch64_ykclient.sha256sum] = "c1ef2a3a743a6e75bb5be1c2009d58ee9046e25e8322a95f2eadccd156605c3f"

URI_aarch64_ykclient-devel = "${EPEL_MIRROR}/aarch64/Packages/y/ykclient-devel-2.15-20.el10_0.aarch64.rpm;name=aarch64_ykclient-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ykclient-devel}"
SRC_URI[aarch64_ykclient-devel.sha256sum] = "94daa43cc85ea6eefe55d20325368b0586785eeca75a16b8d1468c9464284d50"

RDEPENDS:ykclient = " \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:ykclient-devel = " \
 ykclient \
 "
