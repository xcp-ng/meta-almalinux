# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-urllib3-epel"
PV = "1.26.19"
PR = "2.el10_2"
PACKAGES = " \
 python3-urllib3+brotli \
 python3-urllib3+socks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-urllib3-epel-1.26.19-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e49c2c7646f1fe7716667d7301ac8d46314935667767174c87275f826f21536"

URI_x86_64_v2_python3-urllib3+brotli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-urllib3+brotli-1.26.19-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-urllib3+brotli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-urllib3+brotli}"
SRC_URI[x86_64_v2_python3-urllib3+brotli.sha256sum] = "57e450f1332379479a7d92c05b0308612459f9dacf0c7dbde26e683f743356a9"

URI_x86_64_v2_python3-urllib3+socks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-urllib3+socks-1.26.19-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-urllib3+socks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-urllib3+socks}"
SRC_URI[x86_64_v2_python3-urllib3+socks.sha256sum] = "e50bb18cc62867fb75c131732183a399a4eb2ffc4bdd7ce13f89bf9499eb9d4e"

URI_aarch64_python3-urllib3+brotli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-urllib3+brotli-1.26.19-2.el10_2.noarch.rpm;name=aarch64_python3-urllib3+brotli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-urllib3+brotli}"
SRC_URI[aarch64_python3-urllib3+brotli.sha256sum] = "12df807c504c261e4c65936aa327c747dbe5dcdb857863d0b98d9e74c57d639f"

URI_aarch64_python3-urllib3+socks = "${EPEL_MIRROR}/aarch64/Packages/p/python3-urllib3+socks-1.26.19-2.el10_2.noarch.rpm;name=aarch64_python3-urllib3+socks;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-urllib3+socks}"
SRC_URI[aarch64_python3-urllib3+socks.sha256sum] = "298694d90a1af559bff29b1fb8477329edc04e98a9154a2c8ac2c4a4dbdff1b4"

RDEPENDS:python3-urllib3+brotli = " \
 python3 \
 python3-brotli \
 python3-urllib3 \
 "
RDEPENDS:python3-urllib3+socks = " \
 python3 \
 python3-pysocks \
 python3-urllib3 \
 "
