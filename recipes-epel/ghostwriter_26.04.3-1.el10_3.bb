# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghostwriter"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ghostwriter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghostwriter-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "749c0c85b683870fd9888babd1a8bb1eda4a6770e64f4ed9d865acf09b10d314"

URI_x86_64_v2_ghostwriter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghostwriter-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghostwriter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghostwriter}"
SRC_URI[x86_64_v2_ghostwriter.sha256sum] = "8e2b5b96fd3b33f92864530a5b78e5e56e8fd7085a22d97e866ae6b1477991c1"

URI_aarch64_ghostwriter = "${EPEL_MIRROR}/aarch64/Packages/g/ghostwriter-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ghostwriter;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghostwriter}"
SRC_URI[aarch64_ghostwriter.sha256sum] = "8add87a6c39b1394ee074dabc130a9dddf5b477979fe3936f8fbe9a2dafb3fbd"

RDEPENDS:ghostwriter = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 "
