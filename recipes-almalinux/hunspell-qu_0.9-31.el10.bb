# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-qu"
PV = "0.9"
PR = "31.el10"
PACKAGES = " \
 hunspell-qu \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-qu-0.9-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc4806f405c474365e825be998f931ac8b412d206ce961800d655e55e7455530"

URI_x86_64_v2_hunspell-qu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-qu-0.9-31.el10.noarch.rpm;name=x86_64_v2_hunspell-qu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-qu}"
SRC_URI[x86_64_v2_hunspell-qu.sha256sum] = "7a61d91eee6adf5302100c534b798ff17e3429f348c89293a079f63168c4129d"

URI_aarch64_hunspell-qu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-qu-0.9-31.el10.noarch.rpm;name=aarch64_hunspell-qu;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-qu}"
SRC_URI[aarch64_hunspell-qu.sha256sum] = "7a61d91eee6adf5302100c534b798ff17e3429f348c89293a079f63168c4129d"

RDEPENDS:hunspell-qu = " \
 hunspell \
 "
