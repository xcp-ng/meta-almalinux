# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pbr"
PV = "7.0.3"
PR = "2.el10_2"
PACKAGES = " \
 python3-pbr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pbr-7.0.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "743367bb8c7fe416abc6bf7d1fd86889752b8e96272b6d23ecdfce4bcc54a360"

URI_x86_64_v2_python3-pbr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pbr-7.0.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pbr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pbr}"
SRC_URI[x86_64_v2_python3-pbr.sha256sum] = "b243e80d4d5c2b03a91de0c5ad984dee2b2b5b7ee9f32781f08488e9e465ec6d"

URI_aarch64_python3-pbr = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pbr-7.0.3-2.el10_2.noarch.rpm;name=aarch64_python3-pbr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pbr}"
SRC_URI[aarch64_python3-pbr.sha256sum] = "713007e4aa3ae15926b35e28334c7439946d0da4549a229bbc27bb13c6186355"

RDEPENDS:python3-pbr = " \
 git-core \
 python3 \
 python3-setuptools \
 "
