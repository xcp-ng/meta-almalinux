# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "katomic"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 katomic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/katomic-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "554394b267e253dc771b2c88eff2dd078923a0a3294c0889f564e8c8b84c4c8b"

URI_x86_64_v2_katomic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/katomic-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_katomic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_katomic}"
SRC_URI[x86_64_v2_katomic.sha256sum] = "a9c40b7736974a3701352f5baaf92eb521f6c541a8a6ee97803e3a2505134ed2"

URI_aarch64_katomic = "${EPEL_MIRROR}/aarch64/Packages/k/katomic-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_katomic;unpack=0"
SRC_URI:append = " ${URI_aarch64_katomic}"
SRC_URI[aarch64_katomic.sha256sum] = "79d05a854a2909b81149cf35d54b2f6b27750cd6912ed129183c4cec0e2cec05"

RDEPENDS:katomic = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
