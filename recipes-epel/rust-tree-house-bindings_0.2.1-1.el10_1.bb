# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-house-bindings"
PV = "0.2.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-house-bindings+default-devel \
 rust-tree-house-bindings+ropey-devel \
 rust-tree-house-bindings-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-house-bindings-0.2.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5f16934ad867d95969f0180bfab0a096fcd34a5618912dc8aa6862ea895f4ca"

URI_x86_64_v2_rust-tree-house-bindings+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-house-bindings+default-devel-0.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-house-bindings+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-house-bindings+default-devel}"
SRC_URI[x86_64_v2_rust-tree-house-bindings+default-devel.sha256sum] = "c04351267e5e81ecab35a73ac16b9a721459d223e42a049dc021c7dfbac17e48"

URI_x86_64_v2_rust-tree-house-bindings+ropey-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-house-bindings+ropey-devel-0.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-house-bindings+ropey-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-house-bindings+ropey-devel}"
SRC_URI[x86_64_v2_rust-tree-house-bindings+ropey-devel.sha256sum] = "51de954b7a8de1534888d762d0e9354d8fe7c5b2d098c7dbb21945aa482c972b"

URI_x86_64_v2_rust-tree-house-bindings-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-house-bindings-devel-0.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-house-bindings-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-house-bindings-devel}"
SRC_URI[x86_64_v2_rust-tree-house-bindings-devel.sha256sum] = "b61f4d1c54541a0e4a7981be2073990f4d9e3444f69fa0747a3e81172a4f5244"

URI_aarch64_rust-tree-house-bindings+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-house-bindings+default-devel-0.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-tree-house-bindings+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-house-bindings+default-devel}"
SRC_URI[aarch64_rust-tree-house-bindings+default-devel.sha256sum] = "f59fb6914ef1d81d1ab503979356bb5ab41abccc02a7f7091aabf20fe909afcb"

URI_aarch64_rust-tree-house-bindings+ropey-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-house-bindings+ropey-devel-0.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-tree-house-bindings+ropey-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-house-bindings+ropey-devel}"
SRC_URI[aarch64_rust-tree-house-bindings+ropey-devel.sha256sum] = "7d093c55dd25772ad9a37a1074c4194dbca25a9ffb590cc07bd810189db0aea9"

URI_aarch64_rust-tree-house-bindings-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-house-bindings-devel-0.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-tree-house-bindings-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-house-bindings-devel}"
SRC_URI[aarch64_rust-tree-house-bindings-devel.sha256sum] = "04bae469b1711b77e8a684e1bfcdf6f7bad00f72d1d9a519913a5881e857f59f"

RDEPENDS:rust-tree-house-bindings+default-devel = " \
 cargo \
 rust-tree-house-bindings-devel \
 "
RDEPENDS:rust-tree-house-bindings+ropey-devel = " \
 cargo \
 rust-ropey-devel \
 rust-tree-house-bindings-devel \
 "
RDEPENDS:rust-tree-house-bindings-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-libloading+default-devel \
 rust-regex-cursor+default-devel \
 rust-thiserror+default-devel \
 "
