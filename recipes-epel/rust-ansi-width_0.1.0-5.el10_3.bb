# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ansi-width"
PV = "0.1.0"
PR = "5.el10_3"
PACKAGES = " \
 rust-ansi-width+default-devel \
 rust-ansi-width-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ansi-width-0.1.0-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e619d7ea6ce203f21cb1dbc4a458677f711dbcef2df9bc7fa7a5db4c6c28a8f"

URI_x86_64_v2_rust-ansi-width+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi-width+default-devel-0.1.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi-width+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi-width+default-devel}"
SRC_URI[x86_64_v2_rust-ansi-width+default-devel.sha256sum] = "36ac34871c6aea44def190008123e15129de18c2fd99c9050b55b9049e5e85ab"

URI_x86_64_v2_rust-ansi-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi-width-devel-0.1.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi-width-devel}"
SRC_URI[x86_64_v2_rust-ansi-width-devel.sha256sum] = "717208956234436004d448ca043a3e675688d269bbfdd39e1668b2ba3fbe3e96"

URI_aarch64_rust-ansi-width+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi-width+default-devel-0.1.0-5.el10_3.noarch.rpm;name=aarch64_rust-ansi-width+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi-width+default-devel}"
SRC_URI[aarch64_rust-ansi-width+default-devel.sha256sum] = "1c463828400e0462069341c58f57ceb55268e8818479dec0c9a17d1f819408a7"

URI_aarch64_rust-ansi-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi-width-devel-0.1.0-5.el10_3.noarch.rpm;name=aarch64_rust-ansi-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi-width-devel}"
SRC_URI[aarch64_rust-ansi-width-devel.sha256sum] = "d15f2138ed3173baaefa2ecce58bf4eae17aa42593d90cde4f16027f0799ce92"

RDEPENDS:rust-ansi-width+default-devel = " \
 cargo \
 rust-ansi-width-devel \
 "
RDEPENDS:rust-ansi-width-devel = " \
 cargo \
 rust \
 rust-unicode-width0.1+default-devel \
 "
