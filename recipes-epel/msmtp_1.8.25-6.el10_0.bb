# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "msmtp"
PV = "1.8.25"
PR = "6.el10_0"
PACKAGES = " \
 msmtp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/msmtp-1.8.25-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9182402410de7b73a01bc89fa8beba8fc0e5168062d0dffd04ca9ae8e5d53554"

URI_x86_64_v2_msmtp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/msmtp-1.8.25-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_msmtp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_msmtp}"
SRC_URI[x86_64_v2_msmtp.sha256sum] = "3e650c41e6295b6db8c4375bb788dc59724531e39113b33b840f08ae00ec7581"
RPROVIDES:msmtp:x86_64_v2 = "virtual//usr/sbin/sendmail"

URI_aarch64_msmtp = "${EPEL_MIRROR}/aarch64/Packages/m/msmtp-1.8.25-6.el10_0.aarch64.rpm;name=aarch64_msmtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_msmtp}"
SRC_URI[aarch64_msmtp.sha256sum] = "90ea56a28ae416bf4cc81e6a02d41216aa92fb70b0ea5515f2958b283090a092"
RPROVIDES:msmtp:aarch64 = "virtual//usr/sbin/sendmail"

RDEPENDS:msmtp = " \
 alternatives \
 bash \
 glibc \
 gnutls \
 info \
 libgsasl \
 libsecret \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/sbin/sendmail"

PROVIDES:append:aarch64 = " rpm/virtual//usr/sbin/sendmail"
