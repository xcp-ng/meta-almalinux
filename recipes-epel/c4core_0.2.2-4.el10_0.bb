# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c4core"
PV = "0.2.2"
PR = "4.el10_0"
PACKAGES = " \
 c4core \
 c4core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/c4core-0.2.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3abcbc74bb54f81c9a01538e87164e9c0bda88de141d8e5fb5dc1369b1ef7d1"

URI_x86_64_v2_c4core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c4core-0.2.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c4core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c4core}"
SRC_URI[x86_64_v2_c4core.sha256sum] = "44831138be526ed8cdf6efb873f3ec9e04f1e799ba502e4da89fa7c02cb5d2ad"

URI_x86_64_v2_c4core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c4core-devel-0.2.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c4core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c4core-devel}"
SRC_URI[x86_64_v2_c4core-devel.sha256sum] = "9c3bf0e1235733cae98f010035664d04a2b365aa79a35c58d10a981ecb950060"

URI_aarch64_c4core = "${EPEL_MIRROR}/aarch64/Packages/c/c4core-0.2.2-4.el10_0.aarch64.rpm;name=aarch64_c4core;unpack=0"
SRC_URI:append = " ${URI_aarch64_c4core}"
SRC_URI[aarch64_c4core.sha256sum] = "a737a2d4ab1859608f4bd9b25690797bcf31c28080b1301a85b72d3e1d28db5c"

URI_aarch64_c4core-devel = "${EPEL_MIRROR}/aarch64/Packages/c/c4core-devel-0.2.2-4.el10_0.aarch64.rpm;name=aarch64_c4core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_c4core-devel}"
SRC_URI[aarch64_c4core-devel.sha256sum] = "8c5ff4fd09b663685978c912291a6c1b84404c856d56512efd2d95f067d834ad"

RDEPENDS:c4core = " \
 glibc \
 libstdc++ \
 "
RDEPENDS:c4core-devel = " \
 c4core \
 cmake-filesystem \
 debugbreak-devel \
 fast_float-devel \
 "
