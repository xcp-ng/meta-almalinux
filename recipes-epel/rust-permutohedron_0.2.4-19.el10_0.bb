# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-permutohedron"
PV = "0.2.4"
PR = "19.el10_0"
PACKAGES = " \
 rust-permutohedron+default-devel \
 rust-permutohedron+std-devel \
 rust-permutohedron-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-permutohedron-0.2.4-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46f283cf6574a5f988ac004e0d56a68eebd5e3fa21be645928f3578deb2ff7c0"

URI_x86_64_v2_rust-permutohedron+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-permutohedron+default-devel-0.2.4-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-permutohedron+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-permutohedron+default-devel}"
SRC_URI[x86_64_v2_rust-permutohedron+default-devel.sha256sum] = "2ddbdb34a34d7abc61379454c3da0c49affa7d63320d9a1a499effba997f32fe"

URI_x86_64_v2_rust-permutohedron+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-permutohedron+std-devel-0.2.4-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-permutohedron+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-permutohedron+std-devel}"
SRC_URI[x86_64_v2_rust-permutohedron+std-devel.sha256sum] = "f556363de742adaa8e38fdc352e776c555d126b9e93ea1c05d052d2e8310a6a0"

URI_x86_64_v2_rust-permutohedron-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-permutohedron-devel-0.2.4-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-permutohedron-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-permutohedron-devel}"
SRC_URI[x86_64_v2_rust-permutohedron-devel.sha256sum] = "97bc4ef42e1f61c7d9837a337706c5beef36338ec689525175a0fd5cc9b4bc4a"

URI_aarch64_rust-permutohedron+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-permutohedron+default-devel-0.2.4-19.el10_0.noarch.rpm;name=aarch64_rust-permutohedron+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-permutohedron+default-devel}"
SRC_URI[aarch64_rust-permutohedron+default-devel.sha256sum] = "ac986db4763f1dee4e626be66d2ac69645e855e44895abccb7ec457701c2b9f6"

URI_aarch64_rust-permutohedron+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-permutohedron+std-devel-0.2.4-19.el10_0.noarch.rpm;name=aarch64_rust-permutohedron+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-permutohedron+std-devel}"
SRC_URI[aarch64_rust-permutohedron+std-devel.sha256sum] = "e7735d5cd4a797e73d7e6b64ba8202d900a8a896d356ea596157192620ab6aeb"

URI_aarch64_rust-permutohedron-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-permutohedron-devel-0.2.4-19.el10_0.noarch.rpm;name=aarch64_rust-permutohedron-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-permutohedron-devel}"
SRC_URI[aarch64_rust-permutohedron-devel.sha256sum] = "dd2208c069dbdbacf6246a452dd5d9abf6335ab8a352b1feddd3d0484440246a"

RDEPENDS:rust-permutohedron+default-devel = " \
 cargo \
 rust-permutohedron+std-devel \
 rust-permutohedron-devel \
 "
RDEPENDS:rust-permutohedron+std-devel = " \
 cargo \
 rust-permutohedron-devel \
 "
RDEPENDS:rust-permutohedron-devel = " \
 cargo \
 "
