# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-darling_macro0.20"
PV = "0.20.11"
PR = "1.el10_2"
PACKAGES = " \
 rust-darling_macro0.20+default-devel \
 rust-darling_macro0.20-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-darling_macro0.20-0.20.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d56c9a1472ae4371c8fab796f552274f1c3ccab9550021d15835fcc30205de6"

URI_x86_64_v2_rust-darling_macro0.20+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_macro0.20+default-devel-0.20.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_macro0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_macro0.20+default-devel}"
SRC_URI[x86_64_v2_rust-darling_macro0.20+default-devel.sha256sum] = "5ad9f87464849aebe8cb8883e90e5f71b6d92c02c47e868fd5c925219a403705"

URI_x86_64_v2_rust-darling_macro0.20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_macro0.20-devel-0.20.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_macro0.20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_macro0.20-devel}"
SRC_URI[x86_64_v2_rust-darling_macro0.20-devel.sha256sum] = "5c951484b3210e725080d25398d9f37544cf90b84735e7fb6a54fc1ae4973e91"

URI_aarch64_rust-darling_macro0.20+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_macro0.20+default-devel-0.20.11-1.el10_2.noarch.rpm;name=aarch64_rust-darling_macro0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_macro0.20+default-devel}"
SRC_URI[aarch64_rust-darling_macro0.20+default-devel.sha256sum] = "a2b3ade637ec969f062525e3f0d1a362def47dc52d709129e5cd0e1d7c8400e3"

URI_aarch64_rust-darling_macro0.20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_macro0.20-devel-0.20.11-1.el10_2.noarch.rpm;name=aarch64_rust-darling_macro0.20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_macro0.20-devel}"
SRC_URI[aarch64_rust-darling_macro0.20-devel.sha256sum] = "45403fb6932efa384f128a0feef744410221d02d8b90a4d74ef971ea67431830"

RDEPENDS:rust-darling_macro0.20+default-devel = " \
 cargo \
 rust-darling_macro0.20-devel \
 "
RDEPENDS:rust-darling_macro0.20-devel = " \
 cargo \
 rust \
 rust-darling_core0.20+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
