# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-browser-integration"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-browser-integration \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-browser-integration-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d64d9126ea0ef0b73bf3fb93cb6100b0d0aae7310f55cf94c681a2b05a9c847"

URI_x86_64_v2_plasma-browser-integration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-browser-integration-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-browser-integration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-browser-integration}"
SRC_URI[x86_64_v2_plasma-browser-integration.sha256sum] = "d240928759e29be42cd9c3cec9b4859d794cef57eec87a17a9e369b491c5cd33"

URI_aarch64_plasma-browser-integration = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-browser-integration-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-browser-integration;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-browser-integration}"
SRC_URI[aarch64_plasma-browser-integration.sha256sum] = "f23f6fe7c4f952f2a14d3e411e0ba41a4c2ebd96ffb9368e05bb6176954d3633"

RDEPENDS:plasma-browser-integration = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-purpose \
 libstdc++ \
 plasma-activities \
 plasma-workspace-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
