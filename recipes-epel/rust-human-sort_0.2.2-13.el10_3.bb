# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-human-sort"
PV = "0.2.2"
PR = "13.el10_3"
PACKAGES = " \
 rust-human-sort+default-devel \
 rust-human-sort-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-human-sort-0.2.2-13.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73dce2f54fb0fadd4cdf8fc01a696b2cc1c7703034e7d579ec9b2f5c85b16cca"

URI_x86_64_v2_rust-human-sort+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-sort+default-devel-0.2.2-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-sort+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-sort+default-devel}"
SRC_URI[x86_64_v2_rust-human-sort+default-devel.sha256sum] = "17a7df5c38925371cb45c3132a39aff6cdf91d3cb10fc8285ff8ccf12d7e501d"

URI_x86_64_v2_rust-human-sort-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-sort-devel-0.2.2-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-sort-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-sort-devel}"
SRC_URI[x86_64_v2_rust-human-sort-devel.sha256sum] = "b1da67e4aa670d992a25794389cd2f03124c40c0c1284ecc09ffb267652802e1"

URI_aarch64_rust-human-sort+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-sort+default-devel-0.2.2-13.el10_3.noarch.rpm;name=aarch64_rust-human-sort+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-sort+default-devel}"
SRC_URI[aarch64_rust-human-sort+default-devel.sha256sum] = "0dfdec3ff9f199bff4b91ce5333a97bf86c2b2a03dff4a0056546edfa686794a"

URI_aarch64_rust-human-sort-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-sort-devel-0.2.2-13.el10_3.noarch.rpm;name=aarch64_rust-human-sort-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-sort-devel}"
SRC_URI[aarch64_rust-human-sort-devel.sha256sum] = "d68db17a97bf67113108daa17e317db4bcfc630c43f980fa5db02d6aeb263b35"

RDEPENDS:rust-human-sort+default-devel = " \
 cargo \
 rust-human-sort-devel \
 "
RDEPENDS:rust-human-sort-devel = " \
 cargo \
 "
