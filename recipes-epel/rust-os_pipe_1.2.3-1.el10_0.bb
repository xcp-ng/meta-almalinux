# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-os_pipe"
PV = "1.2.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-os_pipe+default-devel \
 rust-os_pipe+io_safety-devel \
 rust-os_pipe-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-os_pipe-1.2.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00ce545ea7f88a3a7cbef0bba26e54817bf1283b12ef46795f3929f9fe80c7f7"

URI_x86_64_v2_rust-os_pipe+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_pipe+default-devel-1.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_pipe+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_pipe+default-devel}"
SRC_URI[x86_64_v2_rust-os_pipe+default-devel.sha256sum] = "9f6c521346b04847847ddf4095e734081b1e46254589275f89260cc5b617276d"

URI_x86_64_v2_rust-os_pipe+io_safety-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_pipe+io_safety-devel-1.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_pipe+io_safety-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_pipe+io_safety-devel}"
SRC_URI[x86_64_v2_rust-os_pipe+io_safety-devel.sha256sum] = "e059541ea21c0cf76a02ce93dec1357fa791ccb15d827d7e6a7cc7f1638e674d"

URI_x86_64_v2_rust-os_pipe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_pipe-devel-1.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_pipe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_pipe-devel}"
SRC_URI[x86_64_v2_rust-os_pipe-devel.sha256sum] = "635886c5e15772dc62ccb7e77538c3bace56b8cc471b09d8d6188fac8b2e008d"

URI_aarch64_rust-os_pipe+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_pipe+default-devel-1.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-os_pipe+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_pipe+default-devel}"
SRC_URI[aarch64_rust-os_pipe+default-devel.sha256sum] = "7214ba5bf77108fbca9c615a278093f8b1837162130e4f210d8232b036339ffd"

URI_aarch64_rust-os_pipe+io_safety-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_pipe+io_safety-devel-1.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-os_pipe+io_safety-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_pipe+io_safety-devel}"
SRC_URI[aarch64_rust-os_pipe+io_safety-devel.sha256sum] = "925b7a8e33d33184082dd32552f8ceaacd1c6fa9779b58a3c7fe297202b995c1"

URI_aarch64_rust-os_pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_pipe-devel-1.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-os_pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_pipe-devel}"
SRC_URI[aarch64_rust-os_pipe-devel.sha256sum] = "52fca83442cb46118d52363cbaf10b0e24cdd1f1dddcc6b3b92d87e281065f71"

RDEPENDS:rust-os_pipe+default-devel = " \
 cargo \
 rust-os_pipe-devel \
 "
RDEPENDS:rust-os_pipe+io_safety-devel = " \
 cargo \
 rust-os_pipe-devel \
 "
RDEPENDS:rust-os_pipe-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
