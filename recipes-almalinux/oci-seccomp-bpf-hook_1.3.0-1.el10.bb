# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oci-seccomp-bpf-hook"
PV = "1.3.0"
PR = "1.el10"
PACKAGES = " \
 oci-seccomp-bpf-hook \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/oci-seccomp-bpf-hook-1.3.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37b24facd0dffdf515c26fc0f80109342e615e67fc61a18d22e6aebeab6f076f"

URI_x86_64_v2_oci-seccomp-bpf-hook = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/oci-seccomp-bpf-hook-1.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_oci-seccomp-bpf-hook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oci-seccomp-bpf-hook}"
SRC_URI[x86_64_v2_oci-seccomp-bpf-hook.sha256sum] = "4ce6c420a9794076a1be30b1cbe08c2e1145a158730303f077354c338a9bec2b"

URI_aarch64_oci-seccomp-bpf-hook = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/oci-seccomp-bpf-hook-1.3.0-1.el10.aarch64.rpm;name=aarch64_oci-seccomp-bpf-hook;unpack=0"
SRC_URI:append = " ${URI_aarch64_oci-seccomp-bpf-hook}"
SRC_URI[aarch64_oci-seccomp-bpf-hook.sha256sum] = "cce3caa6da3dddc8038f2e493b639bf713b9f5884629cd8fa4e94600ec8a8fa5"

RDEPENDS:oci-seccomp-bpf-hook = " \
 bcc \
 glibc \
 libseccomp \
 "
