# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fcoe-utils"
PV = "1.0.34"
PR = "11.gitb233050.el10"
PACKAGES = " \
 fcoe-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/fcoe-utils-1.0.34-11.gitb233050.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "295b8893eab58d4a4be6e66b2878f271269931e1c7839c05601ac984227e40c1"

URI_x86_64_v2_fcoe-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/fcoe-utils-1.0.34-11.gitb233050.el10.x86_64_v2.rpm;name=x86_64_v2_fcoe-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fcoe-utils}"
SRC_URI[x86_64_v2_fcoe-utils.sha256sum] = "661afab72c730521d09b1fb708a6fe2f461e5b0631dd17a06c31d7c98e03996a"

URI_aarch64_fcoe-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/fcoe-utils-1.0.34-11.gitb233050.el10.aarch64.rpm;name=aarch64_fcoe-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_fcoe-utils}"
SRC_URI[aarch64_fcoe-utils.sha256sum] = "015c7ec24b2bc5db736d8eadeb9556ddac751001de5fb5de41b37e7b247bc2b8"

RDEPENDS:fcoe-utils = " \
 bash \
 device-mapper-multipath \
 glibc \
 iproute \
 libpciaccess \
 lldpad \
 systemd \
 "
