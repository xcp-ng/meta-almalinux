# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Base"
PV = "0.89"
PR = "21.el10_0"
PACKAGES = " \
 perl-Test-Base \
 perl-Test-Base-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-Base-0.89-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3982cdfe5953c6bb577e3ce1ffc23c46c9b842bad01c4452bc1d8c3820849de2"

URI_x86_64_v2_perl-Test-Base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Base-0.89-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Base}"
SRC_URI[x86_64_v2_perl-Test-Base.sha256sum] = "16a33327b15e10f4b481c8d48610984ab384029718ada258b8be4e130aa6c3e7"

URI_x86_64_v2_perl-Test-Base-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Base-tests-0.89-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Base-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Base-tests}"
SRC_URI[x86_64_v2_perl-Test-Base-tests.sha256sum] = "06d1e0d6965e1a22bcb11805d12a790baccd82945eb49637d013337dae0191a2"

URI_aarch64_perl-Test-Base = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Base-0.89-21.el10_0.noarch.rpm;name=aarch64_perl-Test-Base;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Base}"
SRC_URI[aarch64_perl-Test-Base.sha256sum] = "a9dc2e5e992e5427097f13a8f37c1a17e6e59a58a5dae4577d6f7dd7bec528cf"

URI_aarch64_perl-Test-Base-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Base-tests-0.89-21.el10_0.noarch.rpm;name=aarch64_perl-Test-Base-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Base-tests}"
SRC_URI[aarch64_perl-Test-Base-tests.sha256sum] = "64f2c198b80cd1c65402f4c5de9ca8a4118bc3376500cf695931ca4bc7353a2f"

RDEPENDS:perl-Test-Base = " \
 perl-Algorithm-Diff \
 perl-Carp \
 perl-Data-Dumper \
 perl-File-Path \
 perl-Filter \
 perl-MIME-Base64 \
 perl-Scalar-List-Utils \
 perl-Spiffy \
 perl-Test-Deep \
 perl-Test-Simple \
 perl-Text-Diff \
 perl-YAML \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:perl-Test-Base-tests = " \
 bash \
 perl-File-Path \
 perl-Test-Base \
 perl-Test-Deep \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-YAML \
 perl-base \
 perl-lib \
 perl-libs \
 virtual/coreutils \
 "
