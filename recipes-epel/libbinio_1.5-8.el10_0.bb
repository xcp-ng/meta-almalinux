# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libbinio"
PV = "1.5"
PR = "8.el10_0"
PACKAGES = " \
 libbinio \
 libbinio-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libbinio-1.5-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "af161ab2bc95600e9d64a94bd601e33daee69649988040fc9ae93e0591ccbaae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbinio-1.5-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbinio;unpack=0"
SRC_URI[x86_64_v2_libbinio.sha256sum] = "04457038d8285442abee47d8079c11fbe72ffec9245f72271c98079ce116103b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbinio-devel-1.5-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbinio-devel;unpack=0"
SRC_URI[x86_64_v2_libbinio-devel.sha256sum] = "eb31a875bce8f84118f6a8217d5c70b3f68b8b02acc70c28cfe1c55bca47be6a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libbinio-1.5-8.el10_0.aarch64.rpm;name=aarch64_libbinio;unpack=0"
SRC_URI[aarch64_libbinio.sha256sum] = "fd12b04b111b78d0fbf4a48116c163472424c6a07cc3763c2447a0b04d27b6e1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libbinio-devel-1.5-8.el10_0.aarch64.rpm;name=aarch64_libbinio-devel;unpack=0"
SRC_URI[aarch64_libbinio-devel.sha256sum] = "b963e2fc033d9a6c30484b50796abf391e85e8a6f5e894a19eabc596921a2192"

RDEPENDS:libbinio = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libbinio-devel = " \
 libbinio \
 pkgconf-pkg-config \
 "
