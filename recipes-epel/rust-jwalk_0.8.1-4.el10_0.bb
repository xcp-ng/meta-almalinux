# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jwalk"
PV = "0.8.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-jwalk+default-devel \
 rust-jwalk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jwalk-0.8.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "321e83ec9d14e26700c68b8585a5742b9fe539e5766e752cc950899784412524"

URI_x86_64_v2_rust-jwalk+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jwalk+default-devel-0.8.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jwalk+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jwalk+default-devel}"
SRC_URI[x86_64_v2_rust-jwalk+default-devel.sha256sum] = "c32721c340698f779791576cb22726b56b5df90083e7914ea195d2f7194a149a"

URI_x86_64_v2_rust-jwalk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jwalk-devel-0.8.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jwalk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jwalk-devel}"
SRC_URI[x86_64_v2_rust-jwalk-devel.sha256sum] = "510aedfe2a72c0402781a537d7e3ea043da054a27448c5d618ce50b5c77afef3"

URI_aarch64_rust-jwalk+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jwalk+default-devel-0.8.1-4.el10_0.noarch.rpm;name=aarch64_rust-jwalk+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jwalk+default-devel}"
SRC_URI[aarch64_rust-jwalk+default-devel.sha256sum] = "67ba5f39bc720f93ae072661d05d87c6c6a0bfa51f7dda0c24581b26298bd8ca"

URI_aarch64_rust-jwalk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jwalk-devel-0.8.1-4.el10_0.noarch.rpm;name=aarch64_rust-jwalk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jwalk-devel}"
SRC_URI[aarch64_rust-jwalk-devel.sha256sum] = "fbceb13a0c26b9bf43c2235253302ee84d2078c3f9271c7ad6a97bb24acccd62"

RDEPENDS:rust-jwalk+default-devel = " \
 cargo \
 rust-jwalk-devel \
 "
RDEPENDS:rust-jwalk-devel = " \
 cargo \
 rust-crossbeam+default-devel \
 rust-rayon+default-devel \
 "
