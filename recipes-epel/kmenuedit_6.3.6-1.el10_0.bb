# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmenuedit"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 kmenuedit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmenuedit-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8c7dd1b0e911a6563ac67a5235486d0caf56f3aa74fa7c2b83c8ccd7319008d"

URI_x86_64_v2_kmenuedit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmenuedit-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmenuedit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmenuedit}"
SRC_URI[x86_64_v2_kmenuedit.sha256sum] = "c00328b933dd6174871e53ade04f6f3d07cdc2ab7d73b0f4a50f4902ce1f7c21"

URI_aarch64_kmenuedit = "${EPEL_MIRROR}/aarch64/Packages/k/kmenuedit-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kmenuedit;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmenuedit}"
SRC_URI[aarch64_kmenuedit.sha256sum] = "d10f728a327b2ea3ea7830bab4c7873c5044911249dd9d4d1f5cfb52a170c89a"

RDEPENDS:kmenuedit = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
