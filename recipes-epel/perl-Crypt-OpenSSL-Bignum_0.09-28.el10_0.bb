# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-OpenSSL-Bignum"
PV = "0.09"
PR = "28.el10_0"
PACKAGES = " \
 perl-Crypt-OpenSSL-Bignum \
 perl-Crypt-OpenSSL-Bignum-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-OpenSSL-Bignum-0.09-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e47f0805da11c861d08916442eabcd4f0b3f34ef60fbcc7a4f03bbfbdd60f62"

URI_x86_64_v2_perl-Crypt-OpenSSL-Bignum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-Bignum-0.09-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-Bignum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-Bignum}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-Bignum.sha256sum] = "190f29094152e2593431604372131301260034d831977dd3b68dc71e69415736"

URI_x86_64_v2_perl-Crypt-OpenSSL-Bignum-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-Bignum-tests-0.09-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-Bignum-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-Bignum-tests}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-Bignum-tests.sha256sum] = "cbaddd02fb0d21dc9bad63bc71c7d913c7bbc5b61bcfd876f06b139ae8a47b94"

URI_aarch64_perl-Crypt-OpenSSL-Bignum = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-Bignum-0.09-28.el10_0.aarch64.rpm;name=aarch64_perl-Crypt-OpenSSL-Bignum;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-Bignum}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-Bignum.sha256sum] = "70ff078dc7a6771073f748db765f6ffff596d1c1bc88fa5a40162b17c2b64df3"

URI_aarch64_perl-Crypt-OpenSSL-Bignum-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-Bignum-tests-0.09-28.el10_0.noarch.rpm;name=aarch64_perl-Crypt-OpenSSL-Bignum-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-Bignum-tests}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-Bignum-tests.sha256sum] = "d380a3b52c4bb899a1ec8a074c30d11a0fcac9b6978844b0b6b55718a2d6ba26"

RDEPENDS:perl-Crypt-OpenSSL-Bignum = " \
 glibc \
 openssl-libs \
 perl-Carp \
 perl-Crypt-OpenSSL-Bignum \
 perl-DynaLoader \
 perl-base \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Crypt-OpenSSL-Bignum-tests = " \
 bash \
 perl-Crypt-OpenSSL-Bignum \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 "
