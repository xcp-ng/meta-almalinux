# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "x2gokdriveclient"
PV = "0.0.0.1"
PR = "2.el10_1"
PACKAGES = " \
 x2gokdriveclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/x2gokdriveclient-0.0.0.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe8c41d33c4bfcc4ecd2907c9d7e4734317758af8d838a50cd17310fbd5eddcc"

URI_x86_64_v2_x2gokdriveclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/x2gokdriveclient-0.0.0.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_x2gokdriveclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_x2gokdriveclient}"
SRC_URI[x86_64_v2_x2gokdriveclient.sha256sum] = "ab890aff16169a087d0d4abcd58fef6e8b0e10b7a96ae86419e56e42769163eb"

URI_aarch64_x2gokdriveclient = "${EPEL_MIRROR}/aarch64/Packages/x/x2gokdriveclient-0.0.0.1-2.el10_1.aarch64.rpm;name=aarch64_x2gokdriveclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_x2gokdriveclient}"
SRC_URI[aarch64_x2gokdriveclient.sha256sum] = "12b5ef6f4be32069ef5febb7c5192bc2cdb96a65d37315080315c4486c464ae4"

RDEPENDS:x2gokdriveclient = " \
 glibc \
 libgcc \
 libstdc++ \
 libxcb \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtx11extras \
 zlib-ng-compat \
 "
