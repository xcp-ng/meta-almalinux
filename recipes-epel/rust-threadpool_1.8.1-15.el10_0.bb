# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-threadpool"
PV = "1.8.1"
PR = "15.el10_0"
PACKAGES = " \
 rust-threadpool+default-devel \
 rust-threadpool-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-threadpool-1.8.1-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a08f45225f058de96b86d233a88cc68b1491cd70031f2768fea8f72fa58891c"

URI_x86_64_v2_rust-threadpool+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-threadpool+default-devel-1.8.1-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-threadpool+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-threadpool+default-devel}"
SRC_URI[x86_64_v2_rust-threadpool+default-devel.sha256sum] = "6e20c98cf097d6de3c35c82d2631aa2b26f6d5b22faf3fbdbd8a554e49f17bc4"

URI_x86_64_v2_rust-threadpool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-threadpool-devel-1.8.1-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-threadpool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-threadpool-devel}"
SRC_URI[x86_64_v2_rust-threadpool-devel.sha256sum] = "b474d811ed6352eba13af41de2e77faf2706c8b837683258f0a13e33185d3378"

URI_aarch64_rust-threadpool+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-threadpool+default-devel-1.8.1-15.el10_0.noarch.rpm;name=aarch64_rust-threadpool+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-threadpool+default-devel}"
SRC_URI[aarch64_rust-threadpool+default-devel.sha256sum] = "0cf612dc84d1e0265883e14325dd13961e535caa5336eace5c35cb5b05db7166"

URI_aarch64_rust-threadpool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-threadpool-devel-1.8.1-15.el10_0.noarch.rpm;name=aarch64_rust-threadpool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-threadpool-devel}"
SRC_URI[aarch64_rust-threadpool-devel.sha256sum] = "32373835b58c0aab1b51fe5c7e4c607e9e640d6619af3c87b49b3ffa0262cdf8"

RDEPENDS:rust-threadpool+default-devel = " \
 cargo \
 rust-threadpool-devel \
 "
RDEPENDS:rust-threadpool-devel = " \
 cargo \
 rust-num_cpus+default-devel \
 "
