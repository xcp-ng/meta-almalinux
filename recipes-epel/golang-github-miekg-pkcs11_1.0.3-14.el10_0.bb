# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-miekg-pkcs11"
PV = "1.0.3"
PR = "14.el10_0"
PACKAGES = " \
 golang-github-miekg-pkcs11-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-miekg-pkcs11-1.0.3-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "855ea75a3b4b66dfb47c7a68091088b7e05f9d86e0f7e79855005632b3a2bfd1"

URI_x86_64_v2_golang-github-miekg-pkcs11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-miekg-pkcs11-devel-1.0.3-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-miekg-pkcs11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-miekg-pkcs11-devel}"
SRC_URI[x86_64_v2_golang-github-miekg-pkcs11-devel.sha256sum] = "e86d6895816a87d08e9dc568dc9142d3ba3e815bbc74e120a40b484d9ac23f37"

URI_aarch64_golang-github-miekg-pkcs11-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-miekg-pkcs11-devel-1.0.3-14.el10_0.noarch.rpm;name=aarch64_golang-github-miekg-pkcs11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-miekg-pkcs11-devel}"
SRC_URI[aarch64_golang-github-miekg-pkcs11-devel.sha256sum] = "44e9eea4f6780b378970e3200693953a9794b335a11a467394b3c0c749734a54"

RDEPENDS:golang-github-miekg-pkcs11-devel = " \
 go-filesystem \
 libtool-ltdl-devel \
 softhsm \
 "
