# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Email-MIME-ContentType"
PV = "1.028"
PR = "1.el10_0"
PACKAGES = " \
 perl-Email-MIME-ContentType \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Email-MIME-ContentType-1.028-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9bb1829a44cdb4ad51793d0e19c9b8cef628b167c64e713ba1c4013604235c60"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Email-MIME-ContentType-1.028-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Email-MIME-ContentType;unpack=0"
SRC_URI[x86_64_v2_perl-Email-MIME-ContentType.sha256sum] = "37908d4079fb98d0a8713b02cecd5a39fb3b0239ba50a90061b3867f9d0826c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Email-MIME-ContentType-1.028-1.el10_0.noarch.rpm;name=aarch64_perl-Email-MIME-ContentType;unpack=0"
SRC_URI[aarch64_perl-Email-MIME-ContentType.sha256sum] = "566c24cdc694f82cdcf4ea71e424841d9e56befaa6a8e0cdadbe0455c75d6d12"

RDEPENDS:perl-Email-MIME-ContentType = " \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-Text-Unidecode \
 perl-libs \
 "
