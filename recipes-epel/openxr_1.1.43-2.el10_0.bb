# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openxr"
PV = "1.1.43"
PR = "2.el10_0"
PACKAGES = " \
 openxr \
 openxr-devel \
 openxr-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openxr-1.1.43-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "962eed1d41d29dbc5a88af1319e4f3abe78db8e7edba749e035a412023cfb8c3"

URI_x86_64_v2_openxr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openxr-1.1.43-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openxr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openxr}"
SRC_URI[x86_64_v2_openxr.sha256sum] = "037d26959d196bf4e9e119e139c64b416aba67d3e1b9eb51a359a3c73c7a2c36"

URI_x86_64_v2_openxr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openxr-devel-1.1.43-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openxr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openxr-devel}"
SRC_URI[x86_64_v2_openxr-devel.sha256sum] = "dd7ac9d901e0793c414852c11fff57999ab5316e59aae273b82f516f08d2b89e"

URI_x86_64_v2_openxr-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openxr-libs-1.1.43-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openxr-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openxr-libs}"
SRC_URI[x86_64_v2_openxr-libs.sha256sum] = "62e030d8a32fb87a89ef9e27c7627e9a0357cfd99c9de9d214ca86760483dfdd"

URI_aarch64_openxr = "${EPEL_MIRROR}/aarch64/Packages/o/openxr-1.1.43-2.el10_0.aarch64.rpm;name=aarch64_openxr;unpack=0"
SRC_URI:append = " ${URI_aarch64_openxr}"
SRC_URI[aarch64_openxr.sha256sum] = "f56f738c0b9b7d403c62c39bc7c9b1ed5c8c4c73e8050bd2f21073911ed6f7cd"

URI_aarch64_openxr-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openxr-devel-1.1.43-2.el10_0.aarch64.rpm;name=aarch64_openxr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openxr-devel}"
SRC_URI[aarch64_openxr-devel.sha256sum] = "13be83096450cbc3bb000158b5e4cee8eeefb06fd13603f92135ce0b189ff90c"

URI_aarch64_openxr-libs = "${EPEL_MIRROR}/aarch64/Packages/o/openxr-libs-1.1.43-2.el10_0.aarch64.rpm;name=aarch64_openxr-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_openxr-libs}"
SRC_URI[aarch64_openxr-libs.sha256sum] = "084c165111546209e397a41da59a12914e13330eee2bd3c3fc58ee1b4b48d248"

RDEPENDS:openxr = " \
 glibc \
 libX11 \
 libXxf86vm \
 libgcc \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 openxr-libs \
 vulkan-loader \
 "
RDEPENDS:openxr-devel = " \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 openxr-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openxr-libs = " \
 glibc \
 jsoncpp \
 libgcc \
 libstdc++ \
 "
