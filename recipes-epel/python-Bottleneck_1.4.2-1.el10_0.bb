# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-Bottleneck"
PV = "1.4.2"
PR = "1.el10_0"
PACKAGES = " \
 python-Bottleneck-doc \
 python3-Bottleneck \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-Bottleneck-1.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91b216e8cd6530bbaead3165f3f57bb732f2bf779c84b1c84e7b645c7d644720"

URI_x86_64_v2_python-Bottleneck-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-Bottleneck-doc-1.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-Bottleneck-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-Bottleneck-doc}"
SRC_URI[x86_64_v2_python-Bottleneck-doc.sha256sum] = "2c2a0efabb7e8fe9894fb8183f3e82919c323ce68c49035b6caf4b017a2b4cab"

URI_x86_64_v2_python3-Bottleneck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-Bottleneck-1.4.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-Bottleneck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-Bottleneck}"
SRC_URI[x86_64_v2_python3-Bottleneck.sha256sum] = "57519d94dae267cbbca0efcb7032e4b5e2bd88eecc978d601820ac0a9c3c80c1"

URI_aarch64_python-Bottleneck-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-Bottleneck-doc-1.4.2-1.el10_0.noarch.rpm;name=aarch64_python-Bottleneck-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-Bottleneck-doc}"
SRC_URI[aarch64_python-Bottleneck-doc.sha256sum] = "1001474af549a22446c51057e4b9b6d133ea177312bc89728a45bdf63e598e9c"

URI_aarch64_python3-Bottleneck = "${EPEL_MIRROR}/aarch64/Packages/p/python3-Bottleneck-1.4.2-1.el10_0.aarch64.rpm;name=aarch64_python3-Bottleneck;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-Bottleneck}"
SRC_URI[aarch64_python3-Bottleneck.sha256sum] = "7eaad784c1129d61fdb47fcdb80545c6cdd86c321c915526a92da03d6cf85c3b"

RDEPENDS:python-Bottleneck-doc = " \
 "
RDEPENDS:python3-Bottleneck = " \
 glibc \
 python3 \
 python3-numpy \
 python3-scipy \
 "
