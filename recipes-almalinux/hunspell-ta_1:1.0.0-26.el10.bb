# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ta"
PE = "1"
PV = "1.0.0"
PR = "26.el10"
PACKAGES = " \
 hunspell-ta \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ta-1.0.0-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92f9b35b9b836a49b775097ee676c7556ef017c779134d54d4f185d903387932"

URI_x86_64_v2_hunspell-ta = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ta-1.0.0-26.el10.noarch.rpm;name=x86_64_v2_hunspell-ta;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-ta}"
SRC_URI[x86_64_v2_hunspell-ta.sha256sum] = "1df6ceec6a22db87d16e7f1a0b5245f1c86011297dde47228a4697d556dc20a4"

URI_aarch64_hunspell-ta = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ta-1.0.0-26.el10.noarch.rpm;name=aarch64_hunspell-ta;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-ta}"
SRC_URI[aarch64_hunspell-ta.sha256sum] = "1df6ceec6a22db87d16e7f1a0b5245f1c86011297dde47228a4697d556dc20a4"

RDEPENDS:hunspell-ta = " \
 hunspell-filesystem \
 "
