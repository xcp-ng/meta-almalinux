# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-git2"
PV = "0.21.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-git2+cred-devel \
 rust-git2+default-devel \
 rust-git2+https-devel \
 rust-git2+openssl-probe-devel \
 rust-git2+openssl-sys-devel \
 rust-git2+ssh-devel \
 rust-git2+unstable-devel \
 rust-git2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-git2-0.21.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e23cd67400900a13d22da6a012f7427a1a89083378da6297ab90dd8a0a06c0bb"

URI_x86_64_v2_rust-git2+cred-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+cred-devel-0.21.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+cred-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+cred-devel}"
SRC_URI[x86_64_v2_rust-git2+cred-devel.sha256sum] = "cc5736318bd3af22f820341d9b2608677b8d1e74b246c7605490c1082c8d1b84"

URI_x86_64_v2_rust-git2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+default-devel-0.21.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+default-devel}"
SRC_URI[x86_64_v2_rust-git2+default-devel.sha256sum] = "f7671f568ca4003c2d7746cf21acdd318adc81ef3d6d459224ac28417f04b552"

URI_x86_64_v2_rust-git2+https-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+https-devel-0.21.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+https-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+https-devel}"
SRC_URI[x86_64_v2_rust-git2+https-devel.sha256sum] = "71b3256ccd81b180758fa171c5c637ec7856b2c9e5ce0c1d72f804f90230b064"

URI_x86_64_v2_rust-git2+openssl-probe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+openssl-probe-devel-0.21.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+openssl-probe-devel}"
SRC_URI[x86_64_v2_rust-git2+openssl-probe-devel.sha256sum] = "1aa03a7981158a7bb305b8be9af39ebdfd8bdea69e62df4b9bdf867e1e0c80bb"

URI_x86_64_v2_rust-git2+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+openssl-sys-devel-0.21.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-git2+openssl-sys-devel.sha256sum] = "a4e043150ad2abff8173d072c6026e4a69991179fbcebbc122cae93198a380d4"

URI_x86_64_v2_rust-git2+ssh-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+ssh-devel-0.21.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+ssh-devel}"
SRC_URI[x86_64_v2_rust-git2+ssh-devel.sha256sum] = "32975960c5e046d94f13abc10673a33958487b7f4e17833691c3d9db4019a9f5"

URI_x86_64_v2_rust-git2+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+unstable-devel-0.21.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+unstable-devel}"
SRC_URI[x86_64_v2_rust-git2+unstable-devel.sha256sum] = "cc5cc59530d7518cff94adfe0e859b764ab920b37b8ed14044a09684dfa6c8c8"

URI_x86_64_v2_rust-git2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2-devel-0.21.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2-devel}"
SRC_URI[x86_64_v2_rust-git2-devel.sha256sum] = "166c03ae805375ff8e273105115e1c0d2c7c14489b41ec3b682c28ecbee44946"

URI_aarch64_rust-git2+cred-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+cred-devel-0.21.0-1.el10_3.noarch.rpm;name=aarch64_rust-git2+cred-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+cred-devel}"
SRC_URI[aarch64_rust-git2+cred-devel.sha256sum] = "f60472faf91e52f088bdbf65b4d14798d69079f95f7703b1c6a0fe40694ff8fa"

URI_aarch64_rust-git2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+default-devel-0.21.0-1.el10_3.noarch.rpm;name=aarch64_rust-git2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+default-devel}"
SRC_URI[aarch64_rust-git2+default-devel.sha256sum] = "d26f6c3359c7ec3770aa9e11f81b803124dfadb031ef05b5ce25d7f257a43468"

URI_aarch64_rust-git2+https-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+https-devel-0.21.0-1.el10_3.noarch.rpm;name=aarch64_rust-git2+https-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+https-devel}"
SRC_URI[aarch64_rust-git2+https-devel.sha256sum] = "76da5c44343cd231221796fc48e26fe4771d80e464d65e679b5c6b5ec8768f67"

URI_aarch64_rust-git2+openssl-probe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+openssl-probe-devel-0.21.0-1.el10_3.noarch.rpm;name=aarch64_rust-git2+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+openssl-probe-devel}"
SRC_URI[aarch64_rust-git2+openssl-probe-devel.sha256sum] = "5b5aa64584056cf35c62b3a9767023d00a76a5ceeda20e331ee3d75d801d2705"

URI_aarch64_rust-git2+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+openssl-sys-devel-0.21.0-1.el10_3.noarch.rpm;name=aarch64_rust-git2+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+openssl-sys-devel}"
SRC_URI[aarch64_rust-git2+openssl-sys-devel.sha256sum] = "b6a74c010f0d352f6d9a7078e9c19d81a9733d90d48b346b729a442f398d1935"

URI_aarch64_rust-git2+ssh-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+ssh-devel-0.21.0-1.el10_3.noarch.rpm;name=aarch64_rust-git2+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+ssh-devel}"
SRC_URI[aarch64_rust-git2+ssh-devel.sha256sum] = "415fc853d6b23dc5590487bd5912ddd176f5e5d7366079d309cfeb7cb3a5a706"

URI_aarch64_rust-git2+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+unstable-devel-0.21.0-1.el10_3.noarch.rpm;name=aarch64_rust-git2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+unstable-devel}"
SRC_URI[aarch64_rust-git2+unstable-devel.sha256sum] = "4b738aff82c8d3870e8259d3867e81822dc2a4e7a068a12baae49338b858e973"

URI_aarch64_rust-git2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2-devel-0.21.0-1.el10_3.noarch.rpm;name=aarch64_rust-git2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2-devel}"
SRC_URI[aarch64_rust-git2-devel.sha256sum] = "cc8aea3d153a3befc25f8c6e3291bdfc7d3d402f6b2b8e293cb37aaaabba3f34"

RDEPENDS:rust-git2+cred-devel = " \
 cargo \
 rust-git2-devel \
 rust-url+default-devel \
 "
RDEPENDS:rust-git2+default-devel = " \
 cargo \
 rust-git2-devel \
 "
RDEPENDS:rust-git2+https-devel = " \
 cargo \
 rust-git2+cred-devel \
 rust-git2+openssl-probe-devel \
 rust-git2+openssl-sys-devel \
 rust-git2-devel \
 rust-libgit2-sys+https-devel \
 "
RDEPENDS:rust-git2+openssl-probe-devel = " \
 cargo \
 rust-git2-devel \
 rust-openssl-probe0.1+default-devel \
 "
RDEPENDS:rust-git2+openssl-sys-devel = " \
 cargo \
 rust-git2-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-git2+ssh-devel = " \
 cargo \
 rust-git2+cred-devel \
 rust-git2-devel \
 rust-libgit2-sys+ssh-devel \
 "
RDEPENDS:rust-git2+unstable-devel = " \
 cargo \
 rust-git2-devel \
 "
RDEPENDS:rust-git2-devel = " \
 bash \
 cargo \
 rust-bitflags+default-devel \
 rust-libc+default-devel \
 rust-libgit2-sys+default-devel \
 rust-log+default-devel \
 "
