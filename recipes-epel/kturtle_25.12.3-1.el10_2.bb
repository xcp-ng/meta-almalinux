# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kturtle"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kturtle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kturtle-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "112095bbf6d29315ff4bcac10a55c489b7889096de625a1b5f64b163ff865705"

URI_x86_64_v2_kturtle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kturtle-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kturtle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kturtle}"
SRC_URI[x86_64_v2_kturtle.sha256sum] = "30b0cfd6e8623b9832b721857ee651b568b87dff150f8cbd79e14cc8e9078a7e"

URI_aarch64_kturtle = "${EPEL_MIRROR}/aarch64/Packages/k/kturtle-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kturtle;unpack=0"
SRC_URI:append = " ${URI_aarch64_kturtle}"
SRC_URI[aarch64_kturtle.sha256sum] = "93addb24e3e803c2276e6304f5a49c2e575f30038d963b1afe96772b3e36eeea"

RDEPENDS:kturtle = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-knewstuff \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
