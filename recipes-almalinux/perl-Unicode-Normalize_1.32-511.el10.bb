# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Unicode-Normalize"
PV = "1.32"
PR = "511.el10"
PACKAGES = " \
 perl-Unicode-Normalize \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Unicode-Normalize-1.32-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f47b4833e214aab058902c89d75ba20ab086f16eeefd08e1b72291a7996ba600"

URI_x86_64_v2_perl-Unicode-Normalize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Unicode-Normalize-1.32-511.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Unicode-Normalize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Unicode-Normalize}"
SRC_URI[x86_64_v2_perl-Unicode-Normalize.sha256sum] = "cab6a60b1d3d541f5f9390d37ca63e459078c5726e25d42fcd44cbb6885e5e06"

URI_aarch64_perl-Unicode-Normalize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Unicode-Normalize-1.32-511.el10.aarch64.rpm;name=aarch64_perl-Unicode-Normalize;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Unicode-Normalize}"
SRC_URI[aarch64_perl-Unicode-Normalize.sha256sum] = "2335a7a8e232b0564c39e74cef30f0341d07bc30c44357899324128c58a81e87"

RDEPENDS:perl-Unicode-Normalize = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
