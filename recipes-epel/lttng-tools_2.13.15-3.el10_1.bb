# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lttng-tools"
PV = "2.13.15"
PR = "3.el10_1"
PACKAGES = " \
 lttng-tools \
 lttng-tools-devel \
 python3-lttng \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lttng-tools-2.13.15-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "218eb0e960293ed37de209959ce81f0ce952ae9d3b986819702a7f97484a46c7"

URI_x86_64_v2_lttng-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lttng-tools-2.13.15-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lttng-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lttng-tools}"
SRC_URI[x86_64_v2_lttng-tools.sha256sum] = "d5a4370049f6278b27bffb10389696dfec89df8b0e106ca4c7f63d12624fa895"

URI_x86_64_v2_lttng-tools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lttng-tools-devel-2.13.15-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lttng-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lttng-tools-devel}"
SRC_URI[x86_64_v2_lttng-tools-devel.sha256sum] = "0d1f170f2900eb888ac079f09c0244b3400941d05f164e3fd86cbbf4a9a3f24e"

URI_x86_64_v2_python3-lttng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lttng-2.13.15-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lttng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lttng}"
SRC_URI[x86_64_v2_python3-lttng.sha256sum] = "d0cb0ab09e43d3cd2b24947abb420e98c1eced23319705afa1d196b6ecab7f81"

URI_aarch64_lttng-tools = "${EPEL_MIRROR}/aarch64/Packages/l/lttng-tools-2.13.15-3.el10_1.aarch64.rpm;name=aarch64_lttng-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_lttng-tools}"
SRC_URI[aarch64_lttng-tools.sha256sum] = "d80f7da8650923727fb5874b3891f1fb45c9c865db67fe00e369a7ed78905290"

URI_aarch64_lttng-tools-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lttng-tools-devel-2.13.15-3.el10_1.aarch64.rpm;name=aarch64_lttng-tools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lttng-tools-devel}"
SRC_URI[aarch64_lttng-tools-devel.sha256sum] = "6cb268585c800322e9920d1bd985528931a56510a9cfd15ab37956b9a40b352a"

URI_aarch64_python3-lttng = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lttng-2.13.15-3.el10_1.aarch64.rpm;name=aarch64_python3-lttng;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lttng}"
SRC_URI[aarch64_python3-lttng.sha256sum] = "cb84be5979546d085179d3b1b6568929caa0d492114c7b311e59591cdb02b2a3"

RDEPENDS:lttng-tools = " \
 bash \
 glibc \
 libgcc \
 libxml2 \
 lttng-ust \
 popt \
 systemd \
 userspace-rcu \
 "
RDEPENDS:lttng-tools-devel = " \
 lttng-tools \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-lttng = " \
 glibc \
 libxml2 \
 lttng-tools \
 python3 \
 userspace-rcu \
 "
