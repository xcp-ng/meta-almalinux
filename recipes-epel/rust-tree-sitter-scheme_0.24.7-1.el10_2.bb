# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-scheme"
PV = "0.24.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-scheme+default-devel \
 rust-tree-sitter-scheme-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-scheme-0.24.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "636bf96d96e3a63a1f78396a715a9701d7d53ea6e05beeefa97c2fee6fc862ea"

URI_x86_64_v2_rust-tree-sitter-scheme+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-scheme+default-devel-0.24.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-scheme+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-scheme+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-scheme+default-devel.sha256sum] = "bd332edd3f846b43ce7ef8fc51ff1a4dd154bb916ced372d2ebadf2e6bd1286a"

URI_x86_64_v2_rust-tree-sitter-scheme-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-scheme-devel-0.24.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-scheme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-scheme-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-scheme-devel.sha256sum] = "f230f7e732eea284e64329e89187e2fbe16192021413c92d50353117bc07ed85"

URI_aarch64_rust-tree-sitter-scheme+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-scheme+default-devel-0.24.7-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-scheme+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-scheme+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-scheme+default-devel.sha256sum] = "d95ae259d4607830e7217760c40c23d896163e9a26abbc64965fb77143d49e29"

URI_aarch64_rust-tree-sitter-scheme-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-scheme-devel-0.24.7-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-scheme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-scheme-devel}"
SRC_URI[aarch64_rust-tree-sitter-scheme-devel.sha256sum] = "9e8fecb6b29a57b54756d0d1bef06802123c2274e2ee8c60b0afc2c285bb5800"

RDEPENDS:rust-tree-sitter-scheme+default-devel = " \
 cargo \
 rust-tree-sitter-scheme-devel \
 "
RDEPENDS:rust-tree-sitter-scheme-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
