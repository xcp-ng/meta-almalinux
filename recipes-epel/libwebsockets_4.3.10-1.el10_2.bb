# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libwebsockets"
PV = "4.3.10"
PR = "1.el10_2"
PACKAGES = " \
 libwebsockets \
 libwebsockets-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libwebsockets-4.3.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b29b032211419236d148a5cb309bc64dc7b012976cfa2e3bf76dbd3ebda5b1ff"

URI_x86_64_v2_libwebsockets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwebsockets-4.3.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwebsockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwebsockets}"
SRC_URI[x86_64_v2_libwebsockets.sha256sum] = "a5dcb45239cce0d79b8ba4fc826263627524fbb8a9888e83c5c5c335f2ee9a04"

URI_x86_64_v2_libwebsockets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwebsockets-devel-4.3.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwebsockets-devel}"
SRC_URI[x86_64_v2_libwebsockets-devel.sha256sum] = "d6cedd3f63493d1d7bea21916b888c9960043ef46660f067b2b4e84ea404dfaf"

URI_aarch64_libwebsockets = "${EPEL_MIRROR}/aarch64/Packages/l/libwebsockets-4.3.10-1.el10_2.aarch64.rpm;name=aarch64_libwebsockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwebsockets}"
SRC_URI[aarch64_libwebsockets.sha256sum] = "e448e8befc2e3693339771808ac13edcf0970e1ae97c271c122b29debfd0de50"

URI_aarch64_libwebsockets-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libwebsockets-devel-4.3.10-1.el10_2.aarch64.rpm;name=aarch64_libwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwebsockets-devel}"
SRC_URI[aarch64_libwebsockets-devel.sha256sum] = "797f0d65de46740dcd68afe9482d7c366fd4c0d030e9072a62063c402225ca91"

RDEPENDS:libwebsockets = " \
 glib2 \
 glibc \
 libev \
 libuv \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libwebsockets-devel = " \
 cmake-filesystem \
 libev-devel \
 libuv-devel \
 libwebsockets \
 openssl-devel \
 pkgconf-pkg-config \
 "
