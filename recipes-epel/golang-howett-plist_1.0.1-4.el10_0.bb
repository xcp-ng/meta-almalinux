# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-howett-plist"
PV = "1.0.1"
PR = "4.el10_0"
PACKAGES = " \
 golang-howett-plist-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-howett-plist-1.0.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "19aa23c5c179dbef3701a431e8c6aea1098a7eb3538e127dc42aec628aee90be"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-howett-plist-devel-1.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-howett-plist-devel;unpack=0"
SRC_URI[x86_64_v2_golang-howett-plist-devel.sha256sum] = "96c134b5f5ee1b73626a9f0a5e202d93699819e0eff2990b635e5d2e5311a2c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-howett-plist-devel-1.0.1-4.el10_0.noarch.rpm;name=aarch64_golang-howett-plist-devel;unpack=0"
SRC_URI[aarch64_golang-howett-plist-devel.sha256sum] = "b6bc3e67871fa84195948891b40be108bedd79d982597e73cddd569ffef5f073"

RDEPENDS:golang-howett-plist-devel = " \
 go-filesystem \
 "
