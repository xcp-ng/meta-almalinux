# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-submodule"
PV = "0.20.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-submodule+default-devel \
 rust-gix-submodule-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-submodule-0.20.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b02008e4c2f5f5ec0f4771bdcc22fc6dba6117db8e2636aa23636a6ab75803b0"

URI_x86_64_v2_rust-gix-submodule+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-submodule+default-devel-0.20.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-submodule+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-submodule+default-devel}"
SRC_URI[x86_64_v2_rust-gix-submodule+default-devel.sha256sum] = "5af10b4f9c70f0eac3fcb58b203a747e893f5034f279488847eabed5d565d92c"

URI_x86_64_v2_rust-gix-submodule-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-submodule-devel-0.20.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-submodule-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-submodule-devel}"
SRC_URI[x86_64_v2_rust-gix-submodule-devel.sha256sum] = "3391fad2383998bdbcba72255926014419cadf4f9ec77c0d2111adccab21ff7e"

URI_aarch64_rust-gix-submodule+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-submodule+default-devel-0.20.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-submodule+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-submodule+default-devel}"
SRC_URI[aarch64_rust-gix-submodule+default-devel.sha256sum] = "77dfa6858a879e1370caeb5e2a043572d646bdec4c103eebb59bf1037478935c"

URI_aarch64_rust-gix-submodule-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-submodule-devel-0.20.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-submodule-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-submodule-devel}"
SRC_URI[aarch64_rust-gix-submodule-devel.sha256sum] = "4033da0bff96f65157347a388d3e7711b41e71e05fccac53cf5966d272d61bd8"

RDEPENDS:rust-gix-submodule+default-devel = " \
 cargo \
 rust-gix-submodule-devel \
 "
RDEPENDS:rust-gix-submodule-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-config+default-devel \
 rust-gix-path+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-refspec+default-devel \
 rust-gix-url+default-devel \
 rust-thiserror+default-devel \
 "
