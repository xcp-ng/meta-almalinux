# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gn"
PV = "2395^20260509.78e67afc82fa"
PR = "1.el10_1"
PACKAGES = " \
 gn \
 gn-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gn-2395^20260509.78e67afc82fa-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5182a758afb123bfb06bc387135ca5d4825d09d9a55290ce6dedefa389f1cbbf"

URI_x86_64_v2_gn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gn-2395^20260509.78e67afc82fa-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gn}"
SRC_URI[x86_64_v2_gn.sha256sum] = "511de49db74074d824d23b72f93bcab387f78ba44f761c33081d87af1573605f"

URI_x86_64_v2_gn-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gn-doc-2395^20260509.78e67afc82fa-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gn-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gn-doc}"
SRC_URI[x86_64_v2_gn-doc.sha256sum] = "9595332930af628ba3bffc35b49890f4a948c832d745ef18883bfb687a07bddd"

URI_aarch64_gn = "${EPEL_MIRROR}/aarch64/Packages/g/gn-2395^20260509.78e67afc82fa-1.el10_1.aarch64.rpm;name=aarch64_gn;unpack=0"
SRC_URI:append = " ${URI_aarch64_gn}"
SRC_URI[aarch64_gn.sha256sum] = "04df9047e1b50323f6810df8a8b6358983e534982e0f8a03faaac66bcd6502a0"

URI_aarch64_gn-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gn-doc-2395^20260509.78e67afc82fa-1.el10_1.noarch.rpm;name=aarch64_gn-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gn-doc}"
SRC_URI[aarch64_gn-doc.sha256sum] = "b74a11f30a60d5143a1ba4a6ef59b43a636cf4f5f34c797556eeab6e8aaabb6f"

RDEPENDS:gn = " \
 emacs-filesystem \
 glibc \
 libstdc++ \
 python3 \
 vim-filesystem \
 "
RDEPENDS:gn-doc = " \
 "
