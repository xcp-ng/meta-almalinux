# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snapbox"
PV = "0.6.21"
PR = "1.el10_0"
PACKAGES = " \
 rust-snapbox+cmd-devel \
 rust-snapbox+color-auto-devel \
 rust-snapbox+color-devel \
 rust-snapbox+debug-devel \
 rust-snapbox+default-devel \
 rust-snapbox+detect-encoding-devel \
 rust-snapbox+diff-devel \
 rust-snapbox+dir-devel \
 rust-snapbox+document-features-devel \
 rust-snapbox+examples-devel \
 rust-snapbox+json-devel \
 rust-snapbox+path-devel \
 rust-snapbox+regex-devel \
 rust-snapbox+structured-data-devel \
 rust-snapbox+term-svg-devel \
 rust-snapbox-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snapbox-0.6.21-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ab667d5f0770694d67bc4fc99316b8cfb113d1f87223a1a29f4fba962237727"

URI_x86_64_v2_rust-snapbox+cmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+cmd-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+cmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+cmd-devel}"
SRC_URI[x86_64_v2_rust-snapbox+cmd-devel.sha256sum] = "c878dc8aaf1d800d540221c1a2466ccdb24350559d2a1212028e7fba17cdf805"

URI_x86_64_v2_rust-snapbox+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+color-auto-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+color-auto-devel}"
SRC_URI[x86_64_v2_rust-snapbox+color-auto-devel.sha256sum] = "69145609d12a1615933912007524d42cca8fa8af263d2a771a2e315c3f3d99ce"

URI_x86_64_v2_rust-snapbox+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+color-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+color-devel}"
SRC_URI[x86_64_v2_rust-snapbox+color-devel.sha256sum] = "94932849ff5637d2841f01255ecd730a95e55cc39bcf2cfc7aae10e70e674838"

URI_x86_64_v2_rust-snapbox+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+debug-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+debug-devel}"
SRC_URI[x86_64_v2_rust-snapbox+debug-devel.sha256sum] = "2a140b2473f1429f35f107583e635aeb8bf60bbe2b9d37b803961b344113ef90"

URI_x86_64_v2_rust-snapbox+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+default-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+default-devel}"
SRC_URI[x86_64_v2_rust-snapbox+default-devel.sha256sum] = "a32fa03a4eff44787027ea77b50348e031b6fc60b6b6cbc203c0e3afbc2da951"

URI_x86_64_v2_rust-snapbox+detect-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+detect-encoding-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+detect-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+detect-encoding-devel}"
SRC_URI[x86_64_v2_rust-snapbox+detect-encoding-devel.sha256sum] = "459e9568091d0fd9c22d879e2f477b1a4eae5ea295a6737f5a02ed46a6160c50"

URI_x86_64_v2_rust-snapbox+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+diff-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+diff-devel}"
SRC_URI[x86_64_v2_rust-snapbox+diff-devel.sha256sum] = "ff7298104a957a6415c8598054d5fa4e893626bf983223ad282c1402648fce15"

URI_x86_64_v2_rust-snapbox+dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+dir-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+dir-devel}"
SRC_URI[x86_64_v2_rust-snapbox+dir-devel.sha256sum] = "1f6972db55cf1ef19d9ad9179eea79ebac7db9aa43284bc6d5f5fe0585d8883a"

URI_x86_64_v2_rust-snapbox+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+document-features-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+document-features-devel}"
SRC_URI[x86_64_v2_rust-snapbox+document-features-devel.sha256sum] = "d63c2d912dbf857847b6339fc1ea86eed8a22e7fbd20938344007bd39fe1fe9a"

URI_x86_64_v2_rust-snapbox+examples-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+examples-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+examples-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+examples-devel}"
SRC_URI[x86_64_v2_rust-snapbox+examples-devel.sha256sum] = "78be77cb85ef5f29817235ff980a90a92f3d994d334380895f3acd1569168461"

URI_x86_64_v2_rust-snapbox+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+json-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+json-devel}"
SRC_URI[x86_64_v2_rust-snapbox+json-devel.sha256sum] = "fb8b09898842b8982abe018521191df5dccd2b02b1e2e7b4da4be492c73e2d6c"

URI_x86_64_v2_rust-snapbox+path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+path-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+path-devel}"
SRC_URI[x86_64_v2_rust-snapbox+path-devel.sha256sum] = "df0933f797fa5129eb4026cc6d70a5b4c7a3f90bae148c9d065f44feb6017107"

URI_x86_64_v2_rust-snapbox+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+regex-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+regex-devel}"
SRC_URI[x86_64_v2_rust-snapbox+regex-devel.sha256sum] = "44a9151f38b23df1c0f06d0162e9622917fa570b0a3aa7f8ddc5ef950f737716"

URI_x86_64_v2_rust-snapbox+structured-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+structured-data-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+structured-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+structured-data-devel}"
SRC_URI[x86_64_v2_rust-snapbox+structured-data-devel.sha256sum] = "be60f6fb59d24a44c396f57cefd7008eea2cc2c29ea4860c5c09e65233555035"

URI_x86_64_v2_rust-snapbox+term-svg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+term-svg-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+term-svg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+term-svg-devel}"
SRC_URI[x86_64_v2_rust-snapbox+term-svg-devel.sha256sum] = "43516620d1a41b0f7212bc5cccc9aef0bb8da74109f197869acb01bee24fa9d7"

URI_x86_64_v2_rust-snapbox-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-devel-0.6.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-devel}"
SRC_URI[x86_64_v2_rust-snapbox-devel.sha256sum] = "ca5c3f6c74b8de1887e16ea24a2b6137bd514ca55dd6d8125437ccb6782970fb"

URI_aarch64_rust-snapbox+cmd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+cmd-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox+cmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+cmd-devel}"
SRC_URI[aarch64_rust-snapbox+cmd-devel.sha256sum] = "c258a9e4fd97e93644a84a4e37eaa6fbed1ba5234c3d1fa5d40edf8af72cad36"

URI_aarch64_rust-snapbox+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+color-auto-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+color-auto-devel}"
SRC_URI[aarch64_rust-snapbox+color-auto-devel.sha256sum] = "7d2613faca0a29cc3c78f113fa4a01072890687e3a51e33a746392c7da36639e"

URI_aarch64_rust-snapbox+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+color-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+color-devel}"
SRC_URI[aarch64_rust-snapbox+color-devel.sha256sum] = "944e000e90c21091bdaaa1538bbc10dad59cae1258cd8551e8018b4bbe60cf14"

URI_aarch64_rust-snapbox+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+debug-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+debug-devel}"
SRC_URI[aarch64_rust-snapbox+debug-devel.sha256sum] = "096461d09a16f458b666483ec41a0a88fd8f394f601365037faa0f8e3627da71"

URI_aarch64_rust-snapbox+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+default-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+default-devel}"
SRC_URI[aarch64_rust-snapbox+default-devel.sha256sum] = "e703a17007ecbe3253780c221388e1ce7fe75272950551c9bf38037607e37e2a"

URI_aarch64_rust-snapbox+detect-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+detect-encoding-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox+detect-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+detect-encoding-devel}"
SRC_URI[aarch64_rust-snapbox+detect-encoding-devel.sha256sum] = "ff12b2a3ca33348d307672ff06c599eca045e9380753baf075455723871fc16e"

URI_aarch64_rust-snapbox+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+diff-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+diff-devel}"
SRC_URI[aarch64_rust-snapbox+diff-devel.sha256sum] = "bb8547e3cd555fd61fbbbca398b44b3c8b1bd7ace41402d453523374d2e53106"

URI_aarch64_rust-snapbox+dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+dir-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox+dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+dir-devel}"
SRC_URI[aarch64_rust-snapbox+dir-devel.sha256sum] = "f99ccd7775c9f4c3ff1e8dba8ce5c9f3f85ed634521493bbc0ac6b1d1b4cc09e"

URI_aarch64_rust-snapbox+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+document-features-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+document-features-devel}"
SRC_URI[aarch64_rust-snapbox+document-features-devel.sha256sum] = "8a0173b9d262a6748befb3e26adf119c64d29098090b85b06737781ebff6374d"

URI_aarch64_rust-snapbox+examples-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+examples-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox+examples-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+examples-devel}"
SRC_URI[aarch64_rust-snapbox+examples-devel.sha256sum] = "f2f1ae5e45480c50da295dd7947a7a823762e6ecf1cde5a4139af459b9a622cf"

URI_aarch64_rust-snapbox+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+json-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+json-devel}"
SRC_URI[aarch64_rust-snapbox+json-devel.sha256sum] = "99099c484861c2f2b06a153ce5d47a72999c0f903f44b29f8f84c49b03e162a3"

URI_aarch64_rust-snapbox+path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+path-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox+path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+path-devel}"
SRC_URI[aarch64_rust-snapbox+path-devel.sha256sum] = "e7aeb0e51ada54466e0c48b953487f13c9ed864f011eb60faa33d8bad40290a1"

URI_aarch64_rust-snapbox+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+regex-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+regex-devel}"
SRC_URI[aarch64_rust-snapbox+regex-devel.sha256sum] = "30713ac60ddd64f7fe09157d55c13e4b8cabce77a218e53635c801f1ce32f6ce"

URI_aarch64_rust-snapbox+structured-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+structured-data-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox+structured-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+structured-data-devel}"
SRC_URI[aarch64_rust-snapbox+structured-data-devel.sha256sum] = "e918f1adfc7b9910ffd2d1c17384a4d07fb9a2dd27567a2d54c21225f65d8ec5"

URI_aarch64_rust-snapbox+term-svg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+term-svg-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox+term-svg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+term-svg-devel}"
SRC_URI[aarch64_rust-snapbox+term-svg-devel.sha256sum] = "033c1f124baafc9051a9afd99039ab787f5fb08c46cbf0d9bb8b832b8034d493"

URI_aarch64_rust-snapbox-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-devel-0.6.21-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-devel}"
SRC_URI[aarch64_rust-snapbox-devel.sha256sum] = "ade6b08a4a6dc7ad584bde7c00eab00c6bc77a94f8c807d781d41dde2eebd2bd"

RDEPENDS:rust-snapbox+cmd-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-os_pipe+default-devel \
 rust-snapbox-devel \
 rust-wait-timeout+default-devel \
 "
RDEPENDS:rust-snapbox+color-auto-devel = " \
 cargo \
 rust-snapbox+color-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-snapbox-devel \
 rust-snapbox-macros+color-devel \
 "
RDEPENDS:rust-snapbox+debug-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-snapbox-devel \
 rust-snapbox-macros+debug-devel \
 "
RDEPENDS:rust-snapbox+default-devel = " \
 cargo \
 rust-snapbox+color-auto-devel \
 rust-snapbox+diff-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+detect-encoding-devel = " \
 cargo \
 rust-content_inspector+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+diff-devel = " \
 cargo \
 rust-similar+default-devel \
 rust-similar+inline-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+dir-devel = " \
 cargo \
 rust-dunce+default-devel \
 rust-filetime+default-devel \
 rust-snapbox+detect-encoding-devel \
 rust-snapbox-devel \
 rust-tempfile+default-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-snapbox+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+examples-devel = " \
 cargo \
 rust-escargot+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+json-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 rust-snapbox+structured-data-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+path-devel = " \
 cargo \
 rust-snapbox+dir-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+regex-devel = " \
 cargo \
 rust-regex+std-devel \
 rust-regex-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+structured-data-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+term-svg-devel = " \
 cargo \
 rust-anstyle-svg+default-devel \
 rust-snapbox+structured-data-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-normalize-line-endings+default-devel \
 rust-snapbox-macros+default-devel \
 "
