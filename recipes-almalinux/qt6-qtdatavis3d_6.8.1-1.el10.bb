# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtdatavis3d"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtdatavis3d \
 qt6-qtdatavis3d-devel \
 qt6-qtdatavis3d-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtdatavis3d-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa53d89f06742aa4dbec76798228ef2f793d49d30c45b6cf80354fcfcd6cd8ec"

URI_x86_64_v2_qt6-qtdatavis3d = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtdatavis3d-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdatavis3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdatavis3d}"
SRC_URI[x86_64_v2_qt6-qtdatavis3d.sha256sum] = "9968761fe0764150c0e1b8d455fabf2fc67df9c487f50df95e1cc31755968230"

URI_x86_64_v2_qt6-qtdatavis3d-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtdatavis3d-devel-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdatavis3d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdatavis3d-devel}"
SRC_URI[x86_64_v2_qt6-qtdatavis3d-devel.sha256sum] = "e0f3fff9398ec2210f8f8bfdb01172bb60a3288cad26d3f11954d9f792698dfc"

URI_x86_64_v2_qt6-qtdatavis3d-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtdatavis3d-examples-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdatavis3d-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdatavis3d-examples}"
SRC_URI[x86_64_v2_qt6-qtdatavis3d-examples.sha256sum] = "ae5a3b698e530685157b25e5f41744e3d01b27bdcde6982e6b25494a948ef2cd"

URI_aarch64_qt6-qtdatavis3d = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtdatavis3d-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtdatavis3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdatavis3d}"
SRC_URI[aarch64_qt6-qtdatavis3d.sha256sum] = "014865671b44e0cdb73976264167055d5dbcf66d4897054ee97f7bea18017136"

URI_aarch64_qt6-qtdatavis3d-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtdatavis3d-devel-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtdatavis3d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdatavis3d-devel}"
SRC_URI[aarch64_qt6-qtdatavis3d-devel.sha256sum] = "9516ea38601215ff99177e7a487c076508120389598022cfc5f5a340edb66005"

URI_aarch64_qt6-qtdatavis3d-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtdatavis3d-examples-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtdatavis3d-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdatavis3d-examples}"
SRC_URI[aarch64_qt6-qtdatavis3d-examples.sha256sum] = "bf157a2ca014b78bf2d006831d30e435b9aeb7feab26e46f8b4ceee24d5a0dfb"

RDEPENDS:qt6-qtdatavis3d = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtdatavis3d-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdatavis3d \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:qt6-qtdatavis3d-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdatavis3d \
 qt6-qtdeclarative \
 "
