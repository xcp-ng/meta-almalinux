# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libssh2-sys"
PV = "0.3.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-libssh2-sys+default-devel \
 rust-libssh2-sys-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libssh2-sys-0.3.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b9d5e33a33752bc5dcb3ed79bcacef237933892511fef47cb50f6e1f4d805667"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libssh2-sys+default-devel-0.3.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libssh2-sys+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libssh2-sys+default-devel.sha256sum] = "c3e811bce37db80b20b0a54ba096f06f4e04fa0b7531b9f52e0c5c469a568950"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libssh2-sys-devel-0.3.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libssh2-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libssh2-sys-devel.sha256sum] = "ad588b47ebd685e848ce3777c4f7de563d9c5f24fa1b3fbe113eee065c87482a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libssh2-sys+default-devel-0.3.3-1.el10_3.noarch.rpm;name=aarch64_rust-libssh2-sys+default-devel;unpack=0"
SRC_URI[aarch64_rust-libssh2-sys+default-devel.sha256sum] = "27b1d9068f085c433c3310ca539ca2d1c09425787dbbe42fb47b22222e150ac6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libssh2-sys-devel-0.3.3-1.el10_3.noarch.rpm;name=aarch64_rust-libssh2-sys-devel;unpack=0"
SRC_URI[aarch64_rust-libssh2-sys-devel.sha256sum] = "cabc8fc048c856e26cc4fd57d1b8d1c97c8b51b74711b3088444b6c74c4db1fb"

RDEPENDS:rust-libssh2-sys+default-devel = " \
 cargo \
 rust-libssh2-sys-devel \
 "
RDEPENDS:rust-libssh2-sys-devel = " \
 cargo \
 libssh2-devel \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys-devel \
 rust-openssl-sys+default-devel \
 rust-pkg-config+default-devel \
 "
