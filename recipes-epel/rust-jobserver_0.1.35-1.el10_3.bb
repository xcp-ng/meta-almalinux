# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jobserver"
PV = "0.1.35"
PR = "1.el10_3"
PACKAGES = " \
 rust-jobserver+default-devel \
 rust-jobserver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jobserver-0.1.35-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38f22b64edc7f5d77dd27d0cf2f43221d7f80815ad8338c574f5a8c4c75ee225"

URI_x86_64_v2_rust-jobserver+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jobserver+default-devel-0.1.35-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jobserver+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jobserver+default-devel}"
SRC_URI[x86_64_v2_rust-jobserver+default-devel.sha256sum] = "c21de35f05ffafb72133d1b6a15a8c898813a0e54a93135e6b0668a9609b5110"

URI_x86_64_v2_rust-jobserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jobserver-devel-0.1.35-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jobserver-devel}"
SRC_URI[x86_64_v2_rust-jobserver-devel.sha256sum] = "05abb4fd75a390ff48468839e5c519d4e4a7d110904cd875af920bacea840b67"

URI_aarch64_rust-jobserver+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jobserver+default-devel-0.1.35-1.el10_3.noarch.rpm;name=aarch64_rust-jobserver+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jobserver+default-devel}"
SRC_URI[aarch64_rust-jobserver+default-devel.sha256sum] = "6817736726dd5f00c59dcf110672e67e5078b72273cb43fa0022278e8ff723ce"

URI_aarch64_rust-jobserver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jobserver-devel-0.1.35-1.el10_3.noarch.rpm;name=aarch64_rust-jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jobserver-devel}"
SRC_URI[aarch64_rust-jobserver-devel.sha256sum] = "0dd8639c841218215dafa91d470ba7d4c4ca8ca7017183b2271fc2a09c7edd86"

RDEPENDS:rust-jobserver+default-devel = " \
 cargo \
 rust-jobserver-devel \
 "
RDEPENDS:rust-jobserver-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
