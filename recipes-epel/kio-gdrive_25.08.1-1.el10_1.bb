# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kio-gdrive"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kio-gdrive \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kio-gdrive-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52fca7ac84a4a6c0f2c56bcbc5ec419a132997476ec6921907cb261d69e18648"

URI_x86_64_v2_kio-gdrive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-gdrive-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-gdrive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-gdrive}"
SRC_URI[x86_64_v2_kio-gdrive.sha256sum] = "3c6ebbb381fb0c44bd16a728e449998f653d8d47cb1aa32d37354261508fbf3e"

URI_aarch64_kio-gdrive = "${EPEL_MIRROR}/aarch64/Packages/k/kio-gdrive-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kio-gdrive;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-gdrive}"
SRC_URI[aarch64_kio-gdrive.sha256sum] = "848ca289041c11b0fe28593c4e37773f190a40fb3c30b2c55e9cc72ad2f9c1e0"

RDEPENDS:kio-gdrive = " \
 accounts-qml-module-qt6 \
 glibc \
 kaccounts-integration-qt6 \
 kaccounts-providers \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-purpose \
 libaccounts-qt6 \
 libkgapi \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
