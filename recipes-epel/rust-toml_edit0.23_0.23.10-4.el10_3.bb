# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_edit0.23"
PV = "0.23.10"
PR = "4.el10_3"
PACKAGES = " \
 rust-toml_edit0.23+debug-devel \
 rust-toml_edit0.23+default-devel \
 rust-toml_edit0.23+display-devel \
 rust-toml_edit0.23+parse-devel \
 rust-toml_edit0.23+serde-devel \
 rust-toml_edit0.23+unbounded-devel \
 rust-toml_edit0.23-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_edit0.23-0.23.10-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a692b1f08d5389fbdc710e3bc2e2753baf25f22d3c881ba62cc4049ead909337"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-toml_edit0.23+debug-devel: (crate(toml_parser/debug) >= 1.0.5 with crate(toml_parser/debug) < 2.0.0~)
# - rust-toml_edit0.23+debug-devel: (crate(toml_parser/default) >= 1.0.5 with crate(toml_parser/default) < 2.0.0~)
# - rust-toml_edit0.23+parse-devel: (crate(toml_parser/default) >= 1.0.5 with crate(toml_parser/default) < 2.0.0~)

URI_x86_64_v2_rust-toml_edit0.23+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.23+debug-devel-0.23.10-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.23+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.23+debug-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.23+debug-devel.sha256sum] = "9065e3af1fdd5c0ec296d10edb782a6cd701bda2910fa3069015806e92f7e5c5"

URI_x86_64_v2_rust-toml_edit0.23+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.23+default-devel-0.23.10-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.23+default-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.23+default-devel.sha256sum] = "ebfea886aa39f3d69174880d66cfe803f8947eb56b1efab433544c9437ec82c9"
RPROVIDES:rust-toml_edit0.23+default-devel:x86_64_v2 = "virtual/crate_toml_edit/default__ge_0.23.0_with_crate_toml_edit/default__lt_0.25.0~ virtual/crate_toml_edit/default__ge_0.23.5_with_crate_toml_edit/default__lt_0.25.0~"

URI_x86_64_v2_rust-toml_edit0.23+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.23+display-devel-0.23.10-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.23+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.23+display-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.23+display-devel.sha256sum] = "632ca9e28a1fda0e479e633cf1828f4e124332f38e8d6b0696ff3e671c2f9a45"
RPROVIDES:rust-toml_edit0.23+display-devel:x86_64_v2 = "virtual/crate_toml_edit/display__ge_0.23.0_with_crate_toml_edit/display__lt_0.25.0~"

URI_x86_64_v2_rust-toml_edit0.23+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.23+parse-devel-0.23.10-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.23+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.23+parse-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.23+parse-devel.sha256sum] = "0faa29d29994c250c40165fd0757c0acb6b16ecfe08354c7a4d2919b952c1148"
RPROVIDES:rust-toml_edit0.23+parse-devel:x86_64_v2 = "virtual/crate_toml_edit/parse__ge_0.23.0_with_crate_toml_edit/parse__lt_0.25.0~ virtual/crate_toml_edit/parse__ge_0.23.2_with_crate_toml_edit/parse__lt_0.25.0~"

URI_x86_64_v2_rust-toml_edit0.23+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.23+serde-devel-0.23.10-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.23+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.23+serde-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.23+serde-devel.sha256sum] = "7d5ed6be7e6dc547df89cb9422465ce65ec4e056b5fb3ecaa607c08f085cc8c2"
RPROVIDES:rust-toml_edit0.23+serde-devel:x86_64_v2 = "virtual/crate_toml_edit/serde__ge_0.23.0_with_crate_toml_edit/serde__lt_0.25.0~ virtual/crate_toml_edit/serde__ge_0.23.5_with_crate_toml_edit/serde__lt_0.25.0~"

URI_x86_64_v2_rust-toml_edit0.23+unbounded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.23+unbounded-devel-0.23.10-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.23+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.23+unbounded-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.23+unbounded-devel.sha256sum] = "92e60cd82d0c4282d960a7c09cdd6448d1f49a7c6a9e2f19e1a5025e1e9ecaf6"

URI_x86_64_v2_rust-toml_edit0.23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.23-devel-0.23.10-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.23-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.23-devel.sha256sum] = "f01de8369c26a33e46fa1114887b9497be27c137b90193ffe6e45a2e2fd3b8e0"
RPROVIDES:rust-toml_edit0.23-devel:x86_64_v2 = "virtual/crate_toml_edit__ge_0.23.2_with_crate_toml_edit__lt_0.25.0~"

URI_aarch64_rust-toml_edit0.23+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.23+debug-devel-0.23.10-4.el10_3.noarch.rpm;name=aarch64_rust-toml_edit0.23+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.23+debug-devel}"
SRC_URI[aarch64_rust-toml_edit0.23+debug-devel.sha256sum] = "cf1de5bc668c019542f473c0835a7cae81ae642272c94dcc142434001f5dc043"

URI_aarch64_rust-toml_edit0.23+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.23+default-devel-0.23.10-4.el10_3.noarch.rpm;name=aarch64_rust-toml_edit0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.23+default-devel}"
SRC_URI[aarch64_rust-toml_edit0.23+default-devel.sha256sum] = "f1aa09e86e0a3d41a367f65fdd73548072a964292a470598fb480ba6f7a2b05b"
RPROVIDES:rust-toml_edit0.23+default-devel:aarch64 = "virtual/crate_toml_edit/default__ge_0.23.0_with_crate_toml_edit/default__lt_0.25.0~ virtual/crate_toml_edit/default__ge_0.23.5_with_crate_toml_edit/default__lt_0.25.0~"

URI_aarch64_rust-toml_edit0.23+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.23+display-devel-0.23.10-4.el10_3.noarch.rpm;name=aarch64_rust-toml_edit0.23+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.23+display-devel}"
SRC_URI[aarch64_rust-toml_edit0.23+display-devel.sha256sum] = "e185ab356fde76e47f79a7ab465d2aff94be6d369240b4d65f0dc8e100a9bff5"
RPROVIDES:rust-toml_edit0.23+display-devel:aarch64 = "virtual/crate_toml_edit/display__ge_0.23.0_with_crate_toml_edit/display__lt_0.25.0~"

URI_aarch64_rust-toml_edit0.23+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.23+parse-devel-0.23.10-4.el10_3.noarch.rpm;name=aarch64_rust-toml_edit0.23+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.23+parse-devel}"
SRC_URI[aarch64_rust-toml_edit0.23+parse-devel.sha256sum] = "ff961762a277fc2c9a065b38a9cfc96682be49acfdadb311201c3cc899a771b9"
RPROVIDES:rust-toml_edit0.23+parse-devel:aarch64 = "virtual/crate_toml_edit/parse__ge_0.23.0_with_crate_toml_edit/parse__lt_0.25.0~ virtual/crate_toml_edit/parse__ge_0.23.2_with_crate_toml_edit/parse__lt_0.25.0~"

URI_aarch64_rust-toml_edit0.23+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.23+serde-devel-0.23.10-4.el10_3.noarch.rpm;name=aarch64_rust-toml_edit0.23+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.23+serde-devel}"
SRC_URI[aarch64_rust-toml_edit0.23+serde-devel.sha256sum] = "7451b427fbeeb1b6e82c8cf92879aef0da11e248fb99ec9c9235d6e4b32e99ef"
RPROVIDES:rust-toml_edit0.23+serde-devel:aarch64 = "virtual/crate_toml_edit/serde__ge_0.23.0_with_crate_toml_edit/serde__lt_0.25.0~ virtual/crate_toml_edit/serde__ge_0.23.5_with_crate_toml_edit/serde__lt_0.25.0~"

URI_aarch64_rust-toml_edit0.23+unbounded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.23+unbounded-devel-0.23.10-4.el10_3.noarch.rpm;name=aarch64_rust-toml_edit0.23+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.23+unbounded-devel}"
SRC_URI[aarch64_rust-toml_edit0.23+unbounded-devel.sha256sum] = "d28a77e2c55539501ee4c652a64cd9a7a2780503dffb569cbc3caa4c3c3c6359"

URI_aarch64_rust-toml_edit0.23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.23-devel-0.23.10-4.el10_3.noarch.rpm;name=aarch64_rust-toml_edit0.23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.23-devel}"
SRC_URI[aarch64_rust-toml_edit0.23-devel.sha256sum] = "24614374391535eef9abeda4aafbdfd09e3132e54943d9f4521ccc4fa50f1a21"
RPROVIDES:rust-toml_edit0.23-devel:aarch64 = "virtual/crate_toml_edit__ge_0.23.2_with_crate_toml_edit__lt_0.25.0~"

RDEPENDS:rust-toml_edit0.23+debug-devel:x86_64_v2 = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-anstyle+default-devel \
 rust-toml_edit0.23+display-devel \
 rust-toml_edit0.23-devel \
"
RDEPENDS:rust-toml_edit0.23+debug-devel:aarch64 = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-anstyle+default-devel \
 rust-toml_edit0.23+display-devel \
 rust-toml_edit0.23-devel \
 rust-toml_parser+debug-devel \
 rust-toml_parser+default-devel \
"
RDEPENDS:rust-toml_edit0.23+default-devel = " \
 cargo \
 rust-toml_edit0.23+display-devel \
 rust-toml_edit0.23+parse-devel \
 rust-toml_edit0.23-devel \
 "
RDEPENDS:rust-toml_edit0.23+display-devel = " \
 cargo \
 rust-toml_edit0.23-devel \
 rust-toml_writer+default-devel \
 "
RDEPENDS:rust-toml_edit0.23+parse-devel:x86_64_v2 = " \
 cargo \
 rust-toml_edit0.23-devel \
 rust-winnow0.7+default-devel \
"
RDEPENDS:rust-toml_edit0.23+parse-devel:aarch64 = " \
 cargo \
 rust-toml_edit0.23-devel \
 rust-toml_parser+default-devel \
 rust-winnow0.7+default-devel \
"
RDEPENDS:rust-toml_edit0.23+serde-devel = " \
 cargo \
 rust-serde_core+default-devel \
 rust-serde_spanned+default-devel \
 rust-serde_spanned+serde-devel \
 rust-toml_datetime0.7+serde-devel \
 rust-toml_edit0.23-devel \
 "
RDEPENDS:rust-toml_edit0.23+unbounded-devel = " \
 cargo \
 rust-toml_edit0.23-devel \
 "
RDEPENDS:rust-toml_edit0.23-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-indexmap+std-devel \
 rust-toml_datetime0.7+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_toml_edit/default__ge_0.23.0_with_crate_toml_edit/default__lt_0.25.0~ rpm/virtual/crate_toml_edit/default__ge_0.23.5_with_crate_toml_edit/default__lt_0.25.0~ rpm/virtual/crate_toml_edit/display__ge_0.23.0_with_crate_toml_edit/display__lt_0.25.0~ rpm/virtual/crate_toml_edit/parse__ge_0.23.0_with_crate_toml_edit/parse__lt_0.25.0~ rpm/virtual/crate_toml_edit/parse__ge_0.23.2_with_crate_toml_edit/parse__lt_0.25.0~ rpm/virtual/crate_toml_edit/serde__ge_0.23.0_with_crate_toml_edit/serde__lt_0.25.0~ rpm/virtual/crate_toml_edit/serde__ge_0.23.5_with_crate_toml_edit/serde__lt_0.25.0~ rpm/virtual/crate_toml_edit__ge_0.23.2_with_crate_toml_edit__lt_0.25.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_toml_edit/default__ge_0.23.0_with_crate_toml_edit/default__lt_0.25.0~ rpm/virtual/crate_toml_edit/default__ge_0.23.5_with_crate_toml_edit/default__lt_0.25.0~ rpm/virtual/crate_toml_edit/display__ge_0.23.0_with_crate_toml_edit/display__lt_0.25.0~ rpm/virtual/crate_toml_edit/parse__ge_0.23.0_with_crate_toml_edit/parse__lt_0.25.0~ rpm/virtual/crate_toml_edit/parse__ge_0.23.2_with_crate_toml_edit/parse__lt_0.25.0~ rpm/virtual/crate_toml_edit/serde__ge_0.23.0_with_crate_toml_edit/serde__lt_0.25.0~ rpm/virtual/crate_toml_edit/serde__ge_0.23.5_with_crate_toml_edit/serde__lt_0.25.0~ rpm/virtual/crate_toml_edit__ge_0.23.2_with_crate_toml_edit__lt_0.25.0~"
