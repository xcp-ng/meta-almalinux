# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-const-oid"
PV = "0.10.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-const-oid+arbitrary-devel \
 rust-const-oid+db-devel \
 rust-const-oid+default-devel \
 rust-const-oid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-const-oid-0.10.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcce38e99b864a0918dd51531ebc161d31bf19114cfae28c1a6ef1aa2850ea5e"

URI_x86_64_v2_rust-const-oid+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-oid+arbitrary-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-oid+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-oid+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-const-oid+arbitrary-devel.sha256sum] = "687dd498a20ef85d506d0c8dd4e785c43c826063a677652e0a0c64493633dcca"

URI_x86_64_v2_rust-const-oid+db-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-oid+db-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-oid+db-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-oid+db-devel}"
SRC_URI[x86_64_v2_rust-const-oid+db-devel.sha256sum] = "aff655856eda2d0cf3b19497d528dda9f5db183558078a2981bbf2ceb8e68380"

URI_x86_64_v2_rust-const-oid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-oid+default-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-oid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-oid+default-devel}"
SRC_URI[x86_64_v2_rust-const-oid+default-devel.sha256sum] = "90e0854d2b44f4b2b76d1a45827912a0c3c05df3fc811dd6464a30ad8bbd3ace"

URI_x86_64_v2_rust-const-oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-oid-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-oid-devel}"
SRC_URI[x86_64_v2_rust-const-oid-devel.sha256sum] = "cd779f590d38cd5ccd905902ed018a4400543f704666b01b83a96f704a9eae5b"

URI_aarch64_rust-const-oid+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-oid+arbitrary-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-const-oid+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-oid+arbitrary-devel}"
SRC_URI[aarch64_rust-const-oid+arbitrary-devel.sha256sum] = "cf37578ff1d1dadf0f9ffd72602988f862c0c8fa8f5749a47c6ddfce9dccd073"

URI_aarch64_rust-const-oid+db-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-oid+db-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-const-oid+db-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-oid+db-devel}"
SRC_URI[aarch64_rust-const-oid+db-devel.sha256sum] = "ba1ba76bd129172e9e12b7470116f12927aeb90d3ee834cb3afc995f532abc37"

URI_aarch64_rust-const-oid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-oid+default-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-const-oid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-oid+default-devel}"
SRC_URI[aarch64_rust-const-oid+default-devel.sha256sum] = "0d209ab2905cafd40273db441f484b83c196c14c20d476a8d83e35e3033835d5"

URI_aarch64_rust-const-oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-oid-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-const-oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-oid-devel}"
SRC_URI[aarch64_rust-const-oid-devel.sha256sum] = "5af5e8cbad8f3d9b0bd22df1bab5edb581053242d7972532e370461735d250b5"

RDEPENDS:rust-const-oid+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-const-oid-devel \
 "
RDEPENDS:rust-const-oid+db-devel = " \
 cargo \
 rust-const-oid-devel \
 "
RDEPENDS:rust-const-oid+default-devel = " \
 cargo \
 rust-const-oid-devel \
 "
RDEPENDS:rust-const-oid-devel = " \
 cargo \
 rust \
 "
