# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-desktop3"
PV = "44.1"
PR = "5.el10_2"
PACKAGES = " \
 gnome-desktop3 \
 gnome-desktop3-devel \
 gnome-desktop4 \
 gnome-desktop4-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-desktop3-44.1-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab3a1444402a89dfa4635a3260d08b062b73db61ba4e536ab3a132a3d4b852a6"

URI_x86_64_v2_gnome-desktop3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-desktop3-44.1-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnome-desktop3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-desktop3}"
SRC_URI[x86_64_v2_gnome-desktop3.sha256sum] = "ad96781858634a12e731e3ddfb35fbe97d11f537a3b2df06926e887c8a27023a"

URI_x86_64_v2_gnome-desktop3-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnome-desktop3-devel-44.1-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnome-desktop3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-desktop3-devel}"
SRC_URI[x86_64_v2_gnome-desktop3-devel.sha256sum] = "b3c792922cfd0e0c5956f00af9431c4b628a946f321fc84fb707f062c5926e13"

URI_x86_64_v2_gnome-desktop4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-desktop4-44.1-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnome-desktop4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-desktop4}"
SRC_URI[x86_64_v2_gnome-desktop4.sha256sum] = "9265e7d56bbe9defeb29d18ed18ab44d8fb7430b2fd5019ba7176c2f7520af89"

URI_x86_64_v2_gnome-desktop4-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnome-desktop4-devel-44.1-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnome-desktop4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-desktop4-devel}"
SRC_URI[x86_64_v2_gnome-desktop4-devel.sha256sum] = "f218557cad88b7b92626dd8cea07985700442e38a7f999190a74c4a0c764fbed"

URI_aarch64_gnome-desktop3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-desktop3-44.1-5.el10_2.aarch64.rpm;name=aarch64_gnome-desktop3;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-desktop3}"
SRC_URI[aarch64_gnome-desktop3.sha256sum] = "db3be6589f9e4216d2ecd298eb4056d252ad1d29bbbd09bbaf8b3c64e7a341cd"

URI_aarch64_gnome-desktop3-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnome-desktop3-devel-44.1-5.el10_2.aarch64.rpm;name=aarch64_gnome-desktop3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-desktop3-devel}"
SRC_URI[aarch64_gnome-desktop3-devel.sha256sum] = "dc40d47924f359f78e15f03aeb4c0360eeeaa937d80c5c8a24a36a9278e11122"

URI_aarch64_gnome-desktop4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-desktop4-44.1-5.el10_2.aarch64.rpm;name=aarch64_gnome-desktop4;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-desktop4}"
SRC_URI[aarch64_gnome-desktop4.sha256sum] = "f601833a2cc08ba0b78f0bf4c42edc522aee33760e330dd655b8f79fa53ccd92"

URI_aarch64_gnome-desktop4-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnome-desktop4-devel-44.1-5.el10_2.aarch64.rpm;name=aarch64_gnome-desktop4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-desktop4-devel}"
SRC_URI[aarch64_gnome-desktop4-devel.sha256sum] = "2120194ce4a97de94e855ce6dd4d69ec6ecd6abc55619a973a71efd27cda6cf1"

RDEPENDS:gnome-desktop3 = " \
 bubblewrap \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gsettings-desktop-schemas \
 gtk3 \
 libgcc \
 libseccomp \
 libxkbcommon \
 shared-mime-info \
 systemd-libs \
 "
RDEPENDS:gnome-desktop3-devel = " \
 gdk-pixbuf2-devel \
 glib2-devel \
 gnome-desktop3 \
 gsettings-desktop-schemas-devel \
 gtk3-devel \
 iso-codes-devel \
 libseccomp-devel \
 libxkbcommon-devel \
 pkgconf-pkg-config \
 systemd-devel \
 xkeyboard-config-devel \
 "
RDEPENDS:gnome-desktop4 = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-desktop3 \
 gtk4 \
 libgcc \
 libseccomp \
 libxkbcommon \
 systemd-libs \
 "
RDEPENDS:gnome-desktop4-devel = " \
 gdk-pixbuf2-devel \
 glib2-devel \
 gnome-desktop4 \
 gnome-desktop4-devel \
 gsettings-desktop-schemas-devel \
 gtk4-devel \
 iso-codes-devel \
 libseccomp-devel \
 libxkbcommon-devel \
 pkgconf-pkg-config \
 systemd-devel \
 xkeyboard-config-devel \
 "
