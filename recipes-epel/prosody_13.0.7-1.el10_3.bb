# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "prosody"
PV = "13.0.7"
PR = "1.el10_3"
PACKAGES = " \
 prosody \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/prosody-13.0.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "06e528b6a8246a8e9ef6d80ee7b4c7e278dca515e5f45a3bbe919b589fc3b56a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/prosody-13.0.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_prosody;unpack=0"
SRC_URI[x86_64_v2_prosody.sha256sum] = "24f9703d4ee827e2d2b0b4533e1883f60fd7827cb14e48fcc8be83742aa8ee03"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/prosody-13.0.7-1.el10_3.aarch64.rpm;name=aarch64_prosody;unpack=0"
SRC_URI[aarch64_prosody.sha256sum] = "ccb0ebe06d226ac8400818c4764f8461beb65c9248f635bde86438e5f07594fb"

RDEPENDS:prosody = " \
 bash \
 glibc \
 libicu \
 lua \
 lua-expat \
 lua-filesystem \
 lua-libs \
 lua-sec \
 lua-socket \
 openssl \
 openssl-libs \
 shadow-utils \
 systemd \
 "
