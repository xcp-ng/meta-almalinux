# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-is_executable"
PV = "1.0.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-is_executable+default-devel \
 rust-is_executable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-is_executable-1.0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f121d53d1ef367846880af8773431658b1ab973f26f3ecfb2f327815318eee1"

URI_x86_64_v2_rust-is_executable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is_executable+default-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is_executable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is_executable+default-devel}"
SRC_URI[x86_64_v2_rust-is_executable+default-devel.sha256sum] = "b168afd7252dfee7d37971951bc12e228ee0ccb200637a6f1d8a8fc168d598ef"

URI_x86_64_v2_rust-is_executable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is_executable-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is_executable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is_executable-devel}"
SRC_URI[x86_64_v2_rust-is_executable-devel.sha256sum] = "f25e43b5e887643e45c55269f107e194c4a875a3de2763eb65618ce733bc331e"

URI_aarch64_rust-is_executable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is_executable+default-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-is_executable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is_executable+default-devel}"
SRC_URI[aarch64_rust-is_executable+default-devel.sha256sum] = "60060bfd39fb86dc6083a6b18eba97fc25aacd4621c0bd33266c67d0c6197725"

URI_aarch64_rust-is_executable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is_executable-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-is_executable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is_executable-devel}"
SRC_URI[aarch64_rust-is_executable-devel.sha256sum] = "093f6c8f3e96030bbef01a24d0ed7e9126223fa4066b22da612c06b19cf73078"

RDEPENDS:rust-is_executable+default-devel = " \
 cargo \
 rust-is_executable-devel \
 "
RDEPENDS:rust-is_executable-devel = " \
 cargo \
 "
