# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libre"
PV = "4.1.0"
PR = "1.el10_0"
PACKAGES = " \
 libre \
 libre-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libre-4.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11458d2be8e4c5ffea39b811bfb4387f771193c474820ede2bb63db93266b7dc"

URI_x86_64_v2_libre = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libre-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libre}"
SRC_URI[x86_64_v2_libre.sha256sum] = "e80b49e80b8734494e3ab4ed33cfaabc2bb5bb9448a2577aca325aac059ef54d"

URI_x86_64_v2_libre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libre-devel-4.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libre-devel}"
SRC_URI[x86_64_v2_libre-devel.sha256sum] = "dbba96fa3e6b4895937ae15504671ccf73cf4c16aa122559f1f3e0d52b33ec73"

URI_aarch64_libre = "${EPEL_MIRROR}/aarch64/Packages/l/libre-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_libre;unpack=0"
SRC_URI:append = " ${URI_aarch64_libre}"
SRC_URI[aarch64_libre.sha256sum] = "6c5ebfa5a489fc4f0e5be6721ac18fd9ea660869e993112ad2847957ba467511"

URI_aarch64_libre-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libre-devel-4.1.0-1.el10_0.aarch64.rpm;name=aarch64_libre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libre-devel}"
SRC_URI[aarch64_libre-devel.sha256sum] = "9c139b158b74b19bb3d996fafe6c141f2582f8a59d32f5dde54407e9b92f9a13"

RDEPENDS:libre = " \
 glibc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libre-devel = " \
 cmake-filesystem \
 libre \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
