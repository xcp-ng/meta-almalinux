# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tikv-jemalloc-sys"
PV = "0.6.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-tikv-jemalloc-sys+background_threads-devel \
 rust-tikv-jemalloc-sys+background_threads_runtime_support-devel \
 rust-tikv-jemalloc-sys+debug-devel \
 rust-tikv-jemalloc-sys+default-devel \
 rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel \
 rust-tikv-jemalloc-sys+profiling-devel \
 rust-tikv-jemalloc-sys+stats-devel \
 rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemalloc-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tikv-jemalloc-sys-0.6.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46b63646c830496057b35c205057e1460b2eb323826a687bceb464fa8c796481"

URI_x86_64_v2_rust-tikv-jemalloc-sys+background_threads-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+background_threads-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+background_threads-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+background_threads-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+background_threads-devel.sha256sum] = "29ef1902589ecd1b66cecf80b2f9a0374fa1338e7a4af2d6c046ea9f15476107"

URI_x86_64_v2_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+background_threads_runtime_support-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel.sha256sum] = "eff9010f3d6df08e73066c47c031673f1e3eab309cc3ef9b5d5b3b1871aa0dfc"

URI_x86_64_v2_rust-tikv-jemalloc-sys+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+debug-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+debug-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+debug-devel.sha256sum] = "1829bb54945021f399be81078f40a113ceefa641c7dc34a24d6bafbcceb8e64f"

URI_x86_64_v2_rust-tikv-jemalloc-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+default-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+default-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+default-devel.sha256sum] = "98fc43914f68234f7ba90f42981833a8e7221d9863b15d3dfa2dde4d018ef68c"

URI_x86_64_v2_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel.sha256sum] = "bdef54df95781602466b414ae43c5fe3044173be524bcc93b92ace479c320c6b"

URI_x86_64_v2_rust-tikv-jemalloc-sys+profiling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+profiling-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+profiling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+profiling-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+profiling-devel.sha256sum] = "78e055261433490ef6205129c4fa3325f5a5b166c634dd55cabc7b413d30c332"

URI_x86_64_v2_rust-tikv-jemalloc-sys+stats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+stats-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+stats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+stats-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+stats-devel.sha256sum] = "7f81e2499b55614b93cfa1abad107f3166290b953e05bba26eb3b28235980eff"

URI_x86_64_v2_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel.sha256sum] = "df87790c66993f268466a02a9baaad7047afaafa396377db8d9f7d8d12a68fe9"

URI_x86_64_v2_rust-tikv-jemalloc-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys-devel.sha256sum] = "084755946d859b88aa445d20b11ff2d72db260139fc11b3b9225e5629c109281"

URI_aarch64_rust-tikv-jemalloc-sys+background_threads-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+background_threads-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+background_threads-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+background_threads-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+background_threads-devel.sha256sum] = "7903418ae3a4cd5f6507e8a42ddec2ac5a56773a12b3ca0407089ecb93e99d4e"

URI_aarch64_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+background_threads_runtime_support-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel.sha256sum] = "f503ccab75c541c31321c8f7959d50ba87c91492fcac129320caddf9644de66f"

URI_aarch64_rust-tikv-jemalloc-sys+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+debug-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+debug-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+debug-devel.sha256sum] = "61554651468a733c9d647e438cb53c75185ebc162567debcd311a8b74debe34b"

URI_aarch64_rust-tikv-jemalloc-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+default-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+default-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+default-devel.sha256sum] = "fa86bdec11042572c055b5b1b93881e6d8156e3c6b92470a093bc7cf099a3431"

URI_aarch64_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel.sha256sum] = "d208350723a06e18b7ed4635ae3e5ad0aee65ead2a99712579a9e80f9117e330"

URI_aarch64_rust-tikv-jemalloc-sys+profiling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+profiling-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+profiling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+profiling-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+profiling-devel.sha256sum] = "34168b22189e872e4d45bdf3ab3473e7991cc3c42ab2adb57d1848155a9f8c2c"

URI_aarch64_rust-tikv-jemalloc-sys+stats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+stats-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+stats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+stats-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+stats-devel.sha256sum] = "480dad915c440e5dd60f1295c0dbe4d09572a9691c0412c6fda03d43d260f44c"

URI_aarch64_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel.sha256sum] = "0cd29330c329de7f85cc654ec3be9d6574d8a50184a6e547a2f4ba6425b8e803"

URI_aarch64_rust-tikv-jemalloc-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys-devel.sha256sum] = "c5cd7ae3f87cec01b68b138e160a217fe6bd659cc8446736e63ed73551925968"

RDEPENDS:rust-tikv-jemalloc-sys+background_threads-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+background_threads_runtime_support-devel \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+background_threads_runtime_support-devel = " \
 cargo \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+debug-devel = " \
 cargo \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+default-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+background_threads_runtime_support-devel \
 rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+profiling-devel = " \
 cargo \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+stats-devel = " \
 cargo \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel = " \
 cargo \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys-devel = " \
 cargo \
 jemalloc-devel \
 rust \
 rust-cc+default-devel \
 rust-libc-devel \
 "
