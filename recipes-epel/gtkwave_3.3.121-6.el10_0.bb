# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtkwave"
PV = "3.3.121"
PR = "6.el10_0"
PACKAGES = " \
 gtkwave \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gtkwave-3.3.121-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15924752af4f931fce6672e6dfedf73b90ec6b8b8c20c5e4c5ce22f0cd9c1df7"

URI_x86_64_v2_gtkwave = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtkwave-3.3.121-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtkwave;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtkwave}"
SRC_URI[x86_64_v2_gtkwave.sha256sum] = "45cb7a4c88b09e739548587ab9e4956c16dd060e80cfbcda2c430810638d0ae5"

URI_aarch64_gtkwave = "${EPEL_MIRROR}/aarch64/Packages/g/gtkwave-3.3.121-6.el10_0.aarch64.rpm;name=aarch64_gtkwave;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtkwave}"
SRC_URI[aarch64_gtkwave.sha256sum] = "9e1315708e042d6b138c8c12ad6e6be24e7c940b21e8b974553a5bb23de6634d"

RDEPENDS:gtkwave = " \
 Judy \
 bzip2-libs \
 cairo \
 gdk-pixbuf2 \
 gdk-pixbuf2-modules-extra \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 pango \
 shared-mime-info \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
