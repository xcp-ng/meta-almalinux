# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-webcolors"
PV = "24.11.1"
PR = "2.el10_0"
PACKAGES = " \
 python3-webcolors \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-webcolors-24.11.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "36abc93d13fee79542e919e99b0e47193947305cd15cd9fbdb52a966d24c4ab5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-webcolors-24.11.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-webcolors;unpack=0"
SRC_URI[x86_64_v2_python3-webcolors.sha256sum] = "779515be5dab29cd05aa78191b95efd4ec564e3a1ba5f53dc1a50885a6b297bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-webcolors-24.11.1-2.el10_0.noarch.rpm;name=aarch64_python3-webcolors;unpack=0"
SRC_URI[aarch64_python3-webcolors.sha256sum] = "a49d923d38b361096836d230df535bc21de8b4b2ed85a98469dec5cb54b1034f"

RDEPENDS:python3-webcolors = " \
 python3 \
 "
