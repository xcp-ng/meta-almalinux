# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-soupsieve"
PV = "2.6"
PR = "5.el10_0"
PACKAGES = " \
 python3-soupsieve \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-soupsieve-2.6-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1e8c4e3c4f441fb6568800883bde36706f295d87d25c34ff297134aa36b0351"

URI_x86_64_v2_python3-soupsieve = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-soupsieve-2.6-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-soupsieve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-soupsieve}"
SRC_URI[x86_64_v2_python3-soupsieve.sha256sum] = "9ed3e6cab9231a51da373359fc4e005640db60a906a516b4951dae7abdc672cf"

URI_aarch64_python3-soupsieve = "${EPEL_MIRROR}/aarch64/Packages/p/python3-soupsieve-2.6-5.el10_0.noarch.rpm;name=aarch64_python3-soupsieve;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-soupsieve}"
SRC_URI[aarch64_python3-soupsieve.sha256sum] = "34ce913848fb1ac8449ba5220ef36ddcafa6b95e6fece6e22502e91bad05d6e2"

RDEPENDS:python3-soupsieve = " \
 python3 \
 "
