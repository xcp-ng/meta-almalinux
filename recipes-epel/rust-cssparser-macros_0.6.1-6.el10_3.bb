# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cssparser-macros"
PV = "0.6.1"
PR = "6.el10_3"
PACKAGES = " \
 rust-cssparser-macros+default-devel \
 rust-cssparser-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cssparser-macros-0.6.1-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27474e204b58120f463c2edcda87b2538a90dae4149b44508585e7213eb31009"

URI_x86_64_v2_rust-cssparser-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cssparser-macros+default-devel-0.6.1-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cssparser-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cssparser-macros+default-devel}"
SRC_URI[x86_64_v2_rust-cssparser-macros+default-devel.sha256sum] = "2a47f29b0959141ba05e918213d9d115ee1d475d87b99434704541eefdbcefec"

URI_x86_64_v2_rust-cssparser-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cssparser-macros-devel-0.6.1-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cssparser-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cssparser-macros-devel}"
SRC_URI[x86_64_v2_rust-cssparser-macros-devel.sha256sum] = "dfec44ac86a32ad5b348f5f0cab9593b74ef6ddb537362cfad1f03f7f76374dc"

URI_aarch64_rust-cssparser-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cssparser-macros+default-devel-0.6.1-6.el10_3.noarch.rpm;name=aarch64_rust-cssparser-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cssparser-macros+default-devel}"
SRC_URI[aarch64_rust-cssparser-macros+default-devel.sha256sum] = "fe22cd992c5004ed219670f6b05b77fd30ad505b60493a9ce4fd7927af537c41"

URI_aarch64_rust-cssparser-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cssparser-macros-devel-0.6.1-6.el10_3.noarch.rpm;name=aarch64_rust-cssparser-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cssparser-macros-devel}"
SRC_URI[aarch64_rust-cssparser-macros-devel.sha256sum] = "85bd9bd2528b0b10bb2a71bc3128b9f0d60784930b0ca56392dbac71dd58fb92"

RDEPENDS:rust-cssparser-macros+default-devel = " \
 cargo \
 rust-cssparser-macros-devel \
 "
RDEPENDS:rust-cssparser-macros-devel = " \
 cargo \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 "
