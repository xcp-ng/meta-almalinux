# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-avif-serialize"
PV = "0.8.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-avif-serialize+default-devel \
 rust-avif-serialize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-avif-serialize-0.8.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4af416064da25638cb2b368972e6f72ca9c17b69c7fb21a3578a24e78cf6725b"

URI_x86_64_v2_rust-avif-serialize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-avif-serialize+default-devel-0.8.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-avif-serialize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-avif-serialize+default-devel}"
SRC_URI[x86_64_v2_rust-avif-serialize+default-devel.sha256sum] = "ad4171dc26ca38cbb6261e90178d54421eea095d9010b544bfb4504e3a6a3017"

URI_x86_64_v2_rust-avif-serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-avif-serialize-devel-0.8.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-avif-serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-avif-serialize-devel}"
SRC_URI[x86_64_v2_rust-avif-serialize-devel.sha256sum] = "59965383632cae6f942f314122fefc2f6a52083de75740b870137e320e41473f"

URI_aarch64_rust-avif-serialize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-avif-serialize+default-devel-0.8.6-1.el10_0.noarch.rpm;name=aarch64_rust-avif-serialize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-avif-serialize+default-devel}"
SRC_URI[aarch64_rust-avif-serialize+default-devel.sha256sum] = "11082ccddc8a8f13e74739782a86c9bcc99792c12cc77d45006cfb9cc0a60f56"

URI_aarch64_rust-avif-serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-avif-serialize-devel-0.8.6-1.el10_0.noarch.rpm;name=aarch64_rust-avif-serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-avif-serialize-devel}"
SRC_URI[aarch64_rust-avif-serialize-devel.sha256sum] = "a7b1723d0059cf3d59201f902dd80dec1876c59dfbc51eb7a32c2fe1e40061c0"

RDEPENDS:rust-avif-serialize+default-devel = " \
 cargo \
 rust-avif-serialize-devel \
 "
RDEPENDS:rust-avif-serialize-devel = " \
 cargo \
 rust \
 rust-arrayvec+default-devel \
 "
