# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxml2"
PV = "2.12.5"
PR = "9.el10_0"
PACKAGES = " \
 libxml2 \
 libxml2-devel \
 libxml2-static \
 python3-libxml2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libxml2-2.12.5-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "486125c6f01f6fca73946e15addd063c783af3dc6ea2d9758e9cc93985634f14"

URI_x86_64_v2_libxml2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libxml2-2.12.5-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_libxml2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxml2}"
SRC_URI[x86_64_v2_libxml2.sha256sum] = "b76be575eacfc40a390b54a9e082831bb02a3736ab90187d42dfa3c7845e4187"

URI_x86_64_v2_libxml2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxml2-devel-2.12.5-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_libxml2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxml2-devel}"
SRC_URI[x86_64_v2_libxml2-devel.sha256sum] = "c76d33854620fdfe682c93accccf65c11fb411a28d86e23de0747333937ab472"

URI_x86_64_v2_libxml2-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxml2-static-2.12.5-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_libxml2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxml2-static}"
SRC_URI[x86_64_v2_libxml2-static.sha256sum] = "c2503f96ef5590b310ef1dffbe1be19ba65f9722d83dbf1433c405201ccadc5f"

URI_x86_64_v2_python3-libxml2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libxml2-2.12.5-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-libxml2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libxml2}"
SRC_URI[x86_64_v2_python3-libxml2.sha256sum] = "ff68980bc49b71083ab652451a5fa86298d095bdaf8db74ac8196d4d2173e92d"

URI_aarch64_libxml2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libxml2-2.12.5-9.el10_0.aarch64.rpm;name=aarch64_libxml2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxml2}"
SRC_URI[aarch64_libxml2.sha256sum] = "0c3f1350f6b4edc73b3d5a53b53a612560f8173daba6c26092203184af9b9385"

URI_aarch64_libxml2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxml2-devel-2.12.5-9.el10_0.aarch64.rpm;name=aarch64_libxml2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxml2-devel}"
SRC_URI[aarch64_libxml2-devel.sha256sum] = "abcc06c60c25d9544bf36c5641b0738ddb66e75d095914a7e03ef4e939f29d0f"

URI_aarch64_libxml2-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxml2-static-2.12.5-9.el10_0.aarch64.rpm;name=aarch64_libxml2-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxml2-static}"
SRC_URI[aarch64_libxml2-static.sha256sum] = "0c0f3dbb8b4bb29a75f425c63a4bc5d62305a1282da19f4f6f1aefc122035db3"

URI_aarch64_python3-libxml2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libxml2-2.12.5-9.el10_0.aarch64.rpm;name=aarch64_python3-libxml2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libxml2}"
SRC_URI[aarch64_python3-libxml2.sha256sum] = "f44a5bb230c3cd1a663f9999151ec4a9fcd784988a0c130eab2b96b1e6c1f950"

RDEPENDS:libxml2 = " \
 glibc \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libxml2-devel = " \
 bash \
 cmake-filesystem \
 libxml2 \
 pkgconf-pkg-config \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:libxml2-static = " \
 "
RDEPENDS:python3-libxml2 = " \
 glibc \
 libxml2 \
 python3 \
 "
