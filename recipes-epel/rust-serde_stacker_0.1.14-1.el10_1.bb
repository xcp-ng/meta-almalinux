# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_stacker"
PV = "0.1.14"
PR = "1.el10_1"
PACKAGES = " \
 rust-serde_stacker+default-devel \
 rust-serde_stacker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_stacker-0.1.14-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98b3ac19bee60c683ec344af29fe8f1a079c1662282206a514faaaf2d6f1b195"

URI_x86_64_v2_rust-serde_stacker+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_stacker+default-devel-0.1.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_stacker+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_stacker+default-devel}"
SRC_URI[x86_64_v2_rust-serde_stacker+default-devel.sha256sum] = "605b33b2ee7e1c1c1899f871290184b2de5336a12390d4226528a3b998afaa15"

URI_x86_64_v2_rust-serde_stacker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_stacker-devel-0.1.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_stacker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_stacker-devel}"
SRC_URI[x86_64_v2_rust-serde_stacker-devel.sha256sum] = "9cbb7b3b35d9bc53b5df09a490ca75a4a50ef99aef9fe72179e1882af2731c25"

URI_aarch64_rust-serde_stacker+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_stacker+default-devel-0.1.14-1.el10_1.noarch.rpm;name=aarch64_rust-serde_stacker+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_stacker+default-devel}"
SRC_URI[aarch64_rust-serde_stacker+default-devel.sha256sum] = "5214a34cdc9781e056c2a9bd1a4501bd57708c6f4ad66536ea6f5aa834961312"

URI_aarch64_rust-serde_stacker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_stacker-devel-0.1.14-1.el10_1.noarch.rpm;name=aarch64_rust-serde_stacker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_stacker-devel}"
SRC_URI[aarch64_rust-serde_stacker-devel.sha256sum] = "9981b2beae2a12427c132d6a3c2a4e943430f5350630c9c2af327cdf40cdc29e"

RDEPENDS:rust-serde_stacker+default-devel = " \
 cargo \
 rust-serde_stacker-devel \
 "
RDEPENDS:rust-serde_stacker-devel = " \
 cargo \
 rust \
 rust-serde-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-stacker+default-devel \
 "
