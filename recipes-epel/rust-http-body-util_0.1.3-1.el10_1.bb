# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http-body-util"
PV = "0.1.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-http-body-util+channel-devel \
 rust-http-body-util+default-devel \
 rust-http-body-util+full-devel \
 rust-http-body-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-body-util-0.1.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97829a4dbc2ac535fb91c2a474b115c7c636dd6de14551c946a1f6b4bc3b047e"

URI_x86_64_v2_rust-http-body-util+channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+channel-devel-0.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util+channel-devel}"
SRC_URI[x86_64_v2_rust-http-body-util+channel-devel.sha256sum] = "1256c047dcf54a1ddbefee82edc093df1da65db7fee0d292e80f7dcf6f2a6030"

URI_x86_64_v2_rust-http-body-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+default-devel-0.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util+default-devel}"
SRC_URI[x86_64_v2_rust-http-body-util+default-devel.sha256sum] = "7fe3cd3553aad134e766ead975d28f8265e7f792a5a006b68b1f774be4c629be"

URI_x86_64_v2_rust-http-body-util+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+full-devel-0.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util+full-devel}"
SRC_URI[x86_64_v2_rust-http-body-util+full-devel.sha256sum] = "e5c9384b00a64336786834d5066f7f329f37047f4d736877e4e71a034fa9d452"

URI_x86_64_v2_rust-http-body-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util-devel-0.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util-devel}"
SRC_URI[x86_64_v2_rust-http-body-util-devel.sha256sum] = "2df8d6d7abc6a4ef0f276148c45154534a661714b05541dcdbdcdb8ae4e8cf26"

URI_aarch64_rust-http-body-util+channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+channel-devel-0.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-http-body-util+channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util+channel-devel}"
SRC_URI[aarch64_rust-http-body-util+channel-devel.sha256sum] = "ddaf98847d7e0cb71054557a674eae652d984b6381c66b5dc8f2e4aa24e7d4f1"

URI_aarch64_rust-http-body-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+default-devel-0.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-http-body-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util+default-devel}"
SRC_URI[aarch64_rust-http-body-util+default-devel.sha256sum] = "dd4f92e6dbfe2c4e770a0929a2e44cc4ac214a1cc0f669eb0c72e94ee333a589"

URI_aarch64_rust-http-body-util+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+full-devel-0.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-http-body-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util+full-devel}"
SRC_URI[aarch64_rust-http-body-util+full-devel.sha256sum] = "d78dc7ed51a17fcd548d1811c4c616263ff81088e2db4f71a542fa2430f97a5c"

URI_aarch64_rust-http-body-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util-devel-0.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-http-body-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util-devel}"
SRC_URI[aarch64_rust-http-body-util-devel.sha256sum] = "fbd285731e41715befe5cc54e4a5e5e2e83227df2ef51b76907f920a6c332fed"

RDEPENDS:rust-http-body-util+channel-devel = " \
 cargo \
 rust-http-body-util-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
RDEPENDS:rust-http-body-util+default-devel = " \
 cargo \
 rust-http-body-util-devel \
 "
RDEPENDS:rust-http-body-util+full-devel = " \
 cargo \
 rust-http-body-util+channel-devel \
 rust-http-body-util-devel \
 "
RDEPENDS:rust-http-body-util-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-futures-core-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-pin-project-lite+default-devel \
 "
