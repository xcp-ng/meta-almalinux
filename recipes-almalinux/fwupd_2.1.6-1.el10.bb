# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fwupd"
PV = "2.1.6"
PR = "1.el10"
PACKAGES = " \
 fwupd \
 fwupd-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/fwupd-2.1.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c928674161546ea62bb140a4adbf4ed320f26f0f924bcb73dcf5e8f72bff5983"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/fwupd-2.1.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_fwupd;unpack=0"
SRC_URI[x86_64_v2_fwupd.sha256sum] = "fd1ae7f777d4007d98a905016dfc25317a710e5b840bffcf0963bbeef772e8a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fwupd-devel-2.1.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_fwupd-devel;unpack=0"
SRC_URI[x86_64_v2_fwupd-devel.sha256sum] = "9fee2b972db66125809b4f858b9095b2a382e7b75f6695cdb4d4e2754936f70d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/fwupd-2.1.6-1.el10.aarch64.rpm;name=aarch64_fwupd;unpack=0"
SRC_URI[aarch64_fwupd.sha256sum] = "a9cd08b9fa03b5304e594c85b3ddf9d1096128c827e7c3a148eec284892155c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fwupd-devel-2.1.6-1.el10.aarch64.rpm;name=aarch64_fwupd-devel;unpack=0"
SRC_URI[aarch64_fwupd-devel.sha256sum] = "a56845ea264b0992ceaf554ac9874d8cbe499c60215c78540fdfc54a1f5bb34b"

RDEPENDS:fwupd:x86_64_v2 = " \
 bash \
 glib2 \
 glibc \
 gnutls \
 json-glib \
 libblkid \
 libdrm \
 libgcc \
 libjcat \
 libmnl \
 libusb1 \
 libxmlb \
 polkit-libs \
 readline \
 shared-mime-info \
 sqlite-libs \
 systemd \
 systemd-libs \
 tpm2-tss \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:fwupd:aarch64 = " \
 bash \
 glib2 \
 glibc \
 gnutls \
 json-glib \
 libblkid \
 libdrm \
 libgcc \
 libjcat \
 libmnl \
 libusb1 \
 libxmlb \
 polkit-libs \
 readline \
 shared-mime-info \
 sqlite-libs \
 systemd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:fwupd-devel = " \
 fwupd \
 glib2-devel \
 libcurl-devel \
 pkgconf-pkg-config \
 "
