# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rmp"
PV = "0.8.15"
PR = "1.el10_1"
PACKAGES = " \
 rust-rmp+default-devel \
 rust-rmp+std-devel \
 rust-rmp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rmp-0.8.15-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9f94b89f0fd2449074c3c334169d741bdfd657976faf0dc67bccf94394c2a86"

URI_x86_64_v2_rust-rmp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmp+default-devel-0.8.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmp+default-devel}"
SRC_URI[x86_64_v2_rust-rmp+default-devel.sha256sum] = "ccb2f90da4d87a8ae089047dbad9cf52d7ab53e873d8681a4a72d742c435e895"

URI_x86_64_v2_rust-rmp+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmp+std-devel-0.8.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmp+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmp+std-devel}"
SRC_URI[x86_64_v2_rust-rmp+std-devel.sha256sum] = "b900367489a1eaae0002ca42afe87e167e99ec3643e77d3b3c46341594ed3626"

URI_x86_64_v2_rust-rmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmp-devel-0.8.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmp-devel}"
SRC_URI[x86_64_v2_rust-rmp-devel.sha256sum] = "be36729910c05d533f46c68b1460c5ccafea46190b4090cbee5fd64c57b1da20"

URI_aarch64_rust-rmp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmp+default-devel-0.8.15-1.el10_1.noarch.rpm;name=aarch64_rust-rmp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmp+default-devel}"
SRC_URI[aarch64_rust-rmp+default-devel.sha256sum] = "ace239ba2f2612a36652d114ef4cd37b0bf639717084460f45e39ab80f76a993"

URI_aarch64_rust-rmp+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmp+std-devel-0.8.15-1.el10_1.noarch.rpm;name=aarch64_rust-rmp+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmp+std-devel}"
SRC_URI[aarch64_rust-rmp+std-devel.sha256sum] = "1c309b7ac1791b5922d327505c81b525056e8be86b409c3f4f81b3ddc45fe758"

URI_aarch64_rust-rmp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmp-devel-0.8.15-1.el10_1.noarch.rpm;name=aarch64_rust-rmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmp-devel}"
SRC_URI[aarch64_rust-rmp-devel.sha256sum] = "9037a166aedc67e62952a16b93b3a728e8d65ef2e259032d07edf8d42a5586ec"

RDEPENDS:rust-rmp+default-devel = " \
 cargo \
 rust-rmp+std-devel \
 rust-rmp-devel \
 "
RDEPENDS:rust-rmp+std-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-rmp-devel \
 "
RDEPENDS:rust-rmp-devel = " \
 cargo \
 rust \
 rust-num-traits-devel \
 "
