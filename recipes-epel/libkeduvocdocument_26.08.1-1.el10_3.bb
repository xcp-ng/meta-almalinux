# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkeduvocdocument"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 libkeduvocdocument \
 libkeduvocdocument-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libkeduvocdocument-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "07d1ea52d54b6d57ac5f4cf30b7fb2b19d52b975790a212b5256dac6b67c57e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkeduvocdocument-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkeduvocdocument;unpack=0"
SRC_URI[x86_64_v2_libkeduvocdocument.sha256sum] = "4b8ab7845d50e6f10d21fb8c0d227ea601fd2ee6d57aa82a2a4729ba3b3423f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkeduvocdocument-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkeduvocdocument-devel;unpack=0"
SRC_URI[x86_64_v2_libkeduvocdocument-devel.sha256sum] = "980e2b484a48f38cf563a46436e9d66b59dd6773c7f9797aca45763bb7116c94"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkeduvocdocument-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkeduvocdocument;unpack=0"
SRC_URI[aarch64_libkeduvocdocument.sha256sum] = "e9c5f6d71c86e237570f9e325f993870436b7094cbf3a702e784bcc69b5c6490"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkeduvocdocument-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkeduvocdocument-devel;unpack=0"
SRC_URI[aarch64_libkeduvocdocument-devel.sha256sum] = "da4962ef580994a177924bcebf9b5bba9ce89025a0796a5302a2f6cf48a4e6c4"

RDEPENDS:libkeduvocdocument = " \
 glibc \
 kdeedu-data \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:libkeduvocdocument-devel = " \
 cmake-filesystem \
 libkeduvocdocument \
 "
