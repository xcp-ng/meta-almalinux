# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-sec-dispatcher"
PV = "2.0"
PR = "14.el10"
PACKAGES = " \
 plexus-sec-dispatcher \
 plexus-sec-dispatcher-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/plexus-sec-dispatcher-2.0-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0bf7b0ce4f5b47942e22856c9e0a561abd53a4f18a9a20699b6f89a6bbec73b"

URI_x86_64_v2_plexus-sec-dispatcher = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plexus-sec-dispatcher-2.0-14.el10.noarch.rpm;name=x86_64_v2_plexus-sec-dispatcher;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-sec-dispatcher}"
SRC_URI[x86_64_v2_plexus-sec-dispatcher.sha256sum] = "5a55b653a5a10bb3af9d92cea849b9d2aef4233928e3a1059a2968a9000f3824"

URI_x86_64_v2_plexus-sec-dispatcher-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-sec-dispatcher-javadoc-2.0-14.el10.noarch.rpm;name=x86_64_v2_plexus-sec-dispatcher-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-sec-dispatcher-javadoc}"
SRC_URI[x86_64_v2_plexus-sec-dispatcher-javadoc.sha256sum] = "976427431a461edbff0e6a5ff1370b3eec6bcc86f878c27b1f4faef86b708d8b"

URI_aarch64_plexus-sec-dispatcher = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plexus-sec-dispatcher-2.0-14.el10.noarch.rpm;name=aarch64_plexus-sec-dispatcher;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-sec-dispatcher}"
SRC_URI[aarch64_plexus-sec-dispatcher.sha256sum] = "5a55b653a5a10bb3af9d92cea849b9d2aef4233928e3a1059a2968a9000f3824"

URI_aarch64_plexus-sec-dispatcher-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-sec-dispatcher-javadoc-2.0-14.el10.noarch.rpm;name=aarch64_plexus-sec-dispatcher-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-sec-dispatcher-javadoc}"
SRC_URI[aarch64_plexus-sec-dispatcher-javadoc.sha256sum] = "976427431a461edbff0e6a5ff1370b3eec6bcc86f878c27b1f4faef86b708d8b"

RDEPENDS:plexus-sec-dispatcher = " \
 atinject \
 javapackages-filesystem \
 plexus-cipher \
 plexus-utils \
 "
RDEPENDS:plexus-sec-dispatcher-javadoc = " \
 javapackages-filesystem \
 "
