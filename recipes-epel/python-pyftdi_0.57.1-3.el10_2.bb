# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyftdi"
PV = "0.57.1"
PR = "3.el10_2"
PACKAGES = " \
 python3-pyftdi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyftdi-0.57.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a75f3b30e45941e1dca1ed680021872ac452497e75e0bac0b6de772f36b5d46"

URI_x86_64_v2_python3-pyftdi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyftdi-0.57.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyftdi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyftdi}"
SRC_URI[x86_64_v2_python3-pyftdi.sha256sum] = "5520bf3d9165ffcda0a5f6f5fd81e21cfc5ab2823825eecd596d3203b74a1ec4"

URI_aarch64_python3-pyftdi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyftdi-0.57.1-3.el10_2.noarch.rpm;name=aarch64_python3-pyftdi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyftdi}"
SRC_URI[aarch64_python3-pyftdi.sha256sum] = "b154c9e9afec47272b90a6dec83cfd812a1c418bb2b8080e5756f6d8f7d50e2c"

RDEPENDS:python3-pyftdi = " \
 python3 \
 python3-pyserial \
 python3-pyusb \
 "
