# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libdeflate-sys"
PV = "1.25.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-libdeflate-sys+default-devel \
 rust-libdeflate-sys+dynamic-devel \
 rust-libdeflate-sys+freestanding-devel \
 rust-libdeflate-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libdeflate-sys-1.25.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7daa2adf3e7ab80b9c1ad2b457502c2301627f4469b9442867c7ed0c761d0d8d"

URI_x86_64_v2_rust-libdeflate-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys+default-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflate-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libdeflate-sys+default-devel.sha256sum] = "dafd51b69adce1d670aa621a078ae6fbea616cb6411e925b4d8806422db38ced"

URI_x86_64_v2_rust-libdeflate-sys+dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys+dynamic-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys+dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflate-sys+dynamic-devel}"
SRC_URI[x86_64_v2_rust-libdeflate-sys+dynamic-devel.sha256sum] = "11b1545fba3ec27b973de2fa5c4a2eb0e799621b9d19270d299b971fd86f90f3"

URI_x86_64_v2_rust-libdeflate-sys+freestanding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys+freestanding-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflate-sys+freestanding-devel}"
SRC_URI[x86_64_v2_rust-libdeflate-sys+freestanding-devel.sha256sum] = "e7aef3fef5da60298ad32b91d424b52e9c6dc81cd2ded7ccadadaafa5794aa43"

URI_x86_64_v2_rust-libdeflate-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflate-sys-devel}"
SRC_URI[x86_64_v2_rust-libdeflate-sys-devel.sha256sum] = "00efecc248aa555998bd3416459cb8b7ba5e8c41db5e104e77e570a7ed82db18"

URI_aarch64_rust-libdeflate-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys+default-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-libdeflate-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflate-sys+default-devel}"
SRC_URI[aarch64_rust-libdeflate-sys+default-devel.sha256sum] = "fde9e185d92c10cbb6d1c80254c9f725ac1df8d0434d6375ab4da272e1c5a446"

URI_aarch64_rust-libdeflate-sys+dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys+dynamic-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-libdeflate-sys+dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflate-sys+dynamic-devel}"
SRC_URI[aarch64_rust-libdeflate-sys+dynamic-devel.sha256sum] = "6680b79f5fed6c7ab0345e58b6813f3024c3d63cdb42bdd7912bf3dfa955de22"

URI_aarch64_rust-libdeflate-sys+freestanding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys+freestanding-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-libdeflate-sys+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflate-sys+freestanding-devel}"
SRC_URI[aarch64_rust-libdeflate-sys+freestanding-devel.sha256sum] = "39eeb9d513e05d0350a7b3ddf4c460fe0439c4a3152024168346102b387787e4"

URI_aarch64_rust-libdeflate-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-libdeflate-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflate-sys-devel}"
SRC_URI[aarch64_rust-libdeflate-sys-devel.sha256sum] = "78ada82992b75862ae442da4dcfca83bb6426fba5855b4d8cb00824c33192fe3"

RDEPENDS:rust-libdeflate-sys+default-devel = " \
 cargo \
 rust-libdeflate-sys-devel \
 "
RDEPENDS:rust-libdeflate-sys+dynamic-devel = " \
 cargo \
 rust-libdeflate-sys-devel \
 "
RDEPENDS:rust-libdeflate-sys+freestanding-devel = " \
 cargo \
 rust-libdeflate-sys-devel \
 "
RDEPENDS:rust-libdeflate-sys-devel = " \
 cargo \
 libdeflate-devel \
 rust-cc+default-devel \
 rust-pkg-config+default-devel \
 "
