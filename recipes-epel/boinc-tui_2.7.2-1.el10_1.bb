# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "boinc-tui"
PV = "2.7.2"
PR = "1.el10_1"
PACKAGES = " \
 boinc-tui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/boinc-tui-2.7.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bc27727d8acf4ff29a98411ca45bf0e5dc22e060e8cb1ae2e8965821bc074c1"

URI_x86_64_v2_boinc-tui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/boinc-tui-2.7.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_boinc-tui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boinc-tui}"
SRC_URI[x86_64_v2_boinc-tui.sha256sum] = "1490ab5f4beac9afb66e172269054e9a54c373d4242ac9d8f5925fba8b13fa4c"

URI_aarch64_boinc-tui = "${EPEL_MIRROR}/aarch64/Packages/b/boinc-tui-2.7.2-1.el10_1.aarch64.rpm;name=aarch64_boinc-tui;unpack=0"
SRC_URI:append = " ${URI_aarch64_boinc-tui}"
SRC_URI[aarch64_boinc-tui.sha256sum] = "8bf730caa18852e52c5f1ed14befc5da347d054fe30bed1879f20d973693a2cc"

RDEPENDS:boinc-tui = " \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-libs \
 openssl-libs \
 "
