# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-relative-luminance"
PV = "1.0.0"
PR = "4.el10_2"
PACKAGES = " \
 rust-relative-luminance+default-devel \
 rust-relative-luminance-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-relative-luminance-1.0.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "459eb7ea9e0d90434d114778bb1b9162386c5f64e8ab65c509fcf80670149936"

URI_x86_64_v2_rust-relative-luminance+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-relative-luminance+default-devel-1.0.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-relative-luminance+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-relative-luminance+default-devel}"
SRC_URI[x86_64_v2_rust-relative-luminance+default-devel.sha256sum] = "fd57d23f38988d3b4c224a1663df55126343ca320f20a03d29d636d253cfc68b"

URI_x86_64_v2_rust-relative-luminance-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-relative-luminance-devel-1.0.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-relative-luminance-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-relative-luminance-devel}"
SRC_URI[x86_64_v2_rust-relative-luminance-devel.sha256sum] = "ebcd9d8e1239a714dfef2b540b082f9c214bffbe18ec588fb56d542555541cd4"

URI_aarch64_rust-relative-luminance+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-relative-luminance+default-devel-1.0.0-4.el10_2.noarch.rpm;name=aarch64_rust-relative-luminance+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-relative-luminance+default-devel}"
SRC_URI[aarch64_rust-relative-luminance+default-devel.sha256sum] = "3252e94fb0b4681d3930d27d404d4b1eaaf0a9368cd4e2e6e211aaa37a529574"

URI_aarch64_rust-relative-luminance-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-relative-luminance-devel-1.0.0-4.el10_2.noarch.rpm;name=aarch64_rust-relative-luminance-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-relative-luminance-devel}"
SRC_URI[aarch64_rust-relative-luminance-devel.sha256sum] = "9678a840c5f91fffb4368124bb3457d8a1df99b45bd551f555e656346d57167e"

RDEPENDS:rust-relative-luminance+default-devel = " \
 cargo \
 rust-relative-luminance-devel \
 "
RDEPENDS:rust-relative-luminance-devel = " \
 cargo \
 "
